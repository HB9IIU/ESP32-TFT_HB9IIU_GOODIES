#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F,
  0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7F, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFE, 0xDF, 0xC0, 0x1F, 0xCE, 0x1C, 0x00, 0xFC, 0x70, 0x20, 0x0F, 0xC3,
  0x80, 0x00, 0x7E, 0x1C, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x1F, 0x8E, 0x00,
  0x00, 0xFC, 0x70, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x3F, 0x9C, 0x00, 0x01,
  0xFC, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0E, 0xFE, 0x00, 0x00, 0x73, 0xF8, 0x00, 0x03,
  0x8F, 0xC0, 0x00, 0x18, 0x7E, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x0E, 0x1F,
  0x80, 0x00, 0x70, 0xFC, 0x00, 0x03, 0x8F, 0xC0, 0x40, 0x18, 0x7E, 0x03,
  0x01, 0xC7, 0xF0, 0x1F, 0x0E, 0x7F, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x7C,
  0x00, 0x78, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0x3E, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0xF8, 0x00,
  0x3E, 0x07, 0xC7, 0xC0, 0x70, 0xF8, 0x1F, 0x1F, 0x0F, 0xF3, 0xE0, 0xF8,
  0xF8, 0x7F, 0xEF, 0x83, 0xE3, 0xE3, 0xFF, 0xBE, 0x1F, 0x1F, 0x1F, 0xFF,
  0xF8, 0x7C, 0x7C, 0x7C, 0x7D, 0xF7, 0xE3, 0xE3, 0xE1, 0xF7, 0xFF, 0x8F,
  0x8F, 0x87, 0xDF, 0xFC, 0x7C, 0x7C, 0x1F, 0x3F, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7E, 0x0F, 0x87, 0x81, 0xF0, 0x00, 0x3E, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x3E, 0x1F, 0x01, 0xF0,
  0x01, 0xF8, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x1F, 0x00,
  0x1F, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x1E,
  0x0F, 0x80, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x01, 0xE1, 0xF0, 0x03,
  0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xC3, 0xFB, 0xF8,
  0x7F, 0x0F, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0x3F,
  0x0F, 0xC1, 0xFC, 0xFC, 0x7E, 0x03, 0xF7, 0xF1, 0xF8, 0x0F, 0xFF, 0x8F,
  0xE0, 0x3F, 0xFE, 0x3F, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0x83, 0xF0,
  0x07, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0xFF, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC3, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xF1, 0xFC,
  0x0F, 0xFF, 0x87, 0xF0, 0x0F, 0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F,
  0x8F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x80, 0xF8, 0x03, 0x83, 0xC0, 0x1F, 0x8F, 0x00, 0x7F,
  0xBC, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xDF, 0x00,
  0x7F, 0x7E, 0x03, 0xF8, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x38,
  0x1F, 0x80, 0x40, 0x78, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x08, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFE, 0xFE, 0xFC, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x01,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F,
  0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xFB, 0xF3, 0xFC, 0xFC, 0xFE, 0x3F, 0x1F, 0x1F, 0xC3,
  0x07, 0xE0, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0x80, 0x0F, 0x00,
  0xFE, 0x00, 0x18, 0x01, 0xF8, 0x00, 0x40, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xF8, 0x01, 0xE0, 0x1F,
  0xE0, 0x06, 0x00, 0x7F, 0x00, 0x20, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x04, 0x00, 0x0F, 0xE0, 0x30, 0x00, 0xFF, 0x01, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xE7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF1, 0xF8, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x03, 0xE0, 0xFC,
  0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF8, 0x01,
  0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0x00, 0x08, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x04, 0x00, 0x0F, 0xF0, 0x30, 0x00, 0xFF, 0x01, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE3, 0x80, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xCF, 0xF8, 0x03, 0xF3, 0xFF, 0x80,
  0x7E, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F,
  0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x20, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87,
  0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F,
  0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xC0, 0x3F, 0xF9, 0xF8, 0x07, 0xFE, 0x7F,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x40, 0x3F, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C,
  0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x8F,
  0xF0, 0x30, 0x1F, 0xC0, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x3F, 0x80, 0xF0, 0x7C, 0x03, 0xFF,
  0xC3, 0xC1, 0xF0, 0x1F, 0xFE, 0x0F, 0x0F, 0x80, 0xFF, 0xF8, 0x3C, 0x3E,
  0x07, 0xE3, 0xE0, 0xF1, 0xF0, 0x3E, 0x0F, 0x83, 0xC7, 0xC0, 0xF8, 0x3C,
  0x0F, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0xF8, 0x1E, 0x07, 0xC0, 0xF3, 0xE0,
  0xF8, 0x1F, 0x07, 0xCF, 0x03, 0xC0, 0x78, 0x1F, 0x7C, 0x1F, 0x03, 0xE0,
  0x7D, 0xF0, 0x7C, 0x0F, 0x81, 0xE7, 0x81, 0xE0, 0x3E, 0x07, 0x9E, 0x07,
  0x80, 0xF0, 0x3E, 0x78, 0x3E, 0x07, 0xC0, 0xF3, 0xE0, 0xF8, 0x1F, 0x03,
  0xCF, 0x83, 0xE0, 0x7C, 0x1F, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0xF0, 0x3C,
  0x0F, 0x81, 0xE3, 0xC0, 0xF0, 0x3E, 0x0F, 0x8F, 0x03, 0xC1, 0xF8, 0x3C,
  0x3C, 0x0F, 0x87, 0xE1, 0xF0, 0xF0, 0x3E, 0x3F, 0x8F, 0x83, 0xC0, 0xFF,
  0xDF, 0xFC, 0x0F, 0x03, 0xFF, 0x3F, 0xE0, 0x3C, 0x07, 0xF8, 0xFF, 0x00,
  0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1,
  0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0x83, 0xFE,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x01, 0xFC,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x07, 0x00, 0x3F, 0xC0, 0x08, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7E,
  0x0F, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x7F, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x10, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0xC0, 0x1F, 0xFE,
  0x07, 0xF0, 0x07, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x63, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7,
  0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x9F,
  0x80, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0x83,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x07, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0xFC,
  0x1F, 0x80, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xE3, 0xE0,
  0xFE, 0x00, 0x7E, 0x07, 0xCF, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0x9F, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFF, 0xC0, 0x7E,
  0x00, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0xF8, 0x01, 0xF8, 0x00, 0xFB, 0xF0, 0x07, 0xE0, 0x07, 0xEF, 0xC0, 0x1F,
  0x80, 0x1F, 0xBF, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x03, 0xF0, 0x01, 0xF9,
  0xF0, 0x0F, 0xC0, 0x07, 0xE7, 0xC0, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x7E, 0x07, 0xF0, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC3, 0xF0, 0x03, 0xF8, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x3F, 0x00,
  0x3F, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0x1F,
  0x9F, 0x80, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x01,
  0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xE0, 0x0F, 0xBF, 0x00, 0x1F, 0x80, 0x3F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0xFF, 0x80, 0x1F, 0x80,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0xFF, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x3F, 0x01, 0xFE, 0x01, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x3F,
  0xC0, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x01,
  0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFA, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0,
  0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC7, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xE0,
  0x1F, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7D, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF7, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xBF, 0x01, 0xF8, 0x0F, 0xE0, 0x3E,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFB, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xCF,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xF8, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xE3, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x8F, 0x83,
  0xF0, 0x03, 0xF0, 0x7C, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0xF8, 0x7F,
  0x00, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x0F, 0x8F, 0xE0,
  0x03, 0xF1, 0xF8, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x00,
  0x3F, 0x3F, 0x03, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x0F, 0x9F, 0x80, 0x03,
  0xF3, 0xE0, 0x3E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x00, 0x3F,
  0x7C, 0x03, 0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xEF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3C, 0x00,
  0x3F, 0x83, 0xF0, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF,
  0x7E, 0x03, 0xFF, 0xF7, 0xE0, 0x7F, 0xCF, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xF9,
  0xF0, 0x03, 0xFF, 0x1F, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFF, 0x80,
  0x1F, 0x9F, 0xFC, 0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7D, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0x00, 0xF8, 0xFF, 0xE0, 0x0F, 0x87,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0x87, 0x01,
  0xFC, 0x04, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x40, 0x7F,
  0x83, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x7F, 0xFB, 0xF0, 0x00, 0xFF, 0xFB, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x01, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x00,
  0x7F, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0xF8, 0x00,
  0x3F, 0xFC, 0xF8, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x0F, 0xF0, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x20, 0xFF, 0x00, 0xC0, 0x7F, 0xEF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xEC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xFE, 0x3E, 0x00, 0x0F, 0xFF, 0x7E, 0x00, 0x1F, 0xFF, 0x7E, 0x00, 0x3F,
  0xFF, 0x7E, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x80, 0x0F, 0xE1,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xBF, 0x00, 0x03, 0xFF, 0x3F, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x70,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x03, 0xF8, 0x00, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x01, 0xF9, 0xFF, 0x80,
  0x3F, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB,
  0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03,
  0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x21, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC,
  0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFE, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x7F, 0x01, 0xFC, 0x00, 0xF8, 0xFF, 0xC3, 0xFF, 0x00,
  0x7C, 0xFF, 0xF3, 0xFF, 0xC0, 0x3E, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xF3, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x81,
  0xF8, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xF8, 0x7F, 0x00, 0x3E, 0x3F, 0xF0, 0x07, 0xCF, 0xFF, 0x00, 0xFB, 0xFF,
  0xE0, 0x1F, 0x7F, 0xFE, 0x07, 0xFF, 0x3F, 0xC0, 0xFF, 0x83, 0xF8, 0x1F,
  0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0xE0, 0x00,
  0xF8, 0xFF, 0xE0, 0x01, 0xF3, 0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xC0, 0x07,
  0xFC, 0x3F, 0x80, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7E, 0x7F, 0xF8, 0x00, 0xFC, 0xFF, 0xE0, 0x01, 0xF8,
  0xFF, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0x8F,
  0x80, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFE, 0x3F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7E, 0x00,
  0x3F, 0xF3, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x01, 0xC1, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x03, 0xE3, 0xFC,
  0x07, 0xCF, 0xF0, 0x0F, 0x9F, 0xE0, 0x1F, 0x7F, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xE2, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x1C, 0x07,
  0xF0, 0x04, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xC0,
  0x0F, 0xE0, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x70,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xE0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x07, 0xF0, 0xFF,
  0x80, 0xFF, 0xFD, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xC0, 0x3F,
  0xF9, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7D, 0xF8,
  0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0xFF, 0x00, 0xFC, 0xFC, 0x03, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0xC0, 0x7E, 0x3F, 0x01,
  0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFF, 0xC0, 0xFC, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0xFC, 0x1F,
  0x7C, 0x1F, 0x83, 0xF0, 0xF9, 0xF0, 0xFC, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0,
  0x3F, 0x0F, 0x9F, 0x0F, 0xC0, 0xFC, 0x7C, 0x7C, 0x7E, 0x03, 0xF1, 0xF1,
  0xF1, 0xF8, 0x0F, 0xCF, 0xC7, 0xC7, 0xC0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00,
  0xFC, 0xF8, 0x7C, 0xFC, 0x03, 0xF7, 0xC1, 0xF7, 0xE0, 0x0F, 0x9F, 0x0F,
  0xDF, 0x80, 0x3E, 0x7C, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0xFB, 0xF0, 0x03,
  0xEF, 0x83, 0xEF, 0xC0, 0x0F, 0xBC, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x80, 0x03, 0xFE, 0x20, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 18, 50, 16, 0, -49 },
  { 114, 20, 18, 24, 7, -49 },
  { 159, 32, 49, 30, 0, -49 },
  { 355, 29, 56, 27, 0, -52 },
  { 558, 38, 50, 43, 3, -49 },
  { 796, 30, 50, 31, 0, -49 },
  { 984, 9, 18, 14, 7, -49 },
  { 1005, 21, 60, 18, 1, -49 },
  { 1163, 21, 60, 18, -5, -49 },
  { 1321, 22, 24, 26, 6, -52 },
  { 1387, 26, 32, 30, 3, -40 },
  { 1491, 13, 17, 14, -3, -8 },
  { 1519, 16, 6, 18, 1, -21 },
  { 1531, 8, 10, 14, 1, -9 },
  { 1541, 32, 49, 23, -3, -49 },
  { 1737, 26, 50, 27, 1, -49 },
  { 1900, 18, 49, 27, 7, -49 },
  { 2011, 30, 49, 27, -2, -49 },
  { 2195, 29, 50, 27, -1, -49 },
  { 2377, 29, 49, 27, -1, -49 },
  { 2555, 29, 50, 27, -1, -49 },
  { 2737, 27, 50, 27, 2, -49 },
  { 2906, 29, 49, 27, 2, -49 },
  { 3084, 28, 50, 27, 0, -49 },
  { 3259, 27, 50, 27, 0, -49 },
  { 3428, 14, 38, 15, 0, -37 },
  { 3495, 19, 46, 15, -4, -37 },
  { 3605, 26, 31, 30, 3, -40 },
  { 3706, 26, 20, 30, 3, -34 },
  { 3771, 26, 31, 30, 3, -40 },
  { 3872, 22, 50, 21, 1, -49 },
  { 4010, 38, 55, 41, 2, -49 },
  { 4272, 28, 49, 29, -4, -49 },
  { 4444, 31, 49, 30, 0, -49 },
  { 4634, 30, 50, 27, 2, -49 },
  { 4822, 32, 49, 33, 0, -49 },
  { 5018, 29, 49, 26, 0, -49 },
  { 5196, 29, 49, 24, 0, -49 },
  { 5374, 34, 50, 34, 2, -49 },
  { 5587, 36, 49, 34, 0, -49 },
  { 5808, 27, 49, 19, -3, -49 },
  { 5974, 27, 62, 15, -10, -49 },
  { 6184, 34, 49, 29, 0, -49 },
  { 6393, 19, 49, 24, 0, -49 },
  { 6510, 47, 49, 45, 0, -49 },
  { 6798, 38, 49, 36, 0, -49 },
  { 7031, 32, 50, 35, 2, -49 },
  { 7231, 30, 49, 29, 0, -49 },
  { 7415, 32, 61, 35, 2, -49 },
  { 7659, 30, 49, 29, 0, -49 },
  { 7843, 31, 50, 26, -2, -49 },
  { 8037, 25, 49, 24, 5, -49 },
  { 8191, 33, 50, 33, 2, -49 },
  { 8398, 28, 49, 29, 6, -49 },
  { 8570, 46, 49, 45, 5, -49 },
  { 8852, 35, 49, 27, -4, -49 },
  { 9067, 27, 49, 26, 5, -49 },
  { 9233, 31, 49, 24, -3, -49 },
  { 9423, 26, 60, 19, -2, -49 },
  { 9618, 12, 49, 24, 7, -49 },
  { 9692, 26, 60, 19, -5, -49 },
  { 9887, 28, 27, 28, 0, -49 },
  { 9982, 22, 4, 21, -6, 6 },
  { 9993, 10, 11, 18, 10, -52 },
  { 10007, 28, 38, 30, 2, -37 },
  { 10140, 28, 53, 29, 0, -52 },
  { 10326, 23, 38, 23, 2, -37 },
  { 10436, 32, 53, 30, 1, -52 },
  { 10648, 24, 38, 27, 2, -37 },
  { 10762, 32, 68, 17, -8, -52 },
  { 11034, 32, 53, 30, -2, -37 },
  { 11246, 27, 52, 29, 0, -52 },
  { 11422, 17, 51, 14, 0, -51 },
  { 11531, 26, 67, 14, -9, -51 },
  { 11749, 29, 52, 26, 0, -52 },
  { 11938, 17, 52, 14, 0, -52 },
  { 12049, 41, 37, 43, 0, -37 },
  { 12239, 27, 37, 29, 0, -37 },
  { 12364, 25, 38, 28, 2, -37 },
  { 12483, 31, 53, 29, -3, -37 },
  { 12689, 29, 53, 29, 1, -37 },
  { 12882, 23, 37, 20, 0, -37 },
  { 12989, 24, 38, 22, -1, -37 },
  { 13103, 17, 46, 17, 2, -45 },
  { 13201, 27, 38, 29, 2, -37 },
  { 13330, 24, 37, 24, 4, -37 },
  { 13441, 38, 37, 38, 4, -37 },
  { 13617, 30, 37, 25, -3, -37 },
  { 13756, 34, 53, 24, -6, -37 },
  { 13982, 25, 37, 20, -3, -37 },
  { 14098, 26, 60, 23, 1, -49 },
  { 14293, 6, 68, 25, 9, -52 },
  { 14344, 25, 60, 22, -4, -49 },
  { 14532, 26, 10, 30, 3, -29 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC68PT7B_H_
