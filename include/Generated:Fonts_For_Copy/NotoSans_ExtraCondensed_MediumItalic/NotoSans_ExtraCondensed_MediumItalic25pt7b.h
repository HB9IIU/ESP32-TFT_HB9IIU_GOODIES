#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87,
  0x00, 0x00, 0x30, 0xE1, 0xC0, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0xCC,
  0x03, 0x60, 0x66, 0x06, 0x60, 0x44, 0x0C, 0xC3, 0xFF, 0x3F, 0xE1, 0x98,
  0x19, 0x81, 0x90, 0x33, 0x0F, 0xFC, 0xFF, 0xC2, 0x60, 0x66, 0x06, 0x60,
  0x4C, 0x0C, 0xC0, 0x01, 0x00, 0x20, 0x1F, 0x8F, 0xE1, 0xA4, 0x64, 0x0C,
  0x81, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xB8, 0x13, 0x02, 0xE6,
  0x78, 0xFF, 0x0F, 0x80, 0x40, 0x08, 0x00, 0x1C, 0x18, 0xF8, 0xC6, 0x63,
  0x19, 0x98, 0x66, 0x43, 0x13, 0x0C, 0xC8, 0x33, 0x66, 0xC9, 0x3F, 0xED,
  0xB7, 0x64, 0xC1, 0xB3, 0x0C, 0xCC, 0x33, 0x31, 0x88, 0x86, 0x26, 0x30,
  0xF0, 0xC3, 0xC0, 0x07, 0x81, 0xF0, 0x37, 0x0C, 0xE1, 0x98, 0x33, 0x06,
  0xC0, 0xF0, 0x1C, 0x07, 0xCD, 0xDB, 0xB3, 0x6E, 0x7D, 0x87, 0x30, 0xE6,
  0x3C, 0xFF, 0x8F, 0x38, 0xFF, 0x6D, 0xA0, 0x03, 0x06, 0x0E, 0x0C, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x60, 0x60, 0x70, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x38,
  0x30, 0x60, 0xE0, 0x0C, 0x0C, 0x48, 0xFF, 0x1F, 0x3C, 0x7C, 0x66, 0x04,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x39, 0x9C, 0xC6, 0x60, 0x7F, 0xF0, 0x7F, 0x80, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x0F, 0x0F, 0xCE, 0x66, 0x37, 0x1B, 0x0D, 0x87, 0xC7, 0xE3,
  0xE1, 0xB0, 0xD8, 0x6C, 0x76, 0x33, 0x19, 0x98, 0xFC, 0x3C, 0x00, 0x0C,
  0x73, 0xFF, 0xDA, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x63,
  0x80, 0x07, 0xC1, 0xFC, 0x33, 0x84, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xFF,
  0x9F, 0xE0, 0x0F, 0x87, 0xF1, 0x1C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E,
  0x1E, 0x07, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xC0, 0x32, 0x1C, 0xFE, 0x3F,
  0x00, 0x00, 0xC0, 0x70, 0x3C, 0x0F, 0x07, 0x83, 0x60, 0x98, 0x6E, 0x33,
  0x8C, 0xC6, 0x33, 0x0C, 0xFF, 0xBF, 0xE0, 0x60, 0x18, 0x06, 0x03, 0x80,
  0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xF8, 0x3F, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x32, 0x1C, 0xFE, 0x3F, 0x00, 0x07,
  0xC3, 0xE1, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0xF8, 0xFF, 0x38, 0xCE,
  0x33, 0x0C, 0xC3, 0x31, 0xCC, 0x73, 0x38, 0xFC, 0x1E, 0x00, 0x3F, 0xDF,
  0xF0, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x0F, 0x87, 0xF1,
  0x8C, 0xE3, 0x38, 0xCE, 0x31, 0x98, 0x7C, 0x0E, 0x0F, 0xC7, 0x31, 0x8E,
  0xE3, 0xB0, 0xEC, 0x3B, 0x8C, 0xFF, 0x1F, 0x80, 0x0F, 0x87, 0xE1, 0x9C,
  0xE3, 0x30, 0xCC, 0x37, 0x1D, 0xC7, 0x73, 0xCF, 0xE3, 0xD8, 0x26, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0xFC, 0x3E, 0x00, 0x09, 0xCE, 0x20, 0x00, 0x00,
  0x00, 0x00, 0xCE, 0x70, 0x04, 0x31, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x31, 0xC6, 0x38, 0xC0, 0x00, 0x40, 0x70, 0x3C, 0x3C, 0x3C, 0x3C,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x3C, 0x3C, 0x3C, 0x3C, 0x0C, 0x02, 0x00, 0x1F, 0x1F, 0x88, 0xE0,
  0x70, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xC1, 0x86, 0x03,
  0x30, 0x0C, 0x8F, 0xB6, 0x64, 0xD1, 0x33, 0xCC, 0xCF, 0x23, 0x2C, 0x88,
  0xA6, 0x66, 0x99, 0x92, 0x6A, 0xC8, 0xEE, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x07, 0x70, 0x0F, 0xC0, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x36, 0x06,
  0xC1, 0x98, 0x33, 0x0E, 0x61, 0x8C, 0x31, 0x8F, 0xF1, 0xFE, 0x70, 0xCC,
  0x1B, 0x83, 0x70, 0x7C, 0x0C, 0x0F, 0x83, 0xFC, 0x73, 0x8C, 0x31, 0x86,
  0x30, 0xCE, 0x39, 0xCE, 0x3F, 0x07, 0xF0, 0xC7, 0x38, 0xE6, 0x1C, 0xC3,
  0x98, 0x67, 0x1C, 0xFF, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x71, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0x08, 0x7E, 0x07, 0xC0, 0x0F, 0x81, 0xFC, 0x1C, 0xE1,
  0x86, 0x18, 0x71, 0x87, 0x38, 0x73, 0x87, 0x30, 0x63, 0x06, 0x30, 0xE7,
  0x0E, 0x70, 0xC6, 0x1C, 0x63, 0x8E, 0x78, 0xFF, 0x0F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC4, 0x3F, 0x07, 0xE0,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x3F, 0x87,
  0xE0, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0xE0, 0xFF, 0x1C, 0x23, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE3, 0xEE, 0x3E, 0xE0, 0xCE, 0x0C, 0xC0, 0xCC, 0x1C, 0xE1, 0x8E, 0x18,
  0x7F, 0x83, 0xF8, 0x0C, 0x18, 0xE1, 0xC7, 0x0E, 0x30, 0x61, 0x83, 0x0C,
  0x18, 0xE1, 0xC7, 0x0E, 0x3F, 0xE1, 0xFF, 0x0C, 0x38, 0xE1, 0xC7, 0x0C,
  0x30, 0x61, 0x83, 0x1C, 0x38, 0xE1, 0xC6, 0x0C, 0x00, 0x1F, 0xC3, 0xE0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x78, 0x3F, 0x00, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x9C, 0x1E, 0x0F,
  0x00, 0x0C, 0x38, 0xE3, 0x87, 0x38, 0x31, 0x81, 0x9C, 0x0D, 0xC0, 0xEC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xEE, 0x06, 0x70, 0x31, 0x81,
  0x8C, 0x1C, 0x70, 0xE3, 0x86, 0x1C, 0x00, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xFF, 0xFC, 0x0E,
  0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xD8,
  0xF8, 0x7C, 0x6C, 0x7E, 0x36, 0x36, 0x1B, 0x1B, 0x0D, 0x99, 0x8E, 0xCD,
  0xC6, 0x6C, 0xE3, 0x36, 0x61, 0x9E, 0x31, 0xCF, 0x18, 0xE3, 0x1C, 0x61,
  0x8C, 0x00, 0x0E, 0x1C, 0x78, 0x71, 0xE1, 0x87, 0x86, 0x1E, 0x18, 0x78,
  0xE3, 0xF3, 0x0C, 0xCC, 0x33, 0x30, 0xCC, 0xC3, 0x37, 0x1C, 0xD8, 0x63,
  0xE1, 0x87, 0x86, 0x1E, 0x38, 0x78, 0xE1, 0xC3, 0x07, 0x00, 0x07, 0xC1,
  0xFC, 0x73, 0x9C, 0x33, 0x06, 0xE0, 0xD8, 0x1B, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0x6C, 0x0D, 0x83, 0xB8, 0x67, 0x1C, 0x7F, 0x0F, 0xC0, 0x0F,
  0x83, 0xF8, 0x73, 0x8C, 0x31, 0x86, 0x30, 0xCE, 0x39, 0xC6, 0x31, 0xC7,
  0xF0, 0xFC, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x00,
  0x07, 0xC1, 0xFC, 0x73, 0x9C, 0x33, 0x06, 0xE0, 0xD8, 0x1B, 0x03, 0xE0,
  0x7C, 0x1F, 0x83, 0xE0, 0x6C, 0x0D, 0x83, 0xB8, 0x67, 0x1C, 0x7F, 0x0F,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x83, 0xF8, 0x73, 0x8C,
  0x71, 0x8E, 0x31, 0xCE, 0x39, 0xC6, 0x33, 0xC7, 0xF0, 0xF8, 0x3B, 0x87,
  0x70, 0xC6, 0x18, 0xC7, 0x18, 0xE3, 0x98, 0x70, 0x03, 0xE0, 0xFF, 0x0E,
  0x21, 0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x84, 0x38, 0x7F, 0x0F, 0xE0, 0xFF,
  0xFF, 0xC6, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x18, 0x73, 0x87, 0x38,
  0x63, 0x06, 0x30, 0x63, 0x0E, 0x70, 0xC6, 0x0C, 0x60, 0xC6, 0x1C, 0xE1,
  0xCE, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x8E, 0x70, 0xFF, 0x07, 0xC0, 0xE0,
  0xFC, 0x1B, 0x87, 0x70, 0xCE, 0x39, 0xC6, 0x38, 0xC7, 0x38, 0xE6, 0x19,
  0xC3, 0x30, 0x6E, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0xC1, 0x83, 0xE0, 0xC1, 0xB0, 0xE1, 0xD8, 0x70, 0xCC, 0x38, 0x66, 0x3C,
  0x73, 0x1E, 0x31, 0x8F, 0x38, 0xCD, 0x98, 0x66, 0xCC, 0x36, 0x6E, 0x1B,
  0x36, 0x0D, 0x9B, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xC0,
  0x70, 0xE0, 0x00, 0x0C, 0x38, 0x63, 0x83, 0x18, 0x19, 0xC0, 0xEC, 0x07,
  0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xB0,
  0x1D, 0x80, 0xCC, 0x0C, 0x70, 0xE3, 0x86, 0x1C, 0x00, 0xE1, 0xF8, 0xEE,
  0x31, 0x9C, 0x66, 0x1B, 0x86, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x0F, 0xE1, 0xFC, 0x43,
  0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xC1, 0xF0,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x7C, 0x3E,
  0x00, 0xE3, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0x18,
  0xC0, 0x07, 0xC1, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x7C, 0x3E, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x3C, 0x0D, 0x86,
  0x63, 0x18, 0xC7, 0x60, 0xF8, 0x30, 0xFF, 0xFF, 0xDD, 0x90, 0x0C, 0x0F,
  0xB3, 0xB9, 0xC6, 0x61, 0xB8, 0xEC, 0x3B, 0x0C, 0xC3, 0x30, 0xCC, 0x73,
  0x3C, 0xFE, 0x3D, 0x80, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x41,
  0xFC, 0xF7, 0x38, 0xCC, 0x33, 0x0C, 0xC3, 0x71, 0xD8, 0x76, 0x19, 0x8E,
  0xE3, 0x3F, 0xCD, 0xE0, 0x0E, 0x1F, 0x3A, 0x70, 0x60, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC4, 0xFC, 0x7C, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x19, 0x8F, 0xF1, 0xDC, 0x71, 0x8C, 0x33, 0x8E, 0x61, 0xCC, 0x31,
  0x86, 0x30, 0xC6, 0x38, 0xC7, 0x1F, 0xC3, 0xD8, 0x00, 0x0E, 0x1F, 0x33,
  0x63, 0x63, 0xE7, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x00,
  0xF0, 0x1E, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x0F, 0xC0, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x0F, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0xFB, 0x0E, 0xE1, 0xC6, 0x18, 0x63, 0x8E, 0x30, 0xE3,
  0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC3, 0x3C, 0x3F, 0x83, 0xD8, 0x01, 0x80,
  0x38, 0x03, 0x08, 0x70, 0xFE, 0x07, 0xC0, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0xC1, 0xFC, 0xF7, 0x38, 0xCC, 0x33, 0x1C, 0xC6, 0x71, 0x98,
  0x66, 0x39, 0x8E, 0xE3, 0x38, 0xCC, 0x30, 0x08, 0x71, 0xC0, 0x00, 0x01,
  0x8E, 0x30, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x8C, 0x00, 0x01, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC1,
  0xE0, 0xE0, 0x00, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x46,
  0x71, 0xCC, 0x33, 0x06, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xEC, 0x19, 0x83,
  0x30, 0xE7, 0x1C, 0xE3, 0x0C, 0x00, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x8E,
  0x30, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x8C, 0x00, 0x03, 0x0C, 0x3F,
  0xFC, 0xF7, 0xB9, 0xCE, 0x33, 0x1C, 0x66, 0x31, 0xCC, 0x63, 0xB8, 0xC6,
  0x61, 0x8C, 0xC7, 0x19, 0x8C, 0x77, 0x18, 0xCE, 0x31, 0x98, 0xE3, 0x00,
  0x0B, 0x05, 0xF3, 0xDC, 0xE3, 0x31, 0xCC, 0x73, 0x19, 0xC6, 0x61, 0x98,
  0xE6, 0x3B, 0x8C, 0xE3, 0x30, 0xC0, 0x0E, 0x1F, 0x8C, 0xEC, 0x76, 0x1F,
  0x1F, 0x0F, 0x87, 0xC3, 0x61, 0xB1, 0xD8, 0xCF, 0xE3, 0xC0, 0x00, 0x81,
  0xFC, 0x7B, 0x8E, 0x31, 0x86, 0x30, 0xC6, 0x19, 0xC7, 0x30, 0xE6, 0x18,
  0xC7, 0x38, 0xC6, 0xF8, 0xDE, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x0F, 0xB3, 0xB9, 0xC6, 0x61, 0xB8, 0xEC, 0x3B, 0x0C,
  0xC3, 0x30, 0xCC, 0x73, 0x1C, 0xFE, 0x3D, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x0B, 0x17, 0x37, 0x38, 0x38, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x0E, 0x1F, 0xCE, 0x4E, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x03, 0x91, 0xCF, 0xC7, 0xC0, 0x18, 0xC3, 0x3F,
  0x71, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0F, 0x3C, 0x31, 0xDC, 0x66,
  0x19, 0x8E, 0x63, 0xB8, 0xCE, 0x33, 0x0C, 0xC7, 0x31, 0x8C, 0xE3, 0xF8,
  0xF6, 0x00, 0xE3, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0x71, 0xB0, 0xF8, 0x78,
  0x3C, 0x1C, 0x0E, 0x06, 0x00, 0x63, 0x8D, 0x9E, 0x76, 0x79, 0xB9, 0x66,
  0xED, 0xB3, 0xB6, 0xCF, 0x97, 0x3E, 0x58, 0xDB, 0x63, 0xCF, 0x0F, 0x3C,
  0x38, 0xF0, 0xE3, 0x80, 0x18, 0xE3, 0xB8, 0x76, 0x07, 0xC0, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x06, 0xE1, 0xCC, 0x31, 0x8E, 0x30, 0x0C, 0x70,
  0xC6, 0x0C, 0x60, 0xCE, 0x0C, 0xC0, 0xDC, 0x0D, 0x80, 0xD8, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x0F,
  0x00, 0xE0, 0x00, 0x1F, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30,
  0x38, 0x18, 0x18, 0x1F, 0xCF, 0xE0, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x07, 0x83, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x3C, 0x0E, 0x07,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x78, 0x38, 0x00,
  0x20, 0x7F, 0x3D, 0xFE, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 8, 7, 9, 2, -18 },
  { 24, 12, 18, 11, 0, -18 },
  { 51, 11, 20, 10, 0, -19 },
  { 79, 14, 18, 16, 1, -18 },
  { 111, 11, 18, 11, 0, -18 },
  { 136, 3, 7, 5, 3, -18 },
  { 139, 8, 22, 7, 0, -18 },
  { 161, 8, 22, 7, -2, -18 },
  { 183, 8, 9, 9, 2, -19 },
  { 192, 10, 12, 11, 1, -15 },
  { 207, 5, 6, 5, -1, -3 },
  { 211, 6, 2, 7, 0, -8 },
  { 213, 3, 3, 5, 0, -3 },
  { 215, 12, 18, 9, -1, -18 },
  { 242, 9, 18, 10, 1, -18 },
  { 263, 6, 18, 10, 3, -18 },
  { 277, 11, 18, 10, -1, -18 },
  { 302, 10, 18, 10, 0, -18 },
  { 325, 10, 18, 10, 0, -18 },
  { 348, 10, 18, 10, 0, -18 },
  { 371, 10, 18, 10, 1, -18 },
  { 394, 10, 18, 10, 1, -18 },
  { 417, 10, 18, 10, 0, -18 },
  { 440, 10, 18, 10, 0, -18 },
  { 463, 5, 14, 5, 0, -14 },
  { 472, 6, 17, 5, -1, -14 },
  { 485, 10, 12, 11, 1, -15 },
  { 500, 10, 7, 11, 1, -12 },
  { 509, 10, 12, 11, 1, -15 },
  { 524, 9, 18, 8, 0, -18 },
  { 545, 14, 20, 15, 1, -18 },
  { 580, 11, 18, 11, -2, -18 },
  { 605, 11, 18, 11, 0, -18 },
  { 630, 11, 18, 10, 1, -18 },
  { 655, 12, 18, 12, 0, -18 },
  { 682, 11, 18, 9, 0, -18 },
  { 707, 11, 18, 9, 0, -18 },
  { 732, 12, 18, 13, 1, -18 },
  { 759, 13, 18, 12, 0, -18 },
  { 789, 10, 18, 7, -1, -18 },
  { 812, 10, 23, 5, -4, -18 },
  { 841, 13, 18, 11, 0, -18 },
  { 871, 7, 18, 9, 0, -18 },
  { 887, 17, 18, 17, 0, -18 },
  { 926, 14, 18, 13, 0, -18 },
  { 958, 11, 18, 13, 1, -18 },
  { 983, 11, 18, 11, 0, -18 },
  { 1008, 11, 22, 13, 1, -18 },
  { 1039, 11, 18, 11, 0, -18 },
  { 1064, 12, 18, 10, -1, -18 },
  { 1091, 9, 18, 9, 2, -18 },
  { 1112, 12, 18, 12, 1, -18 },
  { 1139, 11, 18, 11, 2, -18 },
  { 1164, 17, 18, 17, 2, -18 },
  { 1203, 13, 18, 10, -1, -18 },
  { 1233, 10, 18, 9, 2, -18 },
  { 1256, 11, 18, 9, -1, -18 },
  { 1281, 10, 22, 7, -1, -18 },
  { 1309, 5, 18, 9, 2, -18 },
  { 1321, 10, 22, 7, -2, -18 },
  { 1349, 10, 10, 10, 0, -18 },
  { 1362, 8, 2, 8, -2, 2 },
  { 1364, 3, 4, 7, 4, -19 },
  { 1366, 10, 14, 11, 1, -14 },
  { 1384, 10, 19, 11, 0, -19 },
  { 1408, 8, 14, 8, 1, -14 },
  { 1422, 11, 19, 11, 1, -19 },
  { 1449, 8, 14, 10, 1, -14 },
  { 1463, 12, 25, 6, -3, -19 },
  { 1501, 12, 20, 11, -1, -14 },
  { 1531, 10, 19, 11, 0, -19 },
  { 1555, 6, 19, 5, 0, -19 },
  { 1570, 9, 25, 5, -3, -19 },
  { 1599, 11, 19, 10, 0, -19 },
  { 1626, 6, 19, 5, 0, -19 },
  { 1641, 15, 14, 16, 0, -14 },
  { 1668, 10, 14, 11, 0, -14 },
  { 1686, 9, 14, 10, 1, -14 },
  { 1702, 11, 20, 11, -1, -14 },
  { 1730, 10, 20, 11, 1, -14 },
  { 1755, 8, 14, 7, 0, -14 },
  { 1769, 9, 14, 8, 0, -14 },
  { 1785, 6, 16, 6, 1, -16 },
  { 1797, 10, 13, 11, 1, -13 },
  { 1814, 9, 13, 9, 1, -13 },
  { 1829, 14, 13, 14, 1, -13 },
  { 1852, 11, 13, 9, -1, -13 },
  { 1870, 12, 19, 9, -2, -13 },
  { 1899, 9, 13, 7, -1, -13 },
  { 1914, 10, 22, 8, 0, -18 },
  { 1942, 3, 25, 9, 3, -19 },
  { 1952, 10, 22, 8, -2, -18 },
  { 1980, 10, 4, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC25PT7B_H_
