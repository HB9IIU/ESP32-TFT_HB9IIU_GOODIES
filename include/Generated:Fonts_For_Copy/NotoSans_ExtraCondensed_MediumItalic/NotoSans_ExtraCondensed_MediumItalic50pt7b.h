#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E,
  0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x38,
  0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x70, 0x00, 0xE0, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x1C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEC, 0xF0, 0x3E, 0x61, 0x01,
  0xE3, 0x00, 0x1F, 0x18, 0x00, 0xF9, 0x80, 0x07, 0xCC, 0x00, 0x3E, 0x60,
  0x00, 0xFB, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0D, 0xF0,
  0x00, 0x67, 0x80, 0x03, 0x3E, 0x00, 0x31, 0xF0, 0x01, 0x8F, 0x00, 0x0C,
  0x78, 0x40, 0x63, 0xC1, 0x83, 0x3E, 0x1F, 0xBF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x7F, 0x00, 0x78, 0x0F, 0xF8, 0x07, 0x00, 0xF7, 0x80, 0xF0, 0x1E,
  0x38, 0x0E, 0x01, 0xC3, 0x81, 0xE0, 0x3C, 0x38, 0x1C, 0x03, 0xC3, 0x83,
  0xC0, 0x38, 0x38, 0x38, 0x07, 0x83, 0x87, 0x80, 0x78, 0x78, 0xF0, 0x07,
  0x07, 0x8F, 0x00, 0x70, 0x71, 0xE0, 0x07, 0x07, 0x1E, 0x00, 0x70, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0xFE, 0xF0, 0xE7, 0x9F, 0xF7, 0x1E, 0x71, 0xEF,
  0x7B, 0xCF, 0x3C, 0x77, 0xF8, 0xE3, 0x87, 0x7F, 0x9E, 0x78, 0x73, 0xE1,
  0xC7, 0x07, 0x00, 0x3C, 0x70, 0x70, 0x03, 0x8F, 0x0F, 0x00, 0x78, 0xF0,
  0xF0, 0x07, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0xE0, 0x0E, 0x1E, 0x0E, 0x01,
  0xE1, 0xE1, 0xE0, 0x3C, 0x1E, 0x1E, 0x03, 0xC1, 0xE3, 0xC0, 0x78, 0x1E,
  0x3C, 0x07, 0x81, 0xE7, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x01,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x00, 0x3E,
  0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x1F, 0x1F, 0x7C, 0x7C, 0xF9, 0xF1, 0xE3, 0xC3, 0xCF, 0x9F, 0x0F,
  0xBC, 0x78, 0x3F, 0xF3, 0xE0, 0x7F, 0x8F, 0x81, 0xFE, 0x3C, 0x07, 0xF0,
  0xF0, 0x0F, 0xC3, 0xC0, 0x3E, 0x0F, 0x81, 0xFC, 0x3E, 0x0F, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xEF, 0x87, 0xFF, 0x3E, 0x0F, 0xF0, 0xFC, 0x06, 0x00,
  0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x63, 0xC0, 0xFB, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF,
  0x0F, 0xC0, 0x1F, 0xE0, 0x3E, 0xF0, 0xFC, 0xF0, 0x78, 0xF8, 0x38, 0x78,
  0x10, 0x70, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C,
  0x3C, 0x1E, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3D,
  0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0x0F,
  0x81, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0x79, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83,
  0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x1F, 0xBC, 0xFD, 0xF1,
  0xE7, 0xC7, 0x1E, 0x08, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xF0,
  0xFC, 0x03, 0x81, 0xF0, 0x08, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x10, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xE1, 0xF8, 0x06, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x08, 0x01, 0xF8, 0x30, 0x0F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x77, 0xC0,
  0x03, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x73, 0xE0, 0x03, 0xCF, 0x80, 0x1E,
  0x3E, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x1F, 0x00, 0x78, 0x7C,
  0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x0E,
  0x03, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x02, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x82, 0x00, 0xFC, 0x18, 0x0F, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x1E, 0x00, 0xFB, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFC, 0xFC,
  0x1F, 0xC3, 0xE0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0,
  0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x8F,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3E, 0x1F, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0xF8, 0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x3E,
  0x03, 0xE3, 0xE0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF9, 0xF0, 0x1F, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x03, 0xE0, 0xFF, 0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xE0, 0x1F, 0x1E, 0x03, 0xF1, 0xE0, 0x3E, 0x1F, 0x07, 0xE1, 0xF0,
  0x7E, 0x1F, 0x9F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFB, 0xC0, 0xFF, 0x3C, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFF, 0x0C, 0x1F, 0x08, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0xFF, 0x1E, 0x1C, 0x0F, 0xF8,
  0xF1, 0xE0, 0xFF, 0xC7, 0x8E, 0x0F, 0x1E, 0x3C, 0x70, 0xF0, 0xE1, 0xE7,
  0x87, 0x07, 0x0E, 0x38, 0x78, 0x78, 0x71, 0xC3, 0x83, 0xC3, 0x9E, 0x1C,
  0x1C, 0x1C, 0xE1, 0xE0, 0xE1, 0xE7, 0x0F, 0x0F, 0x0E, 0x38, 0x70, 0x78,
  0x71, 0xC3, 0x83, 0x83, 0x9E, 0x1C, 0x3C, 0x38, 0xF0, 0xE1, 0xE1, 0xC7,
  0x87, 0x1F, 0x1C, 0x3C, 0x38, 0xF8, 0xE1, 0xE1, 0xFF, 0xFE, 0x0F, 0x0F,
  0xE7, 0xE0, 0x78, 0x3E, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x80, 0x03, 0xE0, 0x1C, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1E, 0x1F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0xF8, 0x7F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xE0,
  0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3E, 0x0F,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xF8, 0x30, 0x0F, 0xC0, 0x40, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x1F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x3F, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0x83, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xF0,
  0x3E, 0x3F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFC, 0x1E, 0x03, 0xF0, 0x04, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x04, 0xFC, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F,
  0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7E, 0x03,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x07, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x3C,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0x78, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x19, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE1, 0xF0,
  0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC0, 0xF0, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xBC, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7,
  0xC0, 0xFB, 0xC0, 0x79, 0xE0, 0x3E, 0xF0, 0x1E, 0xF8, 0x0F, 0xBC, 0x0F,
  0x3E, 0x03, 0xCF, 0x83, 0xCF, 0x80, 0xF1, 0xE1, 0xE3, 0xC0, 0x7C, 0x78,
  0x78, 0xF0, 0x1F, 0x1E, 0x3E, 0x7C, 0x07, 0x87, 0x8F, 0x1F, 0x01, 0xE1,
  0xE3, 0xC7, 0xC0, 0x78, 0x79, 0xE1, 0xE0, 0x3E, 0x1E, 0x78, 0x78, 0x0F,
  0x87, 0xBC, 0x3E, 0x03, 0xC1, 0xEF, 0x0F, 0x80, 0xF0, 0x7F, 0x83, 0xE0,
  0x3C, 0x1F, 0xE0, 0xF0, 0x1F, 0x07, 0xF8, 0x3C, 0x07, 0xC1, 0xFC, 0x1F,
  0x01, 0xE0, 0x7F, 0x07, 0xC0, 0x78, 0x1F, 0x81, 0xE0, 0x3E, 0x07, 0xE0,
  0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x1E, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x80, 0x3E,
  0x01, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x03, 0xC0, 0x3F,
  0xC0, 0x3C, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x07, 0xDE, 0x07,
  0x80, 0x79, 0xE0, 0x78, 0x07, 0x9E, 0x07, 0x80, 0x79, 0xE0, 0xF8, 0x0F,
  0x9E, 0x0F, 0x80, 0xF9, 0xE0, 0xF0, 0x0F, 0x8F, 0x0F, 0x00, 0xF0, 0xF1,
  0xF0, 0x0F, 0x0F, 0x1F, 0x01, 0xF0, 0xF1, 0xF0, 0x1F, 0x0F, 0x1E, 0x01,
  0xF0, 0xF1, 0xE0, 0x1E, 0x07, 0xBE, 0x01, 0xE0, 0x7B, 0xE0, 0x3E, 0x07,
  0xBE, 0x03, 0xE0, 0x7B, 0xC0, 0x3C, 0x07, 0xBC, 0x03, 0xC0, 0x7F, 0xC0,
  0x3C, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x7C, 0x03, 0xF8, 0x07, 0x80,
  0x3F, 0x80, 0x78, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0xF8, 0x03, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0x81,
  0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x3E,
  0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xE7, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFC, 0xF8, 0x0F, 0xC0, 0x40,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x04, 0x01, 0xF8, 0x3C, 0x0F, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x3E,
  0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3C,
  0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80,
  0xFC, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F,
  0x80, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xDF, 0x00, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0x3E, 0x7C, 0x03,
  0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x03, 0xC7, 0xC0, 0x7F, 0x01, 0xF1, 0xF0,
  0x1F, 0xC0, 0x7C, 0x7C, 0x07, 0xF0, 0x3E, 0x1F, 0x03, 0xFC, 0x0F, 0x87,
  0xC0, 0xFF, 0x03, 0xC1, 0xF0, 0x7B, 0xC1, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C,
  0x1F, 0x07, 0xBC, 0x1E, 0x07, 0xC3, 0xCE, 0x0F, 0x81, 0xE0, 0xF3, 0x83,
  0xC0, 0x78, 0x78, 0xE1, 0xF0, 0x1E, 0x1E, 0x78, 0x7C, 0x07, 0x87, 0x9E,
  0x1E, 0x01, 0xE3, 0xC7, 0x8F, 0x80, 0x78, 0xF1, 0xE3, 0xC0, 0x1E, 0x3C,
  0x79, 0xF0, 0x07, 0x9E, 0x1E, 0x7C, 0x01, 0xE7, 0x87, 0x9E, 0x00, 0x7B,
  0xC1, 0xEF, 0x80, 0x1E, 0xF0, 0x7B, 0xC0, 0x07, 0xBC, 0x1E, 0xF0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xF9, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0xF8, 0xF8,
  0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1,
  0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF0,
  0x78, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE1, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0x80,
  0x1E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x1E,
  0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x7C, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7C, 0x7C,
  0x3E, 0x1E, 0x1E, 0x0F, 0x07, 0x00, 0xFC, 0x78, 0x1F, 0xF7, 0x81, 0xFF,
  0xBC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8,
  0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0,
  0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0xFD, 0xE0, 0x7F, 0xFF, 0x01, 0xFE,
  0xF0, 0x0F, 0xE7, 0x80, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x9F, 0x80, 0x7D, 0xFE, 0x03, 0xDF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFC,
  0x3E, 0x0F, 0xC0, 0xF0, 0x7E, 0x07, 0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xE0,
  0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E,
  0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC,
  0x1F, 0xFF, 0xC1, 0xEF, 0xFC, 0x0F, 0x3F, 0xC0, 0x78, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC,
  0x10, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x40, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xE7,
  0xC0, 0x3F, 0xEF, 0x00, 0xFF, 0xDE, 0x01, 0xFF, 0xFC, 0x07, 0xC3, 0xF8,
  0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x7C,
  0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x7E, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x70, 0x07, 0xFD, 0xE0,
  0x07, 0xF3, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0x1F, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0xF8,
  0x1F, 0x3E, 0x07, 0x8F, 0x03, 0xE7, 0xC1, 0xF1, 0xF3, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x41, 0xF8,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x1E, 0x01, 0xFF, 0x78, 0x07, 0xFE,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xE0,
  0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xEF, 0x00, 0x3F, 0x9E, 0x00, 0x08, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0x00, 0x7C, 0x03, 0x83, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0xFC, 0x07, 0xDF, 0xE0, 0x7B, 0xFF, 0x07, 0xFF, 0xF0, 0x7E,
  0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC1,
  0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x78,
  0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F,
  0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x9F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x80, 0xF0,
  0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x00,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xE3, 0xC0, 0x1E,
  0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0x8F, 0xC3, 0xF8, 0x1E, 0xFF, 0x9F, 0xE0, 0x7B, 0xFE, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x7C, 0x3F, 0x07, 0xE0, 0xF0,
  0xF8, 0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x01, 0xE0, 0x7C, 0x3C,
  0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x07, 0x87, 0xC0, 0xF8, 0x1E, 0x1E, 0x03,
  0xC0, 0xF8, 0x78, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0,
  0x3C, 0x3E, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x1F,
  0x1F, 0x03, 0xE0, 0x78, 0x7C, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0x3E, 0x1E, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xC3, 0xE0,
  0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x07, 0x8F, 0xC0, 0x79, 0xFE,
  0x07, 0xBF, 0xF0, 0x7F, 0xFF, 0x07, 0xE1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0xF0, 0x07,
  0x9E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x71,
  0xF8, 0x00, 0xF3, 0xFC, 0x00, 0xF7, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFC,
  0x3E, 0x01, 0xF8, 0x1E, 0x01, 0xF8, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0x7F, 0x80, 0x1F, 0x3F, 0x00, 0x1E, 0x08, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x78, 0x1F, 0xF7,
  0x81, 0xFF, 0xBC, 0x0F, 0xFF, 0xE0, 0xF8, 0x7F, 0x07, 0x81, 0xF8, 0x7C,
  0x0F, 0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8,
  0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00,
  0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFE, 0xF0, 0x0F, 0xE7, 0x80, 0x08, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x8F, 0x83, 0xCF, 0x81, 0xEF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xB0, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xE1, 0xF0, 0x20, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC2, 0x03,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0x80, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3F, 0xE7,
  0xFF, 0x3F, 0xF9, 0xFF, 0xC3, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x40, 0x00, 0x0F, 0x80, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xDE, 0x07, 0xFD,
  0xE0, 0x3F, 0x1E, 0x00, 0x40, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0,
  0x7C, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1E, 0xF0,
  0x3F, 0x03, 0xEF, 0x03, 0xF0, 0x3C, 0xF0, 0x3F, 0x07, 0xCF, 0x07, 0xF0,
  0x78, 0xF0, 0x77, 0x07, 0x8F, 0x0F, 0xF0, 0xF8, 0xF0, 0xFF, 0x0F, 0x0F,
  0x0E, 0xF1, 0xF0, 0xF1, 0xEF, 0x1E, 0x0F, 0x1E, 0xF1, 0xE0, 0xF3, 0xCF,
  0x3E, 0x0F, 0x3C, 0xF3, 0xC0, 0xF3, 0x8F, 0x3C, 0x0F, 0x78, 0xF7, 0x80,
  0xF7, 0x8F, 0x78, 0x0F, 0x70, 0xF7, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x7D,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x1E,
  0x00, 0x7C, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01,
  0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x23, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0x00, 0xFF, 0xA0, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 36, 12, 0, -36 },
  { 60, 15, 13, 18, 5, -36 },
  { 85, 23, 36, 22, 0, -36 },
  { 189, 21, 41, 20, 0, -38 },
  { 297, 28, 37, 32, 2, -36 },
  { 427, 22, 37, 23, 0, -36 },
  { 529, 7, 13, 10, 5, -36 },
  { 541, 15, 44, 13, 1, -36 },
  { 624, 16, 44, 13, -4, -36 },
  { 712, 16, 18, 19, 5, -38 },
  { 748, 19, 24, 22, 2, -30 },
  { 805, 9, 13, 11, -2, -6 },
  { 820, 11, 5, 13, 1, -16 },
  { 827, 6, 6, 11, 0, -6 },
  { 832, 24, 36, 17, -3, -36 },
  { 940, 19, 37, 20, 1, -36 },
  { 1028, 14, 36, 20, 5, -36 },
  { 1091, 22, 36, 20, -2, -36 },
  { 1190, 22, 37, 20, -1, -36 },
  { 1292, 22, 36, 20, -1, -36 },
  { 1391, 21, 37, 20, 0, -36 },
  { 1489, 21, 37, 20, 1, -36 },
  { 1587, 21, 36, 20, 1, -36 },
  { 1682, 21, 37, 20, 0, -36 },
  { 1780, 20, 37, 20, 0, -36 },
  { 1873, 11, 27, 11, 0, -27 },
  { 1911, 14, 34, 11, -3, -27 },
  { 1971, 19, 23, 22, 2, -29 },
  { 2026, 19, 15, 22, 2, -25 },
  { 2062, 19, 23, 22, 2, -29 },
  { 2117, 16, 36, 15, 1, -36 },
  { 2189, 29, 40, 30, 1, -36 },
  { 2334, 21, 36, 21, -3, -36 },
  { 2429, 23, 36, 22, 0, -36 },
  { 2533, 22, 37, 20, 2, -36 },
  { 2635, 23, 36, 24, 0, -36 },
  { 2739, 21, 36, 19, 0, -36 },
  { 2834, 21, 36, 18, 0, -36 },
  { 2929, 24, 37, 25, 2, -36 },
  { 3040, 26, 36, 25, 0, -36 },
  { 3157, 19, 36, 14, -2, -36 },
  { 3243, 19, 46, 11, -7, -36 },
  { 3353, 25, 36, 21, 0, -36 },
  { 3466, 14, 36, 18, 0, -36 },
  { 3529, 34, 36, 33, 0, -36 },
  { 3682, 28, 36, 26, 0, -36 },
  { 3808, 23, 37, 26, 2, -36 },
  { 3915, 22, 36, 21, 0, -36 },
  { 4014, 23, 45, 26, 2, -36 },
  { 4144, 22, 36, 22, 0, -36 },
  { 4243, 22, 37, 19, -1, -36 },
  { 4345, 19, 36, 18, 3, -36 },
  { 4431, 24, 37, 24, 2, -36 },
  { 4542, 21, 36, 21, 4, -36 },
  { 4637, 34, 36, 33, 3, -36 },
  { 4790, 26, 36, 20, -3, -36 },
  { 4907, 19, 36, 19, 4, -36 },
  { 4993, 23, 36, 18, -2, -36 },
  { 5097, 20, 44, 14, -2, -36 },
  { 5207, 9, 36, 18, 5, -36 },
  { 5248, 19, 44, 14, -3, -36 },
  { 5353, 20, 20, 20, 0, -36 },
  { 5403, 16, 3, 15, -4, 4 },
  { 5409, 8, 8, 13, 7, -38 },
  { 5417, 21, 28, 22, 1, -27 },
  { 5491, 21, 39, 21, 0, -38 },
  { 5594, 17, 28, 17, 1, -27 },
  { 5654, 23, 39, 22, 1, -38 },
  { 5767, 18, 28, 20, 1, -27 },
  { 5830, 24, 50, 12, -6, -38 },
  { 5980, 23, 39, 22, -1, -27 },
  { 6093, 20, 38, 21, 0, -38 },
  { 6188, 12, 37, 10, 0, -37 },
  { 6244, 18, 49, 10, -6, -37 },
  { 6355, 21, 38, 19, 0, -38 },
  { 6455, 13, 38, 10, 0, -38 },
  { 6517, 30, 27, 32, 0, -27 },
  { 6619, 20, 27, 21, 0, -27 },
  { 6687, 19, 28, 21, 1, -27 },
  { 6754, 24, 39, 21, -3, -27 },
  { 6871, 21, 39, 22, 1, -27 },
  { 6974, 17, 27, 15, 0, -27 },
  { 7032, 17, 28, 16, 0, -27 },
  { 7092, 13, 34, 13, 1, -33 },
  { 7148, 20, 28, 21, 1, -27 },
  { 7218, 17, 27, 18, 3, -27 },
  { 7276, 28, 27, 28, 3, -27 },
  { 7371, 22, 27, 18, -2, -27 },
  { 7446, 25, 39, 18, -4, -27 },
  { 7568, 19, 27, 15, -2, -27 },
  { 7633, 19, 44, 17, 1, -36 },
  { 7738, 4, 50, 18, 7, -38 },
  { 7763, 18, 44, 17, -3, -36 },
  { 7862, 19, 7, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC50PT7B_H_
