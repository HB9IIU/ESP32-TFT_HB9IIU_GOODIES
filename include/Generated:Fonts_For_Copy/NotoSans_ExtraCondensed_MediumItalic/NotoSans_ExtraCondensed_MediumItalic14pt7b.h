#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x64, 0x40, 0xCC, 0x5A, 0x95, 0x20, 0x14, 0x28, 0x9B,
  0xE2, 0x89, 0x3F, 0x28, 0x51, 0x40, 0x08, 0x23, 0xD4, 0x70, 0xC1, 0x8A,
  0x2B, 0xC2, 0x10, 0x67, 0x4A, 0xA5, 0x4B, 0x7B, 0x4A, 0x95, 0x4B, 0x98,
  0x38, 0xA2, 0x8E, 0x31, 0xDD, 0xE6, 0x9B, 0xB0, 0x56, 0x19, 0x88, 0xC4,
  0x23, 0x18, 0x84, 0x30, 0x80, 0x11, 0x11, 0x11, 0x13, 0x22, 0x4C, 0x35,
  0x3E, 0xC5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x2D, 0x60, 0xE0, 0xF0, 0x06,
  0x08, 0x30, 0x41, 0x02, 0x08, 0x10, 0x41, 0x80, 0x18, 0xB6, 0xD3, 0x49,
  0x2C, 0xB6, 0xD1, 0x80, 0x37, 0xF2, 0x22, 0x26, 0x44, 0x78, 0xB0, 0xC2,
  0x18, 0x42, 0x10, 0xC3, 0xC0, 0x39, 0x30, 0xC2, 0x30, 0x61, 0x86, 0x93,
  0xC0, 0x0C, 0x61, 0x8A, 0x49, 0x69, 0x3E, 0x10, 0xC0, 0x3C, 0x86, 0x10,
  0x78, 0x60, 0x86, 0x93, 0xC0, 0x1C, 0xC2, 0x10, 0x79, 0x2C, 0xB2, 0xD9,
  0xC0, 0x7C, 0x10, 0x82, 0x10, 0x42, 0x08, 0x63, 0x00, 0x39, 0xB6, 0xDA,
  0x31, 0xCC, 0xA2, 0x9B, 0xC0, 0x39, 0xB4, 0xD3, 0x49, 0xE0, 0x86, 0x33,
  0x80, 0x2C, 0x00, 0x36, 0x13, 0x00, 0x00, 0x26, 0x4C, 0x09, 0xB1, 0x83,
  0x04, 0xF8, 0x01, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0x7A, 0x46, 0x22, 0x31,
  0x00, 0x46, 0x00, 0x0E, 0x31, 0x23, 0x4D, 0x55, 0x55, 0xA5, 0xBE, 0x80,
  0x40, 0x78, 0x0C, 0x31, 0x45, 0x34, 0x93, 0xD9, 0x47, 0x10, 0x3C, 0x92,
  0x59, 0x79, 0x24, 0xD2, 0xDB, 0xC0, 0x1E, 0x61, 0x83, 0x04, 0x08, 0x30,
  0x20, 0x40, 0xF0, 0x3C, 0x48, 0x9B, 0x34, 0x48, 0x91, 0x26, 0xD9, 0xE0,
  0x3C, 0x82, 0x18, 0x79, 0x04, 0x10, 0xC3, 0xC0, 0x3C, 0x82, 0x18, 0x61,
  0xE4, 0x10, 0xC2, 0x00, 0x1E, 0x65, 0x83, 0x04, 0x29, 0xB1, 0x22, 0x4C,
  0xF8, 0x22, 0x44, 0x9B, 0x37, 0xC8, 0x91, 0x26, 0xCD, 0x10, 0x3C, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x23, 0xC0, 0x08, 0x42, 0x31, 0x88, 0x42, 0x31,
  0x09, 0xCC, 0x00, 0x26, 0x48, 0xA3, 0xC5, 0x0E, 0x14, 0x2C, 0xD9, 0x10,
  0x22, 0x26, 0x44, 0x44, 0xCF, 0x31, 0xCC, 0x63, 0x19, 0xCA, 0x53, 0x95,
  0x45, 0x51, 0x64, 0xD9, 0x26, 0xC0, 0x33, 0x32, 0x32, 0x72, 0x52, 0x5E,
  0x4C, 0x4C, 0xCC, 0x8C, 0x1C, 0x6D, 0x8A, 0x14, 0x68, 0xD1, 0x62, 0x48,
  0xF0, 0x3C, 0x92, 0x59, 0x4D, 0xE4, 0x10, 0xC2, 0x00, 0x1C, 0x6D, 0x8A,
  0x14, 0x68, 0xD1, 0x62, 0x48, 0xF0, 0x40, 0xC0, 0x38, 0xB2, 0x59, 0x4D,
  0xC5, 0x16, 0xDA, 0x20, 0x3D, 0x94, 0x18, 0x30, 0xC1, 0x86, 0x93, 0xC0,
  0xF9, 0x08, 0xC4, 0x21, 0x18, 0xC4, 0x00, 0x22, 0x44, 0x9B, 0x24, 0x48,
  0x93, 0x66, 0x48, 0xE0, 0xCF, 0x2C, 0xB6, 0xD2, 0xCA, 0x28, 0xC3, 0x00,
  0xC8, 0xC4, 0x66, 0x53, 0x29, 0xB5, 0x52, 0xA9, 0x9C, 0xCC, 0x66, 0x00,
  0x32, 0x2C, 0x50, 0xC1, 0x83, 0x0E, 0x14, 0x49, 0x90, 0xCF, 0x6D, 0x1C,
  0x61, 0x84, 0x10, 0xC2, 0x00, 0x3E, 0x08, 0x30, 0x41, 0x82, 0x08, 0x10,
  0x41, 0xF0, 0x39, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0xC0, 0xC9, 0x24,
  0x93, 0x64, 0x38, 0x42, 0x31, 0x08, 0x42, 0x31, 0x09, 0xC0, 0x10, 0x62,
  0x9A, 0x4A, 0x10, 0xF0, 0xD4, 0x14, 0xB4, 0xD2, 0xCB, 0x2D, 0x9E, 0x20,
  0x82, 0x0E, 0x6D, 0xB4, 0xD2, 0xCB, 0x6B, 0x00, 0x19, 0x50, 0x8C, 0x63,
  0x0E, 0x06, 0x08, 0x10, 0xA2, 0xC9, 0x92, 0x64, 0xC9, 0xB1, 0xE0, 0x19,
  0x52, 0xBE, 0x63, 0x0E, 0x06, 0x1C, 0x20, 0x61, 0xC3, 0x04, 0x08, 0x10,
  0x60, 0x81, 0x02, 0x1C, 0x00, 0x14, 0xB4, 0xD2, 0xCB, 0x2D, 0x9E, 0x10,
  0x4F, 0x00, 0x30, 0x82, 0x0E, 0x7D, 0xB4, 0x92, 0xCB, 0x69, 0x00, 0x20,
  0xB4, 0x96, 0xD0, 0x08, 0x02, 0x31, 0x08, 0x42, 0x31, 0x08, 0x4E, 0x00,
  0x30, 0x82, 0x09, 0x69, 0x47, 0x1C, 0x53, 0x49, 0x80, 0x32, 0x22, 0x64,
  0x44, 0x4C, 0x80, 0x3B, 0x6D, 0x4D, 0x49, 0x49, 0xC9, 0xDB, 0x92, 0x39,
  0xB6, 0xD2, 0x4B, 0x2D, 0xA4, 0x10, 0xA4, 0xD2, 0xCB, 0x2D, 0x9C, 0x1C,
  0x6C, 0xD9, 0x32, 0x44, 0x9B, 0x2C, 0x40, 0x83, 0x00, 0x14, 0xB4, 0xD2,
  0xCB, 0x2D, 0x9E, 0x10, 0x43, 0x00, 0x3A, 0x98, 0x84, 0x63, 0x10, 0x33,
  0x50, 0xC3, 0x1A, 0xDC, 0x23, 0x74, 0x44, 0x4C, 0xE0, 0x25, 0xB4, 0x92,
  0x4B, 0x2D, 0x9C, 0x9C, 0xA5, 0x4A, 0x63, 0x18, 0x93, 0x92, 0xB2, 0xB4,
  0xD4, 0xDC, 0xD8, 0x98, 0x26, 0x68, 0xE0, 0xC1, 0x07, 0x1A, 0x64, 0x26,
  0x48, 0x91, 0x42, 0x87, 0x0C, 0x18, 0x20, 0xC3, 0x00, 0x3C, 0xE1, 0x84,
  0x30, 0x84, 0x3C, 0x1C, 0x41, 0x0C, 0x21, 0x8C, 0x18, 0x61, 0x04, 0x18,
  0xFF, 0xFC, 0x30, 0xC6, 0x21, 0x0C, 0x66, 0x21, 0x09, 0x80, 0xCD, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 10, 3, 0, -10 },
  { 6, 5, 4, 5, 1, -10 },
  { 9, 7, 10, 6, 0, -10 },
  { 18, 6, 12, 6, 0, -11 },
  { 27, 7, 10, 9, 1, -10 },
  { 36, 6, 10, 6, 0, -10 },
  { 44, 2, 4, 3, 1, -10 },
  { 45, 5, 12, 4, 0, -10 },
  { 53, 4, 12, 4, -1, -10 },
  { 59, 5, 5, 5, 1, -11 },
  { 63, 5, 6, 6, 1, -8 },
  { 67, 3, 4, 3, -1, -2 },
  { 69, 3, 1, 4, 0, -4 },
  { 70, 2, 2, 3, 0, -2 },
  { 71, 7, 10, 5, -1, -10 },
  { 80, 6, 10, 6, 0, -10 },
  { 88, 4, 10, 6, 1, -10 },
  { 93, 6, 10, 6, 0, -10 },
  { 101, 6, 10, 6, 0, -10 },
  { 109, 6, 10, 6, 0, -10 },
  { 117, 6, 10, 6, 0, -10 },
  { 125, 6, 10, 6, 0, -10 },
  { 133, 6, 10, 6, 0, -10 },
  { 141, 6, 10, 6, 0, -10 },
  { 149, 6, 10, 6, 0, -10 },
  { 157, 3, 8, 3, 0, -8 },
  { 160, 4, 10, 3, -1, -8 },
  { 165, 5, 6, 6, 1, -8 },
  { 169, 5, 4, 6, 1, -7 },
  { 172, 5, 6, 6, 1, -8 },
  { 176, 5, 10, 4, 0, -10 },
  { 183, 8, 11, 8, 0, -10 },
  { 194, 6, 10, 6, -1, -10 },
  { 202, 6, 10, 6, 0, -10 },
  { 210, 7, 10, 6, 0, -10 },
  { 219, 7, 10, 7, 0, -10 },
  { 228, 6, 10, 5, 0, -10 },
  { 236, 6, 10, 5, 0, -10 },
  { 244, 7, 10, 7, 0, -10 },
  { 253, 7, 10, 7, 0, -10 },
  { 262, 6, 10, 4, -1, -10 },
  { 270, 5, 13, 3, -2, -10 },
  { 279, 7, 10, 6, 0, -10 },
  { 288, 4, 10, 5, 0, -10 },
  { 293, 10, 10, 9, 0, -10 },
  { 306, 8, 10, 7, 0, -10 },
  { 316, 7, 10, 7, 0, -10 },
  { 325, 6, 10, 6, 0, -10 },
  { 333, 7, 12, 7, 0, -10 },
  { 344, 6, 10, 6, 0, -10 },
  { 352, 6, 10, 5, 0, -10 },
  { 360, 5, 10, 5, 1, -10 },
  { 367, 7, 10, 7, 0, -10 },
  { 376, 6, 10, 6, 1, -10 },
  { 384, 9, 10, 9, 1, -10 },
  { 396, 7, 10, 5, -1, -10 },
  { 405, 6, 10, 5, 1, -10 },
  { 413, 7, 10, 5, -1, -10 },
  { 422, 5, 12, 4, 0, -10 },
  { 430, 3, 10, 5, 1, -10 },
  { 434, 5, 12, 4, -1, -10 },
  { 442, 6, 6, 6, 0, -10 },
  { 447, 4, 1, 4, -1, 1 },
  { 448, 2, 3, 4, 2, -11 },
  { 449, 6, 8, 6, 0, -8 },
  { 455, 6, 11, 6, 0, -11 },
  { 464, 5, 8, 5, 0, -8 },
  { 469, 7, 11, 6, 0, -11 },
  { 479, 5, 8, 6, 0, -8 },
  { 484, 7, 14, 3, -2, -11 },
  { 497, 6, 11, 6, 0, -8 },
  { 506, 6, 11, 6, 0, -11 },
  { 515, 3, 10, 3, 0, -10 },
  { 519, 5, 13, 3, -2, -10 },
  { 528, 6, 11, 5, 0, -11 },
  { 537, 4, 11, 3, 0, -11 },
  { 543, 8, 8, 9, 0, -8 },
  { 551, 6, 8, 6, 0, -8 },
  { 557, 6, 8, 6, 0, -8 },
  { 563, 7, 11, 6, -1, -8 },
  { 573, 6, 11, 6, 0, -8 },
  { 582, 5, 8, 4, 0, -8 },
  { 587, 5, 8, 5, 0, -8 },
  { 592, 4, 9, 4, 0, -9 },
  { 597, 6, 8, 6, 0, -8 },
  { 603, 5, 8, 5, 1, -8 },
  { 608, 8, 8, 8, 1, -8 },
  { 616, 7, 8, 5, -1, -8 },
  { 623, 7, 11, 5, -1, -8 },
  { 633, 6, 8, 4, -1, -8 },
  { 639, 6, 12, 5, 0, -10 },
  { 648, 1, 14, 5, 2, -11 },
  { 650, 5, 12, 5, -1, -10 },
  { 658, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC14PT7B_H_
