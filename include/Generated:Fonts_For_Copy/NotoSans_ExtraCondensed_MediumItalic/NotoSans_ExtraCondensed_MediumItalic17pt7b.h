#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x33, 0x22, 0x66, 0x00, 0xCC, 0xDE, 0xA5, 0x60, 0x0B, 0x1A,
  0x12, 0x7F, 0x34, 0x24, 0x2C, 0xFE, 0x48, 0x48, 0x50, 0x90, 0x04, 0x18,
  0xF9, 0x46, 0x86, 0x0E, 0x0E, 0x1C, 0x3A, 0xB7, 0xC2, 0x04, 0x00, 0x71,
  0x29, 0x24, 0x92, 0x89, 0x45, 0x5F, 0xAA, 0x29, 0x14, 0x92, 0x49, 0x48,
  0xE0, 0x1C, 0x36, 0x34, 0x34, 0x38, 0x30, 0x7B, 0x5A, 0xCE, 0xCC, 0xDC,
  0xF6, 0xFA, 0x0C, 0x43, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0xC1,
  0x04, 0x00, 0x18, 0xC6, 0x10, 0x8C, 0x63, 0x10, 0x8C, 0x46, 0x22, 0x00,
  0x25, 0x3E, 0xCF, 0x48, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x2D, 0x60,
  0xF0, 0xF0, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x40, 0xC0, 0x1C, 0x6C, 0x9B, 0x36, 0x68, 0xD1, 0x62, 0xCD, 0x93, 0x63,
  0x80, 0x37, 0xFB, 0x22, 0x66, 0x44, 0x4C, 0x1E, 0x13, 0x03, 0x03, 0x02,
  0x06, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xFC, 0x3C, 0x4C, 0x18, 0x30, 0xC7,
  0x06, 0x06, 0x0C, 0x1A, 0x67, 0x80, 0x06, 0x1C, 0x30, 0xA3, 0xC5, 0x93,
  0x64, 0xFC, 0x30, 0x60, 0xC0, 0x3E, 0x60, 0x81, 0x07, 0x0F, 0x83, 0x06,
  0x0C, 0x1A, 0x67, 0x80, 0x0E, 0x30, 0xC1, 0x06, 0x8F, 0x99, 0x22, 0xC5,
  0x99, 0x23, 0xC0, 0x3F, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0xC0, 0x1E, 0x4C, 0x89, 0x33, 0xC3, 0x1E, 0x66, 0xCD, 0x1B,
  0x33, 0xC0, 0x1C, 0x6D, 0x9B, 0x36, 0x6D, 0xDF, 0x12, 0x0C, 0x10, 0x67,
  0x80, 0x32, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0x80, 0x00, 0x00, 0x04, 0x62,
  0x30, 0x04, 0x73, 0x30, 0xE0, 0xE0, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0x07,
  0x07, 0x1D, 0xCC, 0x20, 0x7D, 0x30, 0xC2, 0x18, 0xC2, 0x18, 0x00, 0x0C,
  0x30, 0x0F, 0x86, 0x33, 0x04, 0x9D, 0x4B, 0x56, 0x95, 0x25, 0x4A, 0xD6,
  0xB6, 0xC4, 0x01, 0x00, 0x7C, 0x00, 0x06, 0x1C, 0x28, 0xD1, 0xA2, 0x4C,
  0x9F, 0x66, 0xCD, 0x1E, 0x30, 0x3E, 0x33, 0x33, 0x22, 0x26, 0x7C, 0x6C,
  0x66, 0x46, 0x44, 0xCC, 0xF8, 0x1E, 0x65, 0x82, 0x0C, 0x18, 0x20, 0x40,
  0x81, 0x03, 0x23, 0xC0, 0x3E, 0x37, 0x33, 0x23, 0x23, 0x63, 0x63, 0x62,
  0x46, 0x44, 0xDC, 0xF0, 0x3E, 0x60, 0xC1, 0x02, 0x0F, 0x98, 0x30, 0x40,
  0x83, 0x07, 0xC0, 0x3E, 0x60, 0xC1, 0x02, 0x0F, 0x9F, 0x30, 0x40, 0x83,
  0x06, 0x00, 0x1F, 0x32, 0x60, 0x40, 0xC0, 0xCE, 0x8E, 0x86, 0x84, 0x84,
  0xCC, 0x7C, 0x31, 0x98, 0xCC, 0x44, 0x62, 0x33, 0xF9, 0x88, 0xC4, 0x46,
  0x23, 0x31, 0x98, 0x80, 0x1E, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30,
  0x60, 0x87, 0xC0, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10,
  0x60, 0xC1, 0x86, 0x3C, 0x00, 0x33, 0x99, 0x0D, 0x85, 0x82, 0x83, 0xC1,
  0xE0, 0xD0, 0x48, 0x26, 0x33, 0x19, 0x80, 0x31, 0x8C, 0x42, 0x31, 0x8C,
  0x42, 0x31, 0xF0, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x29, 0xE6, 0x94,
  0x6B, 0x44, 0xAC, 0x4E, 0xC4, 0xCC, 0xCC, 0x8C, 0xC8, 0x38, 0x9C, 0x4E,
  0x65, 0x32, 0x93, 0x49, 0xBC, 0x9E, 0x4F, 0x23, 0x31, 0x98, 0xC0, 0x1E,
  0x6D, 0x8A, 0x1C, 0x38, 0x61, 0xC3, 0x85, 0x1B, 0x67, 0x80, 0x3E, 0x36,
  0x33, 0x22, 0x22, 0x66, 0x7C, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x1E, 0x6D,
  0x8A, 0x1C, 0x38, 0x61, 0xC3, 0x85, 0x1B, 0x67, 0x83, 0x02, 0x06, 0x00,
  0x3E, 0x6C, 0xC9, 0x12, 0x6D, 0xDE, 0x34, 0x48, 0x9B, 0x36, 0x60, 0x3E,
  0x65, 0x83, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x1A, 0x67, 0x80, 0xFC, 0xC3,
  0x0C, 0x20, 0x86, 0x18, 0x61, 0x0C, 0x30, 0x63, 0x62, 0x62, 0x46, 0x46,
  0xC6, 0xC4, 0x8C, 0x8C, 0x8C, 0xD8, 0xF0, 0xC3, 0xC6, 0x44, 0x4C, 0x4C,
  0x48, 0x58, 0x50, 0x70, 0x60, 0x60, 0x60, 0xC6, 0x3C, 0x66, 0xCE, 0x6C,
  0xE4, 0xCE, 0xCD, 0xE8, 0xD6, 0x8F, 0x78, 0xE5, 0x0E, 0x70, 0xE7, 0x0C,
  0x60, 0x19, 0x8D, 0x86, 0x83, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x3C, 0x36,
  0x19, 0x18, 0x80, 0xC6, 0x99, 0x22, 0xC5, 0x0E, 0x18, 0x30, 0x60, 0x81,
  0x06, 0x00, 0x1F, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60,
  0x40, 0xFC, 0x0E, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83,
  0x04, 0x0E, 0x3C, 0x00, 0x92, 0x6D, 0x92, 0x49, 0x30, 0x1C, 0x10, 0xC3,
  0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x33, 0x8E, 0x00, 0x08, 0x38, 0x71,
  0x26, 0x48, 0xF0, 0x80, 0x7F, 0xF0, 0xCC, 0x80, 0x3A, 0x4D, 0x9A, 0x34,
  0x58, 0xB3, 0x66, 0x7C, 0x10, 0x60, 0xC1, 0x82, 0xE6, 0xD9, 0xB3, 0x46,
  0x8B, 0x36, 0x6B, 0x80, 0x3C, 0x86, 0x10, 0x43, 0x0C, 0x12, 0x78, 0x01,
  0x03, 0x03, 0x02, 0x3A, 0x26, 0x66, 0x46, 0x44, 0xC4, 0xCC, 0xCC, 0x7C,
  0x3C, 0x96, 0x53, 0x7B, 0x0C, 0x12, 0x78, 0x07, 0x05, 0x0C, 0x0C, 0x1E,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0xC0,
  0x3A, 0x4D, 0x9A, 0x34, 0x58, 0xB3, 0x6E, 0x7C, 0x10, 0x64, 0xCF, 0x00,
  0x10, 0x60, 0xC1, 0x83, 0xE6, 0xD9, 0xB2, 0x44, 0x8B, 0x36, 0x6C, 0x80,
  0x13, 0x00, 0x22, 0x66, 0x44, 0xCC, 0xC0, 0x04, 0x30, 0x00, 0x08, 0x21,
  0x86, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x18, 0xC0, 0x10, 0x60, 0xC1, 0x82,
  0x65, 0x9A, 0x3C, 0x78, 0xB1, 0x66, 0x4C, 0x80, 0x13, 0x33, 0x22, 0x66,
  0x44, 0x4C, 0xC0, 0x3F, 0xCD, 0x96, 0x65, 0x93, 0x44, 0xD3, 0x3C, 0xCB,
  0x22, 0xC9, 0x80, 0x3E, 0x6D, 0x9B, 0x24, 0x48, 0xB3, 0x66, 0xC8, 0x3C,
  0x4D, 0x9A, 0x34, 0x78, 0xB3, 0x24, 0x78, 0x17, 0x1B, 0x33, 0x33, 0x23,
  0x22, 0x26, 0x66, 0x7C, 0x40, 0x40, 0xC0, 0xC0, 0x3E, 0x4D, 0x9A, 0x34,
  0x58, 0xB3, 0x66, 0x7C, 0x10, 0x20, 0xC1, 0x80, 0x3C, 0xC6, 0x18, 0x41,
  0x0C, 0x30, 0xC0, 0x3D, 0x96, 0x18, 0x30, 0x61, 0xA4, 0xF0, 0x11, 0x9E,
  0x46, 0x31, 0x88, 0x46, 0x18, 0x22, 0x4D, 0x9B, 0x24, 0x49, 0xB3, 0x6E,
  0x78, 0xCF, 0x2D, 0xB4, 0xF2, 0x8A, 0x38, 0xC0, 0xCC, 0xEE, 0xE7, 0x57,
  0x6A, 0xB5, 0x53, 0xB9, 0x98, 0xCC, 0x00, 0x33, 0x16, 0x14, 0x1C, 0x18,
  0x38, 0x28, 0x6C, 0xCC, 0x19, 0x8C, 0x86, 0xC3, 0x41, 0xE0, 0xE0, 0x70,
  0x38, 0x18, 0x0C, 0x04, 0x06, 0x0E, 0x00, 0x3E, 0x18, 0x20, 0xC1, 0x06,
  0x18, 0x30, 0xF8, 0x0E, 0x30, 0x60, 0x81, 0x06, 0x1C, 0x60, 0x20, 0x41,
  0x83, 0x06, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x20,
  0x82, 0x18, 0x61, 0x83, 0x10, 0xC3, 0x0C, 0x23, 0x8C, 0x00, 0xE6, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 5, 4, 6, 2, -12 },
  { 10, 8, 12, 7, 0, -12 },
  { 22, 7, 14, 7, 0, -13 },
  { 35, 9, 12, 11, 1, -12 },
  { 49, 8, 12, 8, 0, -12 },
  { 61, 2, 4, 3, 2, -12 },
  { 62, 6, 15, 4, 0, -12 },
  { 74, 5, 15, 4, -1, -12 },
  { 84, 5, 6, 6, 2, -13 },
  { 88, 6, 8, 7, 1, -10 },
  { 94, 3, 4, 4, -1, -2 },
  { 96, 4, 1, 5, 0, -5 },
  { 97, 2, 2, 4, 0, -2 },
  { 98, 8, 12, 6, -1, -12 },
  { 110, 7, 12, 7, 0, -12 },
  { 121, 4, 12, 7, 2, -12 },
  { 127, 8, 12, 7, -1, -12 },
  { 139, 7, 12, 7, 0, -12 },
  { 150, 7, 12, 7, 0, -12 },
  { 161, 7, 12, 7, 0, -12 },
  { 172, 7, 12, 7, 0, -12 },
  { 183, 8, 12, 7, 0, -12 },
  { 195, 7, 12, 7, 0, -12 },
  { 206, 7, 12, 7, 0, -12 },
  { 217, 4, 9, 4, 0, -9 },
  { 222, 5, 11, 4, -1, -9 },
  { 229, 6, 8, 7, 1, -10 },
  { 235, 6, 4, 7, 1, -8 },
  { 238, 6, 8, 7, 1, -10 },
  { 244, 6, 12, 5, 0, -12 },
  { 253, 10, 13, 10, 0, -12 },
  { 270, 7, 12, 7, -1, -12 },
  { 281, 8, 12, 8, 0, -12 },
  { 293, 7, 12, 7, 1, -12 },
  { 304, 8, 12, 8, 0, -12 },
  { 316, 7, 12, 6, 0, -12 },
  { 327, 7, 12, 6, 0, -12 },
  { 338, 8, 12, 9, 1, -12 },
  { 350, 9, 12, 8, 0, -12 },
  { 364, 7, 12, 5, -1, -12 },
  { 375, 7, 15, 4, -3, -12 },
  { 389, 9, 12, 7, 0, -12 },
  { 403, 5, 12, 6, 0, -12 },
  { 411, 12, 12, 11, 0, -12 },
  { 429, 9, 12, 9, 0, -12 },
  { 443, 7, 12, 9, 1, -12 },
  { 454, 8, 12, 7, 0, -12 },
  { 466, 7, 15, 9, 1, -12 },
  { 480, 7, 12, 7, 0, -12 },
  { 491, 7, 12, 7, 0, -12 },
  { 502, 6, 12, 6, 1, -12 },
  { 511, 8, 12, 8, 1, -12 },
  { 523, 8, 12, 7, 1, -12 },
  { 535, 12, 12, 11, 1, -12 },
  { 553, 9, 12, 7, -1, -12 },
  { 567, 7, 12, 6, 1, -12 },
  { 578, 8, 12, 6, -1, -12 },
  { 590, 7, 15, 5, -1, -12 },
  { 604, 3, 12, 6, 2, -12 },
  { 609, 6, 15, 5, -1, -12 },
  { 621, 7, 7, 7, 0, -12 },
  { 628, 6, 2, 5, -2, 1 },
  { 630, 3, 3, 4, 2, -13 },
  { 632, 7, 9, 7, 0, -9 },
  { 640, 7, 13, 7, 0, -13 },
  { 652, 6, 9, 6, 0, -9 },
  { 659, 8, 13, 7, 0, -13 },
  { 672, 6, 9, 7, 0, -9 },
  { 679, 8, 17, 4, -2, -13 },
  { 696, 7, 13, 7, 0, -9 },
  { 708, 7, 13, 7, 0, -13 },
  { 720, 4, 13, 3, 0, -13 },
  { 727, 6, 17, 3, -2, -13 },
  { 740, 7, 13, 6, 0, -13 },
  { 752, 4, 13, 3, 0, -13 },
  { 759, 10, 9, 11, 0, -9 },
  { 771, 7, 9, 7, 0, -9 },
  { 779, 7, 9, 7, 0, -9 },
  { 787, 8, 13, 7, -1, -9 },
  { 800, 7, 13, 7, 0, -9 },
  { 812, 6, 9, 5, 0, -9 },
  { 819, 6, 9, 6, 0, -9 },
  { 826, 5, 11, 4, 0, -11 },
  { 833, 7, 9, 7, 0, -9 },
  { 841, 6, 9, 6, 1, -9 },
  { 848, 9, 9, 10, 1, -9 },
  { 859, 8, 9, 6, -1, -9 },
  { 868, 9, 13, 6, -2, -9 },
  { 883, 7, 9, 5, -1, -9 },
  { 891, 7, 15, 6, 0, -12 },
  { 905, 2, 17, 6, 2, -13 },
  { 910, 6, 15, 6, -1, -12 },
  { 922, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC17PT7B_H_
