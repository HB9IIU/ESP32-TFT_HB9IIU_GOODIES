#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x78, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0x98, 0x70, 0x0F, 0xC6, 0x08, 0x03, 0xE3, 0x80, 0x01,
  0xF8, 0xE0, 0x00, 0x7C, 0x30, 0x00, 0x1F, 0x0C, 0x00, 0x07, 0xE3, 0x00,
  0x01, 0xF9, 0xC0, 0x00, 0x3F, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x19, 0xF8, 0x00, 0x06, 0x7E, 0x00, 0x01, 0x8F, 0x80, 0x00, 0xE3,
  0xE0, 0x00, 0x38, 0xF8, 0x00, 0x0C, 0x3E, 0x00, 0x03, 0x0F, 0x81, 0x00,
  0xC7, 0xE0, 0x60, 0x71, 0xF8, 0x1E, 0x1D, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x07,
  0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0x07, 0xC7, 0xC0,
  0x7C, 0x01, 0xE1, 0xF0, 0x1E, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x3C, 0x1F,
  0x03, 0xC0, 0x0F, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x78, 0x01, 0xF0,
  0x78, 0x3E, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x87, 0xC0, 0x0F,
  0x83, 0xE1, 0xE0, 0x03, 0xE0, 0xF8, 0xF8, 0x00, 0xF8, 0x3C, 0x3C, 0x00,
  0x3C, 0x0F, 0x1F, 0x07, 0x0F, 0x07, 0xC7, 0x87, 0xF3, 0xC1, 0xE3, 0xE3,
  0xFE, 0xF0, 0x78, 0xF1, 0xFF, 0xBC, 0x3C, 0x7C, 0xF9, 0xFF, 0x9F, 0x3E,
  0x3C, 0x7F, 0xFF, 0x8F, 0x1E, 0x0F, 0x7F, 0xC7, 0xC7, 0x83, 0xDF, 0xF1,
  0xE3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0x00, 0x3C, 0x3C, 0x1F, 0x00,
  0x1F, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x78,
  0x00, 0xF0, 0x78, 0x1E, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x83,
  0xE0, 0x0F, 0x83, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x3C, 0x01, 0xF0, 0x3C,
  0x1F, 0x00, 0x78, 0x0F, 0x07, 0x80, 0x3E, 0x03, 0xC3, 0xE0, 0x0F, 0x00,
  0xF8, 0xF0, 0x07, 0xC0, 0x3F, 0xFC, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0x0F, 0xDF, 0x87,
  0xE3, 0xF3, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x87, 0xE7, 0xC7, 0xE0,
  0xFC, 0xF8, 0xFC, 0x1F, 0xBF, 0x1F, 0x01, 0xFF, 0xC7, 0xE0, 0x3F, 0xF8,
  0xFC, 0x07, 0xFE, 0x1F, 0x00, 0x7F, 0x83, 0xE0, 0x0F, 0xF0, 0x7C, 0x01,
  0xFC, 0x0F, 0x80, 0x3F, 0x81, 0xF8, 0x0F, 0xF8, 0x3F, 0x03, 0xFF, 0x07,
  0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xCF, 0xC0, 0xFF, 0xF1,
  0xF8, 0x0F, 0xF8, 0x3F, 0x80, 0x30, 0x00, 0x00, 0x1F, 0x9F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3,
  0xE1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x81, 0xF0, 0x1C, 0x3C,
  0x07, 0xE7, 0x81, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x3E,
  0x0F, 0xC7, 0xC0, 0xF0, 0xFC, 0x0E, 0x0F, 0x80, 0x81, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0x0C, 0x3E, 0x7F, 0x7F, 0x7F, 0xFE, 0x7E, 0x7C, 0x10, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x1F,
  0xBF, 0x3F, 0x9F, 0x8F, 0x8F, 0x83, 0x87, 0xC1, 0x87, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1E,
  0x03, 0xF8, 0x01, 0x80, 0x7F, 0x00, 0x20, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3E, 0x0F, 0xF0, 0x06, 0x01, 0xFC, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x20, 0x01, 0xFC, 0x0C, 0x00,
  0xFF, 0x03, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x1E,
  0xFC, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0xF9, 0xF8, 0x00, 0x3C, 0x7E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xC3, 0xF0, 0x01, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0x81, 0xF8, 0x03, 0xC0, 0x7E, 0x01, 0xF0,
  0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x18, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x04, 0x00, 0x7F, 0x03, 0x00, 0x7F, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x02,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x3F, 0x3F, 0xC0,
  0x3E, 0x7F, 0xE0, 0x7E, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC7, 0xF0,
  0x7F, 0x83, 0xF0, 0xFF, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xF7, 0xE0, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07,
  0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F,
  0x1F, 0x80, 0xFF, 0x1F, 0xC1, 0xFE, 0x0F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x7C, 0x03, 0xFE, 0x7C, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0xFB, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x80, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x01, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x70, 0x7F, 0x04, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x03,
  0xFC, 0x1E, 0x0F, 0x80, 0xFF, 0xC3, 0xC1, 0xE0, 0x7F, 0xF8, 0x78, 0x7C,
  0x1F, 0xFF, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x78, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xE0, 0xF1, 0xE0, 0xF0, 0x7C,
  0x1E, 0x78, 0x3C, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xE0, 0xF1, 0xE0, 0xF0,
  0x7C, 0x1E, 0x3C, 0x3C, 0x0F, 0x83, 0xCF, 0x07, 0x81, 0xE0, 0x79, 0xE0,
  0xF0, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x83, 0xC7, 0x83, 0xC1, 0xF0, 0x70,
  0xF0, 0xF8, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x83, 0xC3, 0xC3, 0xE1, 0xF0,
  0xF0, 0xF8, 0x3C, 0x7E, 0x3C, 0x1E, 0x07, 0xFD, 0xFF, 0x83, 0xC0, 0xFF,
  0xBF, 0xE0, 0x7C, 0x0F, 0xE3, 0xF8, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x02, 0x00, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFE,
  0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x07, 0x00, 0x7F, 0x80,
  0x40, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x30,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x3F,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x04, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0x00, 0x7F, 0x00, 0x04, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x87, 0xE0, 0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0xF0, 0x7E,
  0x01, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x43, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00,
  0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x78, 0x01, 0xF7, 0xE0, 0x0F, 0x9E,
  0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0x7E, 0x7C, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x01, 0xF3, 0xF0,
  0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x00, 0xFC,
  0x7C, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x07, 0xC7, 0xE0, 0x0F, 0xC7, 0xC1,
  0xF1, 0xF8, 0x03, 0xE1, 0xF0, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x3E, 0x1F,
  0x00, 0x7E, 0x1F, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x07,
  0xC1, 0xF1, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0x0F, 0xC1, 0xF7, 0xC1,
  0xF8, 0x03, 0xE0, 0x7F, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0x07, 0xE0,
  0x7F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x3E, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xF0,
  0x03, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0xF8, 0x01, 0xF7, 0xC0,
  0x3E, 0x00, 0xFD, 0xF0, 0x1F, 0x80, 0x3F, 0x7C, 0x07, 0xE0, 0x0F, 0x9F,
  0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x7E,
  0x3E, 0x0F, 0xC0, 0x1F, 0x8F, 0x83, 0xF0, 0x07, 0xC3, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC7, 0xE0,
  0x0F, 0xC1, 0xF1, 0xF8, 0x03, 0xE0, 0x7C, 0x7C, 0x00, 0xF8, 0x1F, 0x1F,
  0x00, 0x7E, 0x07, 0xC7, 0xC0, 0x1F, 0x81, 0xF3, 0xF0, 0x07, 0xC0, 0x3E,
  0xFC, 0x01, 0xF0, 0x0F, 0xBE, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0x00,
  0xFB, 0xE0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xF8,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x1F, 0xF0, 0x07,
  0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xF9,
  0xFF, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00,
  0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0x00, 0x7F, 0x00, 0x60, 0x0F, 0xC0,
  0x04, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x08,
  0x00, 0x3F, 0x81, 0x80, 0x0F, 0xE0, 0x3E, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF,
  0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFF, 0x00, 0x7C, 0x1F, 0x80, 0x7F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x7E,
  0x03, 0xFF, 0x01, 0xF8, 0x1F, 0x80, 0xFF, 0xC0, 0x7E, 0x07, 0xC0, 0x7D,
  0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0x9E, 0x03,
  0xE0, 0x1F, 0x03, 0xE7, 0x81, 0xF8, 0x07, 0xC0, 0xF9, 0xE0, 0x7E, 0x01,
  0xF0, 0x7C, 0x78, 0x3F, 0x00, 0x7C, 0x1F, 0x1E, 0x0F, 0xC0, 0x1F, 0x07,
  0xC7, 0x83, 0xE0, 0x07, 0xC3, 0xE1, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0xF8,
  0x7E, 0x00, 0x7C, 0x3C, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x0F, 0x8F, 0xC0,
  0x07, 0xC7, 0xC3, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0xF9, 0xF8, 0x00, 0x7C,
  0xF8, 0x3E, 0x7E, 0x00, 0x1F, 0x3C, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x03,
  0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F,
  0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x9F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F,
  0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x3F, 0x87, 0xC0, 0x3F, 0xF3,
  0xE0, 0x1F, 0xFE, 0xF8, 0x0F, 0xFF, 0xBE, 0x03, 0xFF, 0xFF, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x3F,
  0xC0, 0x7F, 0x3F, 0xF0, 0x1F, 0xFE, 0xF8, 0x03, 0xFF, 0xBE, 0x00, 0xFF,
  0xCF, 0x80, 0x1F, 0xC3, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x8F, 0xE0, 0x0F, 0xCF, 0xF8, 0x07, 0xEF, 0xFE, 0x03,
  0xEF, 0xFF, 0x01, 0xFF, 0xBF, 0x80, 0xFF, 0x0F, 0xE0, 0xFF, 0x03, 0xF0,
  0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0xFE,
  0x03, 0xF0, 0x7F, 0x83, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0x7F, 0xF8, 0x0F, 0x9F, 0xF8, 0x07, 0x87, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xF8, 0x10, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x04, 0x07, 0xF9, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0xFF, 0xCF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xBE, 0x00, 0x3F, 0xF3, 0xE0, 0x01, 0xFE, 0x3E, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xF8, 0xFC, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xF0,
  0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x03, 0xF8, 0xF8, 0x3F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x20, 0x7F, 0x03, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x10, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x9F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE1, 0xF0, 0x03, 0xFF, 0x3E, 0x00, 0x7F, 0xFB, 0xE0, 0x07, 0xFF, 0xBE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x3F, 0xC0,
  0x1F, 0xCF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0xF8, 0x00, 0xFF,
  0xDF, 0x80, 0x07, 0xF9, 0xF8, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x80, 0x0F, 0xC0, 0x0C, 0x01, 0xFC,
  0x00, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF1, 0xFC, 0x01, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xEF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0,
  0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00,
  0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x01,
  0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xE0, 0xFC, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x37, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x1F,
  0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xE3, 0xFC, 0x1F, 0xE0,
  0x0F, 0x3F, 0xF1, 0xFF, 0x80, 0xFB, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x3E, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x3E,
  0x01, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x3E, 0x01,
  0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xE1, 0xFC, 0x01, 0xE7, 0xFE, 0x03, 0xEF,
  0xFF, 0x03, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0x07, 0xF8,
  0x3F, 0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80,
  0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xF0,
  0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F,
  0x83, 0xF0, 0x7F, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x3F,
  0x80, 0x03, 0xC7, 0xFC, 0x00, 0x7C, 0xFF, 0xE0, 0x07, 0xDF, 0xFE, 0x00,
  0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x0F,
  0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xBF, 0xF8, 0x01, 0xFB, 0xFF,
  0x00, 0x1F, 0x9F, 0xE0, 0x01, 0xF0, 0x60, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x7F, 0xE7,
  0xC0, 0x7F, 0xFB, 0xE0, 0x3F, 0xFD, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC1, 0xFE, 0x07, 0xF3, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0x80, 0x7F, 0xEF, 0xC0, 0x1F, 0xE7,
  0xE0, 0x01, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE1, 0xF8, 0x0F, 0x3F, 0x80, 0xF9, 0xFC, 0x07, 0xDF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xB0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xF8, 0xF0, 0x1F, 0x80, 0xC0, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x08, 0x01, 0xF8, 0x30, 0x0F, 0xE0, 0xFC, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xFF, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE6, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0C, 0x00, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xF0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC3, 0xFC, 0x07, 0xF7, 0xFE,
  0x03, 0xFF, 0xDF, 0x01, 0xFF, 0xEF, 0x00, 0x7F, 0xE7, 0x80, 0x1F, 0xC7,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00,
  0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F,
  0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7E,
  0x0F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x07,
  0xDF, 0x00, 0xFE, 0x03, 0xF7, 0xC0, 0x3F, 0x80, 0xF9, 0xF0, 0x1F, 0xE0,
  0x3E, 0x7C, 0x07, 0xF8, 0x1F, 0x9F, 0x03, 0xFC, 0x07, 0xC7, 0xC0, 0xFF,
  0x03, 0xF1, 0xF0, 0x3F, 0xC0, 0xF8, 0x7C, 0x1F, 0xF0, 0x3E, 0x1F, 0x07,
  0xBC, 0x1F, 0x87, 0xC3, 0xEF, 0x07, 0xC1, 0xF0, 0xFB, 0xC1, 0xF0, 0x7C,
  0x3C, 0xF0, 0xF8, 0x1F, 0x1F, 0x3C, 0x3E, 0x07, 0xC7, 0x8F, 0x1F, 0x81,
  0xF3, 0xE3, 0xC7, 0xC0, 0x7C, 0xF8, 0xF1, 0xF0, 0x1F, 0x3C, 0x7C, 0xF8,
  0x0F, 0xDF, 0x1F, 0x3E, 0x03, 0xF7, 0xC7, 0xDF, 0x80, 0xF9, 0xE1, 0xF7,
  0xC0, 0x3E, 0xF8, 0x7D, 0xF0, 0x0F, 0xBC, 0x1F, 0xF8, 0x03, 0xEF, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF7, 0xE0, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0C, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x01, 0x3F, 0xE0, 0x01, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xFC, 0x80,
  0x00, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 45, 15, 0, -44 },
  { 91, 18, 16, 22, 6, -44 },
  { 127, 28, 44, 27, 0, -44 },
  { 281, 26, 50, 24, 0, -46 },
  { 444, 34, 45, 39, 3, -44 },
  { 636, 27, 45, 28, 0, -44 },
  { 788, 9, 16, 12, 6, -44 },
  { 806, 19, 54, 16, 1, -44 },
  { 935, 19, 54, 16, -5, -44 },
  { 1064, 19, 22, 23, 6, -47 },
  { 1117, 24, 29, 27, 2, -36 },
  { 1204, 12, 15, 13, -3, -7 },
  { 1227, 14, 5, 16, 1, -19 },
  { 1236, 8, 9, 13, 0, -8 },
  { 1245, 29, 44, 21, -3, -44 },
  { 1405, 24, 45, 24, 1, -44 },
  { 1540, 17, 44, 25, 6, -44 },
  { 1634, 27, 44, 24, -2, -44 },
  { 1783, 26, 45, 24, -1, -44 },
  { 1930, 26, 44, 25, -1, -44 },
  { 2073, 25, 45, 24, 0, -44 },
  { 2214, 24, 45, 24, 2, -44 },
  { 2349, 25, 44, 24, 2, -44 },
  { 2487, 25, 45, 24, 0, -44 },
  { 2628, 24, 45, 24, 0, -44 },
  { 2763, 13, 34, 13, 0, -33 },
  { 2819, 16, 41, 13, -3, -33 },
  { 2901, 24, 28, 27, 2, -36 },
  { 2985, 24, 17, 27, 2, -30 },
  { 3036, 24, 28, 27, 2, -36 },
  { 3120, 20, 45, 18, 1, -44 },
  { 3233, 35, 49, 37, 1, -44 },
  { 3448, 26, 44, 26, -4, -44 },
  { 3591, 28, 44, 27, 0, -44 },
  { 3745, 27, 45, 24, 2, -44 },
  { 3897, 28, 44, 29, 0, -44 },
  { 4051, 26, 44, 23, 0, -44 },
  { 4194, 26, 44, 22, 0, -44 },
  { 4337, 30, 45, 31, 2, -44 },
  { 4506, 32, 44, 30, 0, -44 },
  { 4682, 24, 44, 17, -3, -44 },
  { 4814, 24, 56, 13, -9, -44 },
  { 4982, 31, 44, 26, 0, -44 },
  { 5153, 17, 44, 21, 0, -44 },
  { 5247, 42, 44, 40, 0, -44 },
  { 5478, 34, 44, 32, 0, -44 },
  { 5665, 28, 45, 31, 2, -44 },
  { 5823, 27, 44, 26, 0, -44 },
  { 5972, 28, 54, 31, 2, -44 },
  { 6161, 27, 44, 26, 0, -44 },
  { 6310, 27, 45, 24, -1, -44 },
  { 6462, 23, 44, 22, 4, -44 },
  { 6589, 29, 45, 30, 2, -44 },
  { 6753, 26, 44, 26, 5, -44 },
  { 6896, 42, 44, 41, 4, -44 },
  { 7127, 32, 44, 24, -4, -44 },
  { 7303, 23, 44, 23, 5, -44 },
  { 7430, 28, 44, 21, -3, -44 },
  { 7584, 23, 54, 17, -2, -44 },
  { 7740, 11, 44, 21, 6, -44 },
  { 7801, 23, 54, 17, -4, -44 },
  { 7957, 25, 25, 25, 0, -44 },
  { 8036, 19, 4, 19, -5, 5 },
  { 8046, 9, 10, 16, 9, -47 },
  { 8058, 26, 34, 27, 1, -33 },
  { 8169, 25, 47, 26, 0, -46 },
  { 8316, 21, 34, 20, 1, -33 },
  { 8406, 28, 47, 26, 1, -46 },
  { 8571, 22, 34, 24, 1, -33 },
  { 8665, 29, 62, 15, -7, -47 },
  { 8890, 28, 48, 27, -1, -33 },
  { 9058, 24, 46, 26, 0, -46 },
  { 9196, 15, 45, 12, 0, -45 },
  { 9281, 23, 60, 12, -8, -45 },
  { 9454, 26, 46, 23, 0, -46 },
  { 9604, 15, 46, 12, 0, -46 },
  { 9691, 37, 33, 38, 0, -33 },
  { 9844, 24, 33, 26, 0, -33 },
  { 9943, 23, 34, 26, 1, -33 },
  { 10041, 28, 47, 26, -3, -33 },
  { 10206, 25, 48, 26, 1, -33 },
  { 10356, 21, 33, 18, 0, -33 },
  { 10443, 22, 34, 20, -1, -33 },
  { 10537, 15, 41, 16, 2, -40 },
  { 10614, 25, 34, 26, 1, -33 },
  { 10721, 21, 33, 22, 4, -33 },
  { 10808, 34, 33, 34, 3, -33 },
  { 10949, 28, 33, 22, -3, -33 },
  { 11065, 30, 48, 22, -5, -33 },
  { 11245, 22, 33, 18, -2, -33 },
  { 11336, 23, 54, 20, 1, -44 },
  { 11492, 5, 61, 22, 8, -47 },
  { 11531, 23, 54, 20, -4, -44 },
  { 11687, 24, 9, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC61PT7B_H_
