#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0x39, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x38, 0xE7,
  0x18, 0xE7, 0x18, 0xE3, 0x00, 0x00, 0xC6, 0x01, 0xCE, 0x01, 0x8E, 0x01,
  0x8C, 0x03, 0x8C, 0x03, 0x1C, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x06,
  0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0x39, 0xC0, 0x31, 0xC0, 0x31, 0x80, 0x71, 0x80, 0x63,
  0x80, 0x63, 0x00, 0xE7, 0x00, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0xFE,
  0x07, 0xFC, 0x3F, 0xF1, 0xEC, 0x87, 0x20, 0x1C, 0x80, 0x72, 0x01, 0xD8,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x02, 0xF0, 0x09,
  0xC0, 0x27, 0x01, 0x9C, 0x86, 0xF3, 0xD7, 0x8F, 0xFC, 0x3F, 0xE0, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x83, 0xE0, 0x60, 0xFC,
  0x1C, 0x19, 0x83, 0x07, 0x30, 0xE0, 0xC6, 0x18, 0x38, 0xC7, 0x07, 0x18,
  0xC0, 0xC3, 0x38, 0x18, 0xE6, 0x03, 0x19, 0xCE, 0x63, 0x33, 0xEC, 0xEE,
  0xFD, 0xFB, 0x99, 0xFE, 0x66, 0x39, 0x1C, 0xC6, 0x03, 0x38, 0xC0, 0xE7,
  0x18, 0x18, 0xC3, 0x07, 0x18, 0xE0, 0xC3, 0x18, 0x38, 0x63, 0x06, 0x0C,
  0xE1, 0xC1, 0xF8, 0x70, 0x1E, 0x00, 0x00, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x39, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1D,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF1, 0xCE, 0xE3, 0xB9, 0xEE,
  0x71, 0xDD, 0xC3, 0xF3, 0x87, 0xE7, 0x07, 0x8E, 0x0F, 0x1C, 0x3E, 0x3F,
  0xFC, 0x3F, 0xBC, 0x7E, 0x38, 0x39, 0xDC, 0xE7, 0x39, 0x8C, 0xE0, 0x01,
  0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x00,
  0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x18, 0x33, 0x0F,
  0xEE, 0xFF, 0xC3, 0xF8, 0xF8, 0x3B, 0x0E, 0x70, 0xCF, 0x10, 0x80, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF,
  0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x1E, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x30, 0xE0, 0x7F, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x1F, 0x01, 0xFC, 0x1E, 0xE1, 0xE7, 0x8E, 0x1C,
  0xE0, 0xE7, 0x07, 0x38, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x07, 0x78,
  0x3B, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3, 0x8E, 0x3C,
  0x71, 0xC3, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x03, 0xC1, 0xE0, 0xF8, 0x7E,
  0x7B, 0xBD, 0xC6, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x00, 0x60, 0x07, 0xF0, 0x1F, 0xF0, 0x79, 0xF0, 0x61, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0,
  0x00, 0x60, 0x07, 0xF0, 0x1F, 0xF0, 0x38, 0xF0, 0x41, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x3F, 0x80, 0x7C,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x10, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1B, 0x80, 0x7F,
  0x00, 0xDC, 0x03, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x63, 0x81, 0xC7, 0x03,
  0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x81, 0xE3, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x3C, 0x07, 0xE0, 0x3F, 0x81, 0xE2, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x7C, 0x1F, 0xF8, 0x7D,
  0xE3, 0xC3, 0xCF, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x38,
  0x38, 0xE1, 0xE3, 0x87, 0x0F, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x1F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x7F, 0xC3, 0x8F, 0x1E,
  0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x39, 0xE0, 0xFF, 0x01,
  0xF8, 0x07, 0x80, 0x7F, 0x03, 0xDE, 0x1E, 0x38, 0x70, 0xF3, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0x8F, 0x9E, 0x1F, 0xF0, 0x3F, 0x80,
  0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x83, 0xDE, 0x1E, 0x38, 0x70, 0xF3, 0xC3,
  0xCE, 0x0F, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x78, 0xFF,
  0xE1, 0xFF, 0x87, 0xDC, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x04, 0x1C, 0x78, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xE3,
  0x80, 0x01, 0x01, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3C, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x03, 0x00, 0x10,
  0x00, 0x02, 0x03, 0xF8, 0xFF, 0x18, 0xF2, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xC0, 0xE0, 0x70, 0x0E,
  0x1C, 0x00, 0xC7, 0x00, 0x18, 0xC1, 0xE3, 0x38, 0xFE, 0x66, 0x39, 0x8D,
  0xC6, 0x31, 0xB1, 0xCE, 0x36, 0x31, 0xC6, 0xCE, 0x31, 0xF9, 0xC6, 0x36,
  0x31, 0xC6, 0xC6, 0x39, 0xD8, 0xC7, 0x33, 0x19, 0xEE, 0x63, 0xEF, 0x8C,
  0x39, 0xE1, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x0E, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0x70, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E,
  0x70, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0x07, 0xF8, 0x0F, 0xF8, 0x3C, 0xF8, 0x78, 0x70, 0xE0, 0xE1, 0xC1,
  0xC3, 0x83, 0x8F, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x7F, 0xC0, 0xFF, 0x03,
  0xFF, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x71, 0xC0,
  0xE3, 0x83, 0xC7, 0x0F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x30,
  0x03, 0xFC, 0x0F, 0xF8, 0x3E, 0x60, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x0F, 0x1E, 0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x3C, 0x70, 0x78, 0x70,
  0x70, 0x71, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC3, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC1, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0xF8, 0xE0, 0xF0, 0x10, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x07,
  0xE7, 0x83, 0xF3, 0xC3, 0xF1, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x3C,
  0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x83, 0xC1, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF0, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0xF0, 0x38, 0x3C, 0x0E,
  0x0E, 0x07, 0x83, 0x81, 0xE0, 0xE0, 0x70, 0x78, 0x1C, 0x1E, 0x07, 0x07,
  0x03, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0E, 0x03, 0x83, 0x81,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xF0,
  0x70, 0x38, 0x3C, 0x0E, 0x0F, 0x03, 0x83, 0x81, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC1, 0x3C,
  0x0F, 0xE0, 0x7E, 0x01, 0xC0, 0x00, 0x07, 0x07, 0x83, 0x87, 0x83, 0xC3,
  0x81, 0xE3, 0xC0, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x3D, 0xE0, 0x1C,
  0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xF7, 0x00, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x1C,
  0x07, 0x0F, 0x07, 0x87, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3F,
  0xFF, 0xFB, 0xFE, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0E,
  0xE0, 0xEE, 0x1D, 0xC1, 0xF8, 0x3B, 0x87, 0x70, 0x77, 0x0E, 0xE0, 0xEE,
  0x39, 0xC3, 0x9C, 0x77, 0x87, 0x38, 0xCE, 0x0E, 0x73, 0x9C, 0x1C, 0xE6,
  0x38, 0x39, 0xDC, 0x70, 0xE3, 0xB9, 0xE1, 0xC7, 0xE3, 0x83, 0x8F, 0xC7,
  0x07, 0x1F, 0x0E, 0x1E, 0x3E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0,
  0x07, 0x80, 0xE0, 0xF0, 0x38, 0x3E, 0x07, 0x07, 0xC0, 0xE0, 0xFC, 0x1C,
  0x1F, 0x83, 0x83, 0xF0, 0xE0, 0xEE, 0x1C, 0x1D, 0xC3, 0x83, 0x98, 0x70,
  0x73, 0x9E, 0x0E, 0x73, 0x83, 0x8E, 0x70, 0x71, 0xCE, 0x0E, 0x39, 0xC1,
  0xC3, 0x70, 0x38, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07,
  0x07, 0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x07, 0x01, 0xE0, 0x00, 0x60, 0x01,
  0xFC, 0x07, 0xFE, 0x07, 0x9E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1C, 0x07, 0x3C,
  0x07, 0x38, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0,
  0x38, 0xF0, 0x78, 0x70, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x07,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x78, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83,
  0x8F, 0x07, 0x1E, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE3, 0xC3, 0xFF, 0x07,
  0xFC, 0x0F, 0xE0, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x01, 0xFC,
  0x07, 0xFE, 0x07, 0x9E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1C, 0x07, 0x3C, 0x07,
  0x38, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E,
  0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38,
  0xF0, 0x78, 0x70, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x70, 0xF0, 0xE1, 0xE1, 0xC1, 0xC3, 0x87, 0x8F,
  0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8,
  0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xE0, 0xF1, 0xC1, 0xC3, 0x83, 0x87, 0x07,
  0x0E, 0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x38, 0x00, 0x70, 0x03, 0xFC, 0x1F,
  0xF8, 0x3E, 0xF0, 0xF0, 0x41, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x08, 0x1E,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x07, 0x0E,
  0x07, 0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C,
  0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70,
  0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xE0, 0x3F, 0x80,
  0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x38, 0xE1,
  0xC3, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x3B,
  0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x3C, 0x0E, 0xE0, 0x78, 0x3D, 0xC0, 0xF0, 0x73,
  0x83, 0xC0, 0xE7, 0x07, 0x83, 0xCE, 0x0F, 0x07, 0x1C, 0x3E, 0x0E, 0x38,
  0x6C, 0x38, 0x71, 0xD8, 0x70, 0xE3, 0xB1, 0xE1, 0xC6, 0x63, 0x83, 0x9C,
  0xC7, 0x07, 0x39, 0x9C, 0x0E, 0xE7, 0x38, 0x1D, 0xCE, 0xF0, 0x3B, 0x1D,
  0xC0, 0x7E, 0x3B, 0x80, 0xDC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0x83, 0xC0, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1D, 0xC0,
  0x0F, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x1E,
  0x1E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x7F, 0x07, 0xB8, 0x39, 0xE3,
  0xCF, 0x1C, 0x39, 0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C,
  0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x03, 0xF8, 0x1F, 0x81, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0x70, 0x1D, 0xC0, 0xE7,
  0x03, 0x8C, 0x1C, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x06, 0xF0, 0x1C, 0xFF,
  0xFF, 0xFC, 0xF3, 0x9C, 0x73, 0x80, 0x03, 0x00, 0x3F, 0x71, 0xFF, 0x8F,
  0x1E, 0x38, 0x79, 0xE1, 0xE7, 0x07, 0x9C, 0x1C, 0xF0, 0x73, 0xC1, 0xCE,
  0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x78, 0xF6, 0xC3,
  0xFF, 0x07, 0xDC, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x98, 0x0E, 0xF8, 0x77, 0xE1, 0xF3, 0xC7,
  0x87, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x3C, 0xE0, 0xE7,
  0x83, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x8F, 0x3E, 0x78, 0xEF, 0xC3,
  0xBE, 0x00, 0x03, 0xC1, 0xFC, 0x7F, 0x8F, 0x23, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFB, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x01, 0x8E, 0x0F, 0xDC, 0x3F, 0xF0,
  0x71, 0xE1, 0xC3, 0xC3, 0x87, 0x8E, 0x0F, 0x1C, 0x1C, 0x38, 0x38, 0xF0,
  0x71, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x78,
  0x7B, 0xE0, 0xFE, 0xC0, 0xFB, 0x80, 0x01, 0x80, 0xFE, 0x1F, 0xF1, 0xC7,
  0x38, 0x77, 0x87, 0x70, 0x77, 0x0E, 0xFF, 0xCF, 0xF8, 0xFC, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF1, 0x87, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x03, 0xF7, 0x07,
  0xF6, 0x07, 0x1E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1C, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x38, 0xF8, 0x3D, 0xF0, 0x3F, 0xF0, 0x1F, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x81, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x98, 0x0F, 0xF8, 0x77, 0xE1, 0xF3, 0xC7, 0x8F, 0x1C, 0x38,
  0x70, 0xE3, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x1C, 0x1C,
  0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x3C, 0x38, 0xE0, 0xE3, 0x83, 0x80, 0x07,
  0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0xFC, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x07, 0x3C, 0x1C,
  0xE0, 0x77, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xBC, 0x1E,
  0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xE3, 0x83, 0x80,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x00, 0x00, 0x60, 0xE0, 0x6F, 0xDF, 0x87,
  0xFF, 0xFC, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1,
  0xC7, 0x07, 0x0E, 0x38, 0x38, 0x71, 0xC3, 0x83, 0x8E, 0x1C, 0x38, 0xF0,
  0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x78, 0x71, 0xC3, 0x87, 0x8E, 0x1C, 0x38,
  0xF0, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x70, 0x70, 0x00, 0x60, 0x37, 0xE1,
  0xDF, 0x87, 0xCF, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x0E, 0x38, 0x38,
  0xE0, 0xE3, 0x87, 0x1E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x1C, 0x38,
  0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x00, 0x01, 0x80, 0xFE, 0x1F, 0xF1, 0xC7,
  0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xF7, 0xC7, 0xF8, 0x3E, 0x00, 0x00,
  0x08, 0x03, 0x3E, 0x07, 0x7E, 0x07, 0xCF, 0x07, 0x87, 0x07, 0x07, 0x07,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x3C, 0x3F, 0x78, 0x3B, 0xF0, 0x3B,
  0xE0, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x3F, 0x71, 0xFD, 0x87, 0x1E,
  0x38, 0x78, 0xE1, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x78, 0xF7, 0xC3, 0xFF,
  0x07, 0xDC, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x61, 0xBC, 0x77, 0x8F, 0xF1, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xFF, 0x1F,
  0xE3, 0xC6, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0x88, 0x38, 0xEF, 0x8F, 0xF0, 0xFE,
  0x00, 0x0E, 0x06, 0x03, 0x03, 0x87, 0xFB, 0xF8, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1E, 0x8F,
  0xC3, 0xE0, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x70,
  0xE3, 0x8F, 0x1E, 0xF8, 0xFF, 0xC3, 0xEE, 0x00, 0xE0, 0xFE, 0x0E, 0xE1,
  0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE1,
  0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x87, 0x71, 0xF1, 0xCE, 0x36, 0x39, 0xCF,
  0xC7, 0x39, 0xF9, 0xC7, 0x37, 0x38, 0xEE, 0xEE, 0x1D, 0xDD, 0xC3, 0xB3,
  0xB8, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87,
  0xC0, 0xF0, 0xF0, 0x1C, 0x1E, 0x00, 0x07, 0x0F, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x38, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0xE0, 0x78, 0xF0, 0xF0, 0x70, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC1,
  0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x10, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x0F, 0xC0, 0xE0, 0x0F, 0x80, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x00,
  0x70, 0x1F, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x7C, 0x0F, 0xC0, 0xF0, 0x00, 0x7E, 0x0F,
  0xFC, 0xFB, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 11, 9, 12, 3, -24 },
  { 41, 16, 24, 15, 0, -24 },
  { 89, 14, 28, 14, 0, -26 },
  { 138, 19, 25, 22, 2, -25 },
  { 198, 15, 25, 15, 0, -25 },
  { 245, 5, 9, 7, 3, -24 },
  { 251, 10, 29, 9, 1, -24 },
  { 288, 11, 30, 9, -3, -25 },
  { 330, 11, 12, 13, 3, -26 },
  { 347, 13, 16, 15, 1, -20 },
  { 373, 7, 9, 7, -2, -4 },
  { 381, 8, 3, 9, 0, -11 },
  { 384, 4, 4, 7, 0, -4 },
  { 386, 16, 24, 12, -2, -24 },
  { 434, 13, 25, 14, 1, -25 },
  { 475, 10, 24, 14, 3, -24 },
  { 505, 15, 25, 14, -1, -25 },
  { 552, 15, 25, 14, -1, -25 },
  { 599, 15, 24, 14, -1, -24 },
  { 644, 14, 24, 14, 0, -24 },
  { 686, 14, 25, 14, 1, -25 },
  { 730, 14, 24, 14, 1, -24 },
  { 772, 14, 25, 14, 0, -25 },
  { 816, 14, 25, 14, 0, -25 },
  { 860, 7, 19, 7, 0, -19 },
  { 877, 9, 24, 7, -2, -19 },
  { 904, 13, 16, 15, 1, -20 },
  { 930, 13, 10, 15, 1, -17 },
  { 947, 13, 16, 15, 1, -20 },
  { 973, 11, 25, 10, 1, -25 },
  { 1008, 19, 28, 21, 1, -25 },
  { 1075, 14, 24, 14, -2, -24 },
  { 1117, 15, 24, 15, 0, -24 },
  { 1162, 15, 25, 14, 1, -25 },
  { 1209, 16, 24, 16, 0, -24 },
  { 1257, 14, 24, 13, 0, -24 },
  { 1299, 14, 24, 12, 0, -24 },
  { 1341, 17, 25, 17, 1, -25 },
  { 1395, 18, 24, 17, 0, -24 },
  { 1449, 14, 24, 9, -2, -24 },
  { 1491, 13, 31, 7, -5, -24 },
  { 1542, 17, 24, 14, 0, -24 },
  { 1593, 10, 24, 12, 0, -24 },
  { 1623, 23, 24, 22, 0, -24 },
  { 1692, 19, 24, 18, 0, -24 },
  { 1749, 16, 25, 17, 1, -25 },
  { 1799, 15, 24, 14, 0, -24 },
  { 1844, 16, 31, 17, 1, -25 },
  { 1906, 15, 24, 15, 0, -24 },
  { 1951, 15, 25, 13, -1, -25 },
  { 1998, 13, 24, 12, 2, -24 },
  { 2037, 16, 24, 16, 1, -24 },
  { 2085, 14, 24, 14, 3, -24 },
  { 2127, 23, 24, 23, 2, -24 },
  { 2196, 18, 24, 13, -2, -24 },
  { 2250, 13, 24, 13, 3, -24 },
  { 2289, 15, 24, 12, -1, -24 },
  { 2334, 13, 29, 10, -1, -24 },
  { 2382, 6, 24, 12, 3, -24 },
  { 2400, 13, 29, 10, -2, -24 },
  { 2448, 14, 13, 14, 0, -24 },
  { 2471, 11, 2, 11, -3, 3 },
  { 2474, 5, 5, 9, 5, -26 },
  { 2478, 14, 19, 15, 1, -19 },
  { 2512, 14, 26, 15, 0, -26 },
  { 2558, 11, 19, 11, 1, -19 },
  { 2585, 15, 26, 15, 1, -26 },
  { 2634, 12, 19, 13, 1, -19 },
  { 2663, 16, 34, 8, -4, -26 },
  { 2731, 16, 27, 15, -1, -19 },
  { 2785, 14, 26, 14, 0, -26 },
  { 2831, 8, 25, 7, 0, -25 },
  { 2856, 12, 33, 7, -4, -25 },
  { 2906, 14, 26, 13, 0, -26 },
  { 2952, 9, 26, 7, 0, -26 },
  { 2982, 21, 19, 21, 0, -19 },
  { 3032, 14, 19, 14, 0, -19 },
  { 3066, 12, 19, 14, 1, -19 },
  { 3095, 16, 27, 15, -2, -19 },
  { 3149, 14, 27, 15, 1, -19 },
  { 3197, 11, 19, 10, 0, -19 },
  { 3224, 12, 19, 11, 0, -19 },
  { 3253, 9, 22, 9, 1, -22 },
  { 3278, 13, 18, 14, 1, -18 },
  { 3308, 12, 18, 12, 2, -18 },
  { 3335, 19, 18, 19, 2, -18 },
  { 3378, 16, 18, 12, -2, -18 },
  { 3414, 17, 26, 12, -3, -18 },
  { 3470, 12, 18, 10, -1, -18 },
  { 3497, 12, 29, 11, 1, -24 },
  { 3541, 3, 34, 13, 5, -26 },
  { 3554, 12, 29, 11, -2, -24 },
  { 3598, 13, 4, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC34PT7B_H_
