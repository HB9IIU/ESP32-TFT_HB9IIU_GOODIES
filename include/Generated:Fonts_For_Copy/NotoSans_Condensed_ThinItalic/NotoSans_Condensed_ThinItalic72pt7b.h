#ifndef _NOTOSANS_CONDENSED_THINITALIC72PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x30, 0x18, 0x60,
  0x30, 0xC0, 0x61, 0x80, 0x82, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18,
  0x60, 0x20, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x10, 0x08, 0x20,
  0x30, 0xC0, 0x61, 0x80, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x80, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x31,
  0xF0, 0x07, 0x83, 0x03, 0x00, 0xE0, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x43, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x06, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x02, 0x03, 0x00, 0x80, 0x60, 0x70, 0x0E, 0x06, 0x3C, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x30, 0x06, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x60, 0x18, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x03, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x60, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x60, 0x03, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0xC0, 0x01, 0x80, 0x0C, 0x18, 0x3F, 0x30, 0x03, 0x06, 0x0F,
  0xF6, 0x00, 0x61, 0x83, 0x07, 0xC0, 0x0C, 0x30, 0xC0, 0x78, 0x03, 0x0C,
  0x30, 0x0F, 0x00, 0x61, 0x86, 0x01, 0xB0, 0x18, 0x61, 0x80, 0x16, 0x06,
  0x0C, 0x30, 0x02, 0xE1, 0xC3, 0x0C, 0x00, 0x4F, 0xF0, 0x61, 0x80, 0x18,
  0xF8, 0x18, 0x30, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x00, 0xC1, 0x80,
  0x0C, 0x00, 0x30, 0x30, 0x01, 0x80, 0x06, 0x06, 0x00, 0x30, 0x01, 0x81,
  0x80, 0x06, 0x00, 0x30, 0x30, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x03, 0x03, 0x80, 0x60,
  0x00, 0x30, 0xE0, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x1C, 0x06, 0x00, 0x61, 0xC0, 0x18, 0x03, 0x0C, 0x00, 0xC0, 0x30,
  0xC0, 0x03, 0x01, 0x8E, 0x00, 0x18, 0x08, 0x60, 0x00, 0xC0, 0xC3, 0x00,
  0x03, 0x06, 0x30, 0x00, 0x18, 0x61, 0x80, 0x00, 0xC3, 0x0C, 0x00, 0x03,
  0x30, 0x60, 0x00, 0x1B, 0x86, 0x00, 0x00, 0x78, 0x30, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0F, 0x01, 0x80,
  0x00, 0xCC, 0x0C, 0x00, 0x0E, 0x60, 0x30, 0x00, 0xC3, 0x01, 0xC0, 0x0C,
  0x0C, 0x07, 0x83, 0xC0, 0x60, 0x1F, 0xFC, 0x01, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x84,
  0x10, 0xC3, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x04, 0x00, 0x38, 0x20,
  0x00, 0x71, 0x00, 0x40, 0xC8, 0x3E, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x00,
  0x50, 0x00, 0x0C, 0xC0, 0x00, 0xC2, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x40,
  0x0C, 0x03, 0x01, 0xC0, 0x08, 0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80,
  0xFF, 0xFF, 0x5F, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0E, 0x80, 0x76, 0x07, 0x18,
  0x38, 0x61, 0xC1, 0x8C, 0x0C, 0xE0, 0x31, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x02, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x80,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0xFF, 0x80, 0x0C, 0x7E, 0x7C, 0x01, 0x9C, 0x01, 0xC0, 0x27, 0x00,
  0x18, 0x0D, 0x80, 0x01, 0x81, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00,
  0x60, 0x00, 0x70, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x01,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x78, 0x18, 0x00,
  0x1B, 0x03, 0x00, 0x06, 0x40, 0x30, 0x01, 0x98, 0x03, 0x80, 0xE3, 0x00,
  0x3F, 0xF8, 0x60, 0x01, 0xF8, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x03, 0x01, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xC0, 0x38, 0x08, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x03, 0x00, 0x01, 0xF0, 0x03, 0x03, 0x00,
  0x0F, 0xFC, 0x03, 0x06, 0x00, 0x1C, 0x0C, 0x03, 0x06, 0x00, 0x30, 0x0C,
  0x03, 0x0C, 0x00, 0x60, 0x08, 0x03, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x18, 0x01, 0x80, 0x18, 0x03, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x18, 0x03, 0x00, 0x30, 0x03, 0x30, 0x06, 0x00, 0x30, 0x02,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x30, 0x0C,
  0x00, 0x60, 0x06, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x60, 0x18, 0x00, 0x60,
  0x0C, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x60,
  0x18, 0x00, 0xC0, 0x18, 0x60, 0x18, 0x01, 0xC0, 0x18, 0x60, 0x18, 0x01,
  0xC0, 0x18, 0x60, 0x18, 0x03, 0x80, 0x30, 0xC0, 0x18, 0x02, 0x80, 0x70,
  0xC0, 0x18, 0x06, 0x80, 0x60, 0xC0, 0x18, 0x06, 0x80, 0xC0, 0xC0, 0x18,
  0x0C, 0xC1, 0xC0, 0xC0, 0x0C, 0x18, 0xC3, 0x80, 0x40, 0x0F, 0xF0, 0x7F,
  0x00, 0x60, 0x03, 0xE0, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x0E,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x38, 0x00, 0x20, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x18, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x78, 0x00, 0x60, 0x01, 0xE0, 0x00, 0x60, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0x3F, 0xFC,
  0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x10, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x0C, 0xF8, 0x00, 0x00, 0x03,
  0x36, 0x00, 0x00, 0x00, 0xD8, 0xC0, 0x00, 0x00, 0x6C, 0x30, 0x00, 0x00,
  0x1E, 0x0C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x06, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x33, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x66, 0x00, 0x00, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x31, 0x80, 0x00, 0x03, 0x08,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x30, 0x01, 0x82, 0x00, 0x00, 0x18, 0x60,
  0x03, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x08, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x01, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x40,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x1C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x0C, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x19, 0x80,
  0x03, 0x00, 0x18, 0x00, 0x36, 0x00, 0x06, 0x00, 0x30, 0x00, 0x6C, 0x00,
  0x08, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x30, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x78,
  0x00, 0x00, 0x30, 0x03, 0x40, 0x00, 0x03, 0x00, 0x1B, 0x00, 0x00, 0x18,
  0x00, 0xD8, 0x00, 0x00, 0xC0, 0x0C, 0xC0, 0x00, 0x06, 0x00, 0x62, 0x00,
  0x00, 0x30, 0x03, 0x18, 0x00, 0x03, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x00,
  0x86, 0x00, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x03, 0x06, 0x00, 0x03, 0x00, 0x18, 0x30, 0x00, 0x18, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x06, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x03, 0x01, 0x80, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x10, 0x00, 0x60, 0x18, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x60, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x18, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x60, 0x03, 0x00, 0x00, 0xC3,
  0x00, 0x30, 0x00, 0x03, 0x18, 0x01, 0x80, 0x00, 0x18, 0x80, 0x0C, 0x00,
  0x00, 0xCC, 0x00, 0x60, 0x00, 0x03, 0x60, 0x02, 0x00, 0x00, 0x1B, 0x00,
  0x30, 0x00, 0x00, 0xD8, 0x01, 0x80, 0x00, 0x06, 0x80, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x38, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x7E, 0x00, 0x03, 0x00, 0x1E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xE0, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x03, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x38,
  0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xC0, 0xFC, 0x00,
  0x0C, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x18,
  0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x20, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x01, 0x80, 0x01, 0xE0, 0x03, 0xF0,
  0x0F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x80, 0x18,
  0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x33, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xCC,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x0C, 0x00,
  0x02, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x0C, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x20, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x41, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0xF0, 0xE1, 0x00,
  0x70, 0x06, 0x20, 0x1C, 0x00, 0x4C, 0x07, 0x00, 0x0D, 0x80, 0xC0, 0x01,
  0xB0, 0x30, 0x00, 0x14, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x02,
  0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x36, 0x01, 0x80, 0x0C, 0xC0, 0x30,
  0x03, 0x90, 0x03, 0x00, 0xE2, 0x00, 0x78, 0x78, 0xC0, 0x07, 0xFC, 0x18,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x0C, 0x1F, 0xE0, 0x00, 0xC7, 0x87, 0x80, 0x18,
  0xE0, 0x18, 0x01, 0x98, 0x00, 0xC0, 0x1B, 0x00, 0x0E, 0x01, 0xF0, 0x00,
  0x60, 0x16, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0x3C, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x20, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x06,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0C, 0x07, 0x80, 0x01, 0x80, 0x6C,
  0x00, 0x38, 0x04, 0xC0, 0x07, 0x00, 0x46, 0x00, 0xE0, 0x0C, 0x38, 0x3C,
  0x00, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0xF0, 0x03, 0xC1, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x18, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0xF0, 0xF1, 0x80,
  0x07, 0x00, 0x63, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x70, 0x00, 0xD8, 0x00,
  0xC0, 0x00, 0xF0, 0x03, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x18,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0xD0, 0x01, 0x80, 0x03, 0x20, 0x01,
  0x80, 0x0E, 0xC0, 0x03, 0x00, 0x39, 0x80, 0x07, 0x00, 0xE3, 0x00, 0x07,
  0x87, 0x84, 0x00, 0x07, 0xFC, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0x83, 0x80, 0x38, 0x07, 0x01, 0xC0,
  0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x01, 0x0E, 0x00, 0x0C,
  0x30, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x18, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x80, 0x1E,
  0x06, 0x03, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x80, 0x78, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x78, 0x70, 0xC0, 0x07, 0x00,
  0x63, 0x00, 0x38, 0x00, 0xC8, 0x01, 0xC0, 0x03, 0x20, 0x06, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x38, 0x06, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x07, 0xC0, 0x18, 0x00,
  0x1A, 0x00, 0x60, 0x00, 0xF8, 0x00, 0xC0, 0x07, 0x60, 0x03, 0x00, 0x39,
  0x80, 0x0E, 0x01, 0xC6, 0x00, 0x1E, 0x1E, 0x10, 0x00, 0x3F, 0xE0, 0xC0,
  0x00, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x80, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x30, 0xFF, 0x80, 0x0C, 0x78, 0x78, 0x02, 0x30, 0x06, 0x01, 0x98, 0x00,
  0xC0, 0x6C, 0x00, 0x30, 0x1E, 0x00, 0x0C, 0x05, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x0E, 0x00, 0x00, 0xC6, 0xC0, 0x00, 0x33, 0x30, 0x00, 0x0D,
  0x8C, 0x00, 0x02, 0xC3, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x78, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0xFF, 0x00, 0xFF, 0x80, 0x08, 0xF0, 0xE0, 0x70, 0x70, 0x06,
  0x70, 0x0C, 0x70, 0x0E, 0x01, 0xB0, 0x03, 0x18, 0x01, 0x80, 0x6C, 0x00,
  0x6C, 0x00, 0x30, 0x1E, 0x00, 0x1E, 0x00, 0x0C, 0x05, 0x00, 0x07, 0x80,
  0x03, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x01, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x30, 0xFF, 0x80, 0x08, 0x70, 0x78, 0x06, 0x70, 0x06, 0x01, 0x98, 0x00,
  0xC0, 0x6C, 0x00, 0x30, 0x1E, 0x00, 0x0C, 0x05, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x70, 0x00, 0xE0,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x7F, 0x80, 0x00, 0x43, 0xC3, 0xC0, 0x00, 0x8E, 0x01, 0x80,
  0x03, 0x38, 0x01, 0x80, 0x06, 0xE0, 0x03, 0x00, 0x0D, 0x80, 0x03, 0x00,
  0x16, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60,
  0x0F, 0x00, 0x01, 0x80, 0x1A, 0x00, 0x06, 0x00, 0x36, 0x00, 0x1C, 0x00,
  0x6C, 0x00, 0x70, 0x00, 0xCC, 0x01, 0xC0, 0x03, 0x1E, 0x0F, 0x00, 0x06,
  0x0F, 0xF8, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFE,
  0x0C, 0x00, 0xE0, 0xE1, 0x80, 0x70, 0x06, 0x30, 0x1C, 0x00, 0x64, 0x07,
  0x00, 0x0D, 0x80, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x20, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x1E, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0xD0, 0x18, 0x00, 0x3E,
  0x01, 0x80, 0x0E, 0xC0, 0x30, 0x03, 0x98, 0x07, 0x00, 0xE3, 0x00, 0x78,
  0x78, 0x40, 0x07, 0xFC, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x06, 0x1F, 0xC0, 0x21, 0xE2, 0x03,
  0x18, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x78, 0x1F, 0x00, 0xE0, 0x02, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x03,
  0x80, 0xF8, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x10,
  0x1F, 0xE0, 0x0F, 0x00, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x38, 0x08, 0x00, 0x0E, 0x02, 0x00, 0x07, 0x80,
  0x80, 0x01, 0xE0, 0x30, 0x00, 0xD8, 0x0C, 0x00, 0x64, 0x03, 0x80, 0x31,
  0x00, 0x70, 0x78, 0xC0, 0x0F, 0xF8, 0x30, 0x00, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3,
  0x00, 0x07, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40, 0x03, 0x01, 0x00,
  0x0C, 0x04, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x60, 0x00,
  0x09, 0x80, 0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x02, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x0F,
  0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x0C, 0xC0,
  0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x01,
  0x8C, 0x00, 0x23, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0x43,
  0x00, 0x20, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0x40,
  0x18, 0x30, 0x0C, 0x04, 0x01, 0x83, 0x00, 0xC0, 0x40, 0x30, 0x30, 0x18,
  0x04, 0x03, 0x03, 0x01, 0x80, 0x40, 0x20, 0x30, 0x18, 0x04, 0x06, 0x03,
  0x03, 0x00, 0x40, 0x60, 0x30, 0x30, 0x04, 0x0C, 0x03, 0x06, 0x00, 0x40,
  0xC0, 0x30, 0x60, 0x04, 0x18, 0x03, 0x04, 0x00, 0x41, 0x80, 0x30, 0xC0,
  0x04, 0x30, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x31, 0x80, 0x04, 0x20, 0x03,
  0x18, 0x00, 0x46, 0x00, 0x31, 0x00, 0x04, 0x60, 0x03, 0x30, 0x00, 0x4C,
  0x00, 0x33, 0x00, 0x04, 0xC0, 0x03, 0x60, 0x00, 0x58, 0x00, 0x36, 0x00,
  0x05, 0x80, 0x03, 0x40, 0x00, 0x50, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x08, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x0E,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x1C, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x9E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0B, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x04, 0xF1, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x3D, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 51, 15, 1, -51 },
  { 91, 15, 18, 20, 7, -51 },
  { 125, 32, 51, 32, 1, -51 },
  { 329, 28, 59, 29, 1, -55 },
  { 536, 35, 53, 43, 4, -52 },
  { 768, 29, 53, 31, 0, -52 },
  { 961, 6, 18, 11, 7, -51 },
  { 975, 20, 62, 17, 2, -51 },
  { 1130, 20, 62, 17, -5, -51 },
  { 1285, 21, 23, 27, 9, -55 },
  { 1346, 27, 33, 32, 3, -42 },
  { 1458, 9, 16, 12, -3, -7 },
  { 1476, 16, 1, 20, 2, -20 },
  { 1478, 3, 5, 12, 2, -5 },
  { 1480, 30, 51, 21, -3, -51 },
  { 1672, 27, 53, 29, 2, -52 },
  { 1851, 14, 51, 29, 9, -51 },
  { 1941, 30, 52, 29, -2, -52 },
  { 2136, 30, 53, 29, -1, -52 },
  { 2335, 30, 52, 29, -1, -52 },
  { 2530, 30, 52, 29, -1, -51 },
  { 2725, 27, 53, 29, 3, -52 },
  { 2904, 27, 51, 29, 4, -51 },
  { 3077, 29, 53, 29, 0, -52 },
  { 3270, 27, 53, 29, 1, -52 },
  { 3449, 10, 38, 12, 1, -38 },
  { 3497, 15, 47, 12, -3, -38 },
  { 3586, 27, 31, 32, 3, -41 },
  { 3691, 27, 17, 32, 3, -34 },
  { 3749, 27, 31, 32, 3, -41 },
  { 3854, 21, 52, 21, 2, -52 },
  { 3991, 40, 57, 44, 2, -51 },
  { 4276, 29, 52, 28, -5, -52 },
  { 4465, 31, 51, 32, 1, -51 },
  { 4663, 31, 53, 30, 4, -52 },
  { 4869, 32, 51, 35, 1, -51 },
  { 5073, 30, 51, 29, 1, -51 },
  { 5265, 30, 51, 26, 1, -51 },
  { 5457, 34, 53, 38, 4, -52 },
  { 5683, 37, 51, 37, 1, -51 },
  { 5919, 22, 51, 14, -3, -51 },
  { 6060, 25, 63, 13, -11, -51 },
  { 6257, 34, 51, 29, 1, -51 },
  { 6474, 19, 51, 26, 1, -51 },
  { 6596, 47, 51, 47, 1, -51 },
  { 6896, 37, 51, 38, 1, -51 },
  { 7132, 32, 53, 38, 4, -52 },
  { 7344, 30, 51, 30, 1, -51 },
  { 7536, 32, 64, 38, 4, -52 },
  { 7792, 29, 51, 30, 1, -51 },
  { 7977, 31, 53, 28, -1, -52 },
  { 8183, 25, 51, 25, 6, -51 },
  { 8343, 34, 52, 36, 3, -51 },
  { 8564, 27, 51, 29, 7, -51 },
  { 8737, 46, 51, 48, 7, -51 },
  { 9031, 35, 51, 26, -4, -51 },
  { 9255, 25, 51, 25, 6, -51 },
  { 9415, 33, 51, 27, -2, -51 },
  { 9626, 26, 62, 20, -1, -51 },
  { 9828, 10, 51, 23, 7, -51 },
  { 9892, 26, 62, 20, -5, -51 },
  { 10094, 28, 26, 32, 2, -51 },
  { 10185, 21, 2, 21, -6, 7 },
  { 10191, 7, 11, 15, 11, -55 },
  { 10201, 27, 40, 31, 3, -39 },
  { 10336, 28, 56, 31, 1, -55 },
  { 10532, 22, 40, 23, 3, -39 },
  { 10642, 31, 56, 31, 3, -55 },
  { 10859, 22, 40, 27, 3, -39 },
  { 10969, 33, 72, 15, -9, -55 },
  { 11266, 30, 56, 31, 0, -39 },
  { 11476, 26, 55, 30, 1, -55 },
  { 11655, 13, 51, 12, 1, -51 },
  { 11738, 24, 68, 13, -10, -51 },
  { 11942, 26, 55, 24, 1, -55 },
  { 12121, 13, 55, 12, 1, -55 },
  { 12211, 42, 39, 46, 1, -39 },
  { 12416, 26, 39, 30, 1, -39 },
  { 12543, 25, 40, 30, 3, -39 },
  { 12668, 31, 55, 31, -2, -39 },
  { 12882, 27, 56, 31, 3, -39 },
  { 13071, 21, 39, 20, 1, -39 },
  { 13174, 24, 40, 23, -1, -39 },
  { 13294, 15, 48, 16, 2, -47 },
  { 13384, 26, 39, 30, 3, -38 },
  { 13511, 22, 38, 23, 4, -38 },
  { 13616, 36, 38, 37, 4, -38 },
  { 13787, 29, 38, 24, -3, -38 },
  { 13925, 35, 56, 24, -8, -38 },
  { 14170, 25, 38, 21, -2, -38 },
  { 14289, 25, 62, 23, 2, -51 },
  { 14483, 2, 73, 29, 14, -55 },
  { 14502, 24, 62, 23, -4, -51 },
  { 14688, 27, 7, 32, 3, -29 },
};

const GFXfont NotoSans_Condensed_ThinItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_THINITALIC72PT7B_H_
