#ifndef _NOTOSANS_CONDENSED_THINITALIC69PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x60,
  0x61, 0x81, 0x84, 0x06, 0x30, 0x18, 0xC0, 0x43, 0x03, 0x08, 0x0C, 0x20,
  0x31, 0x80, 0x86, 0x02, 0x18, 0x18, 0x40, 0x61, 0x01, 0x8C, 0x04, 0x30,
  0x10, 0x80, 0xC2, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x80,
  0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xE3, 0x1F,
  0x00, 0x70, 0x60, 0x60, 0x18, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x07, 0x10, 0x00, 0x00, 0x72, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0B, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x08, 0x30,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x30, 0x18, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xC0, 0x38, 0x60, 0x00, 0x60, 0x1C, 0x0C, 0x00, 0x30, 0x06,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x03, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x30, 0x30, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x60, 0x06, 0x06, 0x00, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x0C, 0x18, 0x3E, 0x30,
  0x03, 0x0C, 0x1F, 0xCC, 0x01, 0x83, 0x0C, 0x1B, 0x00, 0x61, 0x86, 0x06,
  0xC0, 0x18, 0x43, 0x00, 0xF0, 0x0C, 0x30, 0xC0, 0x3C, 0x07, 0x18, 0x60,
  0x0D, 0x81, 0x86, 0x18, 0x03, 0x60, 0xC3, 0x0C, 0x00, 0xCF, 0xE0, 0xC3,
  0x00, 0x31, 0xE0, 0x60, 0x80, 0x0C, 0x00, 0x10, 0x60, 0x03, 0x00, 0x0C,
  0x18, 0x00, 0x80, 0x06, 0x06, 0x00, 0x60, 0x01, 0x81, 0x00, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x00, 0x30, 0x30, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x40,
  0x06, 0x03, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x03,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x18, 0x70, 0x0C, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x21, 0xC0, 0x08, 0x06, 0x18,
  0x00, 0xC0, 0x63, 0x00, 0x0C, 0x0C, 0x30, 0x00, 0x60, 0xC6, 0x00, 0x06,
  0x18, 0x60, 0x00, 0x21, 0x86, 0x00, 0x03, 0x30, 0x60, 0x00, 0x33, 0x0C,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x1C, 0x04, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x34, 0x06, 0x00, 0x06, 0x60,
  0x70, 0x00, 0xC6, 0x03, 0x80, 0x38, 0x30, 0x1C, 0x0F, 0x03, 0x00, 0xFF,
  0xC0, 0x18, 0x01, 0xE0, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23,
  0x18, 0xC4, 0x23, 0x18, 0x84, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x20, 0x18, 0x03, 0xC0, 0xC0, 0x03, 0x84,
  0x00, 0x06, 0x20, 0x08, 0x1D, 0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0xC0, 0x00,
  0x0B, 0x00, 0x01, 0x88, 0x00, 0x18, 0x60, 0x01, 0x81, 0x00, 0x18, 0x0C,
  0x03, 0x80, 0x20, 0x08, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x77, 0xF6, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0x83, 0x80, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x10,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x74, 0x07, 0x60, 0x63,
  0x0E, 0x18, 0xE0, 0xCE, 0x04, 0xC0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80,
  0x70, 0x00, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x17, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x07, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x0E, 0x00, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x81, 0xFC, 0x00, 0x31, 0xFF, 0xC0, 0x04, 0x70, 0x0C, 0x01, 0x98, 0x00,
  0xC0, 0x36, 0x00, 0x0C, 0x07, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x10, 0x1C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x08,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x07, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x03,
  0x60, 0x60, 0x01, 0x90, 0x0C, 0x00, 0xEC, 0x03, 0x80, 0xE3, 0x00, 0x3F,
  0xF0, 0xC0, 0x03, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0x01, 0xC0, 0x40, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x70, 0x00, 0xFF, 0x00, 0x41, 0x80, 0x0F, 0xBE, 0x01, 0x06, 0x00, 0x70,
  0x10, 0x04, 0x30, 0x03, 0x80, 0xC0, 0x10, 0xC0, 0x1C, 0x03, 0x00, 0xC6,
  0x00, 0x60, 0x0C, 0x03, 0x18, 0x03, 0x00, 0x20, 0x0C, 0x60, 0x18, 0x01,
  0x80, 0x33, 0x00, 0x60, 0x06, 0x00, 0xCC, 0x03, 0x00, 0x18, 0x03, 0x30,
  0x0C, 0x00, 0x40, 0x0C, 0xC0, 0x30, 0x03, 0x00, 0x66, 0x01, 0x80, 0x0C,
  0x01, 0x98, 0x06, 0x00, 0x30, 0x06, 0x60, 0x18, 0x01, 0x80, 0x19, 0x80,
  0x60, 0x06, 0x00, 0xC6, 0x03, 0x00, 0x18, 0x03, 0x18, 0x0C, 0x00, 0xE0,
  0x0C, 0x40, 0x30, 0x03, 0x80, 0x63, 0x00, 0xC0, 0x0C, 0x01, 0x8C, 0x03,
  0x00, 0x70, 0x0C, 0x30, 0x0C, 0x01, 0x40, 0x30, 0xC0, 0x30, 0x0D, 0x01,
  0x83, 0x00, 0x60, 0x64, 0x0E, 0x0C, 0x01, 0x83, 0x98, 0x70, 0x30, 0x03,
  0xBC, 0x7F, 0x80, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x10, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0x80, 0xFE, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xE0, 0x02, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x0F, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x70, 0x01,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x08, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x01,
  0x80, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x1C,
  0x00, 0x10, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x60, 0xFF, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x80,
  0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x10, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x01, 0xFF, 0x81, 0x80, 0x00, 0xFF, 0xE0, 0x60, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x02, 0x07, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x40, 0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x01, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x02,
  0x76, 0x00, 0x00, 0x06, 0x66, 0x00, 0x00, 0x06, 0xC6, 0x00, 0x00, 0x07,
  0x82, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x02, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0, 0x01, 0xB0, 0x00, 0x00,
  0x0D, 0x80, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x60, 0x02, 0x60, 0x00, 0x00, 0x33, 0x00, 0x33, 0x00, 0x00, 0x03, 0x10,
  0x01, 0x88, 0x00, 0x00, 0x19, 0x80, 0x0C, 0x40, 0x00, 0x01, 0x8C, 0x00,
  0x62, 0x00, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x30, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00,
  0x01, 0x82, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x00,
  0x81, 0x80, 0x0C, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x40, 0x40, 0x00, 0xC0,
  0x60, 0x06, 0x02, 0x00, 0x06, 0x02, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x06, 0x00, 0x40,
  0x30, 0x06, 0x00, 0x30, 0x02, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x86, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x60, 0x01, 0x80, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x09, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x58, 0x00, 0x30, 0x01, 0x80, 0x02, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x1C, 0x00, 0x08, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x02, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x2C, 0x00, 0x00, 0x60, 0x06, 0xC0, 0x00,
  0x06, 0x00, 0x64, 0x00, 0x00, 0xC0, 0x06, 0x60, 0x00, 0x0C, 0x00, 0x66,
  0x00, 0x00, 0xC0, 0x04, 0x60, 0x00, 0x0C, 0x00, 0xC2, 0x00, 0x00, 0xC0,
  0x0C, 0x30, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x01, 0x80, 0x08, 0x30, 0x00,
  0x18, 0x01, 0x81, 0x00, 0x01, 0x80, 0x18, 0x18, 0x00, 0x10, 0x01, 0x81,
  0x80, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0x01, 0x00, 0x80, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x40, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x80, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x08, 0x00,
  0x18, 0x18, 0x01, 0x80, 0x01, 0x81, 0x80, 0x18, 0x00, 0x0C, 0x10, 0x01,
  0x80, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x01, 0x00, 0x00, 0xC3,
  0x00, 0x30, 0x00, 0x06, 0x30, 0x03, 0x00, 0x00, 0x62, 0x00, 0x30, 0x00,
  0x06, 0x60, 0x03, 0x00, 0x00, 0x66, 0x00, 0x60, 0x00, 0x03, 0x60, 0x06,
  0x00, 0x00, 0x34, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x30,
  0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x30,
  0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00,
  0x20, 0x00, 0xE0, 0x06, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06,
  0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06, 0x04, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x68, 0x00, 0x01, 0xE0,
  0x00, 0x0C, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x60, 0x00,
  0x18, 0x80, 0x00, 0x36, 0x00, 0x01, 0x88, 0x00, 0x03, 0x60, 0x00, 0x18,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x08, 0x00, 0x06, 0x60, 0x00, 0x30, 0x80,
  0x00, 0xC6, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x80, 0x00,
  0x86, 0x00, 0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x86,
  0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x01, 0x80, 0x80, 0x03, 0x06, 0x00,
  0x18, 0x08, 0x00, 0x60, 0x60, 0x03, 0x00, 0x80, 0x06, 0x06, 0x00, 0x30,
  0x08, 0x00, 0x40, 0x60, 0x03, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x08,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x08, 0x03, 0x00,
  0x60, 0x18, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x08, 0x06, 0x00, 0x60,
  0x30, 0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x60,
  0x00, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x60, 0x40, 0x00,
  0x81, 0x80, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x60, 0xC0, 0x00, 0x83,
  0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x61, 0x80, 0x00, 0x82, 0x00,
  0x06, 0x10, 0x00, 0x08, 0x60, 0x00, 0x63, 0x00, 0x00, 0x86, 0x00, 0x06,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x60,
  0x00, 0x09, 0x80, 0x00, 0x64, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00,
  0x09, 0x00, 0x00, 0x68, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x0B,
  0x00, 0x00, 0x58, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xF0,
  0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFE, 0x10, 0x07, 0x81, 0xCC, 0x03, 0x80, 0x33, 0x01,
  0xC0, 0x06, 0xC0, 0x60, 0x01, 0xA0, 0x30, 0x00, 0x28, 0x18, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x78, 0x18, 0x00, 0x1C, 0x06,
  0x00, 0x0F, 0x01, 0x80, 0x02, 0xC0, 0x60, 0x01, 0xB0, 0x0C, 0x00, 0xC8,
  0x03, 0x80, 0x62, 0x00, 0x70, 0x70, 0x80, 0x0F, 0xF8, 0x60, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x07, 0xE0, 0x01, 0x87, 0xFE, 0x00, 0x63, 0x81,
  0xC0, 0x19, 0x80, 0x38, 0x06, 0xC0, 0x06, 0x01, 0x60, 0x00, 0xC0, 0xD8,
  0x00, 0x30, 0x3C, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x1E, 0x00, 0x06, 0x07, 0x80, 0x03, 0x81, 0x20,
  0x00, 0xC0, 0x4C, 0x00, 0x60, 0x33, 0x80, 0x70, 0x0C, 0x70, 0x38, 0x03,
  0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0xC0, 0x3C, 0x02, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x18, 0x00,
  0x1F, 0xF8, 0x60, 0x01, 0xE0, 0x71, 0x00, 0x0E, 0x00, 0xEC, 0x00, 0x70,
  0x01, 0xB0, 0x01, 0x80, 0x02, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x38, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x03, 0x80, 0x10, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x78, 0x01,
  0x80, 0x03, 0x40, 0x06, 0x00, 0x0D, 0x00, 0x18, 0x00, 0x6C, 0x00, 0x30,
  0x03, 0x30, 0x00, 0xE0, 0x18, 0xC0, 0x01, 0xC1, 0xC2, 0x00, 0x03, 0xFE,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80,
  0x3C, 0x0C, 0x03, 0x80, 0x30, 0x38, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00,
  0x21, 0x80, 0x01, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x70,
  0x60, 0x0F, 0x06, 0x07, 0xE0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x40, 0x38, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x87, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x07, 0x81,
  0xC4, 0x00, 0x70, 0x07, 0x20, 0x07, 0x00, 0x1B, 0x00, 0x30, 0x00, 0x58,
  0x03, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x80, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x60, 0x10, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x01, 0x00, 0x01, 0xE0, 0x0C,
  0x00, 0x0F, 0x00, 0x60, 0x00, 0xD8, 0x03, 0x00, 0x0E, 0x80, 0x18, 0x00,
  0x6C, 0x00, 0x60, 0x06, 0x60, 0x03, 0x80, 0x63, 0x00, 0x0E, 0x0E, 0x10,
  0x00, 0x3F, 0xE1, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x03, 0xF0, 0x01, 0x87, 0xFE, 0x00,
  0xC7, 0x03, 0x80, 0x66, 0x00, 0xC0, 0x36, 0x00, 0x30, 0x16, 0x00, 0x18,
  0x1E, 0x00, 0x0C, 0x0F, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x47, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x01, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x10, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x0C,
  0xD8, 0x00, 0x06, 0xEC, 0x00, 0x02, 0x63, 0x00, 0x03, 0x61, 0x80, 0x01,
  0xE0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x20, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0x40, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0x87, 0xFC, 0x0F,
  0xFC, 0x01, 0x9C, 0x0E, 0x1C, 0x0E, 0x01, 0xB0, 0x06, 0x30, 0x06, 0x01,
  0x60, 0x03, 0x60, 0x03, 0x01, 0x40, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x03, 0x80, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0x00,
  0x02, 0x00, 0x02, 0x06, 0x00, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x30, 0x00, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x20, 0x00, 0x20, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x00, 0x20, 0x60, 0x00, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x00, 0x60, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xC3, 0xFF, 0x00, 0x67, 0x01, 0xC0, 0x37, 0x00, 0x60, 0x13, 0x00, 0x18,
  0x0B, 0x00, 0x0C, 0x0F, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x20, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x10,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x18,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x87, 0xFE, 0x00, 0x0C,
  0x70, 0x38, 0x00, 0x67, 0x00, 0xE0, 0x02, 0x70, 0x03, 0x00, 0x17, 0x00,
  0x0C, 0x01, 0xB0, 0x00, 0x60, 0x0F, 0x00, 0x03, 0x00, 0x78, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x10, 0x0E,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0xE0, 0x0D,
  0x00, 0x06, 0x00, 0x6C, 0x00, 0x60, 0x02, 0x70, 0x0E, 0x00, 0x31, 0xC1,
  0xE0, 0x01, 0x87, 0xFC, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x0C, 0x01,
  0xC0, 0x71, 0x00, 0x70, 0x07, 0x20, 0x1C, 0x00, 0x6C, 0x03, 0x00, 0x05,
  0x80, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x70, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x02, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x1C, 0x04, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x36,
  0x03, 0x00, 0x06, 0x80, 0x60, 0x01, 0xB0, 0x06, 0x00, 0x66, 0x00, 0xE0,
  0x18, 0xC0, 0x0E, 0x0E, 0x10, 0x00, 0xFF, 0x86, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x0C, 0x3F, 0x80, 0x63, 0x00, 0x03,
  0x30, 0x00, 0x13, 0x00, 0x00, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x20, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x07, 0x80, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0xFF,
  0xF0, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x40,
  0x7F, 0x00, 0x78, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x10, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x1C, 0x08, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x06, 0x00,
  0x07, 0x03, 0x00, 0x07, 0x80, 0x80, 0x06, 0xC0, 0x60, 0x06, 0x40, 0x30,
  0x07, 0x20, 0x0E, 0x0E, 0x10, 0x03, 0xFE, 0x18, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06,
  0x01, 0x00, 0x30, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x01, 0x80, 0x10,
  0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x10, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x03, 0x80, 0x06,
  0x60, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0x16, 0x00, 0x11, 0x80, 0x06, 0xC0,
  0x06, 0x30, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x06,
  0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x83, 0x00, 0x31, 0x80, 0x30, 0x60,
  0x04, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x01, 0x81, 0x80, 0x20, 0xC0, 0x30,
  0x30, 0x0C, 0x18, 0x04, 0x06, 0x01, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x20, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x80, 0x60, 0x60,
  0x30, 0x60, 0x0C, 0x08, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC1, 0x00, 0x30,
  0x40, 0x18, 0x60, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x0C, 0x60, 0x01, 0x18, 0x01, 0x88, 0x00, 0x26, 0x00, 0x33,
  0x00, 0x04, 0xC0, 0x06, 0x40, 0x00, 0x90, 0x00, 0xD8, 0x00, 0x16, 0x00,
  0x1B, 0x00, 0x02, 0xC0, 0x03, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x10,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x08, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x08,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x04, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x10, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x08, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x08, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x80, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x4F, 0x3E, 0x00, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0x1E, 0x1E, 0x80, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 49, 14, 1, -49 },
  { 81, 14, 18, 19, 7, -49 },
  { 113, 30, 49, 30, 1, -49 },
  { 297, 27, 56, 28, 1, -52 },
  { 486, 34, 51, 41, 4, -50 },
  { 703, 28, 51, 30, 0, -50 },
  { 882, 5, 18, 10, 7, -49 },
  { 894, 19, 60, 17, 2, -49 },
  { 1037, 19, 60, 17, -5, -49 },
  { 1180, 21, 21, 26, 8, -52 },
  { 1236, 26, 32, 31, 3, -40 },
  { 1340, 9, 16, 11, -3, -7 },
  { 1358, 15, 2, 19, 2, -20 },
  { 1362, 4, 4, 12, 1, -4 },
  { 1364, 28, 49, 20, -3, -49 },
  { 1536, 25, 51, 28, 2, -50 },
  { 1696, 13, 49, 28, 9, -49 },
  { 1776, 29, 50, 28, -2, -50 },
  { 1958, 29, 51, 28, -1, -50 },
  { 2143, 28, 50, 28, -1, -50 },
  { 2318, 29, 50, 28, -1, -49 },
  { 2500, 27, 51, 28, 2, -50 },
  { 2673, 26, 49, 28, 4, -49 },
  { 2833, 28, 51, 28, 0, -50 },
  { 3012, 26, 51, 28, 1, -50 },
  { 3178, 10, 37, 12, 1, -37 },
  { 3225, 14, 46, 12, -3, -37 },
  { 3306, 26, 29, 31, 3, -39 },
  { 3401, 26, 17, 31, 3, -33 },
  { 3457, 26, 29, 31, 3, -39 },
  { 3552, 20, 50, 20, 2, -50 },
  { 3677, 38, 55, 42, 2, -49 },
  { 3939, 27, 49, 27, -4, -49 },
  { 4105, 29, 49, 30, 1, -49 },
  { 4283, 29, 51, 29, 4, -50 },
  { 4468, 31, 49, 34, 1, -49 },
  { 4658, 29, 49, 27, 1, -49 },
  { 4836, 29, 49, 25, 1, -49 },
  { 5014, 34, 51, 36, 3, -50 },
  { 5231, 35, 49, 35, 1, -49 },
  { 5446, 21, 49, 14, -3, -49 },
  { 5575, 23, 61, 12, -10, -49 },
  { 5751, 32, 49, 28, 1, -49 },
  { 5947, 18, 49, 25, 1, -49 },
  { 6058, 45, 49, 45, 1, -49 },
  { 6334, 36, 49, 36, 1, -49 },
  { 6555, 32, 51, 36, 3, -50 },
  { 6759, 28, 49, 29, 1, -49 },
  { 6931, 32, 62, 36, 3, -50 },
  { 7179, 28, 49, 29, 1, -49 },
  { 7351, 29, 51, 27, -1, -50 },
  { 7536, 24, 49, 24, 6, -49 },
  { 7683, 33, 50, 35, 3, -49 },
  { 7890, 27, 49, 28, 6, -49 },
  { 8056, 44, 49, 46, 7, -49 },
  { 8326, 34, 49, 25, -4, -49 },
  { 8535, 24, 49, 24, 6, -49 },
  { 8682, 31, 49, 26, -2, -49 },
  { 8872, 25, 60, 20, -1, -49 },
  { 9060, 9, 49, 22, 7, -49 },
  { 9116, 24, 60, 20, -4, -49 },
  { 9296, 27, 25, 30, 2, -49 },
  { 9381, 20, 1, 20, -5, 7 },
  { 9384, 7, 11, 15, 10, -53 },
  { 9394, 26, 38, 30, 2, -37 },
  { 9518, 26, 53, 30, 1, -52 },
  { 9691, 21, 38, 22, 3, -37 },
  { 9791, 30, 53, 30, 2, -52 },
  { 9990, 21, 38, 26, 3, -37 },
  { 10090, 32, 70, 14, -9, -53 },
  { 10370, 29, 54, 30, 0, -37 },
  { 10566, 25, 52, 29, 1, -52 },
  { 10729, 13, 49, 12, 1, -49 },
  { 10809, 23, 66, 12, -9, -49 },
  { 10999, 25, 52, 23, 1, -52 },
  { 11162, 13, 52, 11, 1, -52 },
  { 11247, 40, 37, 44, 1, -37 },
  { 11432, 25, 37, 29, 1, -37 },
  { 11548, 25, 38, 29, 2, -37 },
  { 11667, 29, 53, 30, -2, -37 },
  { 11860, 27, 53, 30, 2, -37 },
  { 12039, 21, 37, 19, 1, -37 },
  { 12137, 23, 38, 22, -1, -37 },
  { 12247, 14, 46, 15, 2, -45 },
  { 12328, 25, 37, 29, 2, -36 },
  { 12444, 21, 36, 22, 4, -36 },
  { 12539, 35, 36, 36, 4, -36 },
  { 12697, 28, 36, 23, -3, -36 },
  { 12823, 34, 53, 23, -8, -36 },
  { 13049, 24, 36, 20, -2, -36 },
  { 13157, 24, 60, 22, 2, -49 },
  { 13337, 2, 70, 28, 13, -53 },
  { 13355, 23, 60, 22, -4, -49 },
  { 13528, 26, 5, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_ThinItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_THINITALIC69PT7B_H_
