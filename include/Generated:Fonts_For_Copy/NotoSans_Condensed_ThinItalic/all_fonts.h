#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_ThinItalic
// Headers: 67

#include "NotoSans_Condensed_ThinItalic6pt7b.h"
#include "NotoSans_Condensed_ThinItalic7pt7b.h"
#include "NotoSans_Condensed_ThinItalic8pt7b.h"
#include "NotoSans_Condensed_ThinItalic9pt7b.h"
#include "NotoSans_Condensed_ThinItalic10pt7b.h"
#include "NotoSans_Condensed_ThinItalic11pt7b.h"
#include "NotoSans_Condensed_ThinItalic12pt7b.h"
#include "NotoSans_Condensed_ThinItalic13pt7b.h"
#include "NotoSans_Condensed_ThinItalic14pt7b.h"
#include "NotoSans_Condensed_ThinItalic15pt7b.h"
#include "NotoSans_Condensed_ThinItalic16pt7b.h"
#include "NotoSans_Condensed_ThinItalic17pt7b.h"
#include "NotoSans_Condensed_ThinItalic18pt7b.h"
#include "NotoSans_Condensed_ThinItalic19pt7b.h"
#include "NotoSans_Condensed_ThinItalic20pt7b.h"
#include "NotoSans_Condensed_ThinItalic21pt7b.h"
#include "NotoSans_Condensed_ThinItalic22pt7b.h"
#include "NotoSans_Condensed_ThinItalic23pt7b.h"
#include "NotoSans_Condensed_ThinItalic24pt7b.h"
#include "NotoSans_Condensed_ThinItalic25pt7b.h"
#include "NotoSans_Condensed_ThinItalic26pt7b.h"
#include "NotoSans_Condensed_ThinItalic27pt7b.h"
#include "NotoSans_Condensed_ThinItalic28pt7b.h"
#include "NotoSans_Condensed_ThinItalic29pt7b.h"
#include "NotoSans_Condensed_ThinItalic30pt7b.h"
#include "NotoSans_Condensed_ThinItalic31pt7b.h"
#include "NotoSans_Condensed_ThinItalic32pt7b.h"
#include "NotoSans_Condensed_ThinItalic33pt7b.h"
#include "NotoSans_Condensed_ThinItalic34pt7b.h"
#include "NotoSans_Condensed_ThinItalic35pt7b.h"
#include "NotoSans_Condensed_ThinItalic36pt7b.h"
#include "NotoSans_Condensed_ThinItalic37pt7b.h"
#include "NotoSans_Condensed_ThinItalic38pt7b.h"
#include "NotoSans_Condensed_ThinItalic39pt7b.h"
#include "NotoSans_Condensed_ThinItalic40pt7b.h"
#include "NotoSans_Condensed_ThinItalic41pt7b.h"
#include "NotoSans_Condensed_ThinItalic42pt7b.h"
#include "NotoSans_Condensed_ThinItalic43pt7b.h"
#include "NotoSans_Condensed_ThinItalic44pt7b.h"
#include "NotoSans_Condensed_ThinItalic45pt7b.h"
#include "NotoSans_Condensed_ThinItalic46pt7b.h"
#include "NotoSans_Condensed_ThinItalic47pt7b.h"
#include "NotoSans_Condensed_ThinItalic48pt7b.h"
#include "NotoSans_Condensed_ThinItalic49pt7b.h"
#include "NotoSans_Condensed_ThinItalic50pt7b.h"
#include "NotoSans_Condensed_ThinItalic51pt7b.h"
#include "NotoSans_Condensed_ThinItalic52pt7b.h"
#include "NotoSans_Condensed_ThinItalic53pt7b.h"
#include "NotoSans_Condensed_ThinItalic54pt7b.h"
#include "NotoSans_Condensed_ThinItalic55pt7b.h"
#include "NotoSans_Condensed_ThinItalic56pt7b.h"
#include "NotoSans_Condensed_ThinItalic57pt7b.h"
#include "NotoSans_Condensed_ThinItalic58pt7b.h"
#include "NotoSans_Condensed_ThinItalic59pt7b.h"
#include "NotoSans_Condensed_ThinItalic60pt7b.h"
#include "NotoSans_Condensed_ThinItalic61pt7b.h"
#include "NotoSans_Condensed_ThinItalic62pt7b.h"
#include "NotoSans_Condensed_ThinItalic63pt7b.h"
#include "NotoSans_Condensed_ThinItalic64pt7b.h"
#include "NotoSans_Condensed_ThinItalic65pt7b.h"
#include "NotoSans_Condensed_ThinItalic66pt7b.h"
#include "NotoSans_Condensed_ThinItalic67pt7b.h"
#include "NotoSans_Condensed_ThinItalic68pt7b.h"
#include "NotoSans_Condensed_ThinItalic69pt7b.h"
#include "NotoSans_Condensed_ThinItalic70pt7b.h"
#include "NotoSans_Condensed_ThinItalic71pt7b.h"
#include "NotoSans_Condensed_ThinItalic72pt7b.h"
