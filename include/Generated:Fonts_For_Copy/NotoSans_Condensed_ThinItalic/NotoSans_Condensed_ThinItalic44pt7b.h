#ifndef _NOTOSANS_CONDENSED_THINITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0x90, 0x48, 0x64,
  0x22, 0x12, 0x09, 0x04, 0x84, 0x42, 0x21, 0x20, 0x80, 0x00, 0x20, 0x40,
  0x0C, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x10, 0x01, 0x02, 0x00,
  0x20, 0x40, 0x04, 0x18, 0x01, 0x02, 0x03, 0xFF, 0xFC, 0x04, 0x08, 0x01,
  0x82, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x82, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x00, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x0F, 0xFF, 0xF0, 0x20,
  0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x81,
  0x00, 0x30, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x01, 0xCB, 0xC0, 0xC4,
  0x10, 0x61, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x04, 0x00, 0xC2, 0x00,
  0x30, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x26, 0x00, 0x05, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x02, 0x60, 0x00, 0x8C, 0x00, 0x21,
  0x00, 0x08, 0x60, 0x02, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40,
  0x04, 0x30, 0x03, 0x08, 0x30, 0x8C, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x07, 0x00, 0x10, 0x64,
  0x01, 0x04, 0x30, 0x08, 0x60, 0x80, 0x82, 0x04, 0x0C, 0x30, 0x20, 0x41,
  0x01, 0x06, 0x08, 0x08, 0x20, 0xC0, 0xC2, 0x04, 0x04, 0x10, 0x20, 0x21,
  0x01, 0x01, 0x18, 0x08, 0x08, 0x80, 0x40, 0x8C, 0x7A, 0x04, 0x44, 0x70,
  0x64, 0x41, 0x82, 0x26, 0x0C, 0x32, 0x20, 0x73, 0x13, 0x02, 0xE1, 0x10,
  0x10, 0x18, 0x80, 0x80, 0x84, 0x04, 0x0C, 0x60, 0x60, 0x42, 0x02, 0x04,
  0x10, 0x10, 0x20, 0x80, 0x82, 0x04, 0x0C, 0x30, 0x20, 0x41, 0x01, 0x02,
  0x18, 0x08, 0x20, 0x80, 0x63, 0x08, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x19, 0x80, 0x08, 0x20, 0x04, 0x0C, 0x01, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x20, 0x08, 0x08, 0x02, 0x02, 0x00, 0x81, 0x00, 0x30, 0xC0,
  0x04, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0xC0, 0x01, 0x10, 0x00, 0x84, 0x04, 0x40, 0x82, 0x20, 0x20, 0x98, 0x0C,
  0x24, 0x01, 0x11, 0x00, 0x44, 0xC0, 0x0A, 0x30, 0x03, 0x88, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x1C, 0x10, 0x0C, 0x86, 0x06, 0x20, 0xFE, 0x0C, 0x32,
  0x22, 0x24, 0x44, 0x44, 0x80, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x41, 0x82, 0x02, 0x10, 0x0D, 0x0C, 0x1F, 0x80, 0xC0,
  0x09, 0x00, 0x88, 0x08, 0x20, 0x81, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x0C, 0x21, 0x84, 0x10, 0x82, 0x10, 0x42, 0x00, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xC6, 0x01, 0x02, 0x02, 0x01, 0x06, 0x01, 0x04,
  0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x03, 0x60, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04, 0xC0,
  0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20, 0x60,
  0x60, 0x20, 0xC0, 0x1F, 0x00, 0x03, 0x0D, 0x1A, 0x22, 0xC2, 0x82, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x00, 0x3E, 0x00, 0x30, 0xC0, 0x10, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x71, 0xC0, 0x60, 0x18, 0x10, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x08, 0x06, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x58, 0x00,
  0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x21, 0x00, 0x31, 0x00, 0x10, 0x80,
  0x10, 0x40, 0x18, 0x20, 0x08, 0x30, 0x08, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x02, 0x04, 0x03, 0x06, 0x01, 0x02, 0x00, 0x82, 0x00, 0x43, 0x00,
  0x21, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x01, 0xFF, 0xC0, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x09,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x20, 0x18, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x61, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x47, 0xE0, 0x4C, 0x10,
  0x50, 0x08, 0xE0, 0x08, 0xC0, 0x0C, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10,
  0x80, 0x10, 0x80, 0x20, 0xC0, 0x60, 0x60, 0xC0, 0x3F, 0x80, 0x3F, 0xFF,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x31, 0xC0, 0x10, 0x18, 0x08, 0x02, 0x06, 0x00, 0xC1,
  0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40,
  0x18, 0x08, 0x04, 0x02, 0x02, 0x00, 0x43, 0x00, 0x0B, 0x80, 0x03, 0x80,
  0x03, 0xA0, 0x01, 0x84, 0x01, 0x80, 0x80, 0xC0, 0x10, 0x20, 0x04, 0x10,
  0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x23, 0x00, 0x10, 0x40, 0x04, 0x18, 0x02, 0x03, 0x03, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0x63, 0x00, 0x40, 0x40, 0x40, 0x30, 0x40, 0x08, 0x20,
  0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x06, 0x08, 0x07,
  0x06, 0x06, 0x81, 0xCE, 0x40, 0x38, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x01, 0xFE, 0x00, 0x06, 0x0C, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x0C, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0xE3, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x18, 0x06, 0x00, 0x10, 0x01, 0x80, 0x10, 0x00, 0x40, 0x10, 0x00, 0x10,
  0x10, 0x00, 0x08, 0x18, 0x00, 0x04, 0x08, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x8C, 0x07, 0xF0, 0x44, 0x06, 0x10, 0x22, 0x06, 0x08, 0x13, 0x06, 0x04,
  0x19, 0x02, 0x06, 0x0C, 0x83, 0x02, 0x04, 0xC1, 0x01, 0x02, 0x40, 0x80,
  0x81, 0x20, 0xC0, 0xC0, 0x90, 0x40, 0x40, 0x88, 0x20, 0x20, 0x44, 0x10,
  0x30, 0x62, 0x08, 0x18, 0x21, 0x04, 0x14, 0x31, 0x82, 0x0A, 0x10, 0x41,
  0x89, 0x10, 0x20, 0x78, 0x70, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x68, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x11, 0x00, 0x08, 0xC0, 0x08, 0x60, 0x04, 0x10,
  0x04, 0x08, 0x02, 0x04, 0x03, 0x02, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80,
  0x40, 0xC0, 0x20, 0x7F, 0xF0, 0x20, 0x08, 0x20, 0x04, 0x10, 0x02, 0x10,
  0x01, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x26, 0x00, 0x12, 0x00, 0x0B,
  0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0x03, 0xFF, 0x00, 0x80, 0x60, 0x20,
  0x0C, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01,
  0x04, 0x00, 0x42, 0x00, 0x30, 0x80, 0x08, 0x20, 0x04, 0x08, 0x03, 0x06,
  0x03, 0x01, 0xFF, 0x00, 0x40, 0x70, 0x10, 0x06, 0x04, 0x00, 0x83, 0x00,
  0x30, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x80, 0x0C,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x30, 0x80, 0x18, 0x20,
  0x18, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0E, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x02, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x40,
  0x70, 0x08, 0x03, 0x01, 0x00, 0x20, 0x60, 0x06, 0x08, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x62, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x62, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0xC1, 0x00, 0x30,
  0x60, 0x0C, 0x08, 0x03, 0x01, 0x03, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xC3, 0xC0,
  0x30, 0x02, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x7F, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00,
  0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x82,
  0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x02, 0x02, 0x00, 0x10, 0x18, 0x00,
  0x80, 0x60, 0x0C, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x04, 0x08, 0x00, 0x30,
  0x20, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x60, 0x40,
  0x01, 0x01, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x03,
  0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81, 0xFF, 0xFE, 0x04,
  0x00, 0x18, 0x10, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00,
  0x10, 0x20, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x20,
  0x40, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0x40, 0x80,
  0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0xFC, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x20, 0x06, 0x02, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x03, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x40,
  0x80, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x08, 0x60, 0x00, 0x8C, 0x00, 0x09,
  0x80, 0x01, 0x98, 0x00, 0x12, 0x80, 0x01, 0x48, 0x00, 0x18, 0x80, 0x01,
  0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0x60, 0x02, 0x02, 0x00,
  0x60, 0x20, 0x04, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18,
  0x0C, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0A, 0x07, 0x80, 0x00, 0xA0,
  0x58, 0x00, 0x12, 0x04, 0x80, 0x01, 0x60, 0x48, 0x00, 0x24, 0x0C, 0x80,
  0x02, 0x40, 0x88, 0x00, 0x44, 0x08, 0x80, 0x04, 0x40, 0x88, 0x00, 0x8C,
  0x08, 0x80, 0x08, 0x81, 0x88, 0x01, 0x08, 0x10, 0x80, 0x10, 0x81, 0x08,
  0x02, 0x08, 0x10, 0xC0, 0x21, 0x01, 0x04, 0x04, 0x10, 0x30, 0x40, 0xC1,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x02, 0x04, 0x10, 0x20, 0x60,
  0x43, 0x02, 0x04, 0x04, 0x20, 0x20, 0x40, 0x46, 0x02, 0x04, 0x04, 0x40,
  0x60, 0x40, 0x4C, 0x04, 0x0C, 0x06, 0x80, 0x40, 0x80, 0x38, 0x04, 0x08,
  0x03, 0x00, 0x40, 0x80, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x0C, 0x00,
  0x10, 0x30, 0x00, 0x40, 0xA0, 0x03, 0x06, 0x80, 0x08, 0x12, 0x00, 0x20,
  0x48, 0x00, 0x81, 0x10, 0x02, 0x0C, 0x40, 0x18, 0x21, 0x00, 0x40, 0x84,
  0x01, 0x02, 0x08, 0x04, 0x08, 0x20, 0x30, 0x60, 0x80, 0x81, 0x03, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x41, 0x83, 0x01, 0x84, 0x08,
  0x02, 0x10, 0x20, 0x08, 0x40, 0x80, 0x21, 0x06, 0x00, 0xCC, 0x10, 0x01,
  0x20, 0x40, 0x04, 0x81, 0x00, 0x12, 0x04, 0x00, 0x68, 0x30, 0x00, 0xE0,
  0x80, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00,
  0x0E, 0x18, 0x01, 0x80, 0x40, 0x30, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00,
  0x12, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0x80,
  0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x8C,
  0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x06, 0x02, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x80, 0xC0, 0x20, 0x18,
  0x08, 0x02, 0x06, 0x00, 0x81, 0x00, 0x30, 0x40, 0x0C, 0x10, 0x03, 0x0C,
  0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x20, 0x06, 0x08, 0x01, 0x06, 0x00,
  0xC1, 0x00, 0x60, 0x40, 0x30, 0x1F, 0xF0, 0x07, 0x80, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x18, 0x01, 0x80, 0x40, 0x30,
  0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10,
  0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x16,
  0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0xC0, 0x00, 0x2C, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00,
  0xC8, 0x00, 0x08, 0x80, 0x00, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00,
  0x20, 0x40, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x03, 0xFE, 0x00, 0x80, 0xC0,
  0x20, 0x18, 0x08, 0x02, 0x06, 0x00, 0x81, 0x00, 0x30, 0x40, 0x0C, 0x10,
  0x03, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x06, 0x08, 0x01,
  0x06, 0x00, 0x81, 0x00, 0x60, 0x40, 0x60, 0x1F, 0xE0, 0x04, 0x10, 0x03,
  0x06, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x08, 0x02, 0x02, 0x01, 0x80,
  0xC0, 0x40, 0x10, 0x10, 0x04, 0x04, 0x01, 0x03, 0x00, 0x60, 0x80, 0x08,
  0x20, 0x02, 0x08, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x3C, 0x06, 0x00,
  0x81, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x30, 0x0C, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x18, 0x20,
  0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18,
  0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00,
  0x10, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x03, 0x04,
  0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x03,
  0x04, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x40, 0x80,
  0x02, 0x04, 0x00, 0x30, 0x20, 0x01, 0x01, 0x80, 0x18, 0x04, 0x00, 0x80,
  0x18, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00,
  0xD0, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x0C, 0x20, 0x04, 0x18, 0x06, 0x0C, 0x02, 0x02, 0x03, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x20,
  0x04, 0x20, 0x02, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x24,
  0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0xA0, 0x04, 0x80, 0x12, 0x00,
  0xC8, 0x03, 0x20, 0x08, 0x80, 0x22, 0x01, 0x88, 0x02, 0x20, 0x10, 0x80,
  0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0xC2, 0x02, 0x08, 0x08, 0x20,
  0x60, 0x80, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x08,
  0x30, 0x20, 0x80, 0x82, 0x02, 0x10, 0x08, 0x60, 0x21, 0x00, 0x84, 0x02,
  0x30, 0x08, 0x40, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00,
  0x98, 0x02, 0x40, 0x09, 0x00, 0x2C, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x60, 0x04, 0x01, 0x00, 0x10, 0x0C,
  0x00, 0x40, 0x20, 0x01, 0x01, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00,
  0x21, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x05, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x0C, 0x00, 0x04,
  0x10, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x20, 0x10,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01, 0x80, 0x08, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x26, 0x00, 0x44, 0x01,
  0x08, 0x06, 0x10, 0x08, 0x20, 0x30, 0x40, 0x40, 0x81, 0x01, 0x86, 0x01,
  0x08, 0x02, 0x30, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0x00,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x14,
  0x00, 0x0D, 0x00, 0x02, 0x60, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x40,
  0x18, 0x10, 0x04, 0x06, 0x02, 0x00, 0x80, 0x80, 0x20, 0x40, 0x0C, 0x30,
  0x01, 0x08, 0x00, 0x66, 0x00, 0x0B, 0x00, 0x03, 0xFF, 0xF0, 0xC2, 0x10,
  0x42, 0x08, 0x20, 0x00, 0x60, 0x03, 0xB9, 0x04, 0x09, 0x08, 0x05, 0x10,
  0x06, 0x30, 0x06, 0x20, 0x06, 0x20, 0x06, 0x40, 0x06, 0x40, 0x04, 0x40,
  0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x30, 0x80, 0x30, 0x80, 0x50, 0xC0, 0xD0, 0x41,
  0x90, 0x3F, 0x20, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x38, 0x0C,
  0xFC, 0x09, 0x02, 0x0A, 0x03, 0x0E, 0x01, 0x1C, 0x01, 0x18, 0x01, 0x18,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x03, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x60,
  0x08, 0xA0, 0x18, 0xA0, 0x10, 0x90, 0x60, 0x9F, 0xC0, 0x00, 0xE0, 0x1F,
  0xC1, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x81, 0x07, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x0C, 0x20,
  0x0E, 0xE4, 0x02, 0x06, 0x80, 0x80, 0x50, 0x20, 0x0E, 0x0C, 0x00, 0x81,
  0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x02, 0x08,
  0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x03, 0x02, 0x00, 0x60, 0x40, 0x1C, 0x08, 0x03, 0x01, 0x00, 0xE0, 0x30,
  0x34, 0x02, 0x0C, 0x80, 0x3F, 0x10, 0x00, 0x00, 0x40, 0x0E, 0xC0, 0x40,
  0x82, 0x02, 0x10, 0x0C, 0xC0, 0x32, 0x00, 0x98, 0x02, 0x40, 0x11, 0x00,
  0xCC, 0x0E, 0x20, 0xE0, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x04, 0x0F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x3B, 0x90, 0x10, 0x34, 0x08, 0x05, 0x04, 0x01, 0x43,
  0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x10, 0x01, 0x84, 0x00, 0x63, 0x00,
  0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x08,
  0x20, 0x06, 0x08, 0x01, 0x82, 0x00, 0xE0, 0x80, 0x30, 0x20, 0x1C, 0x0C,
  0x0D, 0x01, 0x06, 0x40, 0x3F, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x80, 0xC0, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x30, 0x0C, 0xFC, 0x0B, 0x02, 0x0A, 0x02, 0x0C, 0x03, 0x0C,
  0x03, 0x18, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x06, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x0C, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80,
  0x10, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0xF8,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x01, 0x0C,
  0x02, 0x08, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x30, 0x10, 0x60, 0x10,
  0xC0, 0x10, 0x80, 0x11, 0x00, 0x33, 0x00, 0x25, 0x00, 0x29, 0x00, 0x39,
  0x00, 0x30, 0x80, 0x60, 0x80, 0x40, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x20, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x04, 0xEE, 0x3B,
  0x82, 0xC1, 0x30, 0x61, 0x40, 0x70, 0x10, 0xC0, 0x30, 0x08, 0xC0, 0x10,
  0x04, 0x60, 0x08, 0x02, 0x30, 0x0C, 0x01, 0x10, 0x04, 0x01, 0x88, 0x02,
  0x00, 0x8C, 0x01, 0x00, 0x44, 0x00, 0x80, 0x22, 0x00, 0xC0, 0x11, 0x00,
  0x40, 0x18, 0x80, 0x20, 0x08, 0xC0, 0x10, 0x04, 0x40, 0x18, 0x02, 0x20,
  0x08, 0x01, 0x10, 0x04, 0x01, 0x08, 0x02, 0x00, 0x8C, 0x01, 0x00, 0x44,
  0x01, 0x80, 0x22, 0x00, 0x80, 0x31, 0x00, 0x40, 0x10, 0x00, 0x30, 0x08,
  0xFC, 0x0B, 0x02, 0x0A, 0x02, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x02, 0x18,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x08, 0xC0, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x00, 0x60, 0x07,
  0x70, 0x10, 0x30, 0x40, 0x21, 0x00, 0x66, 0x00, 0x48, 0x00, 0xB0, 0x01,
  0x40, 0x02, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x64, 0x00, 0x88, 0x02,
  0x18, 0x0C, 0x18, 0x30, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x23, 0xF0, 0x04,
  0x81, 0x00, 0xA0, 0x30, 0x1C, 0x02, 0x03, 0x00, 0x40, 0xC0, 0x08, 0x18,
  0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00, 0x83, 0x00, 0x10, 0x40,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x10, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x00,
  0x10, 0x20, 0x02, 0x06, 0x00, 0x81, 0x40, 0x30, 0x28, 0x04, 0x04, 0x83,
  0x00, 0x9F, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x03, 0xB9, 0x04, 0x0D, 0x08, 0x05, 0x10,
  0x05, 0x30, 0x06, 0x20, 0x02, 0x20, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x38, 0x80, 0x30, 0x80, 0x70, 0xC0, 0xD0, 0x41,
  0x90, 0x3F, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x30, 0x47, 0xC2, 0xC0, 0x14, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0xC0, 0x46, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x08, 0x0C, 0x3F, 0xC0, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x13, 0xF8, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x78, 0x00, 0x18, 0x03, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0,
  0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x80, 0x30, 0x80,
  0x60, 0x80, 0xA0, 0xC1, 0x20, 0x7E, 0x20, 0xC0, 0x0D, 0x00, 0x24, 0x01,
  0x90, 0x04, 0x40, 0x31, 0x00, 0x84, 0x06, 0x10, 0x10, 0x40, 0xC1, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x41, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x44,
  0x01, 0x20, 0x04, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x80, 0x20, 0x0E, 0x00, 0x80, 0x28, 0x06, 0x01, 0x20, 0x18, 0x04, 0x80,
  0xA0, 0x32, 0x02, 0x80, 0x88, 0x12, 0x02, 0x20, 0x48, 0x10, 0x83, 0x30,
  0x42, 0x08, 0xC3, 0x08, 0x21, 0x08, 0x21, 0x04, 0x20, 0x84, 0x11, 0x02,
  0x20, 0x44, 0x08, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x16, 0x02, 0xC0,
  0x50, 0x0A, 0x01, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x80, 0x60, 0x30, 0x10, 0x04,
  0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x18, 0x80, 0x02, 0x60, 0x00, 0x90,
  0x00, 0x28, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x48, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x04, 0x30, 0x02, 0x04, 0x01, 0x81, 0x00, 0x40,
  0x40, 0x20, 0x18, 0x18, 0x02, 0x0C, 0x00, 0x80, 0x00, 0x80, 0x0C, 0x02,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x20, 0x01, 0x00,
  0x80, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x60, 0x00, 0x11, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x05, 0x80,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x98, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x03,
  0xC0, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x7F, 0x01, 0xC1, 0xC1,
  0x80, 0x7E,
};

const GFXglyph NotoSans_Condensed_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 9, 11, 12, 4, -31 },
  { 45, 19, 31, 19, 1, -31 },
  { 119, 18, 36, 18, 0, -33 },
  { 200, 21, 33, 26, 3, -32 },
  { 287, 18, 32, 19, 0, -32 },
  { 359, 4, 11, 7, 4, -31 },
  { 365, 12, 38, 11, 1, -31 },
  { 422, 12, 38, 11, -3, -31 },
  { 479, 13, 13, 17, 5, -33 },
  { 501, 16, 21, 20, 2, -26 },
  { 543, 6, 10, 7, -2, -4 },
  { 551, 10, 2, 12, 1, -13 },
  { 554, 2, 3, 8, 1, -3 },
  { 555, 18, 31, 13, -2, -31 },
  { 625, 16, 32, 18, 1, -32 },
  { 689, 8, 31, 18, 6, -31 },
  { 720, 18, 32, 18, -1, -32 },
  { 792, 18, 32, 18, 0, -32 },
  { 864, 17, 32, 18, 0, -32 },
  { 932, 18, 31, 18, 0, -31 },
  { 1002, 16, 32, 18, 2, -32 },
  { 1066, 16, 31, 18, 3, -31 },
  { 1128, 18, 32, 18, 0, -32 },
  { 1200, 17, 32, 18, 0, -32 },
  { 1268, 7, 23, 7, 0, -23 },
  { 1289, 9, 29, 8, -2, -23 },
  { 1322, 16, 19, 20, 2, -25 },
  { 1360, 16, 11, 20, 2, -21 },
  { 1382, 16, 19, 20, 2, -25 },
  { 1420, 13, 32, 13, 1, -32 },
  { 1472, 25, 35, 27, 1, -31 },
  { 1582, 17, 32, 17, -3, -32 },
  { 1650, 18, 31, 19, 1, -31 },
  { 1720, 19, 32, 18, 2, -32 },
  { 1796, 19, 31, 22, 1, -31 },
  { 1870, 18, 31, 17, 1, -31 },
  { 1940, 18, 31, 16, 1, -31 },
  { 2010, 21, 32, 23, 2, -32 },
  { 2094, 22, 31, 23, 1, -31 },
  { 2180, 13, 31, 9, -2, -31 },
  { 2231, 16, 39, 8, -7, -31 },
  { 2309, 20, 31, 18, 1, -31 },
  { 2387, 11, 31, 16, 1, -31 },
  { 2430, 28, 31, 29, 1, -31 },
  { 2539, 22, 31, 23, 1, -31 },
  { 2625, 20, 32, 23, 2, -32 },
  { 2705, 18, 31, 18, 1, -31 },
  { 2775, 20, 40, 23, 2, -32 },
  { 2875, 18, 31, 18, 1, -31 },
  { 2945, 19, 32, 17, -1, -32 },
  { 3021, 15, 31, 15, 4, -31 },
  { 3080, 21, 31, 22, 2, -31 },
  { 3162, 17, 31, 18, 4, -31 },
  { 3228, 28, 31, 29, 4, -31 },
  { 3337, 22, 31, 16, -3, -31 },
  { 3423, 15, 31, 15, 4, -31 },
  { 3482, 20, 31, 17, -1, -31 },
  { 3560, 16, 38, 12, -1, -31 },
  { 3636, 7, 31, 14, 4, -31 },
  { 3664, 16, 38, 12, -3, -31 },
  { 3740, 18, 16, 19, 1, -31 },
  { 3776, 12, 1, 13, -3, 4 },
  { 3778, 5, 7, 9, 6, -34 },
  { 3783, 16, 24, 19, 2, -24 },
  { 3831, 16, 33, 19, 1, -33 },
  { 3897, 13, 24, 14, 2, -24 },
  { 3936, 19, 33, 19, 2, -33 },
  { 4015, 14, 24, 17, 2, -24 },
  { 4057, 21, 45, 9, -6, -34 },
  { 4176, 18, 35, 19, 0, -24 },
  { 4255, 16, 33, 18, 1, -33 },
  { 4321, 8, 31, 8, 1, -31 },
  { 4352, 15, 42, 8, -6, -31 },
  { 4431, 16, 33, 15, 1, -33 },
  { 4497, 8, 33, 7, 1, -33 },
  { 4530, 25, 24, 28, 1, -24 },
  { 4605, 16, 24, 18, 1, -24 },
  { 4653, 15, 24, 19, 2, -24 },
  { 4698, 19, 34, 19, -2, -24 },
  { 4779, 16, 34, 19, 2, -24 },
  { 4847, 13, 24, 12, 1, -24 },
  { 4886, 14, 24, 14, 0, -24 },
  { 4928, 10, 29, 10, 1, -29 },
  { 4965, 16, 23, 18, 2, -23 },
  { 5011, 14, 23, 14, 2, -23 },
  { 5052, 22, 23, 23, 3, -23 },
  { 5116, 18, 23, 15, -2, -23 },
  { 5168, 22, 34, 14, -5, -23 },
  { 5262, 15, 23, 13, -1, -23 },
  { 5306, 15, 38, 14, 1, -31 },
  { 5378, 1, 44, 18, 9, -33 },
  { 5384, 15, 38, 14, -3, -31 },
  { 5456, 16, 3, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_THINITALIC44PT7B_H_
