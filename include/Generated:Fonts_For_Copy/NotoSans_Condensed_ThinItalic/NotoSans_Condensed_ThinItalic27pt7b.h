#ifndef _NOTOSANS_CONDENSED_THINITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x20, 0x00, 0x04,
  0x20, 0x4A, 0x63, 0x29, 0x4A, 0x40, 0x02, 0x10, 0x22, 0x02, 0x20, 0x42,
  0x04, 0x43, 0xFF, 0x04, 0x40, 0x88, 0x08, 0x80, 0x88, 0x10, 0x81, 0x10,
  0xFF, 0xC2, 0x10, 0x22, 0x02, 0x20, 0x42, 0x04, 0x40, 0x44, 0x00, 0x00,
  0x80, 0x20, 0x04, 0x07, 0xF1, 0x10, 0x22, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x30, 0x03, 0x00, 0x50, 0x09, 0x01, 0x20, 0x44, 0x08, 0x81, 0x12,
  0x24, 0x3F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x18, 0x01, 0x20, 0x91, 0x08,
  0x88, 0x48, 0x44, 0x42, 0x42, 0x12, 0x11, 0x20, 0x89, 0x34, 0x52, 0x64,
  0xA3, 0x6A, 0x14, 0x50, 0x84, 0x84, 0x44, 0x22, 0x42, 0x22, 0x11, 0x10,
  0x90, 0x89, 0x83, 0x80, 0x03, 0x00, 0x90, 0x21, 0x04, 0x20, 0x84, 0x11,
  0x02, 0x20, 0x48, 0x0A, 0x00, 0x80, 0x70, 0x12, 0x04, 0x22, 0x84, 0xA0,
  0x54, 0x0C, 0x80, 0x90, 0x32, 0x0A, 0x3E, 0x20, 0x5A, 0xA8, 0x02, 0x08,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x88, 0x48, 0x37, 0x18, 0x28,
  0x44, 0x04, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x24, 0xA5, 0x00, 0xFC, 0xC0,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x00, 0x03, 0x03, 0x21, 0x08, 0x41, 0x20, 0x48, 0x14, 0x05,
  0x01, 0x40, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x82,
  0x20, 0x88, 0x41, 0xE0, 0x1B, 0xA5, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84,
  0x21, 0x10, 0x84, 0x20, 0x01, 0x80, 0xE6, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xF8, 0x03, 0x01,
  0x98, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x81, 0x60,
  0x1C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x7E, 0x00, 0x00, 0x20, 0x08, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x81, 0x10,
  0x24, 0x08, 0x82, 0x10, 0x42, 0x10, 0x84, 0x10, 0x82, 0x3F, 0xF0, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x60, 0x33, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x43, 0xF0, 0x00, 0x01, 0xC1, 0x80,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x5E, 0x18, 0x44, 0x0A, 0x02,
  0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x21, 0xF0, 0x7F, 0xC0,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x00, 0x03, 0x81,
  0x88, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x08, 0x80, 0xE0,
  0x28, 0x18, 0x84, 0x08, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x11, 0x04,
  0x1F, 0x00, 0x03, 0x01, 0x98, 0x41, 0x08, 0x12, 0x02, 0x40, 0x48, 0x09,
  0x01, 0x20, 0x44, 0x08, 0x83, 0x09, 0xA0, 0xC4, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x7C, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x48, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x11, 0x08, 0x80,
  0x00, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x00, 0x1C, 0x22, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x40, 0x40, 0x00, 0x00, 0x00, 0x80, 0x80, 0x03, 0xF8, 0x08,
  0x08, 0x20, 0x10, 0x80, 0x12, 0x00, 0x24, 0x3C, 0x50, 0x88, 0xA2, 0x11,
  0x44, 0x43, 0x10, 0x86, 0x21, 0x14, 0x42, 0x28, 0x88, 0x51, 0x11, 0x22,
  0x62, 0x43, 0x38, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x40, 0x18, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x21,
  0x04, 0x20, 0x84, 0x20, 0x87, 0xF1, 0x02, 0x20, 0x48, 0x09, 0x01, 0x40,
  0x28, 0x06, 0x00, 0x80, 0x0F, 0xE0, 0x82, 0x08, 0x10, 0x81, 0x10, 0x11,
  0x01, 0x10, 0x21, 0x04, 0x1F, 0x82, 0x08, 0x20, 0x42, 0x04, 0x20, 0x44,
  0x04, 0x40, 0x44, 0x04, 0x40, 0x84, 0x10, 0xFE, 0x00, 0x01, 0x60, 0x21,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x03, 0xF0, 0x0F, 0xC0, 0x41, 0x02, 0x04, 0x10, 0x21, 0x00, 0x88,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02,
  0x20, 0x11, 0x01, 0x08, 0x08, 0x40, 0x82, 0x18, 0x3F, 0x00, 0x0F, 0xF0,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0x82,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0xF8, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x00, 0x60, 0x18, 0xC3,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x79, 0x00, 0x28, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x40, 0x22,
  0x02, 0x08, 0x10, 0x3F, 0x80, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02,
  0x10, 0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x1F, 0xF0, 0x80, 0x42, 0x01,
  0x08, 0x04, 0x20, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01,
  0x08, 0x04, 0x00, 0x0F, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x41,
  0x80, 0x08, 0x18, 0x41, 0x02, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0x48,
  0x02, 0x80, 0x1C, 0x01, 0x60, 0x0C, 0x80, 0x44, 0x02, 0x20, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x20, 0x20, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0xFF, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x06,
  0x14, 0x02, 0x85, 0x00, 0xA1, 0x40, 0x48, 0x50, 0x14, 0x12, 0x09, 0x08,
  0x82, 0x42, 0x21, 0x10, 0x88, 0x48, 0x22, 0x22, 0x10, 0x90, 0x84, 0x24,
  0x21, 0x0A, 0x08, 0x42, 0x84, 0x10, 0xC1, 0x08, 0x10, 0x40, 0x0C, 0x04,
  0x30, 0x10, 0xC0, 0x43, 0x01, 0x12, 0x04, 0x48, 0x21, 0x20, 0x84, 0x82,
  0x11, 0x08, 0x84, 0x42, 0x11, 0x08, 0x44, 0x20, 0x91, 0x02, 0x44, 0x0A,
  0x10, 0x18, 0x40, 0x61, 0x01, 0x88, 0x04, 0x00, 0x01, 0x80, 0x33, 0x02,
  0x04, 0x20, 0x21, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x12, 0x00,
  0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x42,
  0x04, 0x10, 0x20, 0x7E, 0x00, 0x0F, 0xC1, 0x04, 0x20, 0x84, 0x11, 0x02,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x44, 0x30, 0xF8, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x01, 0x80, 0x33, 0x02,
  0x04, 0x20, 0x21, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x12, 0x00,
  0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x42,
  0x04, 0x10, 0x20, 0x76, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x0F, 0xC1, 0x04, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81,
  0x10, 0x47, 0xF0, 0x88, 0x11, 0x02, 0x20, 0x82, 0x10, 0x42, 0x08, 0x41,
  0x08, 0x12, 0x02, 0x00, 0x03, 0x81, 0x8C, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x7E, 0x00, 0xFF, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x44, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x82,
  0x08, 0x0F, 0x80, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x82, 0x10,
  0x42, 0x10, 0x42, 0x08, 0x41, 0x10, 0x22, 0x04, 0x80, 0x90, 0x14, 0x02,
  0x80, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xA0, 0x60,
  0x50, 0x50, 0x48, 0x28, 0x24, 0x24, 0x12, 0x12, 0x11, 0x09, 0x08, 0x88,
  0x88, 0x44, 0x44, 0x24, 0x24, 0x12, 0x12, 0x0A, 0x09, 0x05, 0x05, 0x02,
  0x82, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x00, 0x04,
  0x0C, 0x10, 0x20, 0x21, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x28, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x01, 0x40, 0x04, 0x80, 0x22, 0x01,
  0x08, 0x04, 0x20, 0x20, 0x81, 0x01, 0x0C, 0x04, 0x00, 0x80, 0xE0, 0x24,
  0x11, 0x04, 0x42, 0x11, 0x04, 0x41, 0x20, 0x28, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x0F, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x3F, 0xE0, 0x0F, 0x84, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x03, 0xC0, 0x92, 0x49, 0x12, 0x49, 0x22, 0x49,
  0x24, 0x80, 0x07, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x0F, 0x80, 0x06, 0x01, 0x80, 0x90, 0x44,
  0x11, 0x08, 0x22, 0x09, 0x01, 0x40, 0x60, 0x10, 0xFF, 0x91, 0x22, 0x06,
  0x06, 0x52, 0x0C, 0x83, 0x40, 0x90, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48,
  0x12, 0x04, 0x83, 0x21, 0x47, 0xA0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x40, 0xB6, 0x18, 0x42, 0x04, 0x40, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x50, 0x89, 0xE0, 0x06,
  0x19, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x7C, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x06,
  0x41, 0x94, 0x20, 0xC2, 0x04, 0x40, 0x44, 0x08, 0x80, 0x88, 0x08, 0x80,
  0x88, 0x10, 0x81, 0x08, 0x10, 0x83, 0x08, 0x50, 0x79, 0x00, 0x06, 0x0C,
  0x88, 0x24, 0x14, 0x12, 0x0A, 0x09, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x01, 0xF0, 0x00, 0x38, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x80, 0x68, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x3C, 0x00, 0x03,
  0x01, 0x94, 0x41, 0x88, 0x12, 0x02, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x11, 0x02, 0x20, 0x44, 0x18, 0x85, 0x0F, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x0F, 0xC0, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x30, 0x53, 0x18, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48, 0x12, 0x09, 0x02,
  0x40, 0x90, 0x24, 0x09, 0x04, 0x81, 0x00, 0x08, 0x40, 0x00, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x20, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0xF0, 0x00,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x41, 0x10, 0x84,
  0x42, 0x20, 0x90, 0x28, 0x0D, 0x02, 0x40, 0x90, 0x44, 0x10, 0x84, 0x21,
  0x08, 0x82, 0x00, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x88, 0x00, 0x03, 0x0C, 0x14, 0x93, 0x18, 0x61, 0x10,
  0x41, 0x10, 0x41, 0x20, 0x41, 0x20, 0x81, 0x20, 0x82, 0x20, 0x82, 0x40,
  0x82, 0x40, 0x82, 0x41, 0x02, 0x41, 0x04, 0x41, 0x04, 0x81, 0x04, 0x03,
  0x05, 0x31, 0x84, 0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x90, 0x24,
  0x09, 0x02, 0x40, 0x90, 0x48, 0x10, 0x06, 0x0C, 0x88, 0x24, 0x14, 0x0A,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x11, 0xF0, 0x00,
  0x80, 0xB6, 0x0C, 0x20, 0x81, 0x08, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10,
  0x22, 0x02, 0x20, 0x22, 0x04, 0x20, 0x43, 0x08, 0x5F, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x06, 0x06, 0x52, 0x0C, 0x83,
  0x40, 0x50, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x83, 0x21,
  0x47, 0x90, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x00, 0x17, 0x18,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x0E, 0x08, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x23, 0xE0, 0x10, 0x88, 0x47, 0x91, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x10, 0x87, 0x00, 0x20, 0x48, 0x12, 0x09, 0x02, 0x40, 0x90,
  0x24, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x86, 0x1E, 0x80, 0x80,
  0xC0, 0xA0, 0x50, 0x44, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28, 0x14, 0x0C,
  0x06, 0x02, 0x00, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x14, 0x28, 0xA2, 0x49,
  0x12, 0x49, 0x12, 0x48, 0xA2, 0x45, 0x14, 0x30, 0xA1, 0x86, 0x08, 0x30,
  0x41, 0x00, 0x10, 0x61, 0x08, 0x22, 0x04, 0x80, 0x90, 0x0C, 0x01, 0x00,
  0x60, 0x0A, 0x02, 0x40, 0x88, 0x11, 0x04, 0x11, 0x02, 0x00, 0x04, 0x08,
  0x20, 0x41, 0x04, 0x08, 0x20, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04,
  0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x07,
  0xF0, 0x03, 0x82, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x08, 0x18, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x10, 0x07, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x0F, 0x00,
  0x70, 0x23, 0x10, 0x38,
};

const GFXglyph NotoSans_Condensed_ThinItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 5, 7, 7, 3, -19 },
  { 18, 12, 19, 12, 0, -19 },
  { 47, 11, 23, 11, 0, -21 },
  { 79, 13, 20, 16, 2, -20 },
  { 112, 11, 20, 12, 0, -20 },
  { 140, 2, 7, 4, 3, -19 },
  { 142, 7, 23, 7, 1, -19 },
  { 163, 8, 23, 7, -2, -19 },
  { 186, 8, 8, 10, 3, -20 },
  { 194, 10, 13, 12, 1, -16 },
  { 211, 3, 6, 4, -1, -3 },
  { 214, 6, 1, 7, 1, -8 },
  { 215, 1, 2, 5, 1, -2 },
  { 216, 11, 19, 8, -1, -19 },
  { 243, 10, 20, 11, 1, -20 },
  { 268, 5, 19, 11, 4, -19 },
  { 280, 12, 20, 11, -1, -20 },
  { 310, 11, 20, 11, 0, -20 },
  { 338, 11, 20, 11, 0, -20 },
  { 366, 11, 19, 11, 0, -19 },
  { 393, 10, 20, 11, 1, -20 },
  { 418, 10, 19, 11, 2, -19 },
  { 442, 11, 20, 11, 0, -20 },
  { 470, 11, 20, 11, 0, -20 },
  { 498, 4, 14, 5, 0, -14 },
  { 505, 5, 17, 5, -1, -14 },
  { 516, 10, 11, 12, 1, -15 },
  { 530, 10, 7, 12, 1, -13 },
  { 539, 10, 11, 12, 1, -15 },
  { 553, 8, 20, 8, 1, -20 },
  { 573, 15, 21, 16, 1, -19 },
  { 613, 11, 19, 11, -2, -19 },
  { 640, 12, 19, 12, 0, -19 },
  { 669, 12, 20, 11, 1, -20 },
  { 699, 13, 19, 13, 0, -19 },
  { 730, 12, 19, 11, 0, -19 },
  { 759, 12, 19, 10, 0, -19 },
  { 788, 13, 20, 14, 1, -20 },
  { 821, 14, 19, 14, 0, -19 },
  { 855, 8, 19, 5, -1, -19 },
  { 874, 9, 24, 5, -4, -19 },
  { 901, 13, 19, 11, 0, -19 },
  { 932, 8, 19, 10, 0, -19 },
  { 951, 18, 19, 18, 0, -19 },
  { 994, 14, 19, 14, 0, -19 },
  { 1028, 13, 20, 14, 1, -20 },
  { 1061, 11, 19, 11, 0, -19 },
  { 1088, 13, 25, 14, 1, -20 },
  { 1129, 11, 19, 11, 0, -19 },
  { 1156, 11, 20, 10, 0, -20 },
  { 1184, 10, 19, 9, 2, -19 },
  { 1208, 13, 19, 14, 1, -19 },
  { 1239, 11, 19, 11, 2, -19 },
  { 1266, 17, 19, 18, 3, -19 },
  { 1307, 14, 19, 10, -2, -19 },
  { 1341, 10, 19, 9, 2, -19 },
  { 1365, 13, 19, 10, -1, -19 },
  { 1396, 9, 23, 8, 0, -19 },
  { 1422, 3, 19, 9, 3, -19 },
  { 1430, 10, 23, 8, -2, -19 },
  { 1459, 10, 10, 12, 1, -19 },
  { 1472, 8, 1, 8, -2, 2 },
  { 1473, 3, 5, 6, 4, -21 },
  { 1475, 10, 15, 12, 1, -15 },
  { 1494, 11, 21, 12, 0, -21 },
  { 1523, 8, 15, 9, 1, -15 },
  { 1538, 12, 21, 12, 1, -21 },
  { 1570, 9, 15, 10, 1, -15 },
  { 1587, 13, 27, 6, -4, -21 },
  { 1631, 11, 21, 12, 0, -15 },
  { 1660, 10, 21, 11, 0, -21 },
  { 1687, 5, 19, 5, 0, -19 },
  { 1699, 9, 25, 5, -4, -19 },
  { 1728, 10, 21, 9, 0, -21 },
  { 1755, 5, 21, 4, 0, -21 },
  { 1769, 16, 15, 17, 0, -15 },
  { 1799, 10, 15, 11, 0, -15 },
  { 1818, 9, 15, 11, 1, -15 },
  { 1835, 12, 21, 12, -1, -15 },
  { 1867, 10, 21, 12, 1, -15 },
  { 1894, 8, 14, 7, 0, -14 },
  { 1908, 9, 15, 9, 0, -15 },
  { 1925, 5, 18, 6, 1, -18 },
  { 1937, 10, 14, 11, 1, -14 },
  { 1955, 9, 14, 8, 1, -14 },
  { 1971, 13, 14, 14, 2, -14 },
  { 1994, 11, 14, 9, -1, -14 },
  { 2014, 13, 21, 9, -3, -14 },
  { 2049, 9, 14, 8, -1, -14 },
  { 2065, 9, 23, 9, 1, -19 },
  { 2091, 1, 28, 11, 5, -21 },
  { 2095, 10, 23, 8, -2, -19 },
  { 2124, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_ThinItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_THINITALIC27PT7B_H_
