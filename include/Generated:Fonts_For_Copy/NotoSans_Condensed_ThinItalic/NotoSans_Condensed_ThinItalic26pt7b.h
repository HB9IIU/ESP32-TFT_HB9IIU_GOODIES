#ifndef _NOTOSANS_CONDENSED_THINITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x80, 0x08, 0x80, 0x4A,
  0x65, 0x29, 0x4A, 0x40, 0x02, 0x20, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40,
  0x44, 0x3F, 0xF0, 0x88, 0x08, 0x80, 0x88, 0x11, 0x01, 0x10, 0xFF, 0xC2,
  0x20, 0x22, 0x02, 0x20, 0x42, 0x04, 0x40, 0x44, 0x00, 0x01, 0x00, 0x20,
  0x1E, 0x04, 0xB1, 0x20, 0x24, 0x08, 0x81, 0x10, 0x12, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x50, 0x11, 0x02, 0x20, 0x44, 0x09, 0x01, 0x63, 0xF0, 0x08,
  0x01, 0x00, 0x20, 0x00, 0x38, 0x14, 0x42, 0x44, 0x48, 0x44, 0x84, 0x88,
  0x48, 0x89, 0x08, 0x90, 0x8A, 0x79, 0x29, 0x95, 0x1E, 0x91, 0x09, 0x11,
  0x21, 0x12, 0x12, 0x21, 0x22, 0x24, 0x22, 0x81, 0xC0, 0x03, 0x00, 0x90,
  0x22, 0x04, 0x40, 0x88, 0x11, 0x02, 0x40, 0x50, 0x0C, 0x01, 0x80, 0x50,
  0x91, 0x24, 0x25, 0x04, 0xA0, 0x64, 0x0C, 0x81, 0x10, 0x51, 0xF2, 0x00,
  0x5A, 0xA8, 0x06, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x00, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x08, 0x10, 0x41, 0x04, 0x18, 0x00, 0x08, 0x08, 0x88, 0x69, 0x1E, 0x28,
  0x48, 0x84, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x24, 0xA5, 0x00, 0xF8, 0xC0, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x00, 0x07, 0x04, 0x44, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x42, 0x1E, 0x00, 0x08,
  0xCB, 0x90, 0x88, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x10, 0x03,
  0xC1, 0x84, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0xFE, 0x00, 0x07, 0x06, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x01, 0x07, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x8F, 0xC0, 0x00, 0x40, 0x30, 0x0C, 0x05, 0x02, 0x40, 0xA0, 0x48, 0x22,
  0x10, 0x84, 0x42, 0x11, 0x04, 0x41, 0x20, 0x47, 0xEC, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x3E, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x43, 0xF0, 0x00, 0x03, 0xC3, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x7E, 0x30, 0x48, 0x12, 0x02, 0x81, 0x20, 0x48, 0x12,
  0x04, 0x82, 0x20, 0x87, 0xC0, 0x7F, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x00, 0x07, 0x01, 0x08, 0x40, 0x88, 0x11, 0x02, 0x20, 0x84,
  0x10, 0x44, 0x0B, 0x01, 0x80, 0x48, 0x30, 0x84, 0x09, 0x01, 0x20, 0x24,
  0x04, 0x80, 0x88, 0x20, 0xF8, 0x00, 0x07, 0x02, 0x21, 0x04, 0x41, 0x20,
  0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x32, 0x14, 0x72, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x48, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x21, 0x08, 0x80,
  0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x00,
  0x3C, 0x84, 0x08, 0x10, 0x20, 0x40, 0x82, 0x08, 0x20, 0x81, 0x04, 0x08,
  0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0xE0, 0x1C, 0x60, 0x80, 0x84, 0x01,
  0x10, 0x04, 0x80, 0x14, 0x3E, 0x51, 0x11, 0x44, 0x46, 0x21, 0x18, 0x84,
  0x62, 0x21, 0x90, 0x8A, 0x42, 0x28, 0x99, 0x23, 0x98, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x40, 0x18, 0x03, 0x00, 0xA0,
  0x14, 0x04, 0x80, 0x90, 0x12, 0x04, 0x40, 0x88, 0x21, 0x07, 0xE1, 0x04,
  0x20, 0x88, 0x09, 0x01, 0x40, 0x28, 0x06, 0x00, 0x80, 0x0F, 0x81, 0x0C,
  0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10, 0x87, 0xE0, 0x82,
  0x10, 0x22, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x23, 0xF8, 0x00,
  0x03, 0xE0, 0x41, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x8C, 0x08, 0x20, 0x81, 0x10,
  0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20,
  0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x84, 0x30, 0xFC, 0x00, 0x0F, 0xE1,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x07, 0xF0,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0xF8,
  0x00, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0xFE, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x20, 0x42, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x79, 0x00, 0x48,
  0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x40, 0x42, 0x02, 0x0F, 0xE0, 0x08,
  0x04, 0x20, 0x20, 0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x04,
  0x04, 0x20, 0x10, 0xFF, 0xC2, 0x01, 0x08, 0x08, 0x20, 0x21, 0x00, 0x84,
  0x02, 0x10, 0x10, 0x40, 0x41, 0x01, 0x08, 0x04, 0x00, 0x0F, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x42, 0x40, 0xC0, 0x08, 0x08, 0x40, 0x82, 0x08,
  0x10, 0x81, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x14, 0x01, 0x60, 0x0D,
  0x00, 0x44, 0x02, 0x20, 0x21, 0x01, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x20, 0x20, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x83, 0xF8, 0x08, 0x00, 0x84, 0x00, 0x43,
  0x00, 0x61, 0x80, 0x51, 0x40, 0x30, 0xA0, 0x28, 0x50, 0x14, 0x28, 0x12,
  0x14, 0x09, 0x12, 0x09, 0x09, 0x04, 0x84, 0x44, 0x42, 0x22, 0x22, 0x12,
  0x11, 0x09, 0x10, 0x85, 0x08, 0x42, 0x84, 0x21, 0x82, 0x20, 0xC1, 0x00,
  0x08, 0x04, 0x20, 0x10, 0xC0, 0x43, 0x02, 0x14, 0x08, 0x48, 0x21, 0x20,
  0x84, 0x84, 0x12, 0x10, 0x84, 0x42, 0x11, 0x08, 0x44, 0x21, 0x21, 0x02,
  0x84, 0x0A, 0x10, 0x28, 0x40, 0xA1, 0x01, 0x08, 0x04, 0x00, 0x03, 0xC0,
  0xC2, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0x84,
  0x10, 0x3E, 0x00, 0x0E, 0x01, 0x18, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44,
  0x08, 0x81, 0x20, 0x44, 0x10, 0xFC, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x03, 0xC0, 0xC2, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x0E, 0x01, 0x18, 0x20, 0x84, 0x11, 0x02,
  0x20, 0x44, 0x08, 0x82, 0x10, 0x44, 0x30, 0xF8, 0x11, 0x02, 0x20, 0x84,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x22, 0x02, 0x00, 0x07, 0xC1, 0x04, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x08, 0x01, 0x00, 0x43, 0xF0, 0x00, 0xFF,
  0x84, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x00, 0x10, 0x11, 0x01,
  0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x88, 0x08, 0x80, 0x84, 0x10,
  0x3E, 0x00, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x08,
  0x82, 0x11, 0x04, 0x41, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x60, 0x18,
  0x04, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x50, 0x30, 0x28, 0x18,
  0x14, 0x14, 0x12, 0x0A, 0x09, 0x09, 0x08, 0x84, 0x84, 0x42, 0x44, 0x22,
  0x22, 0x11, 0x11, 0x09, 0x09, 0x04, 0x84, 0x82, 0x82, 0x81, 0x41, 0x40,
  0xA0, 0xA0, 0x20, 0x60, 0x10, 0x30, 0x00, 0x04, 0x08, 0x20, 0x41, 0x04,
  0x08, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x50, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x82, 0x04,
  0x30, 0x20, 0x80, 0xC0, 0x60, 0x48, 0x24, 0x22, 0x21, 0x10, 0x90, 0x48,
  0x28, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x00,
  0x0F, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x04, 0x00, 0xFF, 0x00, 0x0F, 0x84, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x03, 0xC0, 0x92, 0x49, 0x22, 0x49, 0x24,
  0x49, 0x24, 0x80, 0x07, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x0F, 0x80, 0x04, 0x01, 0x80, 0xA0,
  0x28, 0x11, 0x08, 0x42, 0x09, 0x02, 0x40, 0xA0, 0x10, 0xFF, 0xA5, 0x0E,
  0x44, 0x52, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48,
  0x32, 0x08, 0x86, 0x1E, 0x80, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x78, 0x61, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05,
  0x02, 0x40, 0x90, 0x2A, 0x12, 0xF8, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x83, 0x90, 0x8A, 0x20, 0x88, 0x11, 0x02, 0x40,
  0x48, 0x09, 0x02, 0x20, 0x44, 0x08, 0x83, 0x10, 0x42, 0x18, 0x3D, 0x00,
  0x0E, 0x11, 0x21, 0x41, 0x41, 0x82, 0x9C, 0xE0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x7C, 0x00, 0x70, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x07,
  0x80, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x0E, 0x00, 0x07, 0x21, 0x14, 0x41, 0x10, 0x22, 0x04,
  0x80, 0x90, 0x12, 0x04, 0x40, 0x88, 0x11, 0x06, 0x20, 0xC4, 0x30, 0x7A,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x7C, 0x00, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x78, 0x61, 0x10, 0x44, 0x12, 0x04, 0x81,
  0x20, 0x88, 0x24, 0x09, 0x02, 0x41, 0x10, 0x44, 0x12, 0x04, 0x08, 0x40,
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x20, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0xE0, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x04,
  0x42, 0x11, 0x08, 0x82, 0x40, 0xA0, 0x28, 0x0D, 0x02, 0x41, 0x10, 0x44,
  0x10, 0x88, 0x22, 0x08, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x21, 0x00, 0x17, 0x1C, 0x31, 0x44, 0x41, 0x08, 0x82,
  0x12, 0x08, 0x24, 0x10, 0x48, 0x20, 0x90, 0x41, 0x41, 0x02, 0x82, 0x09,
  0x04, 0x12, 0x08, 0x24, 0x10, 0x50, 0x41, 0x00, 0x17, 0x86, 0x11, 0x04,
  0x41, 0x20, 0x48, 0x22, 0x08, 0x82, 0x40, 0x90, 0x24, 0x11, 0x04, 0x41,
  0x20, 0x40, 0x0F, 0x08, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xA0, 0x50, 0x48, 0x23, 0xE0, 0x0B, 0xC1, 0x84, 0x20, 0x84, 0x11,
  0x02, 0x20, 0x44, 0x08, 0x81, 0x20, 0x24, 0x04, 0x81, 0x10, 0x22, 0x08,
  0xBE, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x00, 0x0E, 0x44,
  0x52, 0x09, 0x02, 0x40, 0x90, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x32,
  0x0C, 0x86, 0x1E, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x17,
  0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x02, 0x04, 0xF8, 0x11, 0x08, 0xF2, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x10, 0xE0, 0x20, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x09, 0x05, 0x02, 0x81,
  0x41, 0x20, 0x90, 0x48, 0x67, 0xD0, 0x81, 0x81, 0x82, 0x82, 0x82, 0x44,
  0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x82, 0x0C, 0x20, 0xA1,
  0x85, 0x14, 0x48, 0xA2, 0x49, 0x12, 0x49, 0x14, 0x48, 0xA2, 0x85, 0x14,
  0x30, 0xC1, 0x86, 0x08, 0x20, 0x41, 0x00, 0x10, 0x44, 0x10, 0x88, 0x24,
  0x09, 0x02, 0x80, 0x40, 0x30, 0x0C, 0x04, 0x82, 0x20, 0x88, 0x42, 0x20,
  0x40, 0x04, 0x08, 0x20, 0x81, 0x04, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11,
  0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x01, 0xC0, 0x00, 0x1F, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x07, 0xF0, 0x01, 0x83, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x18, 0x04, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x30, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x83, 0x80, 0x78, 0x61,
  0xE0,
};

const GFXglyph NotoSans_Condensed_ThinItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 19, 5, 1, -19 },
  { 11, 5, 7, 7, 3, -19 },
  { 16, 12, 19, 11, 0, -19 },
  { 45, 11, 22, 11, 0, -20 },
  { 76, 12, 19, 15, 2, -19 },
  { 105, 11, 19, 11, 0, -19 },
  { 132, 2, 7, 4, 3, -19 },
  { 134, 7, 22, 6, 1, -18 },
  { 154, 7, 22, 6, -2, -18 },
  { 174, 8, 8, 10, 3, -20 },
  { 182, 10, 12, 12, 1, -15 },
  { 197, 3, 6, 4, -1, -3 },
  { 200, 5, 1, 7, 1, -8 },
  { 201, 1, 2, 4, 1, -2 },
  { 202, 11, 19, 8, -1, -19 },
  { 229, 9, 19, 11, 1, -19 },
  { 251, 5, 19, 11, 3, -19 },
  { 263, 11, 19, 11, -1, -19 },
  { 290, 10, 19, 11, 0, -19 },
  { 314, 10, 19, 11, 0, -19 },
  { 338, 11, 19, 11, 0, -19 },
  { 365, 10, 19, 11, 1, -19 },
  { 389, 9, 19, 11, 2, -19 },
  { 411, 11, 19, 11, 0, -19 },
  { 438, 10, 19, 11, 0, -19 },
  { 462, 4, 14, 4, 0, -14 },
  { 469, 5, 17, 4, -1, -14 },
  { 480, 10, 11, 12, 1, -15 },
  { 494, 10, 6, 12, 1, -12 },
  { 502, 10, 11, 12, 1, -15 },
  { 516, 7, 19, 8, 1, -19 },
  { 533, 14, 21, 16, 1, -19 },
  { 570, 11, 19, 10, -2, -19 },
  { 597, 11, 19, 11, 0, -19 },
  { 624, 12, 19, 11, 1, -19 },
  { 653, 12, 19, 13, 0, -19 },
  { 682, 11, 19, 10, 0, -19 },
  { 709, 11, 19, 9, 0, -19 },
  { 736, 13, 19, 14, 1, -19 },
  { 767, 14, 19, 13, 0, -19 },
  { 801, 8, 19, 5, -1, -19 },
  { 820, 9, 24, 5, -4, -19 },
  { 847, 13, 19, 11, 0, -19 },
  { 878, 7, 19, 9, 0, -19 },
  { 895, 17, 19, 17, 0, -19 },
  { 936, 14, 19, 14, 0, -19 },
  { 970, 12, 19, 14, 1, -19 },
  { 999, 11, 19, 11, 0, -19 },
  { 1026, 12, 23, 14, 1, -19 },
  { 1061, 11, 19, 11, 0, -19 },
  { 1088, 11, 19, 10, 0, -19 },
  { 1115, 9, 19, 9, 2, -19 },
  { 1137, 12, 19, 13, 1, -19 },
  { 1166, 10, 19, 10, 2, -19 },
  { 1190, 17, 19, 17, 2, -19 },
  { 1231, 13, 19, 9, -2, -19 },
  { 1262, 9, 19, 9, 2, -19 },
  { 1284, 12, 19, 10, -1, -19 },
  { 1313, 9, 23, 7, 0, -19 },
  { 1339, 3, 19, 8, 3, -19 },
  { 1347, 10, 23, 7, -2, -19 },
  { 1376, 10, 10, 11, 1, -19 },
  { 1389, 8, 1, 8, -2, 2 },
  { 1390, 2, 4, 5, 4, -20 },
  { 1391, 10, 14, 11, 1, -14 },
  { 1409, 10, 20, 11, 0, -20 },
  { 1434, 8, 14, 8, 1, -14 },
  { 1448, 11, 20, 11, 1, -20 },
  { 1476, 8, 14, 10, 1, -14 },
  { 1490, 12, 26, 5, -3, -20 },
  { 1529, 11, 20, 11, 0, -14 },
  { 1557, 10, 20, 11, 0, -20 },
  { 1582, 5, 19, 4, 0, -19 },
  { 1594, 9, 25, 5, -4, -19 },
  { 1623, 10, 20, 9, 0, -20 },
  { 1648, 5, 20, 4, 0, -20 },
  { 1661, 15, 14, 16, 0, -14 },
  { 1688, 10, 14, 11, 0, -14 },
  { 1706, 9, 14, 11, 1, -14 },
  { 1722, 11, 20, 11, -1, -14 },
  { 1750, 10, 20, 11, 1, -14 },
  { 1775, 8, 14, 7, 0, -14 },
  { 1789, 8, 14, 8, 0, -14 },
  { 1803, 5, 17, 6, 1, -17 },
  { 1814, 9, 14, 11, 1, -14 },
  { 1830, 8, 14, 8, 1, -14 },
  { 1844, 13, 14, 13, 2, -14 },
  { 1867, 10, 14, 9, -1, -14 },
  { 1885, 13, 20, 9, -3, -14 },
  { 1918, 9, 14, 8, -1, -14 },
  { 1934, 9, 23, 8, 1, -19 },
  { 1960, 1, 26, 10, 5, -20 },
  { 1964, 9, 23, 8, -2, -19 },
  { 1990, 10, 2, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_ThinItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_THINITALIC26PT7B_H_
