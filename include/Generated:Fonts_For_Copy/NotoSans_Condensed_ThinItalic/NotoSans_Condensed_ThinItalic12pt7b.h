#ifndef _NOTOSANS_CONDENSED_THINITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0xB7, 0x60, 0x19, 0x4A, 0xF5, 0x2B, 0xF4,
  0xA0, 0x13, 0xD4, 0xC2, 0x18, 0xCA, 0xE2, 0x00, 0x46, 0xAB, 0x2E, 0xF6,
  0x95, 0x5A, 0x98, 0x11, 0x54, 0xA2, 0x36, 0x52, 0xF0, 0xF0, 0x12, 0x44,
  0x88, 0x88, 0x88, 0x40, 0x24, 0x92, 0x49, 0x2A, 0x00, 0x2D, 0x62, 0x44,
  0xF4, 0x44, 0xE0, 0xE0, 0x80, 0x08, 0x42, 0x21, 0x11, 0x08, 0x80, 0x32,
  0x52, 0x98, 0xC6, 0x52, 0xE0, 0x75, 0xAA, 0x80, 0x30, 0x42, 0x11, 0x11,
  0x08, 0xF0, 0x32, 0x42, 0x13, 0x08, 0x42, 0xE0, 0x08, 0xCA, 0x65, 0x4B,
  0xC2, 0x20, 0x3A, 0x10, 0x83, 0x08, 0x42, 0xE0, 0x19, 0x10, 0xC5, 0x46,
  0x32, 0xF0, 0xF1, 0x12, 0x24, 0x48, 0x80, 0x32, 0x52, 0x93, 0x6A, 0x52,
  0xF0, 0x32, 0x53, 0x14, 0x9C, 0x42, 0xE0, 0x40, 0x20, 0x20, 0x00, 0x94,
  0x16, 0x84, 0x30, 0xF0, 0xF0, 0x86, 0x12, 0xC0, 0x61, 0x11, 0x24, 0x40,
  0x80, 0x1C, 0x45, 0x0A, 0xFA, 0xB5, 0x6A, 0xDA, 0x80, 0xF0, 0x08, 0x46,
  0x52, 0x9D, 0x29, 0x88, 0x32, 0x52, 0x97, 0x26, 0x31, 0xF0, 0x3A, 0x21,
  0x08, 0x42, 0x10, 0xE0, 0x39, 0x14, 0x51, 0x45, 0x18, 0xA2, 0xF0, 0x3A,
  0x10, 0x87, 0x22, 0x10, 0xE0, 0x3A, 0x10, 0x87, 0x22, 0x10, 0x80, 0x3A,
  0x21, 0x09, 0x46, 0x32, 0xF0, 0x25, 0x14, 0x51, 0x79, 0x18, 0xA2, 0x88,
  0x65, 0x24, 0xA4, 0x80, 0x11, 0x11, 0x11, 0x22, 0x22, 0xC0, 0x25, 0x25,
  0x18, 0x61, 0x89, 0x24, 0x90, 0x29, 0x24, 0xA4, 0xE0, 0x21, 0x21, 0x22,
  0x62, 0x66, 0x6A, 0xAA, 0xB2, 0x92, 0x24, 0x96, 0x59, 0x55, 0x59, 0xA2,
  0x88, 0x32, 0x63, 0x18, 0xC6, 0x32, 0xE0, 0x32, 0x52, 0x95, 0xB2, 0x10,
  0x80, 0x32, 0x63, 0x18, 0xC6, 0x32, 0xE1, 0x08, 0x32, 0x52, 0x95, 0x32,
  0x52, 0x90, 0x3A, 0x10, 0x82, 0x08, 0x42, 0xE0, 0xF4, 0x44, 0x44, 0x88,
  0x80, 0x4C, 0x63, 0x18, 0xCA, 0x52, 0xE0, 0x8C, 0x65, 0x2A, 0x53, 0x10,
  0x80, 0x91, 0x91, 0x92, 0xAA, 0xAC, 0xD4, 0xD4, 0x98, 0x90, 0x24, 0x92,
  0x84, 0x10, 0x43, 0x14, 0x88, 0x99, 0xAA, 0xC4, 0x88, 0x80, 0x38, 0x44,
  0x22, 0x21, 0x10, 0xE0, 0x34, 0x44, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x55,
  0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x11, 0x94, 0x98, 0x80,
  0xF0, 0xC0, 0x7A, 0x63, 0x29, 0x78, 0x22, 0x1C, 0x94, 0xA6, 0x32, 0xF0,
  0x74, 0x88, 0x8E, 0x04, 0x13, 0x92, 0x4A, 0x29, 0x24, 0xF0, 0x75, 0xE8,
  0x8F, 0x0C, 0x41, 0x84, 0x10, 0x42, 0x08, 0x20, 0x82, 0x30, 0x7A, 0x63,
  0x29, 0x78, 0x42, 0xE0, 0x22, 0x1C, 0x94, 0xA6, 0x52, 0x90, 0x41, 0x5A,
  0x80, 0x10, 0x01, 0x11, 0x22, 0x22, 0x2C, 0x22, 0x12, 0xA6, 0x22, 0x94,
  0x90, 0x55, 0x5A, 0x80, 0x7E, 0x95, 0x4C, 0x99, 0x32, 0x40, 0x7A, 0x53,
  0x29, 0x48, 0x7A, 0x63, 0x19, 0x78, 0x7A, 0x53, 0x19, 0x7A, 0x10, 0x80,
  0x7A, 0x63, 0x19, 0x78, 0x42, 0x20, 0x74, 0x48, 0x88, 0x78, 0x42, 0x2E,
  0x4D, 0x29, 0x26, 0x4A, 0x53, 0x29, 0x78, 0xB7, 0x69, 0x00, 0xA7, 0xAE,
  0xAC, 0x92, 0x40, 0x56, 0x24, 0xAA, 0x2C, 0xA2, 0x8C, 0x20, 0x82, 0x10,
  0x80, 0x72, 0x44, 0x8E, 0x12, 0x22, 0x2C, 0x44, 0x48, 0x40, 0xFF, 0xF0,
  0x21, 0x11, 0x11, 0x22, 0x22, 0xC0, 0xF0,
};

const GFXglyph NotoSans_Condensed_ThinItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 2, 0, -9 },
  { 5, 3, 4, 3, 1, -9 },
  { 7, 5, 9, 5, 0, -9 },
  { 13, 5, 10, 5, 0, -9 },
  { 20, 6, 9, 7, 1, -9 },
  { 27, 5, 9, 5, 0, -9 },
  { 33, 1, 4, 2, 1, -9 },
  { 34, 4, 11, 3, 0, -9 },
  { 40, 3, 11, 3, -1, -9 },
  { 45, 4, 4, 5, 1, -9 },
  { 47, 4, 6, 5, 1, -7 },
  { 50, 1, 3, 2, 0, -1 },
  { 51, 3, 1, 3, 0, -4 },
  { 52, 1, 1, 2, 0, -1 },
  { 53, 5, 9, 4, -1, -9 },
  { 59, 5, 9, 5, 0, -9 },
  { 65, 2, 9, 5, 2, -9 },
  { 68, 5, 9, 5, 0, -9 },
  { 74, 5, 9, 5, 0, -9 },
  { 80, 5, 9, 5, 0, -9 },
  { 86, 5, 9, 5, 0, -9 },
  { 92, 5, 9, 5, 0, -9 },
  { 98, 4, 9, 5, 1, -9 },
  { 103, 5, 9, 5, 0, -9 },
  { 109, 5, 9, 5, 0, -9 },
  { 115, 2, 6, 2, 0, -6 },
  { 117, 3, 8, 2, -1, -6 },
  { 120, 4, 5, 5, 1, -7 },
  { 123, 4, 3, 5, 1, -6 },
  { 125, 4, 5, 5, 1, -7 },
  { 128, 4, 9, 3, 0, -9 },
  { 133, 7, 10, 7, 0, -9 },
  { 142, 5, 9, 5, -1, -9 },
  { 148, 5, 9, 5, 0, -9 },
  { 154, 5, 9, 5, 1, -9 },
  { 160, 6, 9, 6, 0, -9 },
  { 167, 5, 9, 5, 0, -9 },
  { 173, 5, 9, 4, 0, -9 },
  { 179, 5, 9, 6, 1, -9 },
  { 185, 6, 9, 6, 0, -9 },
  { 192, 3, 9, 2, 0, -9 },
  { 196, 4, 11, 2, -2, -9 },
  { 202, 6, 9, 5, 0, -9 },
  { 209, 3, 9, 4, 0, -9 },
  { 213, 8, 9, 8, 0, -9 },
  { 222, 6, 9, 6, 0, -9 },
  { 229, 5, 9, 6, 1, -9 },
  { 235, 5, 9, 5, 0, -9 },
  { 241, 5, 11, 6, 1, -9 },
  { 248, 5, 9, 5, 0, -9 },
  { 254, 5, 9, 5, 0, -9 },
  { 260, 4, 9, 4, 1, -9 },
  { 265, 5, 9, 6, 1, -9 },
  { 271, 5, 9, 5, 1, -9 },
  { 277, 8, 9, 8, 1, -9 },
  { 286, 6, 9, 4, -1, -9 },
  { 293, 4, 9, 4, 1, -9 },
  { 298, 5, 9, 5, 0, -9 },
  { 304, 4, 11, 3, 0, -9 },
  { 310, 2, 9, 4, 1, -9 },
  { 313, 5, 11, 3, -1, -9 },
  { 320, 5, 5, 5, 0, -9 },
  { 324, 4, 1, 4, -1, 1 },
  { 325, 1, 2, 3, 2, -9 },
  { 326, 5, 6, 5, 0, -6 },
  { 330, 5, 9, 5, 0, -9 },
  { 336, 4, 6, 4, 0, -6 },
  { 339, 6, 9, 5, 0, -9 },
  { 346, 4, 6, 5, 0, -6 },
  { 349, 6, 12, 3, -2, -9 },
  { 358, 5, 9, 5, 0, -6 },
  { 364, 5, 9, 5, 0, -9 },
  { 370, 2, 9, 2, 0, -9 },
  { 373, 4, 12, 2, -2, -9 },
  { 379, 5, 9, 4, 0, -9 },
  { 385, 2, 9, 2, 0, -9 },
  { 388, 7, 6, 8, 0, -6 },
  { 394, 5, 6, 5, 0, -6 },
  { 398, 5, 6, 5, 0, -6 },
  { 402, 5, 9, 5, 0, -6 },
  { 408, 5, 9, 5, 0, -6 },
  { 414, 4, 6, 3, 0, -6 },
  { 417, 4, 6, 4, 0, -6 },
  { 420, 3, 8, 3, 0, -8 },
  { 423, 5, 6, 5, 0, -6 },
  { 427, 3, 6, 4, 1, -6 },
  { 430, 6, 6, 6, 1, -6 },
  { 435, 4, 6, 4, 0, -6 },
  { 438, 6, 9, 4, -1, -6 },
  { 445, 4, 6, 4, 0, -6 },
  { 448, 4, 11, 4, 0, -9 },
  { 454, 1, 12, 5, 2, -9 },
  { 456, 4, 11, 4, -1, -9 },
  { 462, 4, 1, 5, 1, -5 },
};

const GFXfont NotoSans_Condensed_ThinItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_THINITALIC12PT7B_H_
