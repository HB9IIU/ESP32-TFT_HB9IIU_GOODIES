#ifndef _NOTOSANS_CONDENSED_THINITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x00, 0x00, 0x02, 0x08, 0x00, 0x22, 0x89, 0x12, 0x24, 0x48,
  0xA2, 0x44, 0x00, 0x84, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x42, 0x00, 0x84, 0x0F, 0xFF, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x42,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x7F, 0xF8, 0x10, 0x80, 0x21, 0x00,
  0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x40, 0x10, 0x80, 0x00, 0x00, 0x40,
  0x02, 0x00, 0x70, 0x0D, 0x30, 0x88, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11,
  0x00, 0x88, 0x02, 0x40, 0x0A, 0x00, 0x20, 0x01, 0xC0, 0x0B, 0x00, 0x48,
  0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x80, 0x44, 0x64, 0xC0, 0x78, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x1E, 0x02, 0x22, 0x04, 0x22, 0x08, 0x42,
  0x08, 0x42, 0x10, 0x42, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x84,
  0x8E, 0x84, 0x92, 0x85, 0x21, 0x89, 0x41, 0x72, 0x41, 0x02, 0x42, 0x04,
  0x82, 0x08, 0x82, 0x08, 0x82, 0x10, 0x82, 0x10, 0x84, 0x20, 0x84, 0x20,
  0x88, 0x40, 0x70, 0x01, 0xC0, 0x11, 0x01, 0x08, 0x08, 0x40, 0x42, 0x04,
  0x10, 0x20, 0x80, 0x88, 0x04, 0x80, 0x28, 0x00, 0x80, 0x1C, 0x01, 0x20,
  0x10, 0x84, 0x84, 0x28, 0x12, 0x80, 0x94, 0x05, 0x20, 0x19, 0x00, 0x88,
  0x0A, 0x20, 0x91, 0xF8, 0x80, 0x29, 0x24, 0xA4, 0x01, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x00, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x00,
  0x04, 0x02, 0x22, 0x0D, 0x01, 0xF8, 0xC0, 0x90, 0x88, 0x82, 0x01, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x12,
  0x24, 0x48, 0x80, 0xFE, 0xC0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x42, 0x08, 0x21,
  0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88,
  0x10, 0x81, 0x04, 0x20, 0x3C, 0x00, 0x04, 0x33, 0x51, 0x88, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x00,
  0x03, 0xF0, 0x10, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x40, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x60, 0x1E,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x40, 0xC3, 0xF8, 0x00, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xA0, 0x09, 0x00, 0x48, 0x04, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02,
  0x10, 0x20, 0x81, 0x04, 0x10, 0x21, 0x01, 0x08, 0x10, 0xFF, 0xF0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x07, 0xF8, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xE0, 0x0C, 0x60, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x40, 0x83, 0xF8, 0x00, 0x01,
  0xF0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0xF0, 0x50, 0xC6, 0x04, 0x40, 0x4C, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x7F, 0xF0,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x20,
  0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x21, 0x02, 0x08, 0x20,
  0x22, 0x00, 0xE0, 0x0E, 0x01, 0x88, 0x10, 0x21, 0x01, 0x08, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x44, 0x04, 0x20, 0x40, 0xFC, 0x00, 0x03,
  0xE0, 0x20, 0x82, 0x04, 0x20, 0x21, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x61, 0x05, 0x07, 0xD0, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x03, 0xF0,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC0,
  0x04, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08,
  0x21, 0x04, 0x20, 0x80, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x06,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x10, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x7C,
  0x00, 0x60, 0xC0, 0x20, 0x10, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x11,
  0x00, 0x04, 0x83, 0xE1, 0x21, 0x08, 0x50, 0x42, 0x14, 0x20, 0x85, 0x08,
  0x42, 0x44, 0x10, 0xA1, 0x04, 0x28, 0x42, 0x0A, 0x10, 0x84, 0x84, 0x21,
  0x21, 0x18, 0x88, 0x69, 0xC2, 0x04, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x20, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10,
  0x10, 0x80, 0x84, 0x08, 0x20, 0x41, 0x07, 0xF8, 0x20, 0x42, 0x02, 0x10,
  0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00, 0x20, 0x0F,
  0xE0, 0x40, 0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02,
  0x10, 0x11, 0x01, 0x0F, 0x70, 0x47, 0x02, 0x04, 0x20, 0x11, 0x00, 0x88,
  0x04, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0xC3, 0xF8,
  0x00, 0x01, 0xF8, 0x30, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x20, 0xC0, 0x80, 0x82, 0x02, 0x10, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x88, 0x02,
  0x20, 0x10, 0x80, 0x82, 0x0C, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x0F, 0xF0, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFC, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x01, 0xFC, 0x0C, 0x04, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0F,
  0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x00, 0x84, 0x02, 0x0C, 0x04, 0x07, 0xF8, 0x00, 0x08, 0x01, 0x08, 0x02,
  0x08, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04,
  0x10, 0x04, 0x20, 0x04, 0x3F, 0xF4, 0x20, 0x08, 0x20, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x20, 0x80, 0x20, 0x80, 0x20, 0x0F, 0x81, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x03, 0xE0, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x4C, 0x06, 0x00,
  0x08, 0x04, 0x20, 0x20, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x01, 0x08,
  0x04, 0x40, 0x12, 0x00, 0x90, 0x02, 0xC0, 0x0B, 0x00, 0x32, 0x00, 0x88,
  0x04, 0x20, 0x10, 0x40, 0x41, 0x01, 0x04, 0x08, 0x08, 0x20, 0x20, 0x80,
  0x82, 0x02, 0x08, 0x04, 0x00, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x0C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x05, 0x14, 0x00, 0x61, 0x40, 0x0A, 0x14, 0x01, 0x21, 0x40, 0x12,
  0x14, 0x02, 0x42, 0x20, 0x24, 0x22, 0x04, 0x42, 0x20, 0x44, 0x22, 0x08,
  0x44, 0x20, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x20, 0x84, 0x22,
  0x08, 0x82, 0x41, 0x08, 0x24, 0x10, 0x81, 0x81, 0x08, 0x18, 0x10, 0x81,
  0x02, 0x00, 0x08, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x02, 0x12, 0x02,
  0x12, 0x02, 0x12, 0x02, 0x12, 0x02, 0x11, 0x04, 0x21, 0x04, 0x21, 0x04,
  0x21, 0x04, 0x20, 0x88, 0x40, 0x88, 0x40, 0x88, 0x40, 0x88, 0x40, 0x48,
  0x40, 0x50, 0x80, 0x50, 0x80, 0x50, 0x80, 0x30, 0x80, 0x30, 0x80, 0x20,
  0x03, 0xF0, 0x10, 0x60, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00,
  0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80,
  0x41, 0x02, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x41, 0x02, 0x04, 0x10, 0x21,
  0x00, 0x88, 0x04, 0x40, 0x22, 0x02, 0x10, 0x11, 0x00, 0x88, 0x08, 0x40,
  0x83, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x10, 0x60, 0x80,
  0x84, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x41, 0x02, 0x03, 0xF0, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x0F, 0xC0, 0x41, 0x02,
  0x04, 0x10, 0x21, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02, 0x10, 0x11, 0x01,
  0x08, 0x08, 0x41, 0x83, 0xE0, 0x21, 0x01, 0x04, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x03, 0x00, 0x03, 0xF0,
  0x60, 0x42, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x40, 0xC3, 0xF8, 0x00,
  0xFF, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x10, 0x02, 0x20, 0x08,
  0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04,
  0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x04, 0x02, 0x08, 0x08, 0x10,
  0x30, 0x1F, 0xC0, 0x00, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48,
  0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x82, 0x08,
  0x40, 0x84, 0x08, 0x80, 0x88, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x00, 0x80, 0x20, 0x1C, 0x03, 0x00, 0xA0, 0x18, 0x05, 0x01,
  0x40, 0x48, 0x0A, 0x02, 0x40, 0x50, 0x22, 0x04, 0x81, 0x10, 0x24, 0x08,
  0x82, 0x20, 0x84, 0x11, 0x04, 0x20, 0x88, 0x41, 0x08, 0x42, 0x08, 0x42,
  0x20, 0x44, 0x11, 0x02, 0x20, 0x88, 0x12, 0x04, 0x80, 0x90, 0x24, 0x04,
  0x81, 0x40, 0x28, 0x0A, 0x01, 0x40, 0x50, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x02, 0x00, 0x80, 0x00, 0x02, 0x01, 0x02, 0x02, 0x02, 0x04, 0x02, 0x04,
  0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x04, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20,
  0x80, 0x20, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x11, 0x02, 0x10, 0x82,
  0x10, 0x44, 0x08, 0x81, 0x20, 0x28, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x07, 0xFE,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7C, 0x00, 0x84, 0x10, 0x84,
  0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x20,
  0x03, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x7E, 0x00, 0x01, 0x00, 0x30, 0x02, 0x80, 0x48, 0x08, 0x40, 0x84,
  0x10, 0x41, 0x02, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0xFF, 0xC0, 0x91,
  0x22, 0x07, 0x90, 0x85, 0x10, 0x32, 0x02, 0x20, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x84,
  0x28, 0x3C, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x3C, 0x0E, 0x10, 0xA0, 0x86, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x46,
  0x02, 0x30, 0x21, 0x82, 0x13, 0xE0, 0x07, 0xC2, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x81, 0xF4, 0x08, 0x50, 0x40, 0xC2, 0x03, 0x08,
  0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x30, 0x80, 0xC2, 0x06, 0x04, 0x28, 0x0F, 0x20, 0x07, 0x82,
  0x11, 0x04, 0x81, 0x20, 0x50, 0x14, 0x09, 0x0C, 0xFC, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x01, 0xF8, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0xE8, 0x21, 0x42,
  0x06, 0x20, 0x31, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40, 0x12, 0x01,
  0x10, 0x08, 0x80, 0x44, 0x06, 0x20, 0x31, 0x03, 0x04, 0x28, 0x3E, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x10, 0xC0, 0x78,
  0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xBE, 0x0C, 0x11, 0x81, 0x18, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x22,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x24, 0x04, 0x40, 0x44, 0x04, 0x40, 0x48,
  0x08, 0x04, 0x10, 0x00, 0x00, 0x00, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x0C, 0x00, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x81, 0x08, 0x21,
  0x04, 0x10, 0x81, 0x10, 0x12, 0x01, 0x20, 0x24, 0x02, 0xA0, 0x32, 0x02,
  0x20, 0x22, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x88, 0x08, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x20, 0x0B, 0xE3, 0xC1, 0x85, 0x84, 0x60, 0x60, 0x8C,
  0x08, 0x11, 0x01, 0x02, 0x20, 0x40, 0x44, 0x08, 0x09, 0x01, 0x02, 0x20,
  0x20, 0x44, 0x08, 0x08, 0x81, 0x01, 0x10, 0x20, 0x44, 0x04, 0x08, 0x80,
  0x81, 0x10, 0x20, 0x22, 0x04, 0x04, 0x80, 0x81, 0x00, 0x0B, 0xE0, 0xC1,
  0x18, 0x11, 0x81, 0x10, 0x11, 0x01, 0x10, 0x12, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x22, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x80, 0x80, 0x07,
  0xC1, 0x08, 0x40, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x28, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0x04,
  0xF0, 0x14, 0x20, 0xA0, 0x83, 0x01, 0x0C, 0x04, 0x20, 0x10, 0x80, 0x44,
  0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x30, 0x10, 0xC0, 0x43,
  0x02, 0x0C, 0x10, 0x4F, 0x81, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xD0, 0x85, 0x10, 0x32, 0x03, 0x20,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80,
  0xC8, 0x0C, 0x81, 0x84, 0x28, 0x7C, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x0B, 0xC3, 0x01, 0x40, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x00, 0x0F, 0xC4, 0x12, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x12, 0x08, 0xFC,
  0x00, 0x08, 0x20, 0x40, 0x87, 0xE4, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x0F, 0x00, 0x10, 0x11, 0x01, 0x20,
  0x22, 0x02, 0x20, 0x22, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40,
  0x48, 0x08, 0x80, 0x88, 0x18, 0x81, 0x88, 0x28, 0x7D, 0x00, 0x80, 0xE0,
  0x28, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x22, 0x08, 0x82,
  0x40, 0x90, 0x28, 0x0A, 0x01, 0x00, 0x40, 0x00, 0x81, 0x01, 0x81, 0x02,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88,
  0x88, 0x90, 0x90, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x08, 0x18, 0x40, 0x82, 0x08, 0x10,
  0x80, 0x44, 0x02, 0x40, 0x14, 0x00, 0x40, 0x02, 0x00, 0x30, 0x02, 0x40,
  0x12, 0x01, 0x10, 0x10, 0x81, 0x02, 0x08, 0x10, 0x80, 0x80, 0x02, 0x01,
  0x02, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x01, 0x04, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x0F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0xFF, 0x00,
  0x00, 0x60, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x38, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x01, 0x80, 0x38, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x70, 0x00, 0x38, 0x04,
  0x61, 0x81, 0xE0,
};

const GFXglyph NotoSans_Condensed_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 7, 8, 9, 3, -23 },
  { 26, 15, 23, 14, 0, -23 },
  { 70, 13, 26, 13, 0, -24 },
  { 113, 16, 23, 19, 2, -23 },
  { 159, 13, 23, 14, 0, -23 },
  { 197, 3, 8, 5, 3, -23 },
  { 200, 9, 28, 8, 1, -23 },
  { 232, 9, 28, 8, -2, -23 },
  { 264, 9, 10, 12, 4, -24 },
  { 276, 12, 15, 14, 1, -19 },
  { 299, 4, 7, 5, -1, -3 },
  { 303, 7, 1, 9, 1, -9 },
  { 304, 1, 2, 5, 1, -2 },
  { 305, 13, 23, 9, -1, -23 },
  { 343, 12, 23, 13, 1, -23 },
  { 378, 6, 23, 13, 4, -23 },
  { 396, 14, 23, 13, -1, -23 },
  { 437, 13, 23, 13, 0, -23 },
  { 475, 13, 23, 13, 0, -23 },
  { 513, 13, 23, 13, 0, -23 },
  { 551, 12, 23, 13, 1, -23 },
  { 586, 12, 23, 13, 2, -23 },
  { 621, 13, 23, 13, 0, -23 },
  { 659, 13, 23, 13, 0, -23 },
  { 697, 5, 17, 5, 0, -17 },
  { 708, 6, 21, 6, -1, -17 },
  { 724, 12, 13, 14, 1, -18 },
  { 744, 12, 8, 14, 1, -15 },
  { 756, 12, 13, 14, 1, -18 },
  { 776, 9, 23, 9, 1, -23 },
  { 802, 18, 26, 19, 1, -23 },
  { 861, 13, 23, 13, -2, -23 },
  { 899, 13, 23, 14, 1, -23 },
  { 937, 13, 23, 13, 2, -23 },
  { 975, 14, 23, 16, 1, -23 },
  { 1016, 13, 23, 13, 1, -23 },
  { 1054, 13, 23, 12, 1, -23 },
  { 1092, 15, 23, 17, 2, -23 },
  { 1136, 16, 23, 16, 1, -23 },
  { 1182, 9, 23, 6, -1, -23 },
  { 1208, 11, 29, 6, -5, -23 },
  { 1248, 14, 23, 13, 1, -23 },
  { 1289, 8, 23, 11, 1, -23 },
  { 1312, 20, 23, 21, 1, -23 },
  { 1370, 16, 23, 17, 1, -23 },
  { 1416, 14, 23, 17, 2, -23 },
  { 1457, 13, 23, 13, 1, -23 },
  { 1495, 14, 28, 17, 2, -23 },
  { 1544, 13, 23, 13, 1, -23 },
  { 1582, 13, 23, 12, 0, -23 },
  { 1620, 11, 23, 11, 3, -23 },
  { 1652, 15, 23, 16, 2, -23 },
  { 1696, 12, 23, 13, 3, -23 },
  { 1731, 21, 23, 21, 3, -23 },
  { 1792, 16, 23, 11, -2, -23 },
  { 1838, 11, 23, 11, 3, -23 },
  { 1870, 15, 23, 12, -1, -23 },
  { 1914, 11, 28, 9, 0, -23 },
  { 1953, 5, 23, 10, 3, -23 },
  { 1968, 11, 28, 9, -2, -23 },
  { 2007, 12, 12, 14, 1, -23 },
  { 2025, 10, 1, 9, -3, 3 },
  { 2027, 3, 5, 7, 5, -24 },
  { 2029, 12, 17, 14, 1, -17 },
  { 2055, 13, 24, 14, 0, -24 },
  { 2094, 10, 17, 10, 1, -17 },
  { 2116, 14, 24, 14, 1, -24 },
  { 2158, 10, 17, 12, 1, -17 },
  { 2180, 15, 32, 7, -4, -24 },
  { 2240, 13, 25, 14, 0, -17 },
  { 2281, 12, 24, 13, 0, -24 },
  { 2317, 6, 23, 5, 0, -23 },
  { 2335, 10, 31, 6, -4, -23 },
  { 2374, 12, 24, 11, 0, -24 },
  { 2410, 6, 24, 5, 0, -24 },
  { 2428, 19, 17, 20, 0, -17 },
  { 2469, 12, 17, 13, 0, -17 },
  { 2495, 11, 17, 13, 1, -17 },
  { 2519, 14, 24, 14, -1, -17 },
  { 2561, 12, 24, 14, 1, -17 },
  { 2597, 10, 17, 9, 0, -17 },
  { 2619, 10, 17, 10, 0, -17 },
  { 2641, 7, 21, 7, 1, -21 },
  { 2660, 12, 17, 13, 1, -17 },
  { 2686, 10, 17, 10, 2, -17 },
  { 2708, 16, 17, 17, 2, -17 },
  { 2742, 13, 17, 11, -1, -17 },
  { 2770, 16, 25, 11, -4, -17 },
  { 2820, 11, 17, 9, -1, -17 },
  { 2844, 11, 28, 10, 1, -23 },
  { 2883, 1, 32, 13, 6, -24 },
  { 2887, 11, 28, 10, -2, -23 },
  { 2926, 12, 3, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_THINITALIC32PT7B_H_
