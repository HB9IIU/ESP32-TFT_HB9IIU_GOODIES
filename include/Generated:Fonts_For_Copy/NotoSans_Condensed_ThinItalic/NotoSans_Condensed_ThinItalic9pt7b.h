#ifndef _NOTOSANS_CONDENSED_THINITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xE0, 0x37, 0x66, 0xAC, 0x27, 0xA4, 0x66, 0xC4, 0x8D,
  0xEF, 0xBD, 0xF0, 0x25, 0x64, 0xBA, 0xE0, 0xC0, 0x6A, 0x49, 0x20, 0x24,
  0x92, 0xB0, 0x5F, 0x00, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00,
  0x25, 0x99, 0x9A, 0xE0, 0xD6, 0xA0, 0x61, 0x12, 0x24, 0xE0, 0x61, 0x16,
  0x22, 0xE0, 0x12, 0x56, 0xA6, 0x20, 0x74, 0xA2, 0x2E, 0x34, 0x4A, 0x9A,
  0xE0, 0xE9, 0x49, 0x00, 0x25, 0x56, 0xAA, 0xE0, 0x25, 0x99, 0x72, 0xC0,
  0x88, 0x8C, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x44, 0xA8, 0x20, 0x7A, 0xEF,
  0xBF, 0xC1, 0x80, 0x13, 0x35, 0x59, 0x75, 0x69, 0x9E, 0x34, 0x48, 0x88,
  0xE0, 0x75, 0x59, 0x9E, 0x74, 0x68, 0x8E, 0x74, 0x68, 0x88, 0x3A, 0x11,
  0x09, 0x49, 0xC0, 0x4A, 0x5D, 0x29, 0x48, 0x56, 0xA0, 0x24, 0xA4, 0x94,
  0x56, 0x4A, 0xAA, 0x49, 0x49, 0xC0, 0x45, 0x14, 0xAE, 0xAA, 0xA0, 0x4A,
  0x5B, 0x6B, 0x48, 0x32, 0x53, 0x18, 0xCB, 0xC0, 0x75, 0x5A, 0x88, 0x32,
  0x53, 0x18, 0xCB, 0x44, 0x20, 0x75, 0x5A, 0xAA, 0x34, 0x84, 0x22, 0xE0,
  0xF2, 0x49, 0x00, 0x4A, 0x65, 0x29, 0x70, 0xB7, 0x49, 0x00, 0xA7, 0xAE,
  0xAC, 0x92, 0x80, 0x29, 0x88, 0x45, 0x48, 0xBA, 0x49, 0x00, 0x72, 0x44,
  0x8E, 0x69, 0x49, 0x20, 0xFC, 0x31, 0x22, 0x22, 0xE0, 0x65, 0x90, 0xE0,
  0xC0, 0x79, 0x9A, 0xE0, 0x44, 0x75, 0x99, 0xE0, 0x72, 0x4C, 0x11, 0x79,
  0x9A, 0xE0, 0x77, 0x4C, 0x32, 0x22, 0x44, 0x44, 0x80, 0x79, 0x9A, 0xE2,
  0xE0, 0x49, 0xBB, 0x68, 0x5A, 0xA0, 0x24, 0xA4, 0x94, 0x49, 0xDD, 0xA8,
  0x56, 0xA8, 0x7A, 0xEB, 0x5A, 0x80, 0x6E, 0xDA, 0x76, 0xDE, 0x75, 0x99,
  0xE8, 0x80, 0x79, 0x9A, 0xE2, 0x20, 0x6A, 0x48, 0x71, 0x1C, 0x5A, 0xA0,
  0x59, 0xAA, 0xE0, 0xB6, 0xA8, 0xDD, 0xEA, 0xC0, 0xA9, 0x6A, 0x55, 0x56,
  0x44, 0xC0, 0x69, 0x4C, 0x69, 0x45, 0x30, 0xFF, 0x80, 0x32, 0x21, 0x22,
  0xC0, 0xF0,
};

const GFXglyph NotoSans_Condensed_ThinItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 4, 7, 5, 1, -7 },
  { 15, 4, 7, 4, 0, -7 },
  { 19, 1, 2, 1, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 3, 3, 3, 1, -7 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 1, 2, 1, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 7, 4, 0, -7 },
  { 40, 2, 6, 4, 1, -6 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 3, 6, 4, 1, -6 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 1, 5, 2, 0, -5 },
  { 73, 1, 6, 2, 0, -5 },
  { 74, 4, 4, 4, 0, -5 },
  { 76, 4, 2, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -5 },
  { 79, 3, 7, 3, 0, -7 },
  { 82, 5, 7, 5, 0, -6 },
  { 87, 4, 6, 4, -1, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 7, 4, 0, -7 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 4, 6, 3, 0, -6 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 2, 6, 2, 0, -6 },
  { 117, 3, 8, 2, -1, -6 },
  { 120, 4, 6, 4, 0, -6 },
  { 123, 3, 6, 3, 0, -6 },
  { 126, 6, 6, 6, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 5, 7, 5, 0, -7 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 5, 9, 5, 0, -7 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 4, 7, 3, 0, -7 },
  { 156, 3, 6, 3, 1, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 3, 6, 4, 1, -6 },
  { 166, 6, 6, 6, 1, -6 },
  { 171, 5, 6, 3, -1, -6 },
  { 175, 3, 6, 3, 1, -6 },
  { 178, 4, 6, 3, 0, -6 },
  { 181, 3, 7, 3, 0, -6 },
  { 184, 1, 6, 3, 1, -6 },
  { 185, 4, 7, 3, -1, -6 },
  { 189, 4, 3, 4, 0, -6 },
  { 191, 3, 1, 3, -1, 0 },
  { 192, 1, 2, 2, 1, -7 },
  { 193, 4, 5, 4, 0, -5 },
  { 196, 4, 7, 4, 0, -7 },
  { 200, 3, 5, 3, 0, -5 },
  { 202, 4, 7, 4, 0, -7 },
  { 206, 3, 5, 3, 0, -5 },
  { 208, 4, 9, 2, -1, -7 },
  { 213, 4, 7, 4, 0, -5 },
  { 217, 3, 7, 4, 0, -7 },
  { 220, 2, 6, 2, 0, -6 },
  { 222, 3, 8, 2, -1, -6 },
  { 225, 3, 7, 3, 0, -7 },
  { 228, 2, 7, 2, 0, -7 },
  { 230, 5, 5, 6, 0, -5 },
  { 234, 3, 5, 4, 0, -5 },
  { 236, 3, 5, 4, 0, -5 },
  { 238, 4, 7, 4, 0, -5 },
  { 242, 4, 7, 4, 0, -5 },
  { 246, 3, 5, 2, 0, -5 },
  { 248, 3, 5, 3, 0, -5 },
  { 250, 2, 6, 2, 0, -6 },
  { 252, 4, 5, 4, 0, -5 },
  { 255, 3, 5, 3, 0, -5 },
  { 257, 4, 5, 5, 1, -5 },
  { 260, 3, 5, 3, 0, -5 },
  { 262, 4, 7, 3, -1, -5 },
  { 266, 3, 5, 3, 0, -5 },
  { 268, 3, 7, 3, 0, -6 },
  { 271, 1, 9, 4, 1, -7 },
  { 273, 4, 7, 3, -1, -6 },
  { 277, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_ThinItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_THINITALIC9PT7B_H_
