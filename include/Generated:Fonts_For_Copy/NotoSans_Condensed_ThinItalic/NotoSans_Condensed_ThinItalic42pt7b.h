#ifndef _NOTOSANS_CONDENSED_THINITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x80, 0xC0, 0xC0, 0x21, 0x90, 0x88, 0x44, 0x24,
  0x12, 0x11, 0x08, 0x84, 0x42, 0x42, 0x21, 0x00, 0x00, 0x60, 0x80, 0x10,
  0x20, 0x04, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0x20,
  0x04, 0x08, 0x01, 0x06, 0x0F, 0xFF, 0xF0, 0x20, 0x40, 0x08, 0x10, 0x02,
  0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x04,
  0x00, 0x83, 0x03, 0xFF, 0xF8, 0x10, 0x20, 0x04, 0x08, 0x01, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x40, 0x08, 0x20, 0x06, 0x08, 0x01, 0x02, 0x00, 0x41,
  0x80, 0x30, 0x40, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x0F, 0xF0, 0x18, 0x84, 0x18, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x04,
  0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0xC4, 0x00, 0x22, 0x00, 0x09, 0x00,
  0x02, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x2C, 0x00, 0x13, 0x00, 0x08,
  0x80, 0x04, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00,
  0x82, 0x00, 0x43, 0x08, 0x23, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x30, 0x42, 0x01, 0x04, 0x10,
  0x10, 0x20, 0x80, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x08, 0x60, 0x40, 0x42, 0x02, 0x02, 0x20, 0x10, 0x21, 0x00, 0x81, 0x10,
  0x04, 0x08, 0x8F, 0x60, 0xC8, 0x8F, 0x04, 0xC8, 0x28, 0x64, 0xC1, 0x42,
  0x64, 0x0B, 0xE2, 0x20, 0x40, 0x22, 0x02, 0x01, 0x10, 0x10, 0x10, 0x81,
  0x80, 0x84, 0x08, 0x08, 0x60, 0x40, 0xC2, 0x02, 0x04, 0x10, 0x30, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x20, 0x81, 0x00, 0x8C, 0x10, 0x07, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x42, 0x00, 0x40, 0x80, 0x20, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x18, 0x04, 0x08, 0x02, 0x0C, 0x01, 0x04,
  0x00, 0x86, 0x00, 0x26, 0x00, 0x16, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0D,
  0x00, 0x0C, 0x40, 0x0C, 0x20, 0x4C, 0x18, 0x64, 0x04, 0x24, 0x02, 0x12,
  0x00, 0x93, 0x00, 0x49, 0x00, 0x28, 0x80, 0x0C, 0x40, 0x04, 0x30, 0x07,
  0x08, 0x04, 0x86, 0x04, 0x41, 0xFC, 0x10, 0x24, 0x94, 0x92, 0x52, 0x00,
  0x00, 0x30, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x00, 0x01, 0x00, 0x10, 0x02, 0x08, 0x20, 0x62, 0x01,
  0x21, 0x0D, 0xF0, 0x60, 0x0A, 0x01, 0x10, 0x61, 0x04, 0x08, 0x00, 0xC0,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88, 0xC0, 0xFF, 0x80, 0x7C, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x06, 0x02, 0x02, 0x06, 0x02, 0x04,
  0x02, 0x08, 0x03, 0x08, 0x03, 0x10, 0x03, 0x10, 0x03, 0x10, 0x03, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0xC0,
  0x18, 0xC0, 0x10, 0xC0, 0x10, 0x40, 0x20, 0x40, 0x60, 0x40, 0x40, 0x20,
  0x80, 0x1F, 0x00, 0x01, 0x07, 0x0D, 0x11, 0x62, 0xC2, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x00, 0xFE, 0x00,
  0xC0, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0x81, 0x81, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x1F,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x08, 0x06, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x90, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x42, 0x00, 0x43, 0x00, 0x21, 0x00, 0x20, 0x80, 0x20,
  0x40, 0x30, 0x20, 0x10, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x08,
  0x02, 0x0C, 0x02, 0x04, 0x01, 0x04, 0x00, 0x8B, 0xFF, 0xF8, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0xFC, 0x00, 0x63, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x08, 0x06, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x47, 0xE0, 0x58, 0x30, 0x60, 0x10, 0xE0,
  0x08, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x20, 0xC0,
  0x40, 0x40, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x81, 0x80, 0x80, 0x40, 0x80, 0x10, 0x40,
  0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x02, 0x00, 0x81,
  0x80, 0x80, 0x40, 0x80, 0x11, 0x80, 0x0D, 0x80, 0x07, 0x00, 0x0E, 0x40,
  0x0C, 0x10, 0x08, 0x04, 0x08, 0x02, 0x0C, 0x00, 0x84, 0x00, 0x46, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x60, 0x02, 0x10, 0x02, 0x0C,
  0x03, 0x03, 0x03, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x81, 0x00, 0x80,
  0xC0, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x20, 0x04, 0x30, 0x03, 0x10,
  0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18,
  0x40, 0x1C, 0x30, 0x0C, 0x0C, 0x1A, 0x03, 0xF9, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x07, 0xF0, 0x00, 0x06, 0x0C,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x04, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x81,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x04, 0x03, 0x00,
  0x06, 0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00,
  0x03, 0x18, 0x0F, 0xC3, 0x10, 0x30, 0x83, 0x30, 0x20, 0x83, 0x20, 0x40,
  0x82, 0x20, 0xC0, 0x82, 0x20, 0x81, 0x02, 0x41, 0x81, 0x02, 0x41, 0x01,
  0x02, 0x41, 0x03, 0x06, 0x41, 0x02, 0x04, 0x43, 0x02, 0x04, 0x43, 0x06,
  0x08, 0xC3, 0x06, 0x08, 0xC1, 0x0A, 0x10, 0xC1, 0x1A, 0x30, 0xC0, 0xF1,
  0xE0, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00,
  0x10, 0x80, 0x18, 0x40, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x02, 0x04,
  0x02, 0x02, 0x01, 0x01, 0x01, 0xFF, 0x80, 0x80, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x40, 0x08, 0x20, 0x06, 0x30, 0x03, 0x10, 0x00, 0x98, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x04, 0x03, 0xFC, 0x01, 0x01,
  0x80, 0x80, 0x60, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x18,
  0x01, 0x08, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x61, 0x80, 0x60,
  0x81, 0xC0, 0x7F, 0xC0, 0x20, 0x10, 0x10, 0x04, 0x18, 0x03, 0x08, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40,
  0x04, 0x20, 0x06, 0x30, 0x02, 0x10, 0x02, 0x08, 0x06, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x30, 0x10, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x40,
  0xC0, 0x08, 0x04, 0x02, 0x00, 0x40, 0x40, 0x0C, 0x08, 0x00, 0x81, 0x00,
  0x10, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00,
  0x21, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00,
  0xC4, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x10, 0x40, 0x02,
  0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x04, 0x08, 0x01, 0x03, 0x00, 0x60,
  0x40, 0x30, 0x08, 0x1C, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x81, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x7F, 0xF0, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x81, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xF0, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0C, 0x03, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x01, 0xFC, 0x80, 0x00, 0xC8, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x10, 0x80,
  0x01, 0x0C, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x30, 0x60, 0x02, 0x03,
  0x00, 0x20, 0x18, 0x02, 0x00, 0xFF, 0xC0, 0x02, 0x00, 0x08, 0x10, 0x00,
  0xC0, 0x80, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10,
  0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08,
  0x10, 0x00, 0x81, 0x80, 0x04, 0x08, 0x00, 0x20, 0x7F, 0xFF, 0x02, 0x00,
  0x18, 0x10, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02,
  0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01,
  0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40,
  0x03, 0x00, 0x01, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x7F, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x60, 0x40,
  0x18, 0x08, 0x02, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x0C, 0x01, 0x03,
  0x00, 0x60, 0xC0, 0x08, 0x30, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x40,
  0x01, 0x90, 0x00, 0x26, 0x00, 0x05, 0xC0, 0x00, 0xE4, 0x00, 0x18, 0x80,
  0x06, 0x10, 0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0xC0, 0xC0,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x03, 0x00, 0x40,
  0x40, 0x0C, 0x08, 0x00, 0x81, 0x00, 0x10, 0x00, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x02, 0x80, 0x00, 0xA0, 0x50, 0x00, 0x14, 0x0A, 0x00, 0x05, 0x81, 0x40,
  0x00, 0xA0, 0x68, 0x00, 0x24, 0x09, 0x00, 0x04, 0x81, 0x30, 0x01, 0x10,
  0x22, 0x00, 0x26, 0x04, 0x40, 0x08, 0x81, 0x88, 0x01, 0x10, 0x21, 0x00,
  0x42, 0x04, 0x20, 0x08, 0x40, 0x84, 0x02, 0x10, 0x10, 0x80, 0xC2, 0x04,
  0x10, 0x10, 0x40, 0x82, 0x06, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x30,
  0x40, 0xC0, 0x84, 0x08, 0x10, 0x11, 0x81, 0x02, 0x02, 0x20, 0x20, 0x40,
  0x4C, 0x0C, 0x08, 0x09, 0x01, 0x03, 0x01, 0x60, 0x20, 0x40, 0x28, 0x04,
  0x08, 0x07, 0x00, 0x81, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x00, 0x08, 0x18,
  0x00, 0x40, 0xC0, 0x02, 0x0A, 0x00, 0x10, 0x50, 0x01, 0x02, 0x40, 0x08,
  0x12, 0x00, 0x41, 0x90, 0x02, 0x08, 0x80, 0x30, 0x42, 0x01, 0x02, 0x10,
  0x08, 0x10, 0x80, 0x41, 0x86, 0x02, 0x08, 0x10, 0x30, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x30, 0x41, 0x00, 0x82, 0x08, 0x04, 0x20, 0x40, 0x21,
  0x02, 0x01, 0x88, 0x30, 0x04, 0x41, 0x00, 0x26, 0x08, 0x01, 0x20, 0x40,
  0x0D, 0x02, 0x00, 0x28, 0x30, 0x01, 0x41, 0x00, 0x0E, 0x08, 0x00, 0x60,
  0x40, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x30, 0x08, 0x03, 0x03, 0x00,
  0x20, 0xC0, 0x06, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00,
  0x24, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0xD0, 0x00, 0x12, 0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03,
  0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18,
  0xC0, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x30, 0x04, 0x03, 0x03, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0x03, 0x00, 0x80, 0xC0, 0x80, 0x20,
  0x40, 0x18, 0x20, 0x04, 0x10, 0x02, 0x18, 0x01, 0x08, 0x01, 0x84, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x21, 0x80, 0x20, 0x80, 0x30, 0x40, 0x30, 0x20,
  0x70, 0x1F, 0xE0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x30,
  0x08, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x10, 0x00, 0x46, 0x00, 0x08,
  0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x02, 0xC0, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20,
  0x00, 0x44, 0x00, 0x18, 0xC0, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x30,
  0x04, 0x03, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x03,
  0xF8, 0x01, 0x03, 0x00, 0x80, 0xC0, 0x80, 0x20, 0x40, 0x18, 0x20, 0x04,
  0x10, 0x02, 0x18, 0x01, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x61, 0x80, 0x20, 0x80, 0x20, 0x40, 0x30, 0x3F, 0xE0, 0x1F, 0xC0, 0x10,
  0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x06, 0x01, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x30, 0x20, 0x08, 0x30, 0x04, 0x10, 0x02, 0x08, 0x01,
  0x04, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x60, 0x10, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x80, 0x30, 0x1F, 0xF0, 0x00, 0xFF,
  0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00, 0x41, 0x00, 0x04,
  0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00,
  0x82, 0x00, 0x08, 0x20, 0x01, 0x82, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x01, 0x04, 0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0xC0, 0xC0, 0x08, 0x04,
  0x01, 0x00, 0x60, 0x30, 0x01, 0xFC, 0x00, 0x80, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x20, 0x80, 0x40, 0x80, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x81, 0x80, 0x81, 0x00, 0x43, 0x00, 0x42, 0x00, 0x46,
  0x00, 0x44, 0x00, 0x44, 0x00, 0x48, 0x00, 0x48, 0x00, 0x50, 0x00, 0x50,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0A, 0x00, 0x30, 0x01, 0x40, 0x06, 0x00, 0x48, 0x01, 0x40, 0x09,
  0x00, 0x28, 0x03, 0x20, 0x09, 0x00, 0x44, 0x01, 0x20, 0x08, 0x80, 0x64,
  0x02, 0x10, 0x08, 0x80, 0x42, 0x01, 0x10, 0x18, 0x40, 0x42, 0x02, 0x08,
  0x08, 0x40, 0x41, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20,
  0x80, 0x82, 0x04, 0x10, 0x10, 0x40, 0x86, 0x02, 0x10, 0x10, 0x80, 0x42,
  0x02, 0x10, 0x08, 0xC0, 0x44, 0x01, 0x10, 0x08, 0x80, 0x22, 0x01, 0x30,
  0x04, 0x80, 0x24, 0x00, 0x90, 0x04, 0x80, 0x14, 0x00, 0xA0, 0x02, 0x80,
  0x14, 0x00, 0x50, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x10, 0x10, 0x02, 0x01, 0x80, 0x60, 0x08, 0x04, 0x00,
  0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x40, 0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x01, 0x10,
  0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x18, 0x00, 0x80,
  0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x80, 0x40,
  0x04, 0x08, 0x00, 0x40, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x33, 0x00, 0x84, 0x04, 0x10, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x10,
  0xC0, 0x22, 0x00, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0F, 0xF0, 0x00, 0x81, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20,
  0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x32,
  0x00, 0x11, 0x00, 0x10, 0xC0, 0x08, 0x20, 0x08, 0x10, 0x0C, 0x04, 0x04,
  0x02, 0x06, 0x01, 0x82, 0x00, 0x42, 0x00, 0x21, 0x00, 0x09, 0x00, 0x05,
  0x80, 0x03, 0xFF, 0xF0, 0x84, 0x42, 0x21, 0x10, 0x00, 0xC0, 0x07, 0xE4,
  0x30, 0x68, 0xC0, 0x51, 0x00, 0xA4, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40,
  0x0C, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x03, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x31, 0x00, 0x62, 0x01, 0xC4, 0x03, 0x08, 0x0A, 0x08,
  0x24, 0x1F, 0x88, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x30,
  0x09, 0xFC, 0x0B, 0x06, 0x0E, 0x02, 0x1C, 0x02, 0x18, 0x03, 0x18, 0x03,
  0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08,
  0xA0, 0x10, 0xA0, 0x30, 0xB0, 0x60, 0x9F, 0x80, 0x00, 0xC0, 0x1F, 0xC3,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x30, 0xC0, 0x3F, 0x20, 0x30,
  0x28, 0x18, 0x0A, 0x04, 0x01, 0x82, 0x00, 0x60, 0x80, 0x10, 0x40, 0x04,
  0x10, 0x01, 0x04, 0x00, 0x42, 0x00, 0x30, 0x80, 0x08, 0x20, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x01,
  0xC0, 0x80, 0x50, 0x20, 0x28, 0x04, 0x1A, 0x01, 0xF8, 0x80, 0x00, 0x80,
  0x1F, 0x83, 0x04, 0x10, 0x11, 0x00, 0x90, 0x04, 0x80, 0x68, 0x02, 0x40,
  0x36, 0x03, 0x20, 0x61, 0xFC, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x20, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0x30, 0x30, 0x28, 0x18, 0x0A, 0x04, 0x01, 0x82, 0x00, 0x60, 0x80,
  0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x42, 0x00, 0x30, 0x80, 0x08,
  0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x20, 0x0C, 0x08,
  0x03, 0x02, 0x01, 0xC0, 0x80, 0x50, 0x20, 0x28, 0x04, 0x1A, 0x01, 0xF8,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x02, 0x06, 0x00, 0x7F, 0x00, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x60, 0x27, 0xF0, 0x58, 0x20, 0xE0,
  0x23, 0x80, 0x46, 0x00, 0x8C, 0x01, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x30, 0x04, 0x40, 0x08, 0x80,
  0x31, 0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x10,
  0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x3C,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x18, 0x40, 0x40,
  0x81, 0x83, 0x06, 0x04, 0x18, 0x08, 0x20, 0x10, 0x80, 0x22, 0x00, 0xC8,
  0x01, 0x30, 0x02, 0xD0, 0x07, 0x20, 0x0C, 0x40, 0x30, 0x80, 0x40, 0x80,
  0x81, 0x01, 0x02, 0x06, 0x04, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x30, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x06, 0x08, 0x10, 0x20, 0x40, 0x00, 0x20, 0x18, 0x09, 0xF8, 0x7E, 0x0A,
  0x0D, 0x83, 0x0C, 0x05, 0x01, 0x14, 0x06, 0x01, 0x18, 0x06, 0x01, 0x18,
  0x04, 0x01, 0x10, 0x04, 0x01, 0x10, 0x0C, 0x02, 0x30, 0x08, 0x02, 0x20,
  0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x06, 0x20, 0x18, 0x04, 0x60,
  0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x08, 0x40,
  0x20, 0x08, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x80,
  0x60, 0x10, 0x00, 0x30, 0x13, 0xF8, 0x2C, 0x10, 0x60, 0x11, 0x40, 0x23,
  0x00, 0x46, 0x00, 0x88, 0x02, 0x10, 0x04, 0x60, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x84, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x21,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x06, 0x20, 0x08, 0x00, 0x00, 0x40,
  0x0F, 0xC0, 0xC0, 0x86, 0x03, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x08, 0x80, 0x41, 0x02,
  0x03, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x8F, 0xC0, 0x2C, 0x18, 0x0A, 0x02,
  0x03, 0x00, 0x81, 0xC0, 0x30, 0x60, 0x04, 0x18, 0x01, 0x04, 0x00, 0xC3,
  0x00, 0x30, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x21, 0x80,
  0x18, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x81, 0x00, 0x20, 0xA0, 0x10,
  0x28, 0x0C, 0x0B, 0x06, 0x02, 0x7E, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x03, 0xF3, 0x0C, 0x0A,
  0x18, 0x0A, 0x10, 0x06, 0x20, 0x06, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18,
  0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x80, 0x70, 0x80, 0x50, 0x80, 0xA0,
  0x41, 0xA0, 0x7E, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x20, 0x9F, 0x0B, 0x00, 0xE0, 0x14, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x3F, 0xC2, 0x02, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x40, 0x43, 0xFC,
  0x00, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x41, 0xFE, 0x10, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F, 0x00, 0x08, 0x03, 0x08,
  0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x30,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x60, 0x08, 0x40,
  0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x30, 0xC0, 0x70, 0x40,
  0x50, 0x40, 0xA0, 0x3F, 0x20, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x80, 0x44,
  0x02, 0x20, 0x21, 0x01, 0x08, 0x18, 0x40, 0x82, 0x0C, 0x10, 0x40, 0x86,
  0x04, 0x20, 0x23, 0x01, 0x10, 0x09, 0x80, 0x48, 0x02, 0x40, 0x14, 0x00,
  0xA0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x80, 0xA0, 0x68, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x88,
  0x22, 0x08, 0x82, 0x20, 0x90, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x2C, 0x0A,
  0x02, 0x80, 0xE0, 0x28, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x06, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x60, 0xC0, 0x10, 0x40, 0x08,
  0x40, 0x04, 0x60, 0x01, 0x20, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x08, 0x80, 0x08, 0x40, 0x08, 0x20,
  0x0C, 0x18, 0x04, 0x04, 0x04, 0x02, 0x06, 0x01, 0x06, 0x00, 0x40, 0x00,
  0x80, 0x18, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x20, 0x02, 0x01, 0x00, 0x10, 0x10, 0x00, 0x40, 0x80, 0x02,
  0x08, 0x00, 0x10, 0x40, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x6F, 0x01, 0x81, 0xC6, 0x80, 0x78,
};

const GFXglyph NotoSans_Condensed_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 30, 9, 1, -30 },
  { 31, 9, 11, 11, 4, -30 },
  { 44, 18, 30, 18, 1, -30 },
  { 112, 17, 34, 17, 0, -32 },
  { 185, 21, 31, 25, 2, -30 },
  { 267, 17, 30, 18, 0, -30 },
  { 331, 3, 11, 6, 4, -30 },
  { 336, 12, 37, 10, 1, -30 },
  { 392, 12, 37, 10, -3, -30 },
  { 448, 12, 13, 16, 5, -32 },
  { 468, 16, 19, 19, 2, -24 },
  { 506, 5, 9, 7, -2, -4 },
  { 512, 9, 1, 12, 1, -12 },
  { 514, 2, 3, 7, 1, -3 },
  { 515, 17, 30, 12, -2, -30 },
  { 579, 16, 30, 17, 1, -30 },
  { 639, 8, 30, 17, 5, -30 },
  { 669, 18, 30, 17, -1, -30 },
  { 737, 17, 30, 17, 0, -30 },
  { 801, 17, 30, 17, 0, -30 },
  { 865, 17, 30, 17, 0, -30 },
  { 929, 16, 30, 17, 2, -30 },
  { 989, 15, 30, 17, 3, -30 },
  { 1046, 17, 30, 17, 0, -30 },
  { 1110, 17, 30, 17, 0, -30 },
  { 1174, 7, 22, 7, 0, -22 },
  { 1194, 9, 27, 7, -2, -22 },
  { 1225, 16, 18, 19, 2, -24 },
  { 1261, 16, 10, 19, 2, -20 },
  { 1281, 16, 18, 19, 2, -24 },
  { 1317, 13, 30, 12, 1, -30 },
  { 1366, 24, 34, 25, 1, -30 },
  { 1468, 17, 30, 16, -3, -30 },
  { 1532, 17, 30, 19, 1, -30 },
  { 1596, 18, 30, 17, 2, -30 },
  { 1664, 19, 30, 21, 1, -30 },
  { 1736, 17, 30, 17, 1, -30 },
  { 1800, 17, 30, 15, 1, -30 },
  { 1864, 20, 30, 22, 2, -30 },
  { 1939, 21, 30, 22, 1, -30 },
  { 2018, 13, 30, 8, -2, -30 },
  { 2067, 14, 37, 7, -6, -30 },
  { 2132, 19, 30, 17, 1, -30 },
  { 2204, 11, 30, 15, 1, -30 },
  { 2246, 27, 30, 27, 1, -30 },
  { 2348, 21, 30, 22, 1, -30 },
  { 2427, 19, 30, 22, 2, -30 },
  { 2499, 17, 30, 17, 1, -30 },
  { 2563, 19, 37, 22, 2, -30 },
  { 2651, 17, 30, 18, 1, -30 },
  { 2715, 18, 30, 16, -1, -30 },
  { 2783, 14, 30, 15, 4, -30 },
  { 2836, 20, 30, 21, 2, -30 },
  { 2911, 16, 30, 17, 4, -30 },
  { 2971, 27, 30, 28, 4, -30 },
  { 3073, 20, 30, 15, -2, -30 },
  { 3148, 14, 30, 15, 4, -30 },
  { 3201, 19, 30, 16, -1, -30 },
  { 3273, 15, 37, 12, -1, -30 },
  { 3343, 6, 30, 13, 4, -30 },
  { 3366, 15, 37, 12, -3, -30 },
  { 3436, 17, 16, 18, 1, -30 },
  { 3470, 12, 1, 12, -3, 4 },
  { 3472, 4, 7, 9, 6, -32 },
  { 3476, 15, 23, 18, 2, -23 },
  { 3520, 16, 32, 18, 1, -32 },
  { 3584, 13, 23, 14, 2, -23 },
  { 3622, 18, 32, 18, 2, -32 },
  { 3694, 13, 23, 16, 2, -23 },
  { 3732, 20, 42, 9, -6, -32 },
  { 3837, 18, 33, 18, 0, -23 },
  { 3912, 15, 32, 17, 1, -32 },
  { 3972, 7, 30, 7, 1, -30 },
  { 3999, 14, 40, 7, -6, -30 },
  { 4069, 15, 32, 14, 1, -32 },
  { 4129, 7, 32, 7, 1, -32 },
  { 4157, 24, 23, 27, 1, -23 },
  { 4226, 15, 23, 17, 1, -23 },
  { 4270, 14, 23, 18, 2, -23 },
  { 4311, 18, 33, 18, -1, -23 },
  { 4386, 16, 33, 18, 2, -23 },
  { 4452, 12, 23, 12, 1, -23 },
  { 4487, 13, 23, 13, 0, -23 },
  { 4525, 9, 28, 9, 1, -28 },
  { 4557, 16, 22, 17, 1, -22 },
  { 4601, 13, 22, 13, 2, -22 },
  { 4637, 20, 22, 22, 3, -22 },
  { 4692, 17, 22, 14, -2, -22 },
  { 4739, 21, 32, 14, -5, -22 },
  { 4823, 14, 22, 12, -1, -22 },
  { 4862, 15, 37, 13, 1, -30 },
  { 4932, 1, 42, 17, 8, -32 },
  { 4938, 15, 37, 13, -3, -30 },
  { 5008, 16, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_THINITALIC42PT7B_H_
