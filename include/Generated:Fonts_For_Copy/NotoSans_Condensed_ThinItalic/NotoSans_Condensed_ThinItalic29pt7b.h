#ifndef _NOTOSANS_CONDENSED_THINITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x45, 0x14, 0x92, 0x8A, 0x29, 0x24, 0x01, 0x08, 0x08,
  0x80, 0x84, 0x04, 0x20, 0x22, 0x01, 0x10, 0xFF, 0xE0, 0x88, 0x04, 0x40,
  0x42, 0x02, 0x10, 0x11, 0x01, 0x08, 0x7F, 0x70, 0x44, 0x04, 0x20, 0x21,
  0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x60, 0x00, 0x00, 0x80, 0x08, 0x03,
  0xC0, 0xD3, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x00, 0xA0, 0x0E,
  0x00, 0x20, 0x03, 0x00, 0x48, 0x04, 0x80, 0x44, 0x04, 0x40, 0x84, 0x08,
  0x88, 0x90, 0x7E, 0x00, 0x80, 0x10, 0x01, 0x00, 0x1C, 0x08, 0x90, 0x24,
  0x21, 0x10, 0x88, 0x82, 0x22, 0x11, 0x08, 0x44, 0x21, 0x20, 0x84, 0x9A,
  0x24, 0x98, 0xA4, 0x64, 0xA1, 0x64, 0x84, 0x12, 0x10, 0x90, 0x42, 0x42,
  0x11, 0x08, 0x84, 0x22, 0x10, 0x90, 0x44, 0x40, 0xE0, 0x03, 0x80, 0x44,
  0x04, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88, 0x05, 0x00, 0x60,
  0x0C, 0x01, 0x20, 0x22, 0x14, 0x12, 0x41, 0x28, 0x14, 0x80, 0xC8, 0x08,
  0x81, 0x84, 0x34, 0x7C, 0x40, 0x55, 0xAA, 0x01, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x04, 0x02, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x08,
  0x08, 0x88, 0x50, 0x3F, 0x30, 0x48, 0x84, 0x04, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x24, 0xA5, 0x20, 0xFC, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x00, 0x07, 0x82, 0x11, 0x04, 0x41, 0x20, 0x48, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x81,
  0x20, 0x48, 0x22, 0x10, 0x78, 0x00, 0x08, 0xDB, 0x11, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x00, 0x03, 0xE0, 0x41, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xFF, 0x80, 0x07, 0xC1, 0x82, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x18, 0x0F, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0xFE, 0x00,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x50, 0x12, 0x02, 0x80, 0x90, 0x22, 0x08,
  0x41, 0x08, 0x42, 0x10, 0x42, 0x08, 0x81, 0x20, 0x27, 0xFF, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x03, 0xF0, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0xFE,
  0x00, 0x03, 0xE0, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x4E, 0x0A, 0x21, 0x82, 0x60, 0x48, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x04, 0x21, 0x07, 0xC0, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00, 0x03,
  0xC0, 0xC2, 0x08, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x20, 0x82, 0x08,
  0xC0, 0x50, 0x06, 0x01, 0x90, 0x20, 0x84, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x84, 0x08, 0x3F, 0x00, 0x03, 0xC1, 0x84, 0x20, 0x88,
  0x11, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81, 0x88, 0x50,
  0xF4, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x0F, 0xC0,
  0x18, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x82, 0x10, 0x42, 0x08,
  0x00, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x00, 0x1E, 0x21, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0xF0, 0x03, 0x0C, 0x04, 0x02,
  0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0xF1, 0x21, 0x11, 0x42, 0x11,
  0x44, 0x21, 0x44, 0x21, 0x84, 0x21, 0x88, 0x22, 0x88, 0x42, 0x88, 0x42,
  0x88, 0xC4, 0x88, 0xC8, 0x87, 0x30, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x30, 0x80, 0x0F, 0x00, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0A,
  0x00, 0xA0, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x82,
  0x0F, 0xE0, 0x82, 0x10, 0x21, 0x02, 0x20, 0x22, 0x01, 0x40, 0x14, 0x01,
  0x80, 0x10, 0x0F, 0x80, 0x86, 0x10, 0x21, 0x01, 0x10, 0x11, 0x01, 0x20,
  0x22, 0x02, 0x20, 0x42, 0x18, 0x3F, 0x04, 0x08, 0x40, 0x44, 0x04, 0x40,
  0x44, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0xFE, 0x00, 0x01, 0xF0,
  0x10, 0x41, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x21,
  0x82, 0x04, 0x10, 0x10, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x40,
  0x22, 0x02, 0x10, 0x30, 0x82, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x07, 0xF0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x5F, 0x82, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x10, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x3E, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x40, 0x11,
  0x00, 0x84, 0x02, 0x08, 0x08, 0x1F, 0xE0, 0x04, 0x02, 0x10, 0x04, 0x20,
  0x08, 0x40, 0x10, 0x80, 0x41, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x08,
  0x20, 0x10, 0x7F, 0xE1, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10,
  0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x82, 0x01, 0x08, 0x02, 0x00, 0x0F,
  0x81, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x0F, 0x00, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x38, 0x00, 0x04, 0x04, 0x20, 0x20,
  0x81, 0x02, 0x08, 0x08, 0x40, 0x23, 0x01, 0x08, 0x04, 0x40, 0x12, 0x00,
  0x50, 0x01, 0xA0, 0x0C, 0x80, 0x22, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x80, 0x40, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0xFF, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x50, 0xC0, 0x0C, 0x14, 0x02, 0x84, 0x80, 0x50, 0x90,
  0x12, 0x12, 0x02, 0x42, 0x40, 0x90, 0x48, 0x12, 0x11, 0x04, 0x42, 0x20,
  0x88, 0x44, 0x22, 0x08, 0x84, 0x41, 0x11, 0x08, 0x41, 0x21, 0x08, 0x28,
  0x21, 0x06, 0x08, 0x20, 0xC1, 0x08, 0x10, 0x20, 0x04, 0x02, 0x08, 0x04,
  0x30, 0x08, 0x50, 0x10, 0xA0, 0x21, 0x40, 0x84, 0x81, 0x08, 0x82, 0x11,
  0x04, 0x22, 0x08, 0x44, 0x21, 0x04, 0x42, 0x08, 0x84, 0x11, 0x08, 0x22,
  0x10, 0x28, 0x40, 0x50, 0x80, 0xA1, 0x01, 0x42, 0x01, 0x08, 0x02, 0x00,
  0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x02, 0x10, 0x08, 0x80, 0x12, 0x00,
  0x50, 0x01, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x21, 0x00, 0x84, 0x04, 0x18, 0x20, 0x3F,
  0x00, 0x07, 0xC0, 0x42, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10, 0x11,
  0x01, 0x10, 0x11, 0x02, 0x10, 0x43, 0xF8, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x10,
  0x40, 0x80, 0x84, 0x02, 0x10, 0x08, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x21, 0x00, 0x84, 0x04, 0x18, 0x20, 0x3F, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x42, 0x08, 0x10,
  0x81, 0x08, 0x10, 0x81, 0x10, 0x11, 0x01, 0x10, 0x21, 0x02, 0x10, 0xC3,
  0xF0, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x40, 0x84, 0x08, 0x40, 0x84,
  0x08, 0x80, 0xC0, 0x07, 0xE0, 0x81, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0xFE, 0x00, 0xFF,
  0xC2, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x00, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x40,
  0x22, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40,
  0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x08, 0x04, 0x10,
  0x20, 0x3F, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x24, 0x04,
  0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x12,
  0x09, 0x08, 0x84, 0x42, 0x21, 0x10, 0x88, 0x84, 0x42, 0x21, 0x10, 0x88,
  0x48, 0x24, 0x12, 0x09, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x00, 0x04, 0x06, 0x04, 0x08,
  0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x44, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x02, 0x20,
  0x04, 0x40, 0x10, 0x40, 0x40, 0x80, 0x81, 0x02, 0x02, 0x0C, 0x04, 0x00,
  0x80, 0x28, 0x09, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x82, 0x20, 0x24,
  0x05, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3E,
  0x00, 0x88, 0x88, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x11, 0x10,
  0x07, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x00,
  0x02, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x21, 0x04, 0x21, 0x02, 0x40,
  0x48, 0x06, 0x00, 0x80, 0xFF, 0x89, 0x10, 0x07, 0x01, 0x14, 0x41, 0x90,
  0x22, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x11, 0x06, 0x20, 0xC3, 0xE8, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x20, 0xB3, 0x18, 0x23, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x46, 0x11, 0x3C, 0x00,
  0x07, 0x04, 0x44, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x01, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x1C, 0x81, 0x14, 0x10, 0x61, 0x03, 0x08, 0x10,
  0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x61, 0x05, 0x08, 0x30, 0x3E, 0x80, 0x07, 0x04, 0x44, 0x24, 0x14, 0x0A,
  0x05, 0x05, 0x0C, 0xE8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x7C,
  0x00, 0x3C, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x45, 0x08, 0x31, 0x03, 0x10, 0x22, 0x02,
  0x20, 0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x04, 0x40, 0xC4, 0x14,
  0x41, 0x83, 0xE8, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x08, 0x20,
  0x7C, 0x00, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x20,
  0xB2, 0x18, 0x23, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x88, 0x11, 0x02,
  0x40, 0x48, 0x11, 0x02, 0x20, 0x44, 0x09, 0x01, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x01, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x03, 0x80,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x08, 0x82, 0x10,
  0x82, 0x10, 0x44, 0x11, 0x02, 0x40, 0x58, 0x0D, 0x01, 0x20, 0x42, 0x08,
  0x41, 0x08, 0x21, 0x04, 0x11, 0x02, 0x00, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x00,
  0x01, 0x86, 0x0B, 0x24, 0xC6, 0x14, 0x22, 0x04, 0x11, 0x02, 0x08, 0x82,
  0x04, 0x81, 0x02, 0x40, 0x81, 0x20, 0x41, 0x10, 0x40, 0x90, 0x20, 0x48,
  0x10, 0x24, 0x08, 0x12, 0x04, 0x11, 0x04, 0x09, 0x02, 0x04, 0x00, 0x82,
  0xC8, 0x60, 0x88, 0x11, 0x02, 0x20, 0x48, 0x09, 0x02, 0x20, 0x44, 0x09,
  0x01, 0x20, 0x44, 0x08, 0x81, 0x10, 0x24, 0x04, 0x07, 0x02, 0x21, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80,
  0xA0, 0x44, 0x21, 0xF0, 0x00, 0xC0, 0x59, 0x02, 0x84, 0x18, 0x20, 0x80,
  0x84, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x42,
  0x02, 0x10, 0x20, 0xC2, 0x09, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x07, 0x01, 0x14, 0x41, 0x90, 0x32,
  0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x48, 0x19,
  0x05, 0x20, 0xC3, 0xE8, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x01, 0x8B, 0x06, 0x03, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x07, 0x0C, 0x48, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x09, 0xF8, 0x10, 0x41, 0x08, 0x7C, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x82, 0x0E, 0x00, 0x20, 0x64, 0x08, 0x81, 0x10, 0x24, 0x04,
  0x81, 0x10, 0x22, 0x04, 0x40, 0x90, 0x12, 0x04, 0x40, 0x88, 0x31, 0x0A,
  0x1E, 0x40, 0x81, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x10, 0x90,
  0x48, 0x28, 0x14, 0x0C, 0x06, 0x02, 0x00, 0x82, 0x06, 0x08, 0x18, 0x50,
  0xA1, 0x42, 0x89, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x22, 0x85,
  0x0A, 0x14, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x00, 0x10, 0x30,
  0x84, 0x08, 0x40, 0x88, 0x05, 0x00, 0x50, 0x06, 0x00, 0x40, 0x0A, 0x00,
  0xA0, 0x12, 0x02, 0x10, 0x21, 0x04, 0x10, 0x81, 0x00, 0x04, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x28, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x0F, 0xE0, 0x00, 0xC0, 0xC0, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x18,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0xC0, 0x60, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x30, 0x20, 0x00, 0x7C, 0x30, 0x78,
};

const GFXglyph NotoSans_Condensed_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 21, 6, 1, -21 },
  { 15, 6, 8, 8, 3, -21 },
  { 21, 13, 21, 13, 0, -21 },
  { 56, 12, 24, 12, 0, -22 },
  { 92, 14, 21, 17, 2, -21 },
  { 129, 12, 21, 13, 0, -21 },
  { 161, 2, 8, 4, 3, -21 },
  { 163, 8, 26, 7, 1, -21 },
  { 189, 8, 26, 7, -2, -21 },
  { 215, 8, 9, 11, 4, -22 },
  { 224, 11, 13, 13, 1, -17 },
  { 242, 3, 7, 5, -1, -3 },
  { 245, 6, 1, 8, 1, -8 },
  { 246, 1, 2, 5, 1, -2 },
  { 247, 12, 21, 9, -1, -21 },
  { 279, 10, 21, 12, 1, -21 },
  { 306, 5, 21, 12, 4, -21 },
  { 320, 12, 21, 12, -1, -21 },
  { 352, 12, 21, 12, 0, -21 },
  { 384, 11, 21, 12, 0, -21 },
  { 413, 12, 21, 12, 0, -21 },
  { 445, 11, 21, 12, 1, -21 },
  { 474, 11, 21, 12, 2, -21 },
  { 503, 12, 21, 12, 0, -21 },
  { 535, 11, 21, 12, 0, -21 },
  { 564, 5, 15, 5, 0, -15 },
  { 574, 6, 19, 5, -1, -15 },
  { 589, 11, 12, 13, 1, -16 },
  { 606, 11, 7, 13, 1, -14 },
  { 616, 11, 12, 13, 1, -16 },
  { 633, 8, 21, 8, 1, -21 },
  { 654, 16, 24, 18, 1, -21 },
  { 702, 12, 21, 11, -2, -21 },
  { 734, 12, 21, 13, 1, -21 },
  { 766, 13, 21, 12, 1, -21 },
  { 801, 13, 21, 14, 0, -21 },
  { 836, 13, 21, 12, 0, -21 },
  { 871, 13, 21, 11, 0, -21 },
  { 906, 14, 21, 15, 1, -21 },
  { 943, 15, 21, 15, 0, -21 },
  { 983, 9, 21, 6, -1, -21 },
  { 1007, 10, 26, 5, -4, -21 },
  { 1040, 14, 21, 12, 0, -21 },
  { 1077, 8, 21, 10, 0, -21 },
  { 1098, 19, 21, 19, 0, -21 },
  { 1148, 15, 21, 15, 0, -21 },
  { 1188, 14, 21, 15, 1, -21 },
  { 1225, 12, 21, 12, 0, -21 },
  { 1257, 14, 26, 15, 1, -21 },
  { 1303, 12, 21, 12, 0, -21 },
  { 1335, 12, 21, 11, 0, -21 },
  { 1367, 10, 21, 10, 3, -21 },
  { 1394, 14, 21, 15, 1, -21 },
  { 1431, 11, 21, 12, 3, -21 },
  { 1460, 18, 21, 19, 3, -21 },
  { 1508, 15, 21, 10, -2, -21 },
  { 1548, 11, 21, 10, 2, -21 },
  { 1577, 13, 21, 11, -1, -21 },
  { 1612, 10, 26, 8, 0, -21 },
  { 1645, 4, 21, 9, 3, -21 },
  { 1656, 11, 26, 8, -2, -21 },
  { 1692, 11, 11, 13, 1, -21 },
  { 1708, 8, 1, 9, -2, 3 },
  { 1709, 3, 4, 6, 4, -22 },
  { 1711, 11, 16, 12, 1, -16 },
  { 1733, 11, 22, 13, 0, -22 },
  { 1764, 9, 16, 9, 1, -16 },
  { 1782, 13, 22, 13, 1, -22 },
  { 1818, 9, 16, 11, 1, -16 },
  { 1836, 14, 29, 6, -4, -22 },
  { 1887, 12, 23, 13, 0, -16 },
  { 1922, 11, 22, 12, 0, -22 },
  { 1953, 6, 21, 5, 0, -21 },
  { 1969, 10, 28, 5, -4, -21 },
  { 2004, 11, 22, 10, 0, -22 },
  { 2035, 6, 22, 5, 0, -22 },
  { 2052, 17, 16, 18, 0, -16 },
  { 2086, 11, 16, 12, 0, -16 },
  { 2108, 10, 16, 12, 1, -16 },
  { 2128, 13, 23, 13, -1, -16 },
  { 2166, 11, 23, 13, 1, -16 },
  { 2198, 9, 16, 8, 0, -16 },
  { 2216, 9, 16, 9, 0, -16 },
  { 2234, 6, 19, 6, 1, -19 },
  { 2249, 11, 15, 12, 1, -15 },
  { 2270, 9, 15, 9, 2, -15 },
  { 2287, 14, 15, 15, 2, -15 },
  { 2314, 12, 15, 10, -1, -15 },
  { 2337, 14, 22, 10, -3, -15 },
  { 2376, 10, 15, 8, -1, -15 },
  { 2395, 10, 26, 9, 1, -21 },
  { 2428, 1, 29, 12, 5, -22 },
  { 2432, 10, 26, 9, -2, -21 },
  { 2465, 11, 2, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_THINITALIC29PT7B_H_
