#ifndef _NOTOSANS_CONDENSED_THINITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x00,
  0x62, 0x85, 0x12, 0x24, 0x50, 0xA1, 0x44, 0x88, 0x00, 0x41, 0x00, 0x21,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x08, 0x40, 0x08, 0x20, 0x04, 0x10, 0x3F,
  0xFF, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x42, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x10, 0x80, 0x10, 0x40, 0xFF, 0xFC, 0x04, 0x10, 0x04, 0x10,
  0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00, 0x21,
  0x00, 0x20, 0x80, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x0F, 0xE0,
  0x22, 0x20, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x48, 0x00, 0x50, 0x00, 0x40, 0x00, 0xE0, 0x01, 0x60,
  0x02, 0x40, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01,
  0x10, 0x04, 0x61, 0xFF, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x06, 0x40, 0x21, 0x08, 0x10, 0x82, 0x04, 0x20, 0x82,
  0x10, 0x21, 0x04, 0x08, 0x41, 0x02, 0x20, 0x41, 0x08, 0x20, 0x44, 0x08,
  0x11, 0x02, 0x04, 0x8E, 0x82, 0x64, 0x60, 0x92, 0x18, 0x49, 0x05, 0x32,
  0x41, 0x31, 0x10, 0x40, 0x48, 0x10, 0x22, 0x04, 0x18, 0x81, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x40, 0x86, 0x10, 0x21, 0x08, 0x08, 0x86,
  0x03, 0xE0, 0x00, 0xE0, 0x03, 0x30, 0x08, 0x20, 0x10, 0x40, 0x60, 0x80,
  0x81, 0x01, 0x02, 0x02, 0x08, 0x04, 0x10, 0x0C, 0x40, 0x09, 0x00, 0x14,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x40, 0x08, 0x40, 0x30, 0x82, 0x41, 0x89,
  0x01, 0x12, 0x02, 0x48, 0x02, 0x90, 0x06, 0x20, 0x0C, 0x40, 0x18, 0xC0,
  0x50, 0x81, 0x10, 0xFC, 0x20, 0x69, 0x25, 0x24, 0x80, 0x00, 0xC0, 0x40,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x18, 0x04, 0x02, 0x00, 0x04, 0x01, 0x00, 0x42, 0x10, 0x64, 0x07,
  0xF0, 0x80, 0x50, 0x64, 0x20, 0x80, 0x20, 0x04, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xFF, 0xFC,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x44, 0x21, 0x10, 0x88, 0x80, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x0C, 0x40, 0x60, 0x81, 0x02, 0x08, 0x04, 0x20,
  0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x06, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x80, 0x22, 0x00, 0x88, 0x04, 0x20, 0x30, 0x40, 0x81, 0x04, 0x03,
  0xE0, 0x00, 0x06, 0x38, 0x92, 0x28, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x00, 0x00, 0x70, 0x03, 0x8C, 0x02, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x0E, 0x10, 0x30,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0xF0, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x61, 0x01, 0x83, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x12, 0x00,
  0x44, 0x00, 0x88, 0x02, 0x10, 0x08, 0x40, 0x30, 0x80, 0x41, 0x01, 0x02,
  0x06, 0x04, 0x08, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00, 0x84, 0x01, 0x07,
  0xFD, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x03, 0xFE, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x5C, 0x00, 0xC7, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x80, 0x81,
  0xFE, 0x00, 0x00, 0x3C, 0x03, 0x10, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x09, 0xF0, 0x58,
  0x21, 0x40, 0x46, 0x01, 0x10, 0x04, 0x40, 0x13, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x10, 0x08, 0x40, 0x41, 0x82, 0x03,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00,
  0x00, 0xF0, 0x06, 0x18, 0x18, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x00, 0x84, 0x01, 0x08, 0x04, 0x08, 0x08, 0x10, 0x20, 0x11, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x10, 0x0C, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x44,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x40, 0x20, 0xC0,
  0xC0, 0x7E, 0x00, 0x00, 0xE0, 0x06, 0x30, 0x18, 0x10, 0x20, 0x20, 0x80,
  0x41, 0x00, 0x84, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11,
  0x00, 0x21, 0x00, 0xC2, 0x01, 0x84, 0x05, 0x06, 0x34, 0x03, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x04, 0x30, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x30, 0x01, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x00, 0x08,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x10, 0x00, 0x07, 0x03, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x03, 0x00,
  0x40, 0x08, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x22, 0x03, 0xE1, 0x10, 0x62, 0x09, 0x06, 0x10, 0x48, 0x20, 0x82, 0x82,
  0x04, 0x24, 0x10, 0x41, 0x21, 0x02, 0x09, 0x08, 0x10, 0x48, 0x41, 0x82,
  0x82, 0x08, 0x24, 0x10, 0x41, 0x20, 0x86, 0x11, 0x04, 0x30, 0x88, 0x22,
  0xC8, 0x40, 0xE3, 0x82, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x12, 0x00, 0x88, 0x02, 0x20, 0x10, 0x40, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x41, 0x01, 0x07, 0xFC, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x04,
  0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40, 0x07,
  0xF8, 0x08, 0x08, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00,
  0x84, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x60, 0x83, 0x83, 0xFE, 0x04,
  0x06, 0x08, 0x06, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0xC1, 0xFE, 0x00,
  0x00, 0x3C, 0x01, 0xC3, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x04, 0x04, 0x04, 0x02,
  0x08, 0x02, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x80, 0x20, 0x80, 0x40, 0x81, 0x80, 0xFE, 0x00, 0x07, 0xFE,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0xFF, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x07,
  0xFE, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x70, 0x60, 0x30, 0x04, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x07, 0xE2, 0x00, 0x08,
  0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x41, 0x00, 0x20, 0x60, 0x08, 0x0C, 0x02, 0x01, 0xFF,
  0x00, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x20, 0x02, 0x08, 0x00,
  0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x10, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x04, 0x3F, 0xFF, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80,
  0x08, 0x20, 0x02, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04,
  0x10, 0x01, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x00,
  0x07, 0xE0, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x1F, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x1F, 0x00, 0x04, 0x01, 0x82, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x00, 0x81, 0x80, 0x41, 0x80, 0x20, 0x80, 0x10, 0x80, 0x10, 0x80, 0x08,
  0x80, 0x04, 0x80, 0x02, 0xC0, 0x02, 0xE0, 0x01, 0x48, 0x00, 0xC4, 0x00,
  0x42, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x18, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x01, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x18, 0x00,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x28, 0x50, 0x00, 0x50, 0xA0, 0x01, 0x41, 0x40, 0x02, 0x82,
  0x80, 0x09, 0x05, 0x00, 0x12, 0x12, 0x00, 0x44, 0x22, 0x00, 0x90, 0x44,
  0x02, 0x20, 0x88, 0x04, 0x42, 0x10, 0x10, 0x84, 0x20, 0x21, 0x08, 0x40,
  0x84, 0x10, 0x81, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x09, 0x02, 0x08, 0x12, 0x04, 0x20, 0x28, 0x08,
  0x40, 0x50, 0x20, 0x80, 0xC0, 0x41, 0x01, 0x80, 0x80, 0x06, 0x00, 0x20,
  0xC0, 0x08, 0x18, 0x01, 0x05, 0x00, 0x20, 0x90, 0x04, 0x12, 0x01, 0x02,
  0x40, 0x20, 0x48, 0x04, 0x10, 0x80, 0x82, 0x10, 0x10, 0x42, 0x04, 0x08,
  0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x02, 0x10, 0x20,
  0x22, 0x08, 0x04, 0x41, 0x00, 0x88, 0x20, 0x12, 0x04, 0x01, 0x40, 0x80,
  0x28, 0x20, 0x05, 0x04, 0x00, 0xA0, 0x80, 0x08, 0x10, 0x01, 0x00, 0x00,
  0x70, 0x00, 0xC6, 0x01, 0x80, 0x81, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x02, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21,
  0x00, 0x20, 0x40, 0x30, 0x30, 0x30, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x08,
  0x18, 0x10, 0x10, 0x40, 0x20, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x42, 0x03, 0x04, 0x1C, 0x0F,
  0xC0, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xC6, 0x01, 0x80, 0x81, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x00,
  0x20, 0x40, 0x30, 0x30, 0x30, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x07, 0xF0, 0x08,
  0x18, 0x10, 0x10, 0x40, 0x20, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0xC2, 0x03, 0x07, 0xF8, 0x08,
  0x40, 0x10, 0x40, 0x20, 0x80, 0x81, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x20, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x40, 0x00, 0x78,
  0x01, 0x83, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x80, 0x60, 0x7F, 0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x80, 0x0C, 0x40,
  0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC1,
  0x00, 0x40, 0x40, 0x40, 0x1F, 0xC0, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00,
  0x24, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x20,
  0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x21,
  0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x0A, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x28, 0x05, 0x00, 0x90, 0x12,
  0x01, 0x20, 0x24, 0x04, 0x40, 0x48, 0x08, 0x81, 0x10, 0x31, 0x02, 0x20,
  0x42, 0x08, 0x40, 0x84, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x82, 0x10,
  0x21, 0x04, 0x20, 0x44, 0x08, 0x40, 0x88, 0x11, 0x01, 0x20, 0x22, 0x02,
  0x40, 0x48, 0x04, 0x80, 0x90, 0x0A, 0x01, 0x40, 0x14, 0x02, 0x80, 0x30,
  0x05, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x00, 0x03,
  0x00, 0xC0, 0x40, 0x20, 0x10, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41,
  0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0A, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x14, 0x00, 0x04, 0x80, 0x02,
  0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x10, 0x10, 0x04, 0x04,
  0x02, 0x01, 0x01, 0x80, 0x40, 0x40, 0x10, 0x20, 0x06, 0x00, 0x80, 0x1C,
  0x00, 0x90, 0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x08, 0x20, 0x21,
  0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0xC0, 0x14, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x3F, 0x80, 0x84, 0x21, 0x08,
  0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x20, 0x84, 0x21, 0x08, 0x42,
  0x08, 0x40, 0x03, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x80, 0x02, 0x80, 0x0D, 0x00,
  0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08, 0x10, 0x08, 0x60,
  0x10, 0x80, 0x22, 0x00, 0x2C, 0x00, 0x60, 0xFF, 0xE0, 0xC4, 0x22, 0x11,
  0x01, 0xC4, 0x18, 0xD0, 0x81, 0x46, 0x03, 0x10, 0x08, 0x80, 0x22, 0x00,
  0x98, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00,
  0x88, 0x02, 0x20, 0x18, 0xC0, 0x61, 0x02, 0x84, 0x12, 0x0F, 0x90, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x09, 0xE0, 0x4C, 0x41, 0x40, 0x86, 0x02, 0x18, 0x04, 0x40, 0x13,
  0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09,
  0x00, 0x44, 0x01, 0x30, 0x08, 0xC0, 0x23, 0x01, 0x0A, 0x08, 0x27, 0xC0,
  0x01, 0xE0, 0x61, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x01, 0xC4,
  0x06, 0x34, 0x08, 0x14, 0x18, 0x0C, 0x10, 0x0C, 0x20, 0x08, 0x20, 0x08,
  0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x80, 0x10,
  0x80, 0x30, 0x80, 0x30, 0x80, 0x60, 0x80, 0x60, 0x40, 0xA0, 0x41, 0x20,
  0x3E, 0x20, 0x01, 0xC0, 0x63, 0x08, 0x11, 0x81, 0x10, 0x12, 0x01, 0x20,
  0x24, 0x06, 0x40, 0xC4, 0x70, 0x78, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x43, 0xF8, 0x00, 0x07, 0x80, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x7C, 0x00, 0xD0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE2, 0x06, 0x34, 0x10, 0x28, 0x60, 0x30, 0x80,
  0x62, 0x00, 0x84, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21,
  0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x06, 0x20, 0x18, 0x60, 0x30, 0x40,
  0xA0, 0x82, 0x40, 0xF9, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x04, 0x18, 0x07, 0xC0, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x09,
  0xE0, 0x90, 0x85, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0xC0, 0x24, 0x02,
  0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x00, 0x90,
  0x04, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x80, 0x04, 0x30, 0x00, 0x00,
  0x00, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x04, 0x20, 0x20, 0x81, 0x02, 0x08, 0x08, 0x40, 0x23, 0x01, 0x08, 0x04,
  0x40, 0x12, 0x00, 0x54, 0x02, 0x90, 0x0C, 0x40, 0x31, 0x00, 0x82, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x04, 0x04, 0x30, 0x10, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x06, 0x00, 0x09,
  0xE0, 0xE0, 0x91, 0x90, 0x85, 0x05, 0x02, 0x30, 0x30, 0x11, 0x01, 0x80,
  0x88, 0x08, 0x04, 0xC0, 0x40, 0x24, 0x02, 0x02, 0x20, 0x10, 0x11, 0x01,
  0x00, 0x88, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x02, 0x20, 0x10, 0x11,
  0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x02, 0x20, 0x20,
  0x11, 0x01, 0x00, 0x80, 0x09, 0xE0, 0x90, 0x85, 0x02, 0x30, 0x11, 0x00,
  0x88, 0x04, 0xC0, 0x24, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24,
  0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x80, 0x01, 0xE0, 0x31, 0x82, 0x06, 0x30, 0x11, 0x00, 0x90, 0x04, 0x80,
  0x2C, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x18, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x04, 0xC0, 0x22, 0x02, 0x18, 0x20, 0x7E, 0x00, 0x02, 0x38,
  0x04, 0xC4, 0x05, 0x02, 0x06, 0x02, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x30, 0x08, 0x30, 0x10, 0x28, 0x20,
  0x27, 0xC0, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xC4, 0x18, 0xD0, 0x81, 0x46,
  0x03, 0x10, 0x0C, 0x80, 0x22, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00, 0x24,
  0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x03, 0x20, 0x18, 0x80, 0x61,
  0x02, 0x84, 0x12, 0x0F, 0x90, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x09, 0xE2, 0x40,
  0x50, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x00, 0x07, 0xC0, 0x83, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x81, 0x0F, 0xE0, 0x08, 0x08, 0x08, 0x08, 0x3F,
  0x50, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x84, 0x02, 0x10, 0x08, 0x80, 0x22, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x44, 0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84, 0x06, 0x20, 0x18, 0x80,
  0xC2, 0x03, 0x04, 0x14, 0x1F, 0x90, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28,
  0x09, 0x01, 0x20, 0x64, 0x08, 0x83, 0x10, 0x42, 0x08, 0x22, 0x04, 0x40,
  0x90, 0x12, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x0A, 0x03, 0x01, 0x40, 0x60, 0x48, 0x14, 0x09, 0x02, 0x81,
  0x20, 0x90, 0x44, 0x12, 0x08, 0x82, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08,
  0x44, 0x22, 0x08, 0x84, 0x41, 0x20, 0x90, 0x24, 0x12, 0x05, 0x02, 0x80,
  0xA0, 0x50, 0x14, 0x0A, 0x03, 0x00, 0x80, 0x60, 0x10, 0x00, 0x08, 0x04,
  0x20, 0x10, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x24, 0x00, 0xB0,
  0x02, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x05, 0x00, 0x22, 0x01, 0x08,
  0x04, 0x20, 0x20, 0x41, 0x01, 0x04, 0x04, 0x20, 0x18, 0x01, 0x00, 0x40,
  0x40, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0xFF, 0x00,
  0x00, 0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x1C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x0C, 0x00, 0x10, 0x06, 0x30,
  0x60, 0x7E,
};

const GFXglyph NotoSans_Condensed_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 7, 9, 10, 4, -26 },
  { 32, 17, 26, 16, 0, -26 },
  { 88, 15, 30, 15, 0, -28 },
  { 145, 18, 27, 22, 2, -27 },
  { 206, 15, 27, 16, 0, -27 },
  { 257, 3, 9, 6, 4, -26 },
  { 261, 10, 32, 9, 1, -26 },
  { 301, 10, 32, 9, -2, -26 },
  { 341, 10, 12, 14, 5, -28 },
  { 356, 14, 17, 17, 2, -22 },
  { 386, 5, 9, 6, -2, -4 },
  { 392, 8, 1, 10, 1, -11 },
  { 393, 2, 2, 6, 1, -2 },
  { 394, 16, 26, 11, -2, -26 },
  { 446, 14, 27, 15, 1, -27 },
  { 494, 7, 26, 15, 5, -26 },
  { 517, 16, 27, 15, -1, -27 },
  { 571, 15, 27, 15, 0, -27 },
  { 622, 15, 27, 15, 0, -27 },
  { 673, 15, 26, 15, 0, -26 },
  { 722, 14, 27, 15, 1, -27 },
  { 770, 14, 26, 15, 2, -26 },
  { 816, 15, 27, 15, 0, -27 },
  { 867, 15, 27, 15, 0, -27 },
  { 918, 6, 20, 6, 0, -20 },
  { 933, 8, 25, 6, -2, -20 },
  { 958, 13, 16, 17, 2, -21 },
  { 984, 14, 8, 17, 2, -17 },
  { 998, 13, 16, 17, 2, -21 },
  { 1024, 11, 27, 11, 1, -27 },
  { 1062, 21, 29, 22, 1, -26 },
  { 1139, 14, 27, 15, -2, -27 },
  { 1187, 15, 26, 16, 1, -26 },
  { 1236, 16, 27, 15, 2, -27 },
  { 1290, 16, 26, 18, 1, -26 },
  { 1342, 15, 26, 15, 1, -26 },
  { 1391, 15, 26, 13, 1, -26 },
  { 1440, 18, 27, 19, 2, -27 },
  { 1501, 18, 26, 19, 1, -26 },
  { 1560, 11, 26, 7, -1, -26 },
  { 1596, 13, 32, 7, -6, -26 },
  { 1648, 17, 26, 15, 1, -26 },
  { 1704, 9, 26, 13, 1, -26 },
  { 1734, 23, 26, 24, 1, -26 },
  { 1809, 19, 26, 19, 1, -26 },
  { 1871, 17, 27, 19, 2, -27 },
  { 1929, 15, 26, 15, 1, -26 },
  { 1978, 17, 33, 19, 2, -27 },
  { 2049, 15, 26, 15, 1, -26 },
  { 2098, 16, 27, 14, -1, -27 },
  { 2152, 13, 26, 13, 3, -26 },
  { 2195, 17, 26, 19, 2, -26 },
  { 2251, 15, 26, 15, 3, -26 },
  { 2300, 23, 26, 25, 4, -26 },
  { 2375, 18, 26, 13, -2, -26 },
  { 2434, 13, 26, 13, 3, -26 },
  { 2477, 17, 26, 14, -1, -26 },
  { 2533, 14, 32, 10, -1, -26 },
  { 2589, 5, 26, 12, 4, -26 },
  { 2606, 13, 32, 10, -2, -26 },
  { 2658, 15, 13, 16, 1, -26 },
  { 2683, 11, 1, 11, -3, 4 },
  { 2685, 4, 6, 8, 5, -28 },
  { 2688, 14, 20, 16, 1, -20 },
  { 2723, 14, 28, 16, 1, -28 },
  { 2772, 12, 20, 12, 1, -20 },
  { 2802, 16, 28, 16, 1, -28 },
  { 2858, 12, 20, 14, 1, -20 },
  { 2888, 17, 37, 8, -5, -28 },
  { 2967, 15, 29, 16, 0, -20 },
  { 3022, 13, 28, 15, 1, -28 },
  { 3068, 6, 26, 6, 1, -26 },
  { 3088, 12, 35, 6, -5, -26 },
  { 3141, 14, 28, 13, 0, -28 },
  { 3190, 7, 28, 6, 0, -28 },
  { 3215, 21, 20, 23, 1, -20 },
  { 3268, 13, 20, 15, 1, -20 },
  { 3301, 13, 20, 16, 1, -20 },
  { 3334, 16, 28, 16, -1, -20 },
  { 3390, 14, 29, 16, 1, -20 },
  { 3441, 11, 20, 10, 1, -20 },
  { 3469, 12, 20, 12, 0, -20 },
  { 3499, 8, 24, 8, 1, -24 },
  { 3523, 14, 20, 15, 1, -20 },
  { 3558, 11, 20, 12, 2, -20 },
  { 3586, 19, 20, 19, 2, -20 },
  { 3634, 14, 20, 12, -1, -20 },
  { 3669, 18, 29, 12, -4, -20 },
  { 3735, 13, 20, 11, -1, -20 },
  { 3768, 13, 32, 12, 1, -26 },
  { 3820, 1, 37, 15, 7, -28 },
  { 3825, 12, 32, 12, -2, -26 },
  { 3873, 13, 3, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_THINITALIC37PT7B_H_
