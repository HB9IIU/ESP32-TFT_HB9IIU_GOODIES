#ifndef _NOTOSANS_CONDENSED_THINITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x41, 0x00, 0x00, 0x00, 0x08, 0x20, 0x22, 0x45, 0x12, 0x24, 0x48,
  0x91, 0x44, 0x88, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x40, 0x10,
  0x80, 0x21, 0x00, 0x84, 0x0F, 0xFF, 0x02, 0x10, 0x08, 0x20, 0x10, 0x80,
  0x21, 0x00, 0x42, 0x01, 0x08, 0x02, 0x10, 0x77, 0xBC, 0x10, 0x80, 0x21,
  0x00, 0x42, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x21, 0x00,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x07, 0xF0, 0xC8, 0x04, 0x40, 0x42, 0x02,
  0x10, 0x10, 0x80, 0x88, 0x02, 0x40, 0x0A, 0x00, 0x30, 0x00, 0x80, 0x0A,
  0x00, 0x48, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x23,
  0x16, 0x07, 0xC0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0E, 0x02, 0x12, 0x02,
  0x21, 0x04, 0x41, 0x08, 0x41, 0x08, 0x41, 0x10, 0x82, 0x10, 0x82, 0x20,
  0x82, 0x20, 0x82, 0x40, 0x84, 0x4F, 0x84, 0x91, 0x85, 0x21, 0x89, 0x21,
  0x72, 0x41, 0x02, 0x41, 0x04, 0x41, 0x04, 0x41, 0x08, 0x82, 0x10, 0x82,
  0x10, 0x82, 0x20, 0x84, 0x20, 0x84, 0x40, 0x78, 0x01, 0xC0, 0x11, 0x01,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x40, 0x24,
  0x00, 0xC0, 0x0C, 0x00, 0xA0, 0x08, 0x80, 0x84, 0x28, 0x11, 0x40, 0x94,
  0x04, 0xA0, 0x19, 0x00, 0xC8, 0x04, 0x40, 0x51, 0x04, 0x87, 0xC2, 0x25,
  0x24, 0x94, 0x80, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x00, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x00, 0x04, 0x01, 0x08, 0x41, 0x10,
  0x39, 0xC3, 0x81, 0x40, 0x90, 0xC2, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x12, 0x24, 0x48,
  0x80, 0xFE, 0xC0, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x62, 0x08, 0x10, 0x81,
  0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08,
  0x80, 0x88, 0x10, 0x42, 0x03, 0xC0, 0x02, 0x18, 0x51, 0x2C, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x01, 0xE0, 0x18, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x60,
  0x82, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x80, 0x18, 0x1F, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x62, 0x06, 0x1F, 0xC0,
  0x00, 0x08, 0x00, 0xC0, 0x0A, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x04, 0x40,
  0x22, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81,
  0x08, 0x08, 0x40, 0x47, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xE0, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x42, 0x06, 0x1F, 0xC0, 0x00, 0xF8, 0x18, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x13, 0xE0,
  0xA0, 0x86, 0x02, 0x20, 0x13, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x11, 0x00, 0x88, 0x04, 0x20, 0x41, 0x04, 0x07, 0xC0, 0x3F, 0xF4, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x01, 0xE0, 0x30,
  0x83, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x10,
  0x21, 0x01, 0xB0, 0x06, 0x00, 0xD8, 0x08, 0x60, 0x81, 0x08, 0x04, 0x40,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x20, 0x21, 0x03, 0x07, 0xE0,
  0x01, 0xE0, 0x30, 0x83, 0x04, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24,
  0x01, 0x20, 0x09, 0x00, 0x48, 0x06, 0x40, 0x21, 0x03, 0x0C, 0x28, 0x1E,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x1F, 0x80, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0xC0, 0x04, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x08, 0x21, 0x04, 0x20, 0x80, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x00, 0x1F, 0x08, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x39, 0xC0, 0x30, 0x08, 0x10, 0x02, 0x08, 0x00, 0x42, 0x00,
  0x11, 0x00, 0x04, 0x41, 0xE1, 0x20, 0x84, 0x48, 0x42, 0x14, 0x10, 0x85,
  0x08, 0x21, 0x42, 0x08, 0x51, 0x04, 0x18, 0x41, 0x0A, 0x10, 0x42, 0x84,
  0x30, 0xA1, 0x0C, 0x48, 0x45, 0x32, 0x0E, 0x78, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x08, 0x00, 0xFC, 0x00,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x41, 0x02, 0x08, 0x3F,
  0xC1, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05,
  0x00, 0x30, 0x01, 0x07, 0xC0, 0x41, 0x82, 0x02, 0x10, 0x10, 0x80, 0x88,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x88, 0x18, 0x7F, 0x02, 0x04,
  0x10, 0x10, 0x80, 0x88, 0x02, 0x40, 0x12, 0x00, 0x90, 0x09, 0x00, 0x48,
  0x02, 0x40, 0x22, 0x06, 0x1F, 0xC0, 0x00, 0xF8, 0x0C, 0x10, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0F, 0xE0,
  0x07, 0x00, 0x21, 0xC0, 0x80, 0x82, 0x02, 0x08, 0x04, 0x40, 0x11, 0x00,
  0x44, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x20, 0x08, 0x80,
  0x42, 0x02, 0x08, 0x30, 0x3F, 0x00, 0x07, 0xF8, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x7F, 0xC2, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x03, 0xFC, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x00, 0xFC, 0x03, 0x03, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0xFC, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x40, 0x10, 0x20, 0x20, 0x1F, 0xE0,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x20, 0x04, 0x3F, 0xFC,
  0x20, 0x04, 0x20, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20,
  0x07, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x03, 0xE0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x81, 0xC0, 0x00,
  0x08, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80, 0x82, 0x02, 0x0C, 0x04,
  0x30, 0x08, 0x40, 0x11, 0x00, 0x24, 0x00, 0x90, 0x01, 0x60, 0x03, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x10, 0x40, 0x20, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x04, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x05, 0x0A, 0x00,
  0x28, 0x50, 0x02, 0x42, 0x40, 0x14, 0x12, 0x01, 0x20, 0x90, 0x09, 0x08,
  0x80, 0x88, 0x44, 0x04, 0x42, 0x20, 0x44, 0x11, 0x02, 0x21, 0x08, 0x21,
  0x08, 0x41, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84, 0x10, 0x88, 0x21, 0x02,
  0x41, 0x08, 0x14, 0x08, 0x40, 0xA0, 0x82, 0x06, 0x04, 0x10, 0x20, 0x20,
  0x04, 0x00, 0x86, 0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0xA0, 0x10, 0x90,
  0x08, 0x48, 0x08, 0x24, 0x04, 0x11, 0x02, 0x08, 0x81, 0x08, 0x40, 0x84,
  0x20, 0x82, 0x08, 0x41, 0x04, 0x21, 0x02, 0x10, 0x81, 0x10, 0x40, 0x48,
  0x20, 0x24, 0x10, 0x12, 0x10, 0x09, 0x08, 0x03, 0x04, 0x01, 0x82, 0x00,
  0xC1, 0x00, 0x20, 0x01, 0xE0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x21, 0x00,
  0x44, 0x00, 0x88, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x08, 0x10, 0x20, 0x1F, 0x80,
  0x07, 0x00, 0x43, 0x02, 0x04, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x88, 0x04, 0x40, 0x42, 0x0C, 0x1F, 0x81, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x01, 0xE0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x21, 0x00,
  0x44, 0x00, 0x88, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x08, 0x10, 0x20, 0x1F, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x07, 0x00, 0x43, 0x02, 0x04, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x88, 0x0C, 0x40, 0xC3, 0xD8, 0x11, 0x01, 0x04,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42,
  0x01, 0x10, 0x08, 0x00, 0xF8, 0x06, 0x0C, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x20, 0x10, 0x3F, 0xC0,
  0xFF, 0xE0, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x10, 0x02, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02,
  0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04,
  0x10, 0x08, 0x30, 0x20, 0x3F, 0x80, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00,
  0x48, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x41,
  0x02, 0x08, 0x20, 0x41, 0x02, 0x10, 0x10, 0x80, 0x88, 0x02, 0x40, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x18, 0x05, 0x00, 0xC0, 0x28, 0x06, 0x01, 0x40, 0x50,
  0x12, 0x02, 0x80, 0x90, 0x24, 0x08, 0x81, 0x20, 0x44, 0x09, 0x02, 0x20,
  0x88, 0x21, 0x04, 0x41, 0x08, 0x42, 0x10, 0x42, 0x10, 0x82, 0x20, 0x88,
  0x11, 0x04, 0x40, 0x88, 0x22, 0x04, 0x81, 0x20, 0x24, 0x09, 0x01, 0x40,
  0x50, 0x0A, 0x02, 0x80, 0x60, 0x14, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0x02, 0x01, 0x02, 0x01, 0x02, 0x02, 0x02, 0x04, 0x01, 0x04, 0x01, 0x08,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x00, 0xA0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0x80, 0x20,
  0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x08, 0x82, 0x10, 0x42, 0x10, 0x42,
  0x08, 0x81, 0x10, 0x24, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x07, 0xFE, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xFC, 0x00, 0x84, 0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x82,
  0x10, 0x84, 0x21, 0x04, 0x21, 0x03, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFC,
  0x00, 0x01, 0x00, 0x08, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x04, 0x20, 0x21,
  0x02, 0x04, 0x30, 0x21, 0x00, 0x90, 0x04, 0x80, 0x28, 0x00, 0x80, 0xFF,
  0xC0, 0x91, 0x12, 0x03, 0x80, 0x62, 0x46, 0x0C, 0x20, 0x62, 0x03, 0x10,
  0x19, 0x00, 0x88, 0x04, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04,
  0x40, 0x22, 0x03, 0x10, 0x28, 0x42, 0x81, 0xE4, 0x00, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x1C, 0x0B, 0x10,
  0x60, 0x45, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x88, 0x04, 0x40, 0x26, 0x02, 0x30, 0x11, 0x81, 0x0C, 0x10,
  0x9F, 0x00, 0x03, 0x83, 0x11, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x0F,
  0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0xE2, 0x0C, 0x48, 0x60, 0xC1, 0x01, 0x08, 0x04, 0x20, 0x11,
  0x00, 0x44, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x88, 0x04, 0x20, 0x10,
  0x80, 0xC2, 0x03, 0x08, 0x14, 0x10, 0xD0, 0x3E, 0x80, 0x03, 0x81, 0x88,
  0x60, 0x88, 0x12, 0x02, 0x40, 0x90, 0x12, 0x0C, 0x46, 0x1F, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x1E,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x03, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x18, 0x90, 0xC1, 0x42, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00,
  0x88, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40, 0x21, 0x01,
  0x84, 0x06, 0x10, 0x28, 0x21, 0xA0, 0x79, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x82, 0x01, 0xF0, 0x00, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x8C, 0x0B, 0x10,
  0xC1, 0x08, 0x11, 0x81, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x22,
  0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x04, 0x80, 0x40,
  0x04, 0x10, 0x40, 0x00, 0x00, 0x02, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C,
  0x07, 0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x10, 0x82, 0x10, 0x41, 0x08, 0x11, 0x01, 0x20, 0x16,
  0x02, 0x60, 0x2A, 0x03, 0x20, 0x22, 0x02, 0x10, 0x41, 0x04, 0x10, 0x40,
  0x84, 0x08, 0x80, 0x80, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x80, 0x01, 0xC1, 0xC0, 0xA2, 0x62, 0x0C, 0x18, 0x10, 0x81, 0x81,
  0x18, 0x10, 0x11, 0x01, 0x02, 0x10, 0x10, 0x21, 0x02, 0x02, 0x20, 0x20,
  0x22, 0x02, 0x02, 0x20, 0x20, 0x42, 0x04, 0x04, 0x20, 0x40, 0x44, 0x04,
  0x04, 0x40, 0x40, 0x44, 0x04, 0x08, 0x40, 0x80, 0x88, 0x08, 0x08, 0x00,
  0xC0, 0xB1, 0x0C, 0x10, 0x81, 0x18, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20,
  0x12, 0x02, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40,
  0x4C, 0x04, 0x03, 0x80, 0xC4, 0x18, 0x21, 0x02, 0x20, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x48, 0x08, 0x41, 0x03, 0xE0, 0x00, 0x70, 0x16, 0x20, 0x60, 0x42, 0x81,
  0x0C, 0x04, 0x30, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x84, 0x02, 0x10, 0x08, 0xC0, 0x43, 0x01, 0x0C, 0x08, 0x30, 0x40, 0xBE,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x03, 0x80, 0x62, 0x46, 0x0A, 0x20, 0x62, 0x01, 0x10,
  0x09, 0x00, 0x48, 0x04, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x04,
  0x40, 0x22, 0x03, 0x10, 0x28, 0x43, 0x41, 0xE4, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0xC2,
  0xC0, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x00, 0x07, 0x03, 0x0C,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x82, 0x1F, 0x80, 0x08, 0x10,
  0x40, 0x81, 0x0F, 0xC8, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x1E, 0x00, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02,
  0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x48, 0x04,
  0x80, 0x88, 0x08, 0x81, 0x88, 0x28, 0x7C, 0x80, 0x80, 0x60, 0x28, 0x0A,
  0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x22, 0x08, 0x82, 0x40, 0x90,
  0x28, 0x0A, 0x01, 0x00, 0x40, 0x00, 0x80, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x88,
  0x90, 0x90, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x80, 0x80, 0x08, 0x18, 0x40, 0x82, 0x08, 0x08, 0x80, 0x44,
  0x02, 0x40, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x02, 0x40, 0x32, 0x01,
  0x10, 0x10, 0x41, 0x02, 0x08, 0x10, 0x80, 0xC0, 0x02, 0x01, 0x02, 0x01,
  0x02, 0x02, 0x01, 0x02, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x0F, 0xE0,
  0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0xFF, 0x00, 0x00, 0x20,
  0x38, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x38, 0x03, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x18, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x0F, 0x00, 0x3C,
  0x0E, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_Condensed_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 7, 9, 9, 3, -24 },
  { 27, 15, 24, 15, 0, -24 },
  { 72, 13, 27, 13, 0, -25 },
  { 116, 16, 24, 20, 2, -24 },
  { 164, 13, 24, 14, 0, -24 },
  { 203, 3, 9, 5, 3, -24 },
  { 207, 9, 28, 8, 1, -23 },
  { 239, 9, 28, 8, -2, -23 },
  { 271, 10, 10, 13, 4, -25 },
  { 284, 13, 15, 15, 1, -19 },
  { 309, 4, 7, 5, -1, -3 },
  { 313, 7, 1, 9, 1, -9 },
  { 314, 1, 2, 6, 1, -2 },
  { 315, 13, 24, 10, -1, -24 },
  { 354, 12, 24, 13, 1, -24 },
  { 390, 7, 24, 13, 4, -24 },
  { 411, 14, 24, 13, -1, -24 },
  { 453, 13, 24, 13, 0, -24 },
  { 492, 13, 24, 13, 0, -24 },
  { 531, 13, 24, 13, 0, -24 },
  { 570, 13, 24, 13, 1, -24 },
  { 609, 12, 24, 13, 2, -24 },
  { 645, 13, 24, 13, 0, -24 },
  { 684, 13, 24, 13, 0, -24 },
  { 723, 5, 17, 6, 0, -17 },
  { 734, 6, 21, 6, -1, -17 },
  { 750, 13, 14, 15, 1, -19 },
  { 773, 13, 8, 15, 1, -16 },
  { 786, 13, 14, 15, 1, -19 },
  { 809, 10, 24, 10, 1, -24 },
  { 839, 18, 27, 20, 1, -24 },
  { 900, 13, 24, 13, -2, -24 },
  { 939, 13, 24, 15, 1, -24 },
  { 978, 14, 24, 14, 2, -24 },
  { 1020, 14, 24, 16, 1, -24 },
  { 1062, 13, 24, 13, 1, -24 },
  { 1101, 13, 24, 12, 1, -24 },
  { 1140, 16, 24, 17, 2, -24 },
  { 1188, 16, 24, 17, 1, -24 },
  { 1236, 10, 24, 7, -1, -24 },
  { 1266, 11, 30, 6, -5, -24 },
  { 1308, 15, 24, 13, 1, -24 },
  { 1353, 8, 24, 12, 1, -24 },
  { 1377, 21, 24, 22, 1, -24 },
  { 1440, 17, 24, 17, 1, -24 },
  { 1491, 15, 24, 17, 2, -24 },
  { 1536, 13, 24, 14, 1, -24 },
  { 1575, 15, 30, 17, 2, -24 },
  { 1632, 13, 24, 14, 1, -24 },
  { 1671, 15, 24, 13, -1, -24 },
  { 1716, 11, 24, 12, 3, -24 },
  { 1749, 15, 24, 17, 2, -24 },
  { 1794, 13, 24, 13, 3, -24 },
  { 1833, 21, 24, 22, 3, -24 },
  { 1896, 16, 24, 12, -2, -24 },
  { 1944, 11, 24, 11, 3, -24 },
  { 1977, 15, 24, 12, -1, -24 },
  { 2022, 12, 29, 9, -1, -24 },
  { 2066, 5, 24, 10, 3, -24 },
  { 2081, 12, 29, 9, -2, -24 },
  { 2125, 13, 13, 14, 1, -24 },
  { 2147, 10, 1, 10, -3, 3 },
  { 2149, 3, 5, 7, 5, -25 },
  { 2151, 13, 18, 14, 1, -18 },
  { 2181, 13, 25, 14, 0, -25 },
  { 2222, 10, 18, 11, 1, -18 },
  { 2245, 14, 25, 14, 1, -25 },
  { 2289, 11, 18, 12, 1, -18 },
  { 2314, 15, 33, 7, -4, -25 },
  { 2376, 14, 26, 14, 0, -18 },
  { 2422, 12, 25, 14, 0, -25 },
  { 2460, 6, 24, 6, 0, -24 },
  { 2478, 11, 32, 6, -4, -24 },
  { 2522, 12, 25, 11, 0, -25 },
  { 2560, 7, 25, 5, 0, -25 },
  { 2582, 20, 18, 21, 0, -18 },
  { 2627, 12, 18, 14, 0, -18 },
  { 2654, 12, 18, 14, 1, -18 },
  { 2681, 14, 26, 14, -1, -18 },
  { 2727, 13, 26, 14, 1, -18 },
  { 2770, 10, 18, 9, 0, -18 },
  { 2793, 11, 18, 11, 0, -18 },
  { 2818, 7, 22, 7, 1, -22 },
  { 2838, 12, 17, 14, 1, -17 },
  { 2864, 10, 17, 10, 2, -17 },
  { 2886, 16, 17, 17, 2, -17 },
  { 2920, 13, 17, 11, -1, -17 },
  { 2948, 16, 25, 11, -4, -17 },
  { 2998, 11, 17, 10, -1, -17 },
  { 3022, 11, 29, 10, 1, -24 },
  { 3062, 1, 33, 13, 6, -25 },
  { 3067, 11, 29, 10, -2, -24 },
  { 3107, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_THINITALIC33PT7B_H_
