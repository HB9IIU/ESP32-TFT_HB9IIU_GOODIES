#ifndef _NOTOSANS_CONDENSED_THINITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x24, 0x44, 0x00, 0x80, 0xB6, 0xDA, 0x09, 0x09,
  0x0A, 0x12, 0x7F, 0x14, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x48, 0x90, 0x04,
  0x08, 0x69, 0x42, 0x85, 0x0A, 0x08, 0x18, 0x28, 0x50, 0xAF, 0x84, 0x08,
  0x00, 0x31, 0x24, 0xA2, 0x92, 0x49, 0x44, 0xAA, 0xAB, 0xE9, 0x14, 0x92,
  0x4A, 0x29, 0x24, 0x70, 0x1C, 0x24, 0x89, 0x22, 0x43, 0x0C, 0x25, 0x8B,
  0x16, 0x14, 0x67, 0x40, 0xF8, 0x08, 0x44, 0x42, 0x21, 0x08, 0x84, 0x21,
  0x08, 0x21, 0x08, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x21,
  0x10, 0x14, 0x9A, 0x65, 0x48, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08,
  0x10, 0x56, 0xF0, 0x80, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x94, 0x51, 0x86, 0x18, 0x61, 0x86,
  0x28, 0xA4, 0xE0, 0x35, 0xA2, 0x22, 0x24, 0x44, 0x44, 0x80, 0x3C, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x0F, 0x80, 0x3C, 0x04,
  0x08, 0x10, 0x20, 0x8E, 0x02, 0x04, 0x08, 0x10, 0x2F, 0x80, 0x02, 0x0C,
  0x28, 0x51, 0x44, 0x89, 0x22, 0x85, 0xFC, 0x20, 0x40, 0x80, 0x1E, 0x40,
  0x81, 0x04, 0x0F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x2F, 0x80, 0x1E, 0x41,
  0x02, 0x08, 0x1E, 0x22, 0x42, 0x85, 0x0A, 0x24, 0x4F, 0x00, 0x7E, 0x04,
  0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x00, 0x1C, 0x44,
  0x89, 0x12, 0x22, 0x8E, 0x22, 0x85, 0x0A, 0x14, 0x27, 0x80, 0x1C, 0x45,
  0x0A, 0x14, 0x28, 0x51, 0x9D, 0x04, 0x08, 0x20, 0x4F, 0x00, 0x24, 0x00,
  0x00, 0x10, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x06, 0x31, 0x84, 0x06,
  0x02, 0x03, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x20, 0x30, 0x86,
  0x30, 0x00, 0x70, 0x42, 0x11, 0x10, 0x88, 0x84, 0x00, 0x08, 0x00, 0x0F,
  0x04, 0x22, 0x05, 0x01, 0x8E, 0x64, 0x9A, 0x26, 0x92, 0xA4, 0xA9, 0x2B,
  0xF2, 0x00, 0x80, 0x30, 0x03, 0x80, 0x02, 0x08, 0x28, 0x50, 0xA2, 0x44,
  0x9F, 0x22, 0x85, 0x0C, 0x18, 0x20, 0x1E, 0x21, 0x21, 0x21, 0x21, 0x22,
  0x5C, 0x42, 0x42, 0x42, 0x42, 0x84, 0xF8, 0x1F, 0x20, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78, 0x1E, 0x21, 0x21, 0x21,
  0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x84, 0xF8, 0x1F, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x5C, 0x40, 0x40, 0x40, 0x40, 0x80, 0xF8, 0x1F, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x7C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1F,
  0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x19, 0x02, 0x82, 0x41, 0x20, 0x90,
  0x47, 0xC0, 0x10, 0x90, 0x48, 0x24, 0x12, 0x09, 0x09, 0x7C, 0x82, 0x41,
  0x20, 0x90, 0x90, 0x48, 0x20, 0x1C, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x10, 0xE0, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x70, 0x10, 0x90, 0x88, 0x84, 0x82, 0x81, 0x81,
  0xC0, 0x90, 0x48, 0x24, 0x11, 0x10, 0x88, 0x40, 0x11, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x0F, 0x80, 0x10, 0x11, 0x03, 0x10, 0x23, 0x06, 0x30,
  0x63, 0x0A, 0x48, 0xA4, 0x92, 0x49, 0x44, 0xA4, 0x4A, 0x48, 0xC4, 0x88,
  0x40, 0x10, 0x44, 0x13, 0x08, 0xA2, 0x28, 0x8A, 0x24, 0x91, 0x14, 0x45,
  0x11, 0x44, 0x52, 0x08, 0x82, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x78, 0x1E, 0x21, 0x21, 0x21, 0x21,
  0x22, 0x44, 0x78, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x21, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x68, 0x10, 0x10, 0x08,
  0x1E, 0x21, 0x21, 0x21, 0x21, 0x22, 0x74, 0x48, 0x48, 0x48, 0x44, 0x84,
  0x84, 0x1E, 0x41, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x10, 0x2F,
  0x80, 0xFC, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x80, 0x21,
  0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78,
  0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50, 0xA1, 0x43, 0x04, 0x08, 0x00,
  0x84, 0x30, 0x86, 0x30, 0xC6, 0x29, 0x45, 0x29, 0x29, 0x25, 0x28, 0xA5,
  0x18, 0xA2, 0x18, 0x42, 0x08, 0x40, 0x10, 0x88, 0x84, 0x41, 0x40, 0xC0,
  0x40, 0x20, 0x30, 0x14, 0x12, 0x11, 0x08, 0x88, 0x40, 0x86, 0x28, 0xA4,
  0x92, 0x8C, 0x10, 0x82, 0x08, 0x20, 0x80, 0x1F, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0F, 0xC0, 0x1C, 0x42,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x38, 0xAA, 0xA5,
  0x55, 0x40, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x38, 0x10, 0x50, 0xA2, 0x44, 0x50, 0xA0, 0x80, 0xF8, 0xE0, 0x39,
  0x14, 0x61, 0x86, 0x18, 0xA2, 0x8B, 0xE0, 0x10, 0x20, 0x81, 0x02, 0xC6,
  0x48, 0xA1, 0x42, 0x85, 0x0A, 0x24, 0x5F, 0x00, 0x3A, 0x11, 0x08, 0x42,
  0x10, 0x87, 0x80, 0x02, 0x04, 0x08, 0x13, 0xA8, 0x91, 0x42, 0x85, 0x0A,
  0x24, 0x48, 0x9F, 0x00, 0x3A, 0x53, 0x19, 0x72, 0x10, 0x87, 0x80, 0x03,
  0x04, 0x04, 0x08, 0x1C, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0xC0, 0x1D, 0x22, 0x22, 0x42, 0x42, 0x42, 0x84,
  0x84, 0x44, 0x7C, 0x04, 0x08, 0x08, 0xF0, 0x10, 0x20, 0x81, 0x02, 0xC6,
  0x48, 0xA1, 0x42, 0x89, 0x12, 0x28, 0x50, 0x80, 0x10, 0x00, 0x22, 0x44,
  0x44, 0x48, 0x80, 0x04, 0x00, 0x00, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x10, 0xC0, 0x10, 0x20, 0x81, 0x02, 0x24, 0x8A, 0x28, 0x50,
  0xE1, 0x44, 0x48, 0x91, 0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x48, 0x88,
  0x0C, 0xC6, 0x64, 0x88, 0xA1, 0x14, 0x42, 0x88, 0x91, 0x12, 0x22, 0x88,
  0x51, 0x10, 0x0C, 0x64, 0x8A, 0x14, 0x28, 0x91, 0x22, 0x85, 0x08, 0x39,
  0x14, 0x61, 0x86, 0x18, 0x62, 0x8B, 0xC0, 0x06, 0x19, 0x11, 0x21, 0x21,
  0x21, 0x21, 0x22, 0x42, 0x7C, 0x40, 0x40, 0x80, 0x80, 0x3A, 0x89, 0x14,
  0x28, 0x50, 0xA2, 0x44, 0x89, 0xF0, 0x20, 0x81, 0x02, 0x00, 0x0C, 0xC2,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x3D, 0x04, 0x10, 0x20, 0x41, 0x02,
  0x0B, 0xC0, 0x22, 0x72, 0x44, 0x44, 0x48, 0x8E, 0x46, 0x18, 0x61, 0x8A,
  0x28, 0xA4, 0xE8, 0x8E, 0x29, 0x24, 0xA2, 0x8C, 0x30, 0x80, 0x88, 0xC4,
  0xA6, 0x55, 0x2A, 0xA6, 0x53, 0x31, 0x08, 0x88, 0x00, 0x23, 0x14, 0x14,
  0x08, 0x10, 0x28, 0x28, 0x48, 0x84, 0x10, 0x88, 0x84, 0x42, 0x41, 0x20,
  0xA0, 0x50, 0x10, 0x08, 0x08, 0x04, 0x04, 0x0E, 0x00, 0x3C, 0x21, 0x04,
  0x21, 0x04, 0x20, 0xF0, 0x0C, 0x42, 0x08, 0x20, 0x84, 0x10, 0xC1, 0x04,
  0x20, 0x82, 0x08, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x0C, 0x41, 0x04, 0x20, 0x82, 0x30, 0xFE,
};

const GFXglyph NotoSans_Condensed_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 3, 5, 5, 2, -13 },
  { 10, 8, 13, 8, 0, -13 },
  { 23, 7, 15, 7, 0, -14 },
  { 37, 9, 13, 11, 1, -13 },
  { 52, 7, 13, 8, 0, -13 },
  { 64, 1, 5, 3, 2, -13 },
  { 65, 5, 16, 4, 0, -13 },
  { 75, 5, 16, 4, -1, -13 },
  { 85, 5, 6, 7, 2, -14 },
  { 89, 7, 9, 8, 1, -11 },
  { 97, 2, 4, 3, -1, -2 },
  { 98, 4, 1, 5, 0, -5 },
  { 99, 1, 1, 3, 0, -1 },
  { 100, 8, 13, 5, -1, -13 },
  { 113, 6, 13, 7, 1, -13 },
  { 123, 4, 13, 7, 2, -13 },
  { 130, 7, 13, 7, 0, -13 },
  { 142, 7, 13, 7, 0, -13 },
  { 154, 7, 13, 7, 0, -13 },
  { 166, 7, 13, 7, 0, -13 },
  { 178, 7, 13, 7, 1, -13 },
  { 190, 7, 13, 7, 1, -13 },
  { 202, 7, 13, 7, 0, -13 },
  { 214, 7, 13, 7, 0, -13 },
  { 226, 3, 10, 3, 0, -10 },
  { 230, 4, 12, 3, -1, -10 },
  { 236, 7, 7, 8, 1, -10 },
  { 243, 7, 4, 8, 1, -8 },
  { 247, 7, 7, 8, 1, -10 },
  { 254, 5, 13, 5, 1, -13 },
  { 263, 10, 15, 11, 1, -13 },
  { 282, 7, 13, 7, -1, -13 },
  { 294, 8, 13, 8, 0, -13 },
  { 307, 8, 13, 7, 1, -13 },
  { 320, 8, 13, 9, 0, -13 },
  { 333, 8, 13, 7, 0, -13 },
  { 346, 8, 13, 7, 0, -13 },
  { 359, 9, 13, 9, 1, -13 },
  { 374, 9, 13, 9, 0, -13 },
  { 389, 6, 13, 4, -1, -13 },
  { 399, 7, 16, 3, -3, -13 },
  { 413, 9, 13, 7, 0, -13 },
  { 428, 5, 13, 6, 0, -13 },
  { 437, 12, 13, 12, 0, -13 },
  { 457, 10, 13, 9, 0, -13 },
  { 474, 8, 13, 9, 1, -13 },
  { 487, 8, 13, 7, 0, -13 },
  { 500, 8, 16, 9, 1, -13 },
  { 516, 8, 13, 8, 0, -13 },
  { 529, 7, 13, 7, 0, -13 },
  { 541, 6, 13, 6, 2, -13 },
  { 551, 8, 13, 9, 1, -13 },
  { 564, 7, 13, 7, 2, -13 },
  { 576, 11, 13, 12, 2, -13 },
  { 594, 9, 13, 6, -1, -13 },
  { 609, 6, 13, 6, 2, -13 },
  { 619, 9, 13, 7, -1, -13 },
  { 634, 6, 16, 5, 0, -13 },
  { 646, 2, 13, 6, 2, -13 },
  { 650, 6, 16, 5, -1, -13 },
  { 662, 7, 7, 8, 1, -13 },
  { 669, 5, 1, 5, -1, 1 },
  { 670, 1, 3, 4, 3, -14 },
  { 671, 6, 10, 8, 1, -10 },
  { 679, 7, 14, 8, 0, -14 },
  { 692, 5, 10, 6, 1, -10 },
  { 699, 7, 14, 8, 1, -14 },
  { 712, 5, 10, 7, 1, -10 },
  { 719, 8, 18, 4, -2, -14 },
  { 737, 8, 14, 8, 0, -10 },
  { 751, 7, 14, 7, 0, -14 },
  { 764, 4, 13, 3, 0, -13 },
  { 771, 6, 17, 3, -2, -13 },
  { 784, 7, 14, 6, 0, -14 },
  { 797, 4, 14, 3, 0, -14 },
  { 804, 11, 10, 11, 0, -10 },
  { 818, 7, 10, 7, 0, -10 },
  { 827, 6, 10, 8, 1, -10 },
  { 835, 8, 14, 8, -1, -10 },
  { 849, 7, 14, 8, 1, -10 },
  { 862, 6, 10, 5, 0, -10 },
  { 870, 6, 10, 6, 0, -10 },
  { 878, 4, 12, 4, 0, -12 },
  { 884, 6, 9, 7, 1, -9 },
  { 891, 6, 9, 6, 1, -9 },
  { 898, 9, 9, 9, 1, -9 },
  { 909, 8, 9, 6, -1, -9 },
  { 918, 9, 13, 6, -2, -9 },
  { 933, 6, 9, 5, 0, -9 },
  { 940, 6, 16, 6, 1, -13 },
  { 952, 1, 18, 7, 3, -14 },
  { 955, 6, 16, 6, -1, -13 },
  { 967, 7, 1, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_THINITALIC18PT7B_H_
