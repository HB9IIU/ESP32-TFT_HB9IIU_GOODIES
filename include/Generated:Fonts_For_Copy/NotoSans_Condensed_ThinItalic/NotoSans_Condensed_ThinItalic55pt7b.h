#ifndef _NOTOSANS_CONDENSED_THINITALIC55PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x31, 0x02, 0x10, 0x63,
  0x06, 0x30, 0x42, 0x04, 0x20, 0x42, 0x0C, 0x60, 0x86, 0x08, 0x40, 0x84,
  0x08, 0x41, 0x8C, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x08,
  0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x10, 0x00, 0x20, 0x30, 0x00, 0x60,
  0x20, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x40, 0x60, 0x00, 0xC0,
  0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x02, 0x03,
  0x00, 0x02, 0x03, 0x00, 0x06, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x06,
  0x00, 0x0C, 0x04, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0x18, 0x08, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10,
  0x00, 0x20, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x33, 0xC0, 0x30, 0xC1, 0x01,
  0x82, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x10, 0x00, 0x60, 0x40, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00,
  0x0C, 0x20, 0x00, 0x18, 0x80, 0x00, 0x32, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x16, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x18, 0x00, 0x08, 0x30, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00,
  0x06, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x04,
  0x08, 0x00, 0x30, 0x60, 0x00, 0x83, 0x03, 0x02, 0x18, 0x07, 0xFF, 0xC0,
  0x02, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x40, 0x7E, 0x00, 0x10,
  0x18, 0x60, 0x06, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x80, 0x20, 0x30, 0x10,
  0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x40, 0x60, 0x20, 0x08, 0x08, 0x04,
  0x03, 0x03, 0x01, 0x80, 0x60, 0x40, 0x30, 0x0C, 0x18, 0x04, 0x01, 0x06,
  0x00, 0x80, 0x20, 0x80, 0x10, 0x0C, 0x30, 0x06, 0x01, 0x84, 0x00, 0xC0,
  0x21, 0x87, 0x98, 0x04, 0x21, 0xFB, 0x01, 0x8C, 0x61, 0xE0, 0x23, 0x18,
  0x3C, 0x0C, 0x46, 0x02, 0x81, 0x18, 0xC0, 0x58, 0x42, 0x10, 0x0B, 0xF8,
  0xC6, 0x01, 0x1C, 0x10, 0x80, 0x60, 0x06, 0x30, 0x0C, 0x01, 0x86, 0x01,
  0x80, 0x20, 0xC0, 0x30, 0x0C, 0x10, 0x04, 0x01, 0x02, 0x00, 0x80, 0x60,
  0x40, 0x30, 0x08, 0x18, 0x06, 0x03, 0x03, 0x00, 0x80, 0x40, 0x60, 0x10,
  0x10, 0x0C, 0x06, 0x06, 0x01, 0x80, 0x80, 0x80, 0x30, 0x30, 0x30, 0x02,
  0x0C, 0x04, 0x00, 0x61, 0x01, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x03, 0x06, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x20, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x08, 0x00, 0x80,
  0x20, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x20, 0x10, 0x00, 0x80, 0xC0,
  0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x11, 0x80, 0x00, 0x4C, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x40,
  0x00, 0x61, 0x80, 0x03, 0x02, 0x01, 0x18, 0x0C, 0x0C, 0x40, 0x30, 0x23,
  0x00, 0x40, 0x98, 0x01, 0x86, 0x60, 0x02, 0x11, 0x00, 0x0C, 0xC4, 0x00,
  0x32, 0x30, 0x00, 0x58, 0xC0, 0x01, 0xC3, 0x00, 0x02, 0x0C, 0x00, 0x18,
  0x10, 0x00, 0xF0, 0x60, 0x06, 0x41, 0x80, 0x31, 0x83, 0x03, 0x82, 0x07,
  0xFC, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x84, 0x63, 0x10, 0x84, 0x63, 0x10,
  0x84, 0x60, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x80, 0x80,
  0xC0, 0x80, 0x31, 0x00, 0x19, 0x03, 0x07, 0x7F, 0x01, 0x80, 0x06, 0x80,
  0x0C, 0x80, 0x18, 0x40, 0x30, 0x40, 0xC0, 0x60, 0x40, 0x20, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF,
  0x80, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x06, 0x18, 0x30, 0x41,
  0x82, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x00, 0xFF, 0xFF, 0xFE, 0x5F, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0xC0, 0x08, 0x06, 0x01, 0x00,
  0x20, 0x30, 0x02, 0x02, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00, 0x03, 0x30,
  0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01,
  0x88, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00,
  0x40, 0xC0, 0x0C, 0x0C, 0x00, 0x80, 0x40, 0x18, 0x06, 0x03, 0x00, 0x30,
  0x60, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x1D, 0x06,
  0x61, 0x8C, 0xE1, 0x30, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0x80, 0x60, 0x04, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xE0, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00, 0x02, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x06, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x02, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40, 0x03, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x10, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x40, 0x02, 0x01,
  0x80, 0x04, 0x06, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0x20, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x80, 0x0C, 0x03, 0x00, 0xE0, 0x07, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0xFC, 0x01,
  0x1E, 0x70, 0x09, 0x80, 0xC0, 0xD0, 0x03, 0x05, 0x00, 0x08, 0x38, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x06,
  0x10, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80,
  0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x80, 0x06, 0x03, 0x00, 0x30, 0x02, 0x01, 0x80, 0x0C,
  0x04, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x04, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x20, 0x18, 0x00, 0xC0, 0xC0, 0x01, 0x8E, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xEC, 0x00, 0x0E, 0x18, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x60, 0x18, 0x00, 0x80, 0xC0, 0x03, 0x02, 0x00, 0x04,
  0x18, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x30, 0x18, 0x03,
  0x00, 0x40, 0x30, 0x03, 0x03, 0x00, 0x08, 0x18, 0x00, 0x41, 0x80, 0x02,
  0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x30,
  0x80, 0x01, 0x84, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x0E, 0x06, 0x00,
  0xD0, 0x18, 0x1D, 0x80, 0x7F, 0x8C, 0x00, 0xF0, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x02, 0x07, 0x00, 0x1F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x07, 0x06, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0xC0, 0xC0, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0xF8, 0x18, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00,
  0x43, 0x00, 0x3F, 0x81, 0x18, 0x03, 0x8C, 0x04, 0x60, 0x18, 0x10, 0x11,
  0x00, 0xC0, 0xC0, 0x4C, 0x06, 0x03, 0x01, 0x20, 0x10, 0x08, 0x04, 0x80,
  0xC0, 0x20, 0x36, 0x02, 0x01, 0x80, 0xD8, 0x18, 0x06, 0x03, 0x40, 0x40,
  0x10, 0x09, 0x01, 0x00, 0x40, 0x2C, 0x0C, 0x03, 0x01, 0xB0, 0x30, 0x0C,
  0x06, 0xC0, 0x80, 0x20, 0x13, 0x02, 0x01, 0x80, 0xC8, 0x08, 0x06, 0x02,
  0x20, 0x20, 0x38, 0x18, 0x80, 0x80, 0xA0, 0x42, 0x03, 0x06, 0x83, 0x08,
  0x0C, 0x32, 0x18, 0x20, 0x1F, 0x8F, 0xC0, 0x80, 0x3C, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00,
  0x66, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20,
  0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x20,
  0x10, 0x03, 0x00, 0x80, 0x18, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x08, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0x00, 0x10, 0x10, 0x00,
  0xC1, 0x80, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x02,
  0xC0, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xE0, 0x01, 0x00, 0x70, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x18,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00,
  0x02, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0x20, 0x20, 0x00,
  0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60,
  0x18, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0x60, 0x1C, 0x00, 0x80, 0x0C, 0x01,
  0x00, 0x0C, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x20,
  0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00,
  0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0x81, 0x00, 0x03, 0x02, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x18, 0x0F, 0x80,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xE0,
  0x08, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x78, 0x00, 0x20, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x0C,
  0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00,
  0x60, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x60,
  0x00, 0x08, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x08, 0x00, 0x02, 0x04,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x80,
  0x80, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x10, 0x00, 0xE0, 0x08, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x06, 0x0F, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0x1C,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20,
  0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08,
  0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x10, 0x10, 0x00, 0x04, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x08, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x02, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10,
  0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0x20, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x10, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x40, 0x01, 0x80, 0x20, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x02, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x40,
  0xC0, 0x00, 0x20, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x68, 0x00, 0x01,
  0xA6, 0x00, 0x00, 0xA3, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x10, 0x08, 0x00, 0x08, 0x06, 0x00, 0x04, 0x03, 0x00,
  0x06, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x80, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00,
  0x40, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x04, 0x02, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x14, 0x02, 0xC0, 0x00,
  0x06, 0x80, 0x48, 0x00, 0x00, 0xB0, 0x09, 0x00, 0x00, 0x36, 0x03, 0x20,
  0x00, 0x04, 0xC0, 0x64, 0x00, 0x01, 0x90, 0x08, 0x80, 0x00, 0x62, 0x01,
  0x10, 0x00, 0x0C, 0xC0, 0x22, 0x00, 0x03, 0x18, 0x0C, 0x60, 0x00, 0x62,
  0x01, 0x8C, 0x00, 0x18, 0x40, 0x21, 0x80, 0x03, 0x08, 0x04, 0x30, 0x00,
  0xC3, 0x01, 0x82, 0x00, 0x10, 0x60, 0x30, 0x40, 0x06, 0x08, 0x06, 0x08,
  0x00, 0x81, 0x00, 0x81, 0x00, 0x30, 0x60, 0x10, 0x20, 0x04, 0x0C, 0x06,
  0x04, 0x01, 0x81, 0x80, 0xC0, 0x80, 0x20, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x01, 0x80, 0x40, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x08,
  0x04, 0x03, 0x00, 0x83, 0x00, 0x80, 0x40, 0x10, 0x40, 0x10, 0x08, 0x02,
  0x18, 0x06, 0x03, 0x00, 0x42, 0x00, 0xC0, 0x60, 0x08, 0xC0, 0x10, 0x0C,
  0x01, 0x10, 0x02, 0x01, 0x00, 0x26, 0x00, 0x40, 0x20, 0x06, 0x80, 0x18,
  0x0C, 0x00, 0xF0, 0x03, 0x01, 0x80, 0x1C, 0x00, 0x40, 0x20, 0x03, 0x80,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x30, 0x1E, 0x00, 0x03, 0x01, 0xA0, 0x00, 0x20, 0x12, 0x00, 0x02, 0x01,
  0x30, 0x00, 0x60, 0x13, 0x00, 0x06, 0x03, 0x10, 0x00, 0x40, 0x31, 0x00,
  0x04, 0x02, 0x18, 0x00, 0x40, 0x21, 0x80, 0x0C, 0x02, 0x08, 0x00, 0xC0,
  0x60, 0x80, 0x08, 0x06, 0x0C, 0x00, 0x80, 0x40, 0xC0, 0x18, 0x04, 0x04,
  0x01, 0x80, 0xC0, 0x40, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10,
  0x08, 0x02, 0x03, 0x00, 0x80, 0x20, 0x30, 0x18, 0x03, 0x02, 0x01, 0x80,
  0x30, 0x20, 0x10, 0x01, 0x02, 0x01, 0x00, 0x10, 0x60, 0x10, 0x01, 0x86,
  0x03, 0x00, 0x18, 0x40, 0x30, 0x00, 0x84, 0x02, 0x00, 0x0C, 0x40, 0x20,
  0x00, 0xCC, 0x06, 0x00, 0x04, 0xC0, 0x60, 0x00, 0x48, 0x06, 0x00, 0x06,
  0x80, 0x40, 0x00, 0x78, 0x04, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x43, 0x00, 0x00, 0x31, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x06, 0x40, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x70, 0x38, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x02, 0x03, 0xC0, 0x08, 0x03,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x10, 0x00, 0x40,
  0x40, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80,
  0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x00, 0x06,
  0x04, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x70, 0x08,
  0x0F, 0x00, 0x3F, 0xF0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1C,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18, 0x08,
  0x00, 0x0C, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x31, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x40, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x61, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x70, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x02, 0x03, 0xC0, 0x08, 0x03, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x10, 0x00, 0x40, 0x40, 0x01,
  0x03, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x03, 0x02,
  0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00,
  0x30, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0xE0, 0x0F, 0xFE, 0x00,
  0x20, 0x20, 0x01, 0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x40,
  0x30, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x30, 0x06, 0x00, 0x80, 0x18,
  0x02, 0x00, 0x20, 0x08, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x04,
  0x00, 0x30, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x06, 0x08, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x70, 0x07, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x80, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x10, 0x20, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00,
  0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x03, 0x02,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x40,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x60,
  0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x41,
  0x80, 0x06, 0x0C, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00,
  0x80, 0x40, 0x0C, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04,
  0x03, 0x00, 0x20, 0x10, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0xC0,
  0x02, 0x04, 0x00, 0x10, 0x60, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x21,
  0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x64, 0x00, 0x03, 0x60, 0x00,
  0x1A, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0x60, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x09,
  0x80, 0x02, 0xC0, 0x01, 0x30, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x13, 0x00,
  0x08, 0xC0, 0x02, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x43, 0x00, 0x11,
  0x80, 0x18, 0x60, 0x06, 0x30, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x41, 0x80,
  0x30, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x02, 0x06, 0x00, 0x83, 0x00, 0xC0,
  0xC0, 0x30, 0x60, 0x10, 0x18, 0x04, 0x0C, 0x02, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x10, 0x0C, 0x04, 0x06, 0x06, 0x01, 0x81, 0x80,
  0xC0, 0x80, 0x30, 0x20, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC1,
  0x00, 0x60, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x84, 0x00,
  0x61, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x20, 0x01, 0x88, 0x00, 0xC4,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0x40, 0x03, 0x20, 0x00, 0xC8, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x78,
  0x00, 0x2C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x18,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x80, 0x03, 0x00, 0x30, 0x00, 0x20,
  0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x08, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x04, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x10, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x20, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x80, 0x30, 0x00, 0x18, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x02,
  0x60, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06, 0x10, 0x01, 0x82, 0x00, 0x20,
  0x60, 0x0C, 0x0C, 0x01, 0x01, 0x80, 0x60, 0x10, 0x18, 0x02, 0x03, 0x00,
  0x40, 0xC0, 0x08, 0x10, 0x01, 0x86, 0x00, 0x30, 0x80, 0x02, 0x30, 0x00,
  0x4C, 0x00, 0x09, 0x00, 0x01, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0x40, 0x81, 0x02, 0x06,
  0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x30,
  0x60, 0xC0, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x00, 0x00,
  0xCC, 0x00, 0x04, 0x60, 0x00, 0x61, 0x00, 0x02, 0x0C, 0x00, 0x30, 0x20,
  0x01, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x20, 0x08, 0x01, 0x80, 0xC0,
  0x04, 0x04, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x33,
  0x00, 0x01, 0x90, 0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC2, 0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0x08, 0x00, 0x03, 0xF8, 0xC0,
  0x70, 0x64, 0x06, 0x01, 0x20, 0x60, 0x0D, 0x06, 0x00, 0x38, 0x20, 0x01,
  0xC3, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40,
  0x00, 0x86, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x18,
  0xC0, 0x00, 0x86, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00,
  0x18, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06,
  0x00, 0x70, 0x10, 0x06, 0x80, 0xC0, 0x64, 0x03, 0x06, 0x20, 0x0F, 0xE3,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x20, 0x01, 0x0F, 0xE0, 0x09, 0xC1, 0x80, 0xD8, 0x06, 0x07, 0x80,
  0x30, 0x28, 0x00, 0x81, 0xC0, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x02, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x06, 0x00, 0x18, 0x38, 0x00, 0x83, 0x40, 0x0C, 0x1B, 0x00,
  0xC0, 0x8C, 0x1C, 0x04, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x3F, 0xC0, 0x70, 0x20, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x81, 0x00, 0xFF,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x08, 0x08, 0x00, 0x7F, 0x18, 0x01, 0xC1, 0x98,
  0x03, 0x00, 0xD0, 0x06, 0x00, 0x50, 0x0C, 0x00, 0x50, 0x08, 0x00, 0x70,
  0x18, 0x00, 0x70, 0x10, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x20, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40,
  0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x03, 0x80, 0x80, 0x03, 0x00,
  0xC0, 0x07, 0x00, 0xC0, 0x05, 0x00, 0xC0, 0x0D, 0x00, 0x40, 0x1B, 0x00,
  0x60, 0x32, 0x00, 0x30, 0x62, 0x00, 0x1F, 0xC2, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0x80, 0x70, 0x60, 0x60, 0x30, 0x60, 0x08, 0x60,
  0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x01, 0x98, 0x00, 0xC8, 0x00, 0xC4,
  0x00, 0xC6, 0x00, 0xC2, 0x01, 0xC1, 0x07, 0x80, 0xFE, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x81, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x40, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0x84, 0x01, 0xC1, 0x98, 0x06, 0x01, 0xA0, 0x18, 0x01,
  0x40, 0x60, 0x02, 0x80, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x04, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x06, 0x04, 0x00,
  0x1C, 0x08, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x40, 0x60, 0x07,
  0x80, 0x40, 0x1B, 0x00, 0xC0, 0x64, 0x00, 0xC1, 0x88, 0x00, 0xFE, 0x10,
  0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x80, 0x18, 0x01, 0xC1, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x02, 0x00, 0x23,
  0xFC, 0x02, 0x60, 0x60, 0x6C, 0x02, 0x07, 0x80, 0x30, 0x50, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x20,
  0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x04,
  0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00,
  0x82, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x01,
  0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x09, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x03, 0x02, 0x00, 0x40, 0x60,
  0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x04, 0x06, 0x00, 0x40, 0xC0, 0x0C,
  0x08, 0x00, 0xC1, 0x00, 0x08, 0x30, 0x00, 0x86, 0x00, 0x18, 0xC0, 0x01,
  0x9C, 0x00, 0x13, 0x40, 0x01, 0x24, 0x00, 0x14, 0x60, 0x03, 0x86, 0x00,
  0x38, 0x20, 0x03, 0x03, 0x00, 0x20, 0x30, 0x02, 0x01, 0x00, 0x60, 0x10,
  0x06, 0x01, 0x80, 0x40, 0x18, 0x04, 0x00, 0x80, 0xC0, 0x08, 0x0C, 0x00,
  0xC0, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x20, 0x02, 0x3F, 0x83, 0xFC, 0x02, 0x60, 0xC6, 0x06, 0x06,
  0x80, 0x4C, 0x02, 0x05, 0x00, 0x78, 0x03, 0x07, 0x00, 0x70, 0x03, 0x06,
  0x00, 0x70, 0x03, 0x0E, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x02, 0x0C,
  0x00, 0x60, 0x02, 0x0C, 0x00, 0x40, 0x02, 0x08, 0x00, 0x40, 0x06, 0x18,
  0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x04, 0x18, 0x00, 0x80, 0x04, 0x10,
  0x00, 0x80, 0x04, 0x10, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30,
  0x01, 0x80, 0x08, 0x20, 0x01, 0x00, 0x08, 0x20, 0x01, 0x00, 0x18, 0x20,
  0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x10, 0x60, 0x02, 0x00, 0x10, 0x40,
  0x02, 0x00, 0x10, 0x40, 0x02, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0xC0,
  0x06, 0x00, 0x20, 0xC0, 0x04, 0x00, 0x20, 0x80, 0x04, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x23, 0xFC, 0x02, 0x60, 0x60, 0x6C, 0x02, 0x05, 0x80, 0x30,
  0x50, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02,
  0x0C, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x04, 0x10, 0x00,
  0x41, 0x00, 0x04, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x82, 0x00,
  0x08, 0x20, 0x00, 0x82, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x08,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x07, 0x06, 0x01, 0x80, 0x60,
  0x60, 0x04, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00, 0x26,
  0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x16, 0x00, 0x06, 0xC0, 0x00, 0xD0,
  0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x03, 0x60,
  0x00, 0x68, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x46, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0xC1, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x3F,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x43, 0xF8, 0x00, 0x4E,
  0x0C, 0x00, 0xD8, 0x06, 0x00, 0x90, 0x06, 0x00, 0xB0, 0x02, 0x00, 0xE0,
  0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x04, 0x06, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x20, 0x0A, 0x00,
  0x60, 0x1B, 0x00, 0xC0, 0x19, 0x83, 0x80, 0x10, 0xFE, 0x00, 0x10, 0x10,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x40, 0x70, 0x66, 0x06, 0x01, 0xA0,
  0x60, 0x05, 0x06, 0x00, 0x28, 0x30, 0x01, 0xC3, 0x00, 0x0E, 0x10, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x01, 0xC2, 0x00,
  0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x78, 0x10, 0x06, 0xC0,
  0xC0, 0x64, 0x03, 0x06, 0x20, 0x0F, 0xE1, 0x00, 0x08, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x02, 0x3F, 0x02, 0x60, 0x06, 0xC0,
  0x05, 0x80, 0x05, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0xFF, 0x80, 0xC0, 0x60, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x10, 0x02, 0x0C, 0x07, 0x07, 0xFE, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x03, 0xFF, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0xE0, 0x18, 0x00, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x04, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x60, 0x80, 0x06, 0x08, 0x00, 0xE0, 0x80, 0x0E, 0x08, 0x01, 0x40, 0xC0,
  0x34, 0x06, 0x0E, 0x40, 0x3F, 0x84, 0x00, 0x40, 0x00, 0x80, 0x01, 0xC0,
  0x00, 0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31,
  0x80, 0x10, 0xC0, 0x18, 0x20, 0x08, 0x10, 0x0C, 0x08, 0x04, 0x04, 0x06,
  0x02, 0x02, 0x01, 0x03, 0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10,
  0xC0, 0x08, 0x60, 0x04, 0x60, 0x02, 0x30, 0x01, 0x90, 0x00, 0xD8, 0x00,
  0x68, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x02, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xA0,
  0x04, 0xC0, 0x0A, 0x00, 0xCC, 0x01, 0xA0, 0x08, 0xC0, 0x12, 0x00, 0x8C,
  0x03, 0x20, 0x18, 0xC0, 0x22, 0x01, 0x0C, 0x06, 0x20, 0x30, 0xC0, 0x42,
  0x02, 0x0C, 0x0C, 0x20, 0x60, 0xC0, 0x82, 0x06, 0x0C, 0x08, 0x20, 0x40,
  0xC1, 0x82, 0x0C, 0x04, 0x10, 0x20, 0x80, 0x43, 0x02, 0x18, 0x04, 0x20,
  0x21, 0x00, 0x46, 0x02, 0x10, 0x04, 0x40, 0x23, 0x00, 0x4C, 0x02, 0x20,
  0x04, 0xC0, 0x26, 0x00, 0x48, 0x02, 0x40, 0x05, 0x80, 0x24, 0x00, 0x50,
  0x02, 0xC0, 0x07, 0x00, 0x28, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x18,
  0x01, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x60, 0x02, 0x03, 0x00, 0x0C, 0x08,
  0x00, 0x10, 0x60, 0x00, 0x43, 0x00, 0x01, 0x88, 0x00, 0x06, 0x60, 0x00,
  0x0B, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x58, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC3, 0x00,
  0x02, 0x0C, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x80, 0x18,
  0x06, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x20, 0x18, 0x00, 0xC0, 0xC0, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x60, 0x04, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x10, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x40, 0x30, 0x00, 0x08, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x20,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x60, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFE, 0x00, 0x58, 0x1C, 0x07, 0x00, 0x3F, 0xE8, 0x00,
  0x3C, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 39, 11, 1, -39 },
  { 55, 12, 14, 15, 5, -39 },
  { 76, 24, 39, 24, 1, -39 },
  { 193, 22, 45, 22, 0, -42 },
  { 317, 27, 41, 33, 3, -40 },
  { 456, 22, 41, 24, 0, -40 },
  { 569, 5, 14, 8, 5, -39 },
  { 578, 15, 48, 13, 2, -39 },
  { 668, 15, 48, 13, -4, -39 },
  { 758, 16, 18, 21, 7, -42 },
  { 794, 21, 25, 25, 2, -32 },
  { 860, 7, 12, 9, -2, -5 },
  { 871, 12, 2, 15, 2, -16 },
  { 874, 3, 4, 9, 1, -4 },
  { 876, 22, 39, 16, -2, -39 },
  { 984, 20, 41, 22, 2, -40 },
  { 1087, 11, 39, 22, 7, -39 },
  { 1141, 23, 40, 22, -1, -40 },
  { 1256, 23, 41, 22, -1, -40 },
  { 1374, 23, 40, 22, -1, -40 },
  { 1489, 22, 40, 22, 0, -39 },
  { 1599, 21, 41, 22, 2, -40 },
  { 1707, 21, 39, 22, 3, -39 },
  { 1810, 22, 41, 22, 0, -40 },
  { 1923, 21, 41, 22, 1, -40 },
  { 2031, 8, 29, 9, 1, -29 },
  { 2060, 11, 36, 9, -2, -29 },
  { 2110, 21, 23, 25, 2, -31 },
  { 2171, 21, 13, 25, 2, -26 },
  { 2206, 21, 23, 25, 2, -31 },
  { 2267, 16, 40, 16, 2, -40 },
  { 2347, 30, 44, 33, 2, -39 },
  { 2512, 21, 39, 22, -3, -39 },
  { 2615, 23, 39, 24, 1, -39 },
  { 2728, 23, 41, 23, 3, -40 },
  { 2846, 25, 39, 27, 1, -39 },
  { 2968, 23, 39, 22, 1, -39 },
  { 3081, 23, 39, 20, 1, -39 },
  { 3194, 26, 41, 29, 3, -40 },
  { 3328, 28, 39, 28, 1, -39 },
  { 3465, 16, 39, 11, -2, -39 },
  { 3543, 19, 49, 10, -8, -39 },
  { 3660, 25, 39, 22, 1, -39 },
  { 3782, 14, 39, 20, 1, -39 },
  { 3851, 35, 39, 36, 1, -39 },
  { 4022, 28, 39, 29, 1, -39 },
  { 4159, 25, 41, 29, 3, -40 },
  { 4288, 22, 39, 23, 1, -39 },
  { 4396, 25, 49, 29, 3, -40 },
  { 4550, 22, 39, 23, 1, -39 },
  { 4658, 24, 41, 21, -1, -40 },
  { 4781, 19, 39, 19, 5, -39 },
  { 4874, 25, 40, 28, 3, -39 },
  { 4999, 21, 39, 22, 5, -39 },
  { 5102, 35, 39, 37, 5, -39 },
  { 5273, 27, 39, 20, -3, -39 },
  { 5405, 19, 39, 19, 5, -39 },
  { 5498, 25, 39, 21, -2, -39 },
  { 5620, 20, 48, 16, -1, -39 },
  { 5740, 7, 39, 17, 6, -39 },
  { 5775, 20, 48, 16, -4, -39 },
  { 5895, 21, 20, 24, 2, -39 },
  { 5948, 16, 2, 16, -4, 5 },
  { 5952, 5, 9, 12, 8, -42 },
  { 5958, 21, 31, 24, 2, -30 },
  { 6040, 21, 43, 24, 1, -42 },
  { 6153, 17, 31, 18, 2, -30 },
  { 6219, 24, 43, 24, 2, -42 },
  { 6348, 17, 31, 21, 2, -30 },
  { 6414, 25, 55, 11, -7, -42 },
  { 6586, 23, 43, 24, 0, -30 },
  { 6710, 20, 42, 23, 1, -42 },
  { 6815, 10, 39, 9, 1, -39 },
  { 6864, 18, 52, 10, -7, -39 },
  { 6981, 20, 42, 19, 1, -42 },
  { 7086, 10, 42, 9, 1, -42 },
  { 7139, 32, 30, 35, 1, -30 },
  { 7259, 20, 30, 23, 1, -30 },
  { 7334, 19, 31, 23, 2, -30 },
  { 7408, 24, 43, 24, -2, -30 },
  { 7537, 21, 43, 24, 2, -30 },
  { 7650, 16, 29, 15, 1, -29 },
  { 7708, 17, 31, 18, 0, -30 },
  { 7774, 12, 37, 12, 1, -36 },
  { 7830, 20, 30, 23, 2, -29 },
  { 7905, 17, 29, 17, 3, -29 },
  { 7967, 28, 29, 28, 3, -29 },
  { 8069, 22, 29, 18, -2, -29 },
  { 8149, 27, 42, 18, -6, -29 },
  { 8291, 18, 29, 16, -1, -29 },
  { 8357, 19, 48, 17, 2, -39 },
  { 8471, 1, 55, 22, 11, -42 },
  { 8478, 19, 48, 17, -3, -39 },
  { 8592, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_THINITALIC55PT7B_H_
