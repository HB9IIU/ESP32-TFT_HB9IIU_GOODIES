#ifndef _NOTOSANS_CONDENSED_THINITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x44, 0x40, 0x08, 0x59, 0xAA, 0xA0, 0x09,
  0x04, 0x82, 0x41, 0x23, 0xF8, 0x90, 0x48, 0x48, 0x24, 0x7F, 0x12, 0x09,
  0x04, 0x82, 0x80, 0x04, 0x1F, 0x24, 0x28, 0x28, 0x28, 0x10, 0x08, 0x14,
  0x12, 0x12, 0x14, 0xF8, 0x20, 0x20, 0x30, 0xA4, 0x52, 0x51, 0x48, 0xA4,
  0xA2, 0x5F, 0x35, 0x6C, 0x8A, 0x49, 0x24, 0x94, 0x4A, 0x38, 0x0C, 0x12,
  0x12, 0x22, 0x24, 0x1C, 0x10, 0x30, 0x49, 0x8A, 0x86, 0x84, 0x84, 0x7A,
  0xF8, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x80,
  0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x44, 0x21, 0x11, 0x08, 0x80, 0x13,
  0x43, 0xCC, 0xD0, 0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10,
  0x29, 0x40, 0xF0, 0x80, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x18, 0x49, 0x0A, 0x18, 0x30, 0x61,
  0x42, 0x85, 0x0A, 0x24, 0x49, 0x1E, 0x00, 0x13, 0xD1, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x1C, 0x44, 0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x20, 0x82,
  0x08, 0x1F, 0x80, 0x1E, 0x21, 0x01, 0x01, 0x01, 0x02, 0x1C, 0x24, 0x04,
  0x02, 0x02, 0x04, 0x04, 0xF8, 0x01, 0x02, 0x06, 0x0A, 0x0A, 0x12, 0x24,
  0x24, 0x44, 0x84, 0xFE, 0x08, 0x08, 0x08, 0x1F, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x38, 0x04, 0x02, 0x02, 0x02, 0x04, 0x04, 0xF8, 0x0E, 0x20, 0x82,
  0x04, 0x12, 0x3A, 0x42, 0x85, 0x0A, 0x14, 0x28, 0x9E, 0x00, 0x7E, 0x04,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x00, 0x1E,
  0x21, 0x21, 0x21, 0x21, 0x22, 0x1C, 0x28, 0x44, 0x82, 0x82, 0x82, 0x84,
  0x78, 0x0C, 0x64, 0x8A, 0x14, 0x28, 0x50, 0xA3, 0x3A, 0x04, 0x10, 0x20,
  0x9E, 0x00, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x00, 0x24, 0x48,
  0x02, 0x18, 0xC2, 0x0C, 0x04, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x80, 0xC0, 0x60, 0x20, 0x63, 0x08, 0x60, 0x70, 0x42, 0x10, 0x88, 0x88,
  0x44, 0x20, 0x00, 0x40, 0x07, 0x06, 0x22, 0x05, 0x01, 0x46, 0x62, 0x59,
  0x26, 0x49, 0xA2, 0x69, 0x2A, 0x4A, 0x6C, 0x80, 0x20, 0x04, 0x00, 0xF0,
  0x02, 0x04, 0x18, 0x50, 0xA2, 0x44, 0x89, 0x3E, 0x45, 0x0A, 0x18, 0x30,
  0x40, 0x1E, 0x11, 0x21, 0x21, 0x21, 0x21, 0x3E, 0x42, 0x42, 0x41, 0x42,
  0x42, 0x86, 0xF8, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x78, 0x1E, 0x08, 0x84, 0x24, 0x12, 0x09, 0x04,
  0x82, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x48, 0x47, 0xC0, 0x1F, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xF8, 0x1F,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x0F, 0x88, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x0E, 0x81, 0x40,
  0xA0, 0x50, 0x48, 0x23, 0xF0, 0x10, 0x44, 0x12, 0x04, 0x82, 0x20, 0x88,
  0x23, 0xF9, 0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x80, 0x1C,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x43, 0x80, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0xE0, 0x10, 0x88, 0x88, 0x44, 0x42, 0x41, 0x40, 0xC0, 0x50, 0x48, 0x24,
  0x11, 0x08, 0x88, 0x44, 0x10, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x88, 0x7C, 0x10, 0x08, 0x80, 0x8C, 0x0C, 0x60, 0x62, 0x85, 0x14, 0x28,
  0xA2, 0x49, 0x14, 0x49, 0x22, 0x49, 0x12, 0x88, 0x94, 0x88, 0xC4, 0x42,
  0x20, 0x10, 0x44, 0x12, 0x84, 0xA1, 0x28, 0x8A, 0x22, 0x49, 0x12, 0x44,
  0x91, 0x44, 0x31, 0x0C, 0x83, 0x20, 0x80, 0x0E, 0x08, 0x88, 0x28, 0x14,
  0x0C, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x43, 0xC0, 0x1E,
  0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x7C, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x0E, 0x08, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x40,
  0xA0, 0x90, 0x48, 0x43, 0x40, 0x40, 0x10, 0x08, 0x00, 0x1E, 0x11, 0x11,
  0x21, 0x21, 0x21, 0x22, 0x3C, 0x48, 0x48, 0x44, 0x44, 0x84, 0x84, 0x1E,
  0x21, 0x20, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04,
  0xF8, 0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x00,
  0x20, 0x90, 0x50, 0x28, 0x24, 0x12, 0x09, 0x05, 0x02, 0x82, 0x41, 0x20,
  0x90, 0x48, 0x43, 0xC0, 0x83, 0x06, 0x14, 0x28, 0x91, 0x22, 0x48, 0x91,
  0x42, 0x86, 0x0C, 0x10, 0x00, 0x84, 0x18, 0x41, 0x84, 0x28, 0xC2, 0x8C,
  0x29, 0x44, 0x94, 0x4A, 0x48, 0xA4, 0x8A, 0x50, 0xC5, 0x0C, 0x50, 0x82,
  0x08, 0x20, 0x10, 0x88, 0x44, 0x41, 0x40, 0xA0, 0x60, 0x20, 0x10, 0x14,
  0x0A, 0x09, 0x08, 0x84, 0x44, 0x10, 0x86, 0x18, 0xA2, 0x92, 0x4A, 0x30,
  0x41, 0x08, 0x20, 0x82, 0x00, 0x1F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x07, 0xE0, 0x1E, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0xE0,
  0x92, 0x49, 0x12, 0x49, 0x22, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0xE0, 0x10, 0x30, 0xA1,
  0x24, 0x48, 0xA0, 0x80, 0xF8, 0xAC, 0x3E, 0x8E, 0x14, 0x28, 0x50, 0xA1,
  0x44, 0x89, 0xF0, 0x10, 0x10, 0x20, 0x20, 0x3E, 0x21, 0x21, 0x41, 0x41,
  0x42, 0x42, 0x42, 0x44, 0xF8, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83,
  0xC0, 0x01, 0x01, 0x02, 0x02, 0x3E, 0x42, 0x82, 0x84, 0x84, 0x84, 0x84,
  0x88, 0x88, 0xF8, 0x3D, 0x18, 0x62, 0xF2, 0x08, 0x20, 0x83, 0xC0, 0x03,
  0x04, 0x04, 0x04, 0x08, 0x1E, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x80, 0x1F, 0x21, 0x41, 0x42, 0x42,
  0x42, 0x82, 0x84, 0x44, 0x7C, 0x04, 0x04, 0x08, 0x88, 0x70, 0x10, 0x20,
  0x81, 0x03, 0xE4, 0x48, 0xA1, 0x42, 0x85, 0x0A, 0x28, 0x50, 0x80, 0x11,
  0x00, 0x22, 0x24, 0x44, 0x44, 0x88, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x43, 0x00, 0x10,
  0x20, 0x81, 0x02, 0x24, 0x8A, 0x28, 0x50, 0xE1, 0x22, 0x48, 0x91, 0x00,
  0x11, 0x22, 0x22, 0x24, 0x44, 0x44, 0x88, 0x3F, 0xE4, 0x44, 0x88, 0xA1,
  0x14, 0x22, 0x88, 0x51, 0x0A, 0x22, 0x84, 0x50, 0x88, 0x3E, 0x44, 0x8A,
  0x14, 0x28, 0x51, 0x22, 0x85, 0x08, 0x3D, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x8B, 0xC0, 0x1F, 0x08, 0x44, 0x24, 0x12, 0x09, 0x08, 0x84, 0x42, 0x22,
  0x3E, 0x10, 0x08, 0x08, 0x04, 0x00, 0x3E, 0x86, 0x0C, 0x28, 0x50, 0xA1,
  0x44, 0x89, 0xF0, 0x20, 0x40, 0x82, 0x00, 0x3C, 0x82, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x00, 0x3D, 0x04, 0x10, 0x20, 0x40, 0x82, 0x0B, 0xC0, 0x21,
  0x1E, 0x44, 0x21, 0x08, 0x44, 0x21, 0xC0, 0x42, 0x89, 0x14, 0x28, 0x50,
  0xA2, 0x44, 0x89, 0xF0, 0x86, 0x28, 0xA4, 0x92, 0x8A, 0x30, 0xC2, 0x00,
  0x88, 0x62, 0x29, 0x4A, 0x54, 0xA5, 0x29, 0x4A, 0x63, 0x10, 0x84, 0x21,
  0x00, 0x21, 0x12, 0x14, 0x14, 0x08, 0x18, 0x28, 0x28, 0x44, 0x84, 0x10,
  0x88, 0x44, 0x42, 0x21, 0x20, 0x90, 0x50, 0x18, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x03, 0x00, 0x1E, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41,
  0xF0, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x10, 0x81, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x60, 0xFF, 0xFF, 0xE0, 0x18, 0x10, 0x41, 0x04, 0x20, 0x82, 0x04,
  0x21, 0x04, 0x10, 0x42, 0x08, 0xC0, 0x61, 0x3C,
};

const GFXglyph NotoSans_Condensed_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 5, 2, -14 },
  { 11, 9, 14, 8, 0, -14 },
  { 27, 8, 15, 8, 0, -14 },
  { 42, 9, 14, 11, 1, -14 },
  { 58, 8, 14, 8, 0, -14 },
  { 72, 1, 5, 3, 2, -14 },
  { 73, 5, 17, 5, 1, -14 },
  { 84, 5, 17, 5, -1, -14 },
  { 95, 6, 6, 7, 2, -14 },
  { 100, 7, 9, 9, 1, -11 },
  { 108, 3, 4, 3, -1, -2 },
  { 110, 4, 1, 5, 1, -6 },
  { 111, 1, 1, 3, 0, -1 },
  { 112, 8, 14, 6, -1, -14 },
  { 126, 7, 14, 8, 1, -14 },
  { 139, 4, 14, 8, 2, -14 },
  { 146, 7, 14, 8, 0, -14 },
  { 159, 8, 14, 8, 0, -14 },
  { 173, 8, 14, 8, 0, -14 },
  { 187, 8, 14, 8, 0, -14 },
  { 201, 7, 14, 8, 1, -14 },
  { 214, 7, 14, 8, 1, -14 },
  { 227, 8, 14, 8, 0, -14 },
  { 241, 7, 14, 8, 0, -14 },
  { 254, 3, 10, 3, 0, -10 },
  { 258, 4, 12, 3, -1, -10 },
  { 264, 7, 8, 9, 1, -11 },
  { 271, 7, 5, 9, 1, -9 },
  { 276, 7, 8, 9, 1, -11 },
  { 283, 5, 14, 6, 1, -14 },
  { 292, 10, 16, 12, 1, -14 },
  { 312, 7, 14, 7, -1, -14 },
  { 325, 8, 14, 8, 0, -14 },
  { 339, 8, 14, 8, 1, -14 },
  { 353, 9, 14, 9, 0, -14 },
  { 369, 8, 14, 8, 0, -14 },
  { 383, 8, 14, 7, 0, -14 },
  { 397, 9, 14, 10, 1, -14 },
  { 413, 10, 14, 10, 0, -14 },
  { 431, 6, 14, 4, -1, -14 },
  { 442, 7, 17, 3, -3, -14 },
  { 457, 9, 14, 8, 0, -14 },
  { 473, 5, 14, 7, 0, -14 },
  { 482, 13, 14, 12, 0, -14 },
  { 505, 10, 14, 10, 0, -14 },
  { 523, 9, 14, 10, 1, -14 },
  { 539, 8, 14, 8, 0, -14 },
  { 553, 9, 17, 10, 1, -14 },
  { 573, 8, 14, 8, 0, -14 },
  { 587, 8, 14, 7, 0, -14 },
  { 601, 6, 14, 7, 2, -14 },
  { 612, 9, 14, 10, 1, -14 },
  { 628, 7, 14, 8, 2, -14 },
  { 641, 12, 14, 13, 2, -14 },
  { 662, 9, 14, 7, -1, -14 },
  { 678, 6, 14, 7, 2, -14 },
  { 689, 9, 14, 7, -1, -14 },
  { 705, 7, 17, 5, 0, -14 },
  { 720, 3, 14, 6, 2, -14 },
  { 726, 7, 17, 5, -1, -14 },
  { 741, 7, 7, 8, 1, -14 },
  { 748, 5, 1, 6, -1, 2 },
  { 749, 2, 3, 4, 3, -15 },
  { 750, 7, 10, 8, 1, -10 },
  { 759, 8, 14, 8, 0, -14 },
  { 773, 6, 10, 6, 1, -10 },
  { 781, 8, 14, 8, 1, -14 },
  { 795, 6, 10, 7, 1, -10 },
  { 803, 8, 20, 4, -2, -15 },
  { 823, 8, 15, 8, 0, -10 },
  { 838, 7, 14, 8, 0, -14 },
  { 851, 4, 14, 3, 0, -14 },
  { 858, 7, 19, 3, -3, -14 },
  { 875, 7, 14, 6, 0, -14 },
  { 888, 4, 14, 3, 0, -14 },
  { 895, 11, 10, 12, 0, -10 },
  { 909, 7, 10, 8, 0, -10 },
  { 918, 6, 10, 8, 1, -10 },
  { 926, 9, 14, 8, -1, -10 },
  { 942, 7, 14, 8, 1, -10 },
  { 955, 6, 10, 5, 0, -10 },
  { 963, 6, 10, 6, 0, -10 },
  { 971, 5, 12, 4, 0, -12 },
  { 979, 7, 10, 8, 1, -10 },
  { 988, 6, 10, 6, 1, -10 },
  { 996, 10, 10, 10, 1, -10 },
  { 1009, 8, 10, 6, -1, -10 },
  { 1019, 9, 15, 6, -2, -10 },
  { 1036, 7, 10, 6, -1, -10 },
  { 1045, 6, 17, 6, 1, -14 },
  { 1058, 1, 19, 8, 3, -14 },
  { 1061, 6, 17, 6, -1, -14 },
  { 1074, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_THINITALIC19PT7B_H_
