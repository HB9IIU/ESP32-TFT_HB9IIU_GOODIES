#ifndef _NOTOSANS_CONDENSED_THINITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0xC0, 0x21, 0x21, 0x21, 0x42, 0x42, 0x42,
  0x42, 0x42, 0x84, 0x84, 0x00, 0x41, 0x80, 0x10, 0x40, 0x08, 0x10, 0x02,
  0x0C, 0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x20, 0x04, 0x10, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x20, 0x80, 0x08, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00,
  0x41, 0x00, 0x30, 0x40, 0x08, 0x10, 0x02, 0x08, 0x0F, 0xFF, 0xE0, 0x40,
  0x80, 0x10, 0x40, 0x04, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x20, 0x80,
  0x10, 0x20, 0x04, 0x18, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x19, 0x78, 0x10, 0x84, 0x10,
  0x80, 0x18, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x08, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x09, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x24, 0x00, 0x13, 0x00, 0x10, 0x80, 0x08, 0x60, 0x04, 0x10, 0x02,
  0x18, 0x01, 0x08, 0x01, 0x04, 0x00, 0x84, 0x10, 0x44, 0x07, 0xFC, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC8, 0x02, 0x18, 0x40, 0x41, 0x04, 0x04, 0x30, 0x40, 0x82, 0x04, 0x18,
  0x20, 0x41, 0x04, 0x04, 0x20, 0x40, 0x42, 0x04, 0x08, 0x40, 0x40, 0x84,
  0x04, 0x08, 0x80, 0xC0, 0x88, 0xEC, 0x11, 0x13, 0x81, 0x32, 0x1C, 0x32,
  0x41, 0x42, 0x44, 0x16, 0xC4, 0x81, 0x10, 0x88, 0x10, 0x08, 0x81, 0x01,
  0x18, 0x10, 0x31, 0x01, 0x02, 0x10, 0x10, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x10, 0x41, 0x01, 0x04, 0x30, 0x10, 0x82, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x66, 0x00, 0x61, 0x00, 0x20, 0xC0, 0x20, 0x60, 0x10,
  0x30, 0x08, 0x10, 0x04, 0x08, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x86, 0x00,
  0x46, 0x00, 0x16, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0D, 0x00, 0x0C, 0x80,
  0x0C, 0x20, 0xCC, 0x10, 0x44, 0x0C, 0x24, 0x02, 0x22, 0x01, 0x13, 0x00,
  0x59, 0x00, 0x28, 0x80, 0x18, 0x40, 0x0C, 0x30, 0x06, 0x08, 0x04, 0x86,
  0x0C, 0x41, 0xFC, 0x30, 0x24, 0xA4, 0x92, 0x90, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x02, 0x08, 0x20, 0x62, 0x01, 0xC7, 0x07, 0x80, 0xA0, 0x12, 0x02,
  0x10, 0xC1, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF,
  0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88, 0xC0,
  0xFF, 0x80, 0xBC, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x03, 0xB8, 0x0C, 0x10, 0x10,
  0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x30, 0x80, 0x41, 0x01, 0x82, 0x06, 0x02, 0x18, 0x07,
  0xE0, 0x00, 0x03, 0x05, 0x1A, 0x32, 0x42, 0x82, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x00, 0x38, 0x00, 0xE3, 0x00,
  0xC0, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x78, 0x03, 0x8E, 0x06, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x03, 0xE0, 0x04, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x80, 0x40, 0xFF, 0x80, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x05, 0x00, 0x0D, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x32, 0x00, 0x22, 0x00, 0x46, 0x00, 0xC4, 0x00, 0x84, 0x01, 0x04, 0x02,
  0x04, 0x02, 0x08, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20,
  0x10, 0x60, 0x10, 0x40, 0x10, 0x80, 0x10, 0xFF, 0xFE, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x01,
  0xFF, 0x81, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x10, 0x18, 0x0F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x71, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x23, 0xE0, 0x26, 0x30, 0x38, 0x08, 0x50, 0x08, 0x60, 0x0C, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x08, 0xC0, 0x08, 0xC0,
  0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20, 0x20, 0x40, 0x1F,
  0x80, 0x3F, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0xE7, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x40, 0x18, 0x20, 0x04,
  0x10, 0x06, 0x18, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x80, 0xC0,
  0x80, 0x20, 0x80, 0x09, 0x80, 0x03, 0x00, 0x06, 0xC0, 0x0C, 0x30, 0x0C,
  0x08, 0x08, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x46, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x06, 0x10, 0x02, 0x08, 0x03, 0x03, 0x03,
  0x00, 0xFE, 0x00, 0x00, 0x30, 0x01, 0xCC, 0x03, 0x02, 0x06, 0x02, 0x04,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x03, 0x10, 0x06, 0x10, 0x06, 0x08,
  0x1A, 0x07, 0x72, 0x01, 0x84, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0xFE, 0x00, 0x04, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x18, 0x00, 0x01,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x20, 0x20, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x03, 0x81, 0xCE, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x20, 0x08, 0x00, 0x20,
  0x20, 0x00, 0x40, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18,
  0x0F, 0x82, 0x20, 0x21, 0x04, 0x40, 0x82, 0x09, 0x02, 0x04, 0x12, 0x08,
  0x10, 0x24, 0x10, 0x20, 0x50, 0x40, 0x41, 0xA0, 0x80, 0x82, 0x41, 0x02,
  0x04, 0x86, 0x04, 0x09, 0x08, 0x08, 0x26, 0x10, 0x30, 0x4C, 0x20, 0x61,
  0x98, 0x41, 0x42, 0x30, 0x46, 0x88, 0x60, 0xF9, 0xE0, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x0A, 0x00, 0x13, 0x00,
  0x11, 0x00, 0x21, 0x00, 0x21, 0x00, 0x61, 0x00, 0x41, 0x00, 0x41, 0x00,
  0x81, 0x00, 0x81, 0x01, 0x01, 0x01, 0x01, 0x03, 0xFF, 0x03, 0xFF, 0x04,
  0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x03, 0xFC, 0x01,
  0x01, 0x81, 0x00, 0x40, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x30, 0x02,
  0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC3, 0x00, 0xC1, 0x01,
  0xC0, 0xFF, 0x00, 0x40, 0xE0, 0x20, 0x18, 0x20, 0x04, 0x10, 0x03, 0x08,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08,
  0x40, 0x0C, 0x60, 0x0C, 0x20, 0x0C, 0x10, 0x1C, 0x0F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x70, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x81, 0x80,
  0x40, 0x10, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x10, 0xC0, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x10, 0x80, 0x04, 0x60, 0x03, 0x10, 0x00, 0x84, 0x00, 0x61, 0x00,
  0x10, 0x40, 0x08, 0x30, 0x04, 0x08, 0x06, 0x02, 0x07, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x83, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x83, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x1E, 0x01, 0x80,
  0x30, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x1F, 0x88,
  0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0xC0, 0x02, 0x04, 0x00, 0x20, 0x60, 0x02,
  0x02, 0x00, 0x20, 0x18, 0x06, 0x00, 0xFF, 0xC0, 0x02, 0x00, 0x10, 0x60,
  0x01, 0x04, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C,
  0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x41,
  0x00, 0x04, 0x10, 0x00, 0x41, 0xFF, 0xF8, 0x10, 0x00, 0x81, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x00, 0x03, 0xF8, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x0F, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x3E, 0x00,
  0x02, 0x00, 0x60, 0xC0, 0x10, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x60,
  0x08, 0x18, 0x03, 0x06, 0x00, 0x40, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00,
  0x22, 0x00, 0x08, 0xC0, 0x01, 0x30, 0x00, 0x2E, 0x00, 0x05, 0x40, 0x00,
  0xC4, 0x00, 0x30, 0x80, 0x04, 0x10, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06,
  0x04, 0x00, 0x80, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x18,
  0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x00, 0x80, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x70, 0x50, 0x00, 0x1C, 0x14, 0x00, 0x0E, 0x05,
  0x00, 0x02, 0x81, 0x40, 0x01, 0xA0, 0xD0, 0x00, 0x48, 0x24, 0x00, 0x34,
  0x09, 0x00, 0x09, 0x02, 0x40, 0x06, 0x40, 0x90, 0x01, 0x10, 0x46, 0x00,
  0x84, 0x10, 0x80, 0x22, 0x04, 0x20, 0x10, 0x81, 0x08, 0x04, 0x20, 0x42,
  0x02, 0x08, 0x20, 0x80, 0x86, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x08, 0x10, 0x60, 0x82, 0x04, 0x10, 0x21, 0x02, 0x04, 0x08, 0x40,
  0x81, 0x01, 0x20, 0x20, 0x40, 0x48, 0x08, 0x30, 0x14, 0x02, 0x08, 0x05,
  0x01, 0x02, 0x01, 0x80, 0x40, 0x80, 0x60, 0x10, 0x00, 0x02, 0x00, 0x08,
  0x38, 0x00, 0x81, 0x40, 0x04, 0x0A, 0x00, 0x20, 0x50, 0x01, 0x02, 0xC0,
  0x08, 0x32, 0x00, 0x81, 0x10, 0x04, 0x08, 0x80, 0x20, 0x46, 0x01, 0x02,
  0x10, 0x18, 0x20, 0x80, 0x81, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x18, 0x20, 0x20, 0x81, 0x00, 0x84, 0x08, 0x04, 0x20, 0x40,
  0x21, 0x06, 0x01, 0x10, 0x20, 0x04, 0x81, 0x00, 0x24, 0x08, 0x01, 0x20,
  0x40, 0x09, 0x06, 0x00, 0x30, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x08, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0xE0, 0x04, 0x06, 0x01, 0x00, 0x40,
  0x40, 0x04, 0x10, 0x00, 0x86, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x64,
  0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x02, 0xC0, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x48, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80,
  0x02, 0x18, 0x00, 0x81, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x02, 0x06, 0x04, 0x03, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x03,
  0x18, 0x02, 0x10, 0x06, 0x10, 0x0C, 0x10, 0x18, 0x1F, 0xE0, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x1C, 0xE0, 0x04, 0x06, 0x01, 0x00, 0x40, 0x40, 0x04,
  0x10, 0x00, 0x86, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x64, 0x00, 0x08,
  0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0xC0, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48,
  0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x18,
  0x00, 0x81, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x3F, 0x80, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x03, 0xF8, 0x02, 0x06, 0x04, 0x03, 0x04, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x03, 0x18, 0x02, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x30, 0x1F, 0xC0,
  0x20, 0xC0, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x60, 0x40, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x10, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x10, 0x00, 0x1E, 0x00, 0x38, 0xF0, 0x10, 0x04, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x80, 0x30, 0x1F, 0xF0, 0x00, 0xFF, 0xFC,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0x80,
  0x04, 0x30, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x82, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01,
  0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x08,
  0x10, 0x01, 0x01, 0x00, 0x40, 0x30, 0x10, 0x01, 0xFC, 0x00, 0x80, 0x03,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18,
  0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x20, 0x80, 0x40, 0x80, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x81, 0x00, 0x81, 0x00, 0x82, 0x00, 0x82, 0x00,
  0x86, 0x00, 0x84, 0x00, 0x4C, 0x00, 0x48, 0x00, 0x48, 0x00, 0x50, 0x00,
  0x50, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x14, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x06, 0x20, 0x31, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x41, 0x04, 0x08, 0x30, 0x41, 0x02, 0x08, 0x10, 0xC0,
  0x82, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x11,
  0x00, 0x88, 0x04, 0x80, 0x26, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x01, 0x00, 0x30, 0x10, 0x06,
  0x01, 0x00, 0x40, 0x08, 0x08, 0x00, 0x81, 0x80, 0x08, 0x10, 0x00, 0x82,
  0x00, 0x08, 0x20, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x05,
  0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xA0, 0x00, 0x13, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00,
  0xC1, 0x00, 0x08, 0x10, 0x01, 0x00, 0x80, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x08, 0x04, 0x00, 0x80, 0x80, 0x0C, 0x00, 0x80, 0x0E, 0x00, 0x28,
  0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x04, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x04, 0x30, 0x10, 0x80, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0xFC, 0x00, 0x82,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x00, 0xFE, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x03, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xA0, 0x00, 0xA0, 0x01, 0x10, 0x03,
  0x10, 0x02, 0x18, 0x04, 0x08, 0x04, 0x08, 0x08, 0x04, 0x18, 0x04, 0x10,
  0x06, 0x30, 0x02, 0x20, 0x02, 0x40, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x84,
  0x42, 0x21, 0x01, 0xF1, 0x03, 0x19, 0x04, 0x0E, 0x08, 0x06, 0x18, 0x06,
  0x10, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x10,
  0x40, 0x30, 0x40, 0x30, 0x40, 0x50, 0x20, 0x90, 0x3F, 0x20, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x11, 0xF0, 0x24, 0x30, 0x50, 0x21, 0xC0, 0x23, 0x80,
  0x46, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x66, 0x00, 0x8A, 0x02, 0x16, 0x08, 0x27, 0xE0, 0x00, 0x03, 0xF0, 0x61,
  0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x7C, 0x40, 0x30, 0x90, 0x10, 0x14, 0x08, 0x06, 0x06,
  0x01, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x04, 0x00,
  0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0x83, 0x00, 0x20,
  0xC0, 0x18, 0x30, 0x06, 0x04, 0x03, 0x81, 0x00, 0xC0, 0x40, 0x50, 0x18,
  0x24, 0x03, 0xF1, 0x00, 0x03, 0xE0, 0x31, 0x82, 0x04, 0x20, 0x23, 0x01,
  0x90, 0x09, 0x00, 0x48, 0x04, 0x40, 0x64, 0x06, 0x23, 0xC1, 0xE0, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x04, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x1F, 0xC0, 0x04, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x80, 0xC2, 0x40, 0x80,
  0xA0, 0x80, 0x50, 0xC0, 0x30, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x06, 0x10,
  0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x61, 0x00, 0x21,
  0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x10, 0x0E, 0x08, 0x06, 0x04, 0x05,
  0x03, 0x04, 0x80, 0xFC, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x03, 0x0E, 0x00,
  0x7C, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x23, 0xE0, 0xB0, 0xC3, 0x81, 0x14,
  0x04, 0x60, 0x11, 0x80, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0xC8,
  0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00, 0x44,
  0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x10, 0x80, 0x82, 0x06, 0x18, 0x30, 0x40, 0x81, 0x04, 0x04, 0x20,
  0x11, 0x00, 0x88, 0x02, 0x60, 0x0B, 0x80, 0x29, 0x00, 0xC4, 0x06, 0x10,
  0x10, 0x40, 0x40, 0x81, 0x02, 0x0C, 0x08, 0x20, 0x20, 0x80, 0x42, 0x01,
  0x08, 0x04, 0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x00, 0x08, 0xF0, 0x7C, 0x16, 0x13,
  0x0C, 0x38, 0x34, 0x08, 0xA0, 0x30, 0x11, 0x80, 0x40, 0x23, 0x00, 0x80,
  0x44, 0x03, 0x00, 0x88, 0x04, 0x01, 0x30, 0x08, 0x02, 0x40, 0x10, 0x08,
  0x80, 0x20, 0x11, 0x00, 0x80, 0x22, 0x01, 0x00, 0x48, 0x02, 0x00, 0x90,
  0x04, 0x02, 0x20, 0x08, 0x04, 0x40, 0x20, 0x08, 0x80, 0x40, 0x12, 0x00,
  0x80, 0x64, 0x01, 0x00, 0x88, 0x06, 0x01, 0x10, 0x08, 0x02, 0x00, 0x08,
  0xF8, 0x2C, 0x30, 0xE0, 0x45, 0x01, 0x18, 0x04, 0x60, 0x11, 0x00, 0x44,
  0x01, 0x30, 0x04, 0x80, 0x32, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x24,
  0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22,
  0x00, 0x80, 0x01, 0xF0, 0x06, 0x10, 0x10, 0x10, 0x40, 0x21, 0x80, 0x62,
  0x00, 0x4C, 0x00, 0x90, 0x01, 0x20, 0x02, 0xC0, 0x0D, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x48, 0x00, 0xB0, 0x03, 0x60, 0x04, 0xC0, 0x08, 0x80, 0x21,
  0x00, 0xC2, 0x01, 0x02, 0x04, 0x03, 0xF0, 0x00, 0x02, 0x3E, 0x01, 0x21,
  0x80, 0xA0, 0x40, 0xA0, 0x10, 0x70, 0x08, 0x30, 0x04, 0x18, 0x02, 0x08,
  0x01, 0x0C, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18,
  0xC0, 0x08, 0x40, 0x04, 0x20, 0x06, 0x10, 0x02, 0x08, 0x03, 0x0C, 0x01,
  0x05, 0x01, 0x02, 0xC1, 0x01, 0x3F, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xF1, 0x03, 0x09, 0x04, 0x05, 0x08, 0x05, 0x18, 0x06,
  0x10, 0x06, 0x30, 0x06, 0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18,
  0x40, 0x38, 0x40, 0x30, 0x40, 0x50, 0x60, 0x90, 0x3F, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x08, 0xF0, 0xB0, 0x0A, 0x01, 0x40,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x03, 0xF0, 0x60, 0xC6, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x88,
  0x18, 0x7F, 0x80, 0x04, 0x02, 0x01, 0x01, 0x00, 0x81, 0xFD, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x1E, 0x00, 0x08, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x01, 0x18,
  0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x46, 0x00, 0x88, 0x03,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x31, 0x80, 0x63, 0x01, 0x82, 0x07, 0x04,
  0x1A, 0x07, 0xE4, 0x00, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02,
  0x20, 0x21, 0x01, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x86, 0x04,
  0x20, 0x23, 0x01, 0x10, 0x09, 0x80, 0x48, 0x02, 0xC0, 0x14, 0x00, 0xA0,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0xB0, 0x18, 0x04,
  0x80, 0xC0, 0x64, 0x06, 0x02, 0x20, 0x50, 0x11, 0x02, 0x81, 0x08, 0x22,
  0x08, 0x41, 0x10, 0xC2, 0x10, 0x84, 0x10, 0x84, 0x20, 0x8C, 0x22, 0x04,
  0x41, 0x10, 0x22, 0x09, 0x01, 0x20, 0x48, 0x09, 0x02, 0x40, 0x50, 0x14,
  0x02, 0x80, 0xA0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20,
  0x08, 0x00, 0x06, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0xC0, 0x30,
  0x40, 0x08, 0x40, 0x04, 0x60, 0x02, 0x20, 0x00, 0xA0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x08, 0x40,
  0x08, 0x20, 0x0C, 0x10, 0x04, 0x04, 0x04, 0x02, 0x06, 0x01, 0x06, 0x00,
  0xC0, 0x00, 0x80, 0x18, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0x08, 0x06, 0x00, 0x40, 0x20, 0x02, 0x03, 0x00, 0x10, 0x10, 0x00, 0x80,
  0x80, 0x04, 0x08, 0x00, 0x10, 0x40, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00,
  0x22, 0x00, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x80,
  0x00, 0x14, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0x03, 0x06, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 29, 8, 1, -29 },
  { 30, 8, 10, 11, 4, -29 },
  { 40, 18, 29, 18, 1, -29 },
  { 106, 17, 33, 17, 0, -31 },
  { 177, 20, 30, 24, 2, -30 },
  { 252, 17, 30, 18, 0, -30 },
  { 316, 3, 10, 6, 4, -29 },
  { 320, 11, 35, 10, 1, -29 },
  { 369, 11, 35, 10, -3, -29 },
  { 418, 12, 13, 16, 5, -31 },
  { 438, 15, 19, 18, 2, -24 },
  { 474, 5, 9, 7, -2, -4 },
  { 480, 9, 1, 11, 1, -12 },
  { 482, 2, 3, 7, 1, -3 },
  { 483, 17, 29, 12, -2, -29 },
  { 545, 15, 30, 17, 1, -30 },
  { 602, 8, 29, 17, 5, -29 },
  { 631, 17, 30, 17, -1, -30 },
  { 695, 16, 30, 17, 0, -30 },
  { 755, 16, 30, 17, 0, -30 },
  { 815, 17, 29, 17, 0, -29 },
  { 877, 16, 30, 17, 1, -30 },
  { 937, 16, 29, 17, 2, -29 },
  { 995, 17, 30, 17, 0, -30 },
  { 1059, 16, 30, 17, 0, -30 },
  { 1119, 7, 22, 7, 0, -22 },
  { 1139, 9, 27, 7, -2, -22 },
  { 1170, 15, 17, 18, 2, -23 },
  { 1202, 15, 9, 18, 2, -19 },
  { 1219, 15, 17, 18, 2, -23 },
  { 1251, 12, 30, 12, 1, -30 },
  { 1296, 23, 33, 25, 1, -29 },
  { 1391, 16, 29, 16, -3, -29 },
  { 1449, 17, 29, 18, 1, -29 },
  { 1511, 18, 30, 17, 2, -30 },
  { 1579, 18, 29, 20, 1, -29 },
  { 1645, 17, 29, 16, 1, -29 },
  { 1707, 17, 29, 15, 1, -29 },
  { 1769, 20, 30, 21, 2, -30 },
  { 1844, 20, 29, 21, 1, -29 },
  { 1917, 13, 29, 8, -2, -29 },
  { 1965, 14, 36, 7, -6, -29 },
  { 2028, 19, 29, 17, 1, -29 },
  { 2097, 10, 29, 15, 1, -29 },
  { 2134, 26, 29, 27, 1, -29 },
  { 2229, 21, 29, 22, 1, -29 },
  { 2306, 19, 30, 22, 2, -30 },
  { 2378, 16, 29, 17, 1, -29 },
  { 2436, 19, 37, 22, 2, -30 },
  { 2524, 16, 29, 17, 1, -29 },
  { 2582, 18, 30, 16, -1, -30 },
  { 2650, 14, 29, 14, 4, -29 },
  { 2701, 19, 29, 21, 2, -29 },
  { 2770, 16, 29, 16, 4, -29 },
  { 2828, 26, 29, 27, 4, -29 },
  { 2923, 20, 29, 15, -2, -29 },
  { 2996, 14, 29, 14, 4, -29 },
  { 3047, 18, 29, 15, -1, -29 },
  { 3113, 15, 35, 12, -1, -29 },
  { 3179, 6, 29, 13, 4, -29 },
  { 3201, 15, 35, 12, -3, -29 },
  { 3267, 16, 15, 18, 1, -29 },
  { 3297, 12, 1, 12, -3, 4 },
  { 3299, 4, 6, 9, 6, -31 },
  { 3302, 16, 22, 18, 1, -22 },
  { 3346, 15, 31, 18, 1, -31 },
  { 3405, 12, 22, 13, 2, -22 },
  { 3438, 18, 31, 18, 1, -31 },
  { 3508, 13, 22, 15, 2, -22 },
  { 3544, 19, 41, 9, -5, -31 },
  { 3642, 17, 32, 18, 0, -22 },
  { 3710, 14, 31, 17, 1, -31 },
  { 3765, 7, 29, 7, 1, -29 },
  { 3791, 14, 39, 7, -6, -29 },
  { 3860, 14, 31, 14, 1, -31 },
  { 3915, 7, 31, 7, 1, -31 },
  { 3943, 23, 22, 26, 1, -22 },
  { 4007, 14, 22, 17, 1, -22 },
  { 4046, 15, 22, 17, 1, -22 },
  { 4088, 17, 31, 18, -1, -22 },
  { 4154, 16, 32, 18, 1, -22 },
  { 4218, 12, 22, 11, 1, -22 },
  { 4251, 13, 22, 13, 0, -22 },
  { 4287, 9, 27, 9, 1, -27 },
  { 4318, 15, 22, 17, 1, -22 },
  { 4360, 13, 22, 13, 2, -22 },
  { 4396, 21, 22, 21, 2, -22 },
  { 4454, 17, 22, 14, -2, -22 },
  { 4501, 21, 32, 13, -5, -22 },
  { 4585, 14, 22, 12, -1, -22 },
  { 4624, 14, 35, 13, 1, -29 },
  { 4686, 1, 41, 16, 8, -31 },
  { 4692, 15, 35, 13, -3, -29 },
  { 4758, 15, 3, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_THINITALIC41PT7B_H_
