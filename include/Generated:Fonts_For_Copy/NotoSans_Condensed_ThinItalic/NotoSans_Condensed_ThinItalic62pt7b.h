#ifndef _NOTOSANS_CONDENSED_THINITALIC62PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x18, 0xC1, 0x84, 0x0C,
  0x20, 0x63, 0x03, 0x18, 0x10, 0x80, 0x84, 0x0C, 0x20, 0x63, 0x02, 0x18,
  0x10, 0x80, 0x84, 0x0C, 0x20, 0x43, 0x02, 0x10, 0x10, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10,
  0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x01, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x20, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x40, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x08, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0xE1, 0x87, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x60, 0x20,
  0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x04,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0x38, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x10, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x40, 0x20,
  0xE0, 0x3E, 0x13, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xC0, 0x61, 0x80, 0x02, 0x03, 0x03, 0x00, 0x18, 0x08, 0x0C, 0x00,
  0xC0, 0x60, 0x30, 0x03, 0x01, 0x00, 0x40, 0x18, 0x0C, 0x01, 0x00, 0x40,
  0x20, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x08, 0x06, 0x00, 0xC0, 0x60, 0x18,
  0x03, 0x03, 0x00, 0x40, 0x0C, 0x0C, 0x03, 0x00, 0x20, 0x60, 0x0C, 0x00,
  0x81, 0x00, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x18, 0x20, 0x02, 0x00, 0x61,
  0x80, 0x08, 0x01, 0x0C, 0x1F, 0x20, 0x0C, 0x30, 0xFE, 0x80, 0x31, 0x86,
  0x1A, 0x01, 0x84, 0x30, 0x38, 0x06, 0x31, 0x80, 0xF0, 0x30, 0x86, 0x03,
  0xC0, 0xC6, 0x30, 0x0F, 0x06, 0x30, 0xC0, 0x37, 0xF0, 0xC2, 0x00, 0xCF,
  0x06, 0x18, 0x03, 0x00, 0x18, 0x60, 0x0C, 0x00, 0xC1, 0x00, 0x30, 0x02,
  0x0C, 0x00, 0x80, 0x18, 0x30, 0x02, 0x00, 0x40, 0xC0, 0x18, 0x03, 0x03,
  0x00, 0x60, 0x18, 0x08, 0x01, 0x80, 0x60, 0x20, 0x04, 0x03, 0x00, 0x80,
  0x30, 0x08, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x01, 0x00, 0x60, 0x18,
  0x0C, 0x00, 0x80, 0x40, 0x60, 0x02, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x0C,
  0x00, 0x30, 0xC0, 0x60, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x08, 0x03,
  0x00, 0x04, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x61,
  0x80, 0x40, 0x31, 0x80, 0x30, 0x11, 0x80, 0x18, 0x18, 0xC0, 0x06, 0x08,
  0xC0, 0x03, 0x0C, 0x60, 0x00, 0x84, 0x30, 0x00, 0x66, 0x10, 0x00, 0x33,
  0x18, 0x00, 0x0B, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01,
  0xC0, 0x80, 0x01, 0xE0, 0x60, 0x01, 0x90, 0x30, 0x01, 0x8C, 0x0C, 0x01,
  0x86, 0x07, 0x03, 0x81, 0x80, 0xFF, 0x80, 0xC0, 0x1C, 0x00, 0x00, 0x18,
  0xC4, 0x23, 0x18, 0x84, 0x23, 0x18, 0x84, 0x23, 0x10, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x30, 0x10,
  0x06, 0x0C, 0x00, 0x62, 0x00, 0x0C, 0x83, 0xC0, 0xFF, 0xC0, 0x18, 0x00,
  0x0F, 0x00, 0x06, 0x40, 0x02, 0x18, 0x03, 0x02, 0x01, 0x80, 0xC0, 0xC0,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x10, 0x01, 0x80, 0x60, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x04,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41,
  0x00, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x62, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x98, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x00, 0x00, 0x42, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x20, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x60, 0x01, 0xC1, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x0E, 0x03, 0xA0, 0x76, 0x0C, 0x63, 0x86, 0x70, 0x4C, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x0E, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x38, 0x03, 0xC0, 0x3C,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x90, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x08, 0x00,
  0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x10, 0x10,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0,
  0x20, 0x00, 0x60, 0x08, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x08, 0x03, 0x00, 0x06,
  0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x7F, 0x00, 0x31,
  0xFF, 0x80, 0x33, 0x00, 0xC0, 0x26, 0x00, 0x60, 0x2C, 0x00, 0x30, 0x78,
  0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x10, 0x60, 0x00, 0x10, 0x60,
  0x00, 0x10, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x20, 0x03, 0x00, 0x30, 0x06, 0x00, 0x1C,
  0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0E, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x02, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0x60, 0x20, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xC6, 0x00, 0x01, 0x81, 0x80, 0x03, 0x80, 0x60,
  0x03, 0x80, 0x18, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x08, 0x60, 0x00,
  0x04, 0x30, 0x00, 0x02, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x70, 0x01, 0xC0, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xC0, 0xE0,
  0x07, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x00, 0x03, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x08, 0x60,
  0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x71, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x83, 0x00, 0x05, 0x06, 0x00, 0x1E,
  0x06, 0x00, 0xEC, 0x0E, 0x03, 0x90, 0x07, 0xFC, 0x60, 0x03, 0xE0, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x07, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0xE0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x0E,
  0x00, 0x43, 0x00, 0x1F, 0xF0, 0x10, 0xC0, 0x0C, 0x08, 0x04, 0x20, 0x06,
  0x02, 0x01, 0x18, 0x03, 0x01, 0x80, 0x46, 0x01, 0x80, 0x60, 0x33, 0x00,
  0xC0, 0x10, 0x0C, 0xC0, 0x30, 0x04, 0x03, 0x30, 0x18, 0x03, 0x00, 0xC8,
  0x06, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x20, 0x09, 0x80, 0xC0, 0x18, 0x02,
  0x60, 0x30, 0x06, 0x01, 0x90, 0x08, 0x01, 0x80, 0x64, 0x06, 0x00, 0x40,
  0x13, 0x01, 0x80, 0x30, 0x0C, 0xC0, 0x60, 0x0C, 0x03, 0x30, 0x18, 0x07,
  0x00, 0x8C, 0x06, 0x01, 0xC0, 0x63, 0x01, 0x80, 0x70, 0x10, 0xC0, 0x60,
  0x3C, 0x0C, 0x30, 0x18, 0x1B, 0x06, 0x0C, 0x03, 0x0C, 0xC3, 0x03, 0x00,
  0xFE, 0x1F, 0x80, 0xC0, 0x1F, 0x03, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x36, 0x00, 0x00, 0x26, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x46, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x86,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x02,
  0x00, 0x06, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x02,
  0x00, 0x18, 0x02, 0x00, 0x18, 0x02, 0x00, 0x30, 0x02, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x60, 0x03, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01,
  0x30, 0x00, 0x01, 0x30, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x18, 0x0F, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x80,
  0x03, 0x80, 0x60, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x40, 0x07, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x20, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18, 0x10,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x20, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0x40, 0x00, 0xC0, 0x10, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x60, 0x07,
  0x00, 0x04, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x40, 0x03,
  0x80, 0x04, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xF0, 0xC0, 0x00, 0xFF, 0xC3, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x01, 0x80, 0x60, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x08, 0x38, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x30, 0x00, 0x80, 0x03,
  0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x10, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x10, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x67,
  0x80, 0x00, 0x02, 0x6C, 0x00, 0x00, 0x16, 0x20, 0x00, 0x01, 0xE1, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x50, 0x00,
  0x00, 0x1A, 0x00, 0xD0, 0x00, 0x00, 0x1E, 0x00, 0xD0, 0x00, 0x00, 0x36,
  0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x90, 0x00, 0x00, 0x64, 0x00, 0x98,
  0x00, 0x00, 0x64, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x01, 0x18, 0x00, 0x01, 0x88, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x03, 0x08, 0x00, 0x03, 0x18, 0x03, 0x08, 0x00,
  0x06, 0x18, 0x03, 0x08, 0x00, 0x06, 0x10, 0x02, 0x08, 0x00, 0x0C, 0x10,
  0x06, 0x08, 0x00, 0x08, 0x30, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x06, 0x0C,
  0x00, 0x10, 0x30, 0x04, 0x0C, 0x00, 0x30, 0x20, 0x04, 0x0C, 0x00, 0x20,
  0x20, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x40, 0x60, 0x0C,
  0x04, 0x00, 0xC0, 0x60, 0x08, 0x04, 0x00, 0x80, 0x40, 0x18, 0x04, 0x01,
  0x80, 0xC0, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x02, 0x00, 0x80, 0x10, 0x06, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x18, 0x01,
  0x80, 0x20, 0x06, 0x18, 0x01, 0x00, 0x20, 0x02, 0x30, 0x01, 0x00, 0x60,
  0x02, 0x30, 0x03, 0x00, 0x60, 0x02, 0x60, 0x03, 0x00, 0x60, 0x02, 0x60,
  0x03, 0x00, 0x40, 0x02, 0xC0, 0x02, 0x00, 0x40, 0x03, 0xC0, 0x06, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x02, 0x00, 0x50,
  0x00, 0x02, 0x00, 0xD0, 0x00, 0x06, 0x00, 0xD8, 0x00, 0x06, 0x00, 0xD8,
  0x00, 0x06, 0x00, 0x88, 0x00, 0x04, 0x00, 0x88, 0x00, 0x0C, 0x01, 0x8C,
  0x00, 0x0C, 0x01, 0x8C, 0x00, 0x0C, 0x01, 0x84, 0x00, 0x0C, 0x01, 0x06,
  0x00, 0x08, 0x03, 0x06, 0x00, 0x18, 0x03, 0x06, 0x00, 0x18, 0x03, 0x02,
  0x00, 0x18, 0x03, 0x03, 0x00, 0x18, 0x02, 0x03, 0x00, 0x10, 0x06, 0x03,
  0x00, 0x30, 0x06, 0x01, 0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x80, 0x60, 0x0C, 0x00,
  0xC0, 0x60, 0x0C, 0x00, 0xC0, 0x60, 0x08, 0x00, 0xC0, 0x40, 0x18, 0x00,
  0x40, 0xC0, 0x18, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x60, 0xC0, 0x18, 0x00,
  0x60, 0xC0, 0x10, 0x00, 0x20, 0x80, 0x30, 0x00, 0x31, 0x80, 0x30, 0x00,
  0x31, 0x80, 0x30, 0x00, 0x31, 0x80, 0x20, 0x00, 0x11, 0x00, 0x20, 0x00,
  0x19, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x60, 0x00,
  0x0B, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x30, 0x3E, 0x00, 0x18, 0x03, 0x80, 0x08, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x02, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0xC0, 0x20, 0x01, 0xC0, 0x10, 0x03, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x30, 0x3E, 0x00, 0x18, 0x03, 0x80, 0x08, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x03, 0x00, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x20, 0x03, 0x80, 0x10, 0x1F, 0x80, 0x1F, 0xFE, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00,
  0x10, 0x02, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0x80, 0x40, 0x00, 0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x01, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x18, 0x03, 0xC0,
  0x3C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x02, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x18, 0x00, 0x40, 0x18, 0x00, 0x40, 0x10, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0x80, 0x00, 0x41, 0x80, 0x00, 0x41, 0x80, 0x00, 0x43, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x46, 0x00, 0x00, 0x46, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x68, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x38, 0x00, 0x04, 0xC0, 0x00, 0x38,
  0x00, 0x0C, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0xC0, 0x00, 0x58, 0x00, 0x18,
  0xC0, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x00, 0x98, 0x00, 0x10, 0xC0, 0x01,
  0x98, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x01, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x18, 0x00, 0x60, 0xC0, 0x02, 0x18, 0x00, 0x40, 0xC0,
  0x06, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x18, 0x00, 0x80, 0xC0, 0x0C, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x08, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x18, 0x02, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x00, 0xC0, 0x20, 0x18, 0x0C,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0x40, 0x18, 0x08, 0x00, 0xC0,
  0xC0, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x00, 0xC4, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x16,
  0x00, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x10, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x01, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x00, 0x20, 0x07, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x64, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20,
  0x01, 0x80, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x01, 0x00, 0x80, 0x04, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x22,
  0x00, 0x00, 0x98, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x31, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x10, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x04, 0x00, 0x1F, 0xC3,
  0x00, 0x79, 0xE2, 0x00, 0xC0, 0x22, 0x01, 0x80, 0x36, 0x03, 0x00, 0x16,
  0x06, 0x00, 0x1C, 0x04, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0,
  0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x40, 0x40, 0x03, 0xC0, 0x60, 0x02, 0xC0,
  0x60, 0x04, 0x80, 0x30, 0x0C, 0x80, 0x38, 0x38, 0x80, 0x1F, 0xE1, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x07, 0xF0,
  0x03, 0x1E, 0x38, 0x03, 0x30, 0x0C, 0x03, 0x60, 0x0C, 0x02, 0xC0, 0x06,
  0x02, 0xC0, 0x06, 0x07, 0x80, 0x02, 0x07, 0x00, 0x02, 0x07, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x02, 0x0C, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10,
  0x70, 0x00, 0x30, 0x70, 0x00, 0x20, 0x50, 0x00, 0x60, 0x50, 0x00, 0xC0,
  0x58, 0x01, 0x80, 0xCC, 0x03, 0x00, 0xCE, 0x0E, 0x00, 0x83, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x0F, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xF0, 0xC0, 0x03, 0xC7, 0x18, 0x00, 0xC0, 0x32, 0x00, 0x30, 0x02,
  0x40, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x07, 0x00, 0x40, 0x00, 0xE0, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x06,
  0x00, 0x0F, 0x00, 0xC0, 0x01, 0xC0, 0x08, 0x00, 0x68, 0x01, 0x80, 0x1B,
  0x00, 0x30, 0x03, 0x60, 0x03, 0x01, 0xCC, 0x00, 0x70, 0x71, 0x00, 0x07,
  0xF8, 0x20, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x8E, 0x00,
  0xC0, 0x60, 0x18, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30,
  0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x0C,
  0x30, 0x01, 0x82, 0x00, 0x30, 0x60, 0x0E, 0x06, 0x0F, 0x80, 0x7F, 0xC0,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x02, 0x01,
  0xC0, 0xE0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x70, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xC0, 0x07, 0x8E, 0x30, 0x03,
  0x00, 0xC8, 0x01, 0x80, 0x12, 0x00, 0xC0, 0x06, 0x80, 0x60, 0x00, 0xE0,
  0x10, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x02, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x04,
  0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x38, 0x0C, 0x00, 0x1E, 0x03, 0x00, 0x07, 0x00, 0x40, 0x03, 0x40, 0x18,
  0x01, 0xB0, 0x06, 0x00, 0xEC, 0x00, 0xC0, 0x73, 0x00, 0x38, 0x38, 0x80,
  0x07, 0xF8, 0x20, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x80, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x7F, 0x00, 0x47, 0x8E,
  0x03, 0x30, 0x0C, 0x0D, 0x80, 0x30, 0x2C, 0x00, 0x40, 0xA0, 0x01, 0x07,
  0x00, 0x04, 0x1C, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x04, 0x18, 0x00, 0x30, 0x40,
  0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01,
  0x82, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x41, 0x80, 0x01, 0x04,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0xC0, 0x40, 0x06, 0x03, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x20, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x01,
  0x00, 0x04, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00,
  0x08, 0xE0, 0x00, 0x26, 0xC0, 0x01, 0xB3, 0x00, 0x06, 0x8C, 0x00, 0x16,
  0x10, 0x00, 0x70, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x08,
  0x00, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01,
  0x80, 0x18, 0x04, 0x00, 0x60, 0x10, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x01, 0x0F,
  0xE0, 0x3F, 0x80, 0x31, 0xC7, 0x07, 0x1C, 0x03, 0x70, 0x19, 0xC0, 0x60,
  0x34, 0x01, 0x90, 0x03, 0x02, 0x80, 0x0B, 0x00, 0x30, 0x38, 0x00, 0xE0,
  0x03, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC0, 0x03, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x60, 0x01, 0x80, 0x02, 0x06, 0x00, 0x18, 0x00, 0x20,
  0xC0, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x00,
  0x06, 0x08, 0x00, 0x30, 0x00, 0x40, 0x80, 0x03, 0x00, 0x04, 0x18, 0x00,
  0x30, 0x00, 0xC1, 0x80, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x00, 0xC1,
  0x00, 0x06, 0x00, 0x08, 0x30, 0x00, 0x60, 0x01, 0x83, 0x00, 0x04, 0x00,
  0x18, 0x30, 0x00, 0x40, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x10, 0x20, 0x00,
  0xC0, 0x01, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x80, 0x03, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x40, 0x01, 0x80, 0x02, 0x04, 0x00, 0x18, 0x00,
  0x20, 0xC0, 0x01, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x00, 0x60, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x01, 0x07, 0xF0, 0x0C, 0x78, 0xE0, 0x33, 0x00, 0xC0,
  0x98, 0x03, 0x02, 0xC0, 0x04, 0x0E, 0x00, 0x10, 0x70, 0x00, 0x41, 0xC0,
  0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x06, 0x18,
  0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x00, 0x3F,
  0xC0, 0x01, 0xE3, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x18, 0x00, 0x20, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x64,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x06,
  0x07, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0xFE, 0x00,
  0x04, 0x78, 0xE0, 0x01, 0x9C, 0x06, 0x00, 0x36, 0x00, 0xC0, 0x05, 0xC0,
  0x0C, 0x00, 0xB0, 0x01, 0x80, 0x3C, 0x00, 0x10, 0x07, 0x00, 0x02, 0x00,
  0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x30, 0x18, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x10, 0x08,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x40, 0x30, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x10, 0x07, 0x00, 0x06, 0x00, 0xA0, 0x01, 0x80, 0x16, 0x00,
  0x60, 0x06, 0x60, 0x18, 0x00, 0xCE, 0x0E, 0x00, 0x18, 0xFF, 0x80, 0x02,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC3, 0x00, 0x78, 0xE3, 0x00, 0xC0, 0x32, 0x01, 0x80, 0x12, 0x03,
  0x00, 0x1A, 0x06, 0x00, 0x0E, 0x04, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x08,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xE0, 0xC0, 0x01, 0xE0, 0xC0, 0x01, 0xC0, 0x40, 0x03, 0x40, 0x60,
  0x03, 0xC0, 0x60, 0x06, 0xC0, 0x30, 0x0C, 0xC0, 0x38, 0x38, 0x80, 0x1F,
  0xE0, 0x80, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x07, 0xC0, 0xC7,
  0x90, 0x33, 0x00, 0x09, 0x80, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0x87, 0xC0, 0x60, 0x04, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x02, 0x00, 0x18, 0x1E, 0x03, 0x80, 0x3F,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x3F, 0xF9, 0xFF, 0xC1, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x7E, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x81, 0x80, 0x03, 0x02, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x10,
  0x30, 0x00, 0x20, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x60, 0xC0,
  0x01, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00,
  0x78, 0x18, 0x01, 0xA0, 0x18, 0x06, 0x40, 0x38, 0x38, 0x80, 0x3F, 0xE3,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0x20,
  0x00, 0x64, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40,
  0x03, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81,
  0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x08, 0x60, 0x01, 0x08,
  0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02, 0xC0,
  0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1A, 0x00, 0x0C, 0x00, 0x34, 0x00,
  0x38, 0x00, 0x48, 0x00, 0x50, 0x01, 0x90, 0x01, 0xA0, 0x02, 0x20, 0x03,
  0x40, 0x0C, 0x40, 0x04, 0x80, 0x18, 0x80, 0x19, 0x00, 0x21, 0x00, 0x22,
  0x00, 0xC2, 0x00, 0xC4, 0x01, 0x04, 0x01, 0x08, 0x06, 0x08, 0x06, 0x10,
  0x0C, 0x10, 0x08, 0x20, 0x30, 0x20, 0x30, 0x40, 0x60, 0x40, 0x60, 0x80,
  0x80, 0x80, 0x81, 0x83, 0x01, 0x03, 0x03, 0x04, 0x02, 0x04, 0x06, 0x18,
  0x04, 0x18, 0x0C, 0x30, 0x08, 0x20, 0x18, 0x40, 0x10, 0xC0, 0x31, 0x80,
  0x31, 0x00, 0x62, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xCC, 0x01, 0x98, 0x01,
  0x90, 0x03, 0x20, 0x03, 0x60, 0x06, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x10, 0x60, 0x00, 0x08, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x40,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x04, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x04, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x05,
  0x81, 0xC0, 0x1E, 0x00, 0xE0, 0x68, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 44, 13, 1, -44 },
  { 67, 13, 16, 17, 6, -44 },
  { 93, 27, 44, 27, 1, -44 },
  { 242, 25, 51, 25, 0, -47 },
  { 402, 30, 46, 37, 4, -45 },
  { 575, 25, 46, 27, 0, -45 },
  { 719, 5, 16, 9, 6, -44 },
  { 729, 17, 54, 15, 2, -44 },
  { 844, 17, 54, 15, -4, -44 },
  { 959, 18, 19, 24, 8, -47 },
  { 1002, 23, 28, 28, 3, -36 },
  { 1083, 8, 14, 10, -3, -6 },
  { 1097, 13, 2, 17, 2, -18 },
  { 1101, 3, 4, 11, 1, -4 },
  { 1103, 26, 44, 18, -3, -44 },
  { 1246, 23, 46, 25, 2, -45 },
  { 1379, 12, 44, 25, 8, -44 },
  { 1445, 25, 45, 25, -1, -45 },
  { 1586, 26, 46, 25, -1, -45 },
  { 1736, 26, 45, 25, -1, -45 },
  { 1883, 26, 45, 25, -1, -44 },
  { 2030, 24, 46, 25, 2, -45 },
  { 2168, 23, 44, 25, 4, -44 },
  { 2295, 25, 46, 25, 0, -45 },
  { 2439, 23, 46, 25, 1, -45 },
  { 2572, 9, 33, 11, 1, -33 },
  { 2610, 13, 41, 11, -3, -33 },
  { 2677, 23, 26, 28, 3, -35 },
  { 2752, 23, 14, 28, 3, -29 },
  { 2793, 23, 26, 28, 3, -35 },
  { 2868, 18, 45, 18, 2, -45 },
  { 2970, 34, 50, 38, 2, -44 },
  { 3183, 24, 44, 24, -4, -44 },
  { 3315, 26, 44, 27, 1, -44 },
  { 3458, 27, 46, 26, 3, -45 },
  { 3614, 28, 44, 30, 1, -44 },
  { 3768, 26, 44, 25, 1, -44 },
  { 3911, 26, 44, 23, 1, -44 },
  { 4054, 30, 46, 32, 3, -45 },
  { 4227, 31, 44, 32, 1, -44 },
  { 4398, 18, 44, 12, -2, -44 },
  { 4497, 21, 55, 11, -9, -44 },
  { 4642, 29, 44, 25, 1, -44 },
  { 4802, 16, 44, 22, 1, -44 },
  { 4890, 40, 44, 40, 1, -44 },
  { 5110, 32, 44, 33, 1, -44 },
  { 5286, 28, 46, 33, 3, -45 },
  { 5447, 25, 44, 26, 1, -44 },
  { 5585, 28, 56, 33, 3, -45 },
  { 5781, 25, 44, 26, 1, -44 },
  { 5919, 26, 46, 24, -1, -45 },
  { 6069, 22, 44, 22, 5, -44 },
  { 6190, 29, 45, 31, 3, -44 },
  { 6354, 24, 44, 25, 6, -44 },
  { 6486, 40, 44, 41, 6, -44 },
  { 6706, 31, 44, 22, -4, -44 },
  { 6877, 22, 44, 22, 5, -44 },
  { 6998, 28, 44, 23, -2, -44 },
  { 7152, 22, 54, 18, -1, -44 },
  { 7301, 9, 44, 20, 6, -44 },
  { 7351, 22, 54, 18, -4, -44 },
  { 7500, 24, 23, 27, 2, -44 },
  { 7569, 18, 2, 18, -5, 6 },
  { 7574, 6, 9, 13, 9, -47 },
  { 7581, 24, 34, 27, 2, -33 },
  { 7683, 24, 48, 27, 1, -47 },
  { 7827, 19, 34, 20, 2, -33 },
  { 7908, 27, 48, 27, 2, -47 },
  { 8070, 20, 34, 23, 2, -33 },
  { 8155, 29, 62, 13, -8, -47 },
  { 8380, 26, 48, 27, 0, -33 },
  { 8536, 22, 47, 26, 1, -47 },
  { 8666, 11, 44, 11, 1, -44 },
  { 8727, 20, 59, 11, -8, -44 },
  { 8875, 22, 47, 21, 1, -47 },
  { 9005, 11, 47, 10, 1, -47 },
  { 9070, 36, 33, 39, 1, -33 },
  { 9219, 22, 33, 26, 1, -33 },
  { 9310, 22, 34, 26, 2, -33 },
  { 9404, 27, 47, 27, -2, -33 },
  { 9563, 24, 47, 27, 2, -33 },
  { 9704, 18, 33, 17, 1, -33 },
  { 9779, 21, 34, 20, -1, -33 },
  { 9869, 13, 42, 14, 2, -41 },
  { 9938, 23, 34, 26, 2, -33 },
  { 10036, 19, 33, 19, 3, -33 },
  { 10115, 31, 33, 32, 4, -33 },
  { 10243, 25, 33, 21, -2, -33 },
  { 10347, 30, 48, 20, -7, -33 },
  { 10527, 21, 33, 18, -2, -33 },
  { 10614, 21, 54, 20, 2, -44 },
  { 10756, 2, 62, 25, 12, -47 },
  { 10772, 21, 54, 19, -4, -44 },
  { 10914, 23, 6, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_THINITALIC62PT7B_H_
