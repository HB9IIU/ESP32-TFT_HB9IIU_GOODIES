#ifndef _NOTOSANS_CONDENSED_THINITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x0C, 0x00, 0x18, 0x22, 0x0C, 0x41, 0x98, 0x33, 0x04, 0x40, 0x88, 0x31,
  0x06, 0x60, 0x8C, 0x11, 0x02, 0x20, 0xC4, 0x11, 0x82, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x18,
  0x08, 0x00, 0x10, 0x18, 0x00, 0x10, 0x10, 0x00, 0x30, 0x10, 0x00, 0x20,
  0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x20, 0x1F, 0xFF,
  0xFF, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0xC0, 0x00, 0x80,
  0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x03, 0x01,
  0x00, 0x03, 0x01, 0x00, 0x02, 0x03, 0x00, 0x06, 0x02, 0x00, 0x06, 0x02,
  0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x0C,
  0x00, 0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18,
  0x00, 0x30, 0x10, 0x00, 0x30, 0x10, 0x00, 0x20, 0x30, 0x00, 0x20, 0x20,
  0x00, 0x60, 0x20, 0x00, 0x40, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0,
  0x0E, 0x21, 0xC0, 0x60, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x20,
  0x60, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0,
  0x00, 0x83, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x80, 0x00,
  0x36, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x05,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x86, 0x00, 0x02, 0x08, 0x00, 0x08, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00,
  0x40, 0xC0, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0xC0, 0x86,
  0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x80,
  0xE6, 0x00, 0x20, 0x30, 0x40, 0x0C, 0x04, 0x0C, 0x01, 0x01, 0x81, 0x80,
  0x60, 0x20, 0x30, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xC0, 0x40, 0x20,
  0x18, 0x18, 0x0C, 0x03, 0x06, 0x01, 0x80, 0x40, 0x80, 0x20, 0x08, 0x30,
  0x04, 0x01, 0x04, 0x01, 0x80, 0x61, 0x80, 0x30, 0x0C, 0x20, 0x06, 0x01,
  0x0C, 0x10, 0xC0, 0x63, 0x0F, 0x98, 0x0C, 0x43, 0x1B, 0x01, 0x18, 0xC1,
  0x60, 0x62, 0x30, 0x2C, 0x08, 0xC4, 0x06, 0x83, 0x11, 0x80, 0xD9, 0xC6,
  0x20, 0x19, 0xE0, 0x84, 0x02, 0x00, 0x21, 0x80, 0x40, 0x0C, 0x20, 0x08,
  0x01, 0x04, 0x01, 0x00, 0x60, 0x80, 0x60, 0x08, 0x30, 0x0C, 0x03, 0x06,
  0x01, 0x00, 0x40, 0xC0, 0x20, 0x18, 0x10, 0x0C, 0x06, 0x02, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x08, 0x0C, 0x04, 0x01, 0x81, 0x01, 0x80, 0x30,
  0x60, 0x20, 0x02, 0x18, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40,
  0x20, 0x03, 0x00, 0x80, 0x08, 0x02, 0x00, 0x20, 0x08, 0x00, 0x80, 0x60,
  0x02, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x81, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x11, 0x80, 0x00, 0x5C, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x10, 0x00, 0x18, 0x40, 0x00,
  0xC1, 0x80, 0xC6, 0x02, 0x02, 0x10, 0x0C, 0x08, 0xC0, 0x10, 0x62, 0x00,
  0x41, 0x18, 0x01, 0x8C, 0x40, 0x02, 0x21, 0x00, 0x0D, 0x8C, 0x00, 0x14,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x3C, 0x10,
  0x01, 0xB0, 0x60, 0x0C, 0x40, 0xC0, 0xE1, 0x81, 0xFE, 0x02, 0x00, 0x80,
  0x00, 0x18, 0x84, 0x63, 0x10, 0x84, 0x63, 0x10, 0x84, 0x60, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x08, 0x18, 0x1C,
  0x20, 0x0C, 0x40, 0x06, 0x87, 0x03, 0xF0, 0x06, 0x00, 0x12, 0x00, 0x44,
  0x03, 0x0C, 0x0C, 0x08, 0x30, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x04, 0x30, 0xC2, 0x18, 0x43, 0x08, 0x21, 0x04, 0x20, 0xFF, 0xE0,
  0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x0E, 0x70, 0x03, 0x03, 0x00, 0xC0, 0x30,
  0x30, 0x06, 0x04, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x21,
  0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0x4C,
  0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0x20,
  0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x04, 0xC0,
  0x00, 0x90, 0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00,
  0x06, 0x20, 0x00, 0x84, 0x00, 0x30, 0x80, 0x04, 0x18, 0x01, 0x83, 0x00,
  0x60, 0x20, 0x08, 0x06, 0x03, 0x00, 0x61, 0xC0, 0x07, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x70, 0x3C, 0x1B, 0x18, 0x8C, 0x26, 0x0B, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xE1, 0xC0, 0x0C, 0x01, 0x80, 0x20,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0xE0, 0x07, 0x80, 0x60, 0x04,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x08, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x68, 0x00,
  0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x08,
  0x40, 0x00, 0x61, 0x00, 0x03, 0x04, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x02, 0x00, 0x08, 0x08, 0x00, 0x40, 0x60, 0x03, 0x01, 0x80, 0x08,
  0x04, 0x00, 0x40, 0x10, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x0C,
  0x03, 0x00, 0x20, 0x18, 0x00, 0x80, 0x40, 0x02, 0x03, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0D, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x80, 0x0C, 0x03, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xE0, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x06, 0x00, 0x23, 0xFC, 0x01, 0x30, 0x38, 0x1B, 0x00,
  0x40, 0xB0, 0x03, 0x07, 0x00, 0x08, 0x30, 0x00, 0x41, 0x80, 0x02, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x01,
  0x08, 0x00, 0x18, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20, 0xC0,
  0x03, 0x06, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80, 0x18, 0x06, 0x01, 0x80,
  0x18, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xE3, 0x80, 0x0C, 0x03, 0x00, 0x20, 0x06, 0x01, 0x80, 0x08,
  0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x08,
  0x00, 0x30, 0x20, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x18, 0x04, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x20, 0x30, 0x00, 0xC1, 0x80, 0x01, 0x98, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xC6, 0x00, 0x1C, 0x08, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x60, 0x30, 0x00, 0x80, 0x80, 0x03, 0x06, 0x00, 0x04,
  0x10, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30,
  0x00, 0x10, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x08, 0x18, 0x00,
  0x60, 0x30, 0x03, 0x00, 0x60, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0x1C, 0x01, 0x80, 0x40, 0x30, 0x06, 0x02, 0x00,
  0x20, 0x60, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x18, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00, 0x06, 0x10, 0x00, 0x61,
  0x80, 0x0A, 0x08, 0x01, 0xE0, 0xC0, 0x36, 0x07, 0x9C, 0x40, 0x1F, 0x84,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x08, 0x1C, 0x00, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x07, 0x06, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x00, 0x40, 0x1C,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1E,
  0x3C, 0x08, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x83, 0x00, 0x18, 0x03,
  0x08, 0x03, 0xFC, 0x0C, 0x60, 0x18, 0x30, 0x31, 0x00, 0xC0, 0xC0, 0xCC,
  0x06, 0x02, 0x03, 0x30, 0x10, 0x08, 0x08, 0x80, 0xC0, 0x60, 0x26, 0x02,
  0x01, 0x80, 0x98, 0x18, 0x04, 0x02, 0x40, 0x40, 0x10, 0x19, 0x03, 0x00,
  0xC0, 0x6C, 0x0C, 0x03, 0x01, 0x30, 0x20, 0x08, 0x04, 0xC0, 0x80, 0x60,
  0x33, 0x02, 0x01, 0x80, 0x88, 0x08, 0x06, 0x06, 0x20, 0x20, 0x38, 0x18,
  0x80, 0x80, 0xC0, 0xC2, 0x02, 0x05, 0x82, 0x08, 0x0C, 0x36, 0x18, 0x20,
  0x19, 0x8D, 0xC0, 0x80, 0x3C, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00,
  0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x02, 0x20,
  0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x30, 0x01, 0x01, 0x80,
  0x18, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x06, 0x00,
  0x40, 0x3F, 0xFE, 0x03, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80, 0x04, 0x08,
  0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02,
  0x10, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x02, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x20, 0x00,
  0x80, 0x40, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x01,
  0x80, 0x06, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60, 0x18, 0x03, 0x80, 0x3F,
  0xF8, 0x00, 0x60, 0xF8, 0x00, 0x80, 0x1C, 0x01, 0x00, 0x08, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x30, 0x20, 0x00, 0x60, 0x40, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x10, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x00, 0x06, 0x02,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0xC0, 0x08, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x40, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x80, 0x70, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x00,
  0x06, 0x01, 0x00, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x01,
  0x80, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0xC1, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x10, 0x0F,
  0xFF, 0x80, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x83, 0xE0, 0x03,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFC,
  0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x0C, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x03, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x80, 0x18, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x10,
  0x08, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x40, 0x20, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x3F, 0xFF, 0xF8, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x60, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x10,
  0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x08, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0x40, 0x20, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x21, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x20, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x04, 0x00, 0xC0,
  0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0,
  0x00, 0x40, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x08, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x68,
  0x00, 0x01, 0x24, 0x00, 0x00, 0xA3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x70,
  0x40, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x02, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x80,
  0x10, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x02, 0x00, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xA0, 0x1C, 0x00, 0x00, 0x3C, 0x02,
  0xC0, 0x00, 0x05, 0x80, 0x58, 0x00, 0x01, 0xA0, 0x0B, 0x00, 0x00, 0x24,
  0x03, 0x60, 0x00, 0x0C, 0x80, 0x64, 0x00, 0x01, 0x30, 0x08, 0x80, 0x00,
  0x66, 0x01, 0x10, 0x00, 0x08, 0x80, 0x62, 0x00, 0x03, 0x10, 0x0C, 0x40,
  0x00, 0x42, 0x01, 0x88, 0x00, 0x18, 0xC0, 0x21, 0x00, 0x02, 0x10, 0x04,
  0x30, 0x00, 0xC2, 0x01, 0x86, 0x00, 0x10, 0x40, 0x30, 0xC0, 0x06, 0x18,
  0x04, 0x18, 0x00, 0x83, 0x00, 0x81, 0x00, 0x30, 0x40, 0x10, 0x20, 0x04,
  0x08, 0x06, 0x04, 0x01, 0x81, 0x00, 0xC0, 0x80, 0x20, 0x60, 0x10, 0x10,
  0x0C, 0x0C, 0x02, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x60, 0x20, 0x18,
  0x0C, 0x18, 0x04, 0x03, 0x01, 0x82, 0x01, 0x80, 0x40, 0x30, 0xC0, 0x30,
  0x08, 0x06, 0x10, 0x04, 0x03, 0x00, 0x46, 0x00, 0x80, 0x60, 0x08, 0x80,
  0x30, 0x0C, 0x01, 0x30, 0x06, 0x01, 0x00, 0x24, 0x00, 0x80, 0x20, 0x05,
  0x80, 0x10, 0x0C, 0x00, 0xA0, 0x02, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x20, 0x1C, 0x00, 0x02, 0x01, 0xE0, 0x00, 0x60, 0x12, 0x00,
  0x06, 0x01, 0x20, 0x00, 0x60, 0x12, 0x00, 0x04, 0x03, 0x30, 0x00, 0x40,
  0x31, 0x00, 0x0C, 0x02, 0x10, 0x00, 0xC0, 0x21, 0x00, 0x08, 0x06, 0x18,
  0x00, 0x80, 0x60, 0x80, 0x08, 0x06, 0x08, 0x01, 0x80, 0x40, 0xC0, 0x18,
  0x04, 0x0C, 0x01, 0x00, 0xC0, 0x40, 0x10, 0x0C, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x20, 0x20, 0x18, 0x02, 0x02,
  0x01, 0x80, 0x30, 0x60, 0x10, 0x03, 0x06, 0x01, 0x00, 0x10, 0x40, 0x10,
  0x01, 0x04, 0x03, 0x00, 0x18, 0x40, 0x30, 0x01, 0x8C, 0x02, 0x00, 0x08,
  0xC0, 0x20, 0x00, 0x88, 0x06, 0x00, 0x0C, 0x80, 0x60, 0x00, 0xC8, 0x06,
  0x00, 0x05, 0x80, 0x40, 0x00, 0x58, 0x04, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x04, 0x01, 0x00, 0x06,
  0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x60, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x18, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x08, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x04,
  0x00, 0x20, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x20,
  0x60, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00, 0x30, 0x30, 0x00, 0x80, 0xC0,
  0x06, 0x02, 0x00, 0x70, 0x08, 0x07, 0x00, 0x3F, 0xF0, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x04, 0x01, 0x00, 0x06,
  0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x60, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x08, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x04,
  0x00, 0x20, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x20,
  0x60, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0,
  0x0C, 0x02, 0x00, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0x81, 0x80,
  0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x30, 0x01, 0x00, 0xC0, 0x0C,
  0x01, 0x00, 0x30, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x18, 0x00,
  0x80, 0x60, 0x02, 0x01, 0x80, 0x08, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0,
  0xC0, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x78, 0x7C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x70, 0x1C, 0x01, 0x80, 0x1F, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x81,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x40, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0x80, 0x00, 0x60, 0x40,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08,
  0x00, 0x06, 0x04, 0x00, 0x03, 0x02, 0x00, 0x01, 0x01, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x01, 0x80, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x48,
  0x00, 0x06, 0x40, 0x00, 0x32, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60,
  0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0x40, 0x08, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00, 0x20, 0x10, 0x01, 0x01,
  0x80, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x60, 0x00,
  0x82, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0xC0,
  0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x05,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x03, 0x60, 0x00, 0x60,
  0x00, 0x4C, 0x00, 0x1C, 0x00, 0x09, 0x80, 0x02, 0x80, 0x03, 0x30, 0x00,
  0xD0, 0x00, 0x46, 0x00, 0x12, 0x00, 0x18, 0xC0, 0x06, 0x40, 0x02, 0x18,
  0x00, 0xC8, 0x00, 0xC3, 0x00, 0x11, 0x00, 0x18, 0x60, 0x06, 0x20, 0x02,
  0x0C, 0x00, 0x84, 0x00, 0xC1, 0x80, 0x30, 0x80, 0x10, 0x30, 0x04, 0x10,
  0x06, 0x06, 0x00, 0x82, 0x00, 0x80, 0xC0, 0x30, 0x40, 0x10, 0x18, 0x04,
  0x08, 0x06, 0x03, 0x01, 0x81, 0x00, 0x80, 0x60, 0x20, 0x20, 0x30, 0x0C,
  0x0C, 0x04, 0x04, 0x01, 0x81, 0x00, 0x81, 0x80, 0x30, 0x20, 0x10, 0x30,
  0x06, 0x0C, 0x02, 0x04, 0x00, 0xC1, 0x00, 0x41, 0x80, 0x18, 0x60, 0x08,
  0x20, 0x03, 0x08, 0x01, 0x0C, 0x00, 0x61, 0x00, 0x21, 0x00, 0x0C, 0x60,
  0x04, 0x20, 0x01, 0x88, 0x00, 0x8C, 0x00, 0x33, 0x00, 0x11, 0x00, 0x06,
  0x40, 0x02, 0x60, 0x00, 0xD8, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x09, 0x00,
  0x03, 0x40, 0x01, 0x40, 0x00, 0x78, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x08, 0x00, 0x30, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40,
  0x30, 0x00, 0x10, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x08, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x10, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x10,
  0x00, 0x10, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0B, 0x00, 0x06, 0xC0, 0x01, 0x30, 0x00, 0xC4, 0x00, 0x61, 0x00, 0x10,
  0x40, 0x0C, 0x10, 0x02, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x20, 0x20, 0x08,
  0x18, 0x02, 0x04, 0x00, 0x83, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x30,
  0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x02, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81, 0x03, 0x06, 0x04,
  0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x20,
  0x40, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x80, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x58, 0x00, 0x06, 0x40, 0x00, 0x63, 0x00, 0x02, 0x08, 0x00,
  0x30, 0x60, 0x01, 0x03, 0x00, 0x18, 0x08, 0x00, 0x80, 0x60, 0x0C, 0x01,
  0x00, 0xC0, 0x0C, 0x04, 0x00, 0x60, 0x60, 0x01, 0x02, 0x00, 0x0C, 0x30,
  0x00, 0x23, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC6, 0x10, 0x42, 0x08, 0x41, 0x00, 0x7E, 0x00, 0x0E, 0x71,
  0x03, 0x81, 0x90, 0x60, 0x0B, 0x04, 0x00, 0xE0, 0xC0, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00,
  0x0C, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x00, 0x8C, 0x00, 0x08, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08,
  0x00, 0x30, 0x80, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x0A, 0x04, 0x01, 0xA0,
  0x60, 0x32, 0x03, 0x06, 0x60, 0x1F, 0xC4, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x1F, 0x80, 0x23, 0x9C, 0x06, 0x60, 0x60,
  0x48, 0x02, 0x05, 0x80, 0x30, 0x70, 0x01, 0x0E, 0x00, 0x10, 0xE0, 0x01,
  0x0C, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00,
  0x11, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00,
  0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x0C, 0x60,
  0x00, 0x86, 0x00, 0x18, 0x70, 0x03, 0x0D, 0x00, 0x20, 0x98, 0x06, 0x08,
  0xC1, 0xC0, 0x87, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x79, 0xC0,
  0xE0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x02, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x03, 0xE1,
  0x80, 0x1C, 0xE2, 0x00, 0xE0, 0x64, 0x03, 0x00, 0x68, 0x04, 0x00, 0x70,
  0x18, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x08, 0x00, 0x10, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40, 0x80,
  0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x40, 0x01, 0xC0, 0x80, 0x03, 0x01, 0x00, 0x06,
  0x02, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0xF0, 0x08, 0x03, 0x40,
  0x18, 0x0C, 0x80, 0x18, 0x31, 0x00, 0x1F, 0xC6, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x73, 0x80, 0xE0, 0x60, 0xC0, 0x30, 0x40, 0x08, 0x60,
  0x04, 0x60, 0x02, 0x20, 0x03, 0x30, 0x01, 0x10, 0x01, 0x88, 0x00, 0x8C,
  0x01, 0x84, 0x01, 0x82, 0x07, 0x81, 0xFE, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0x03, 0x01,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x40, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x09, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x73, 0x88, 0x03,
  0x81, 0x90, 0x0C, 0x01, 0xA0, 0x10, 0x01, 0xC0, 0x60, 0x03, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x20, 0x00,
  0x40, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x06, 0x04, 0x00, 0x0C,
  0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x00, 0x07, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00, 0x70, 0x18,
  0x01, 0xE0, 0x30, 0x03, 0x80, 0x20, 0x0D, 0x00, 0x60, 0x32, 0x00, 0x60,
  0xCC, 0x00, 0x7F, 0x18, 0x00, 0x10, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x18, 0x00,
  0xF9, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x21,
  0xF8, 0x04, 0xF3, 0x81, 0xB0, 0x18, 0x3C, 0x01, 0x05, 0x00, 0x20, 0xC0,
  0x04, 0x18, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC2, 0x00,
  0x18, 0xC0, 0x02, 0x18, 0x00, 0x43, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00,
  0x63, 0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01,
  0x0C, 0x00, 0x21, 0x80, 0x04, 0x20, 0x01, 0x84, 0x00, 0x31, 0x80, 0x04,
  0x30, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x00, 0x00, 0x80, 0x70, 0x18,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x09, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x02, 0x04, 0x00, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x04, 0x03, 0x00, 0x80,
  0xC0, 0x30, 0x10, 0x06, 0x04, 0x00, 0x81, 0x00, 0x10, 0x60, 0x02, 0x18,
  0x00, 0xC6, 0x00, 0x19, 0xC0, 0x02, 0x78, 0x00, 0x49, 0x00, 0x0A, 0x20,
  0x03, 0xC6, 0x00, 0x70, 0xC0, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x20, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x0C, 0x04, 0x01, 0x81, 0x80, 0x10,
  0x30, 0x02, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x04, 0xE7, 0x0E, 0x38, 0x1B, 0x03, 0x30, 0x18,
  0x2C, 0x02, 0xC0, 0x30, 0x50, 0x05, 0x00, 0x20, 0xC0, 0x0E, 0x00, 0x43,
  0x80, 0x18, 0x00, 0x86, 0x00, 0x30, 0x01, 0x0C, 0x00, 0x40, 0x06, 0x18,
  0x00, 0x80, 0x0C, 0x20, 0x03, 0x00, 0x10, 0xC0, 0x06, 0x00, 0x21, 0x80,
  0x08, 0x00, 0xC2, 0x00, 0x10, 0x01, 0x84, 0x00, 0x60, 0x02, 0x08, 0x00,
  0xC0, 0x04, 0x30, 0x01, 0x00, 0x08, 0x60, 0x02, 0x00, 0x30, 0x80, 0x04,
  0x00, 0x61, 0x00, 0x18, 0x00, 0x82, 0x00, 0x30, 0x01, 0x0C, 0x00, 0x40,
  0x02, 0x18, 0x00, 0x80, 0x0C, 0x20, 0x01, 0x00, 0x18, 0x40, 0x06, 0x00,
  0x21, 0x80, 0x0C, 0x00, 0x43, 0x00, 0x10, 0x01, 0x84, 0x00, 0x20, 0x03,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x4F, 0x38, 0x1B, 0x01,
  0x82, 0xC0, 0x10, 0x50, 0x02, 0x0C, 0x00, 0x43, 0x80, 0x08, 0x60, 0x01,
  0x0C, 0x00, 0x21, 0x80, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x10,
  0x80, 0x06, 0x10, 0x00, 0xC2, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0x42,
  0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x60, 0x00, 0x7E, 0x00, 0x3C, 0xE0, 0x0C, 0x06, 0x03, 0x00, 0x60,
  0x40, 0x04, 0x18, 0x00, 0x86, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x0C, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0x80, 0x00, 0x90,
  0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x40,
  0x00, 0xC8, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xC6, 0x00, 0x10, 0xC0,
  0x06, 0x08, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18, 0x01, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x8E, 0x70, 0x03, 0x30, 0x30, 0x04,
  0xC0, 0x20, 0x0B, 0x00, 0x60, 0x1C, 0x00, 0x40, 0x30, 0x00, 0x80, 0xE0,
  0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08, 0x18, 0x00,
  0x10, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40, 0x80, 0x01, 0x81, 0x00, 0x03,
  0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x20, 0x00, 0x60,
  0x40, 0x00, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x14, 0x00, 0x80, 0x68, 0x03, 0x00, 0xCC, 0x18, 0x01, 0x0F,
  0xE0, 0x02, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x08, 0x07, 0x38, 0x80, 0xC0, 0x64, 0x0C, 0x01, 0xA0, 0x40,
  0x07, 0x06, 0x00, 0x38, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00,
  0x61, 0x00, 0x03, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40, 0x01, 0x82, 0x00, 0x1C,
  0x18, 0x00, 0xE0, 0xC0, 0x0F, 0x02, 0x00, 0xD0, 0x18, 0x0C, 0x80, 0x60,
  0xCC, 0x01, 0xFC, 0x60, 0x01, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0x02, 0x79, 0x06, 0xC0, 0x05, 0x80, 0x05,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x00, 0xFE, 0x01, 0xE7, 0xC1, 0x80, 0x21, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x0C, 0x18, 0x0C,
  0x0F, 0xFC, 0x00, 0x20, 0x00, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x03, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x7E, 0x00, 0x80, 0x0C,
  0x00, 0x21, 0x80, 0x04, 0x20, 0x01, 0x84, 0x00, 0x30, 0x80, 0x04, 0x30,
  0x00, 0x86, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x10, 0xC0,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x43, 0x00,
  0x08, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x00, 0x0C, 0x20, 0x03, 0x84, 0x00, 0xE0, 0x80, 0x14, 0x18, 0x04,
  0x81, 0x83, 0x10, 0x1F, 0xC6, 0x00, 0x40, 0x00, 0x80, 0x01, 0xC0, 0x01,
  0xA0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x63, 0x00, 0x21, 0x80,
  0x30, 0xC0, 0x10, 0x60, 0x18, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02,
  0x06, 0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00, 0x21, 0x80, 0x10, 0x80,
  0x08, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x78,
  0x01, 0xC0, 0x0B, 0x00, 0x38, 0x03, 0x60, 0x07, 0x00, 0x4C, 0x01, 0x60,
  0x09, 0x80, 0x2C, 0x03, 0x30, 0x0D, 0x80, 0x46, 0x01, 0x30, 0x18, 0xC0,
  0x66, 0x02, 0x18, 0x08, 0x40, 0x43, 0x03, 0x08, 0x18, 0x60, 0x41, 0x02,
  0x0C, 0x08, 0x20, 0xC1, 0x82, 0x04, 0x10, 0x30, 0x40, 0x82, 0x06, 0x18,
  0x10, 0x80, 0xC2, 0x02, 0x10, 0x18, 0xC0, 0x46, 0x01, 0x10, 0x08, 0x80,
  0x26, 0x01, 0x30, 0x04, 0x80, 0x24, 0x00, 0x90, 0x04, 0x80, 0x16, 0x00,
  0xB0, 0x02, 0x80, 0x14, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x04, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x20, 0x18, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x98, 0x00, 0x06,
  0xC0, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00, 0x30, 0x80, 0x00,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x06, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x80, 0x08, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x02, 0x00, 0x08, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x40, 0x60, 0x00, 0x10, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x02, 0x30, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x1F, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x03, 0x80, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x0B, 0x07, 0x00,
  0xF0, 0x0F, 0x1D, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 39, 11, 1, -39 },
  { 50, 11, 14, 15, 5, -39 },
  { 70, 24, 39, 24, 1, -39 },
  { 187, 22, 44, 22, 0, -41 },
  { 308, 27, 40, 32, 3, -39 },
  { 443, 22, 40, 23, 0, -39 },
  { 553, 5, 14, 8, 5, -39 },
  { 562, 14, 47, 13, 2, -38 },
  { 645, 15, 47, 13, -4, -38 },
  { 734, 15, 17, 21, 7, -41 },
  { 766, 21, 24, 24, 2, -31 },
  { 829, 6, 12, 9, -2, -5 },
  { 838, 11, 1, 15, 2, -15 },
  { 840, 3, 3, 9, 1, -3 },
  { 842, 22, 39, 16, -2, -39 },
  { 950, 19, 40, 22, 2, -39 },
  { 1045, 10, 39, 22, 7, -39 },
  { 1094, 22, 39, 22, -1, -39 },
  { 1202, 23, 40, 22, -1, -39 },
  { 1317, 22, 39, 22, -1, -39 },
  { 1425, 22, 40, 22, 0, -39 },
  { 1535, 21, 40, 22, 2, -39 },
  { 1640, 20, 39, 22, 3, -39 },
  { 1738, 22, 40, 22, 0, -39 },
  { 1848, 20, 40, 22, 1, -39 },
  { 1948, 8, 29, 9, 1, -29 },
  { 1977, 11, 36, 9, -2, -29 },
  { 2027, 21, 23, 24, 2, -31 },
  { 2088, 21, 12, 24, 2, -25 },
  { 2120, 21, 23, 24, 2, -31 },
  { 2181, 16, 39, 16, 2, -39 },
  { 2259, 30, 44, 33, 2, -39 },
  { 2424, 21, 39, 21, -3, -39 },
  { 2527, 23, 39, 24, 1, -39 },
  { 2640, 23, 40, 22, 3, -39 },
  { 2755, 24, 39, 27, 1, -39 },
  { 2872, 22, 39, 21, 1, -39 },
  { 2980, 22, 39, 20, 1, -39 },
  { 3088, 26, 40, 28, 3, -39 },
  { 3218, 27, 39, 28, 1, -39 },
  { 3350, 16, 39, 11, -2, -39 },
  { 3428, 19, 48, 10, -8, -39 },
  { 3542, 25, 39, 22, 1, -39 },
  { 3664, 14, 39, 19, 1, -39 },
  { 3733, 35, 39, 35, 1, -39 },
  { 3904, 28, 39, 28, 1, -39 },
  { 4041, 24, 40, 28, 3, -39 },
  { 4161, 22, 39, 22, 1, -39 },
  { 4269, 24, 48, 28, 3, -39 },
  { 4413, 22, 39, 23, 1, -39 },
  { 4521, 23, 40, 21, -1, -39 },
  { 4636, 18, 39, 19, 5, -39 },
  { 4724, 25, 40, 27, 3, -39 },
  { 4849, 21, 39, 22, 5, -39 },
  { 4952, 35, 39, 36, 5, -39 },
  { 5123, 26, 39, 19, -3, -39 },
  { 5250, 18, 39, 19, 5, -39 },
  { 5338, 25, 39, 20, -2, -39 },
  { 5460, 20, 48, 15, -1, -39 },
  { 5580, 7, 39, 17, 6, -39 },
  { 5615, 19, 48, 15, -3, -39 },
  { 5729, 21, 20, 24, 2, -39 },
  { 5782, 16, 2, 16, -4, 5 },
  { 5786, 5, 8, 11, 8, -41 },
  { 5791, 20, 30, 23, 2, -29 },
  { 5866, 20, 42, 23, 1, -41 },
  { 5971, 17, 30, 18, 2, -29 },
  { 6035, 23, 42, 24, 2, -41 },
  { 6156, 17, 30, 20, 2, -29 },
  { 6220, 25, 54, 11, -7, -41 },
  { 6389, 23, 42, 23, 0, -29 },
  { 6510, 19, 41, 22, 1, -41 },
  { 6608, 10, 39, 9, 1, -39 },
  { 6657, 18, 52, 9, -7, -39 },
  { 6774, 19, 41, 18, 1, -41 },
  { 6872, 10, 41, 9, 1, -41 },
  { 6924, 31, 29, 34, 1, -29 },
  { 7037, 19, 29, 22, 1, -29 },
  { 7106, 19, 30, 23, 2, -29 },
  { 7178, 23, 41, 23, -2, -29 },
  { 7296, 21, 42, 24, 2, -29 },
  { 7407, 16, 29, 15, 1, -29 },
  { 7465, 17, 30, 17, 0, -29 },
  { 7529, 12, 36, 12, 1, -35 },
  { 7583, 19, 29, 22, 2, -28 },
  { 7652, 17, 28, 17, 3, -28 },
  { 7712, 27, 28, 28, 3, -28 },
  { 7807, 22, 28, 18, -2, -28 },
  { 7884, 26, 41, 18, -6, -28 },
  { 8018, 18, 28, 16, -1, -28 },
  { 8081, 18, 48, 17, 2, -39 },
  { 8189, 2, 54, 22, 10, -41 },
  { 8203, 18, 48, 17, -3, -39 },
  { 8311, 21, 4, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_THINITALIC54PT7B_H_
