#ifndef _NOTOSANS_CONDENSED_THINITALIC53PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x30,
  0x00, 0x10, 0x62, 0x0C, 0xC1, 0x18, 0x22, 0x04, 0x41, 0x88, 0x23, 0x04,
  0x60, 0x88, 0x11, 0x06, 0x20, 0x8C, 0x11, 0x02, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80,
  0x02, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20, 0x20, 0x00,
  0xC0, 0x40, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x18,
  0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x02, 0x03,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x40,
  0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x30, 0x10, 0x00, 0x40, 0x60, 0x00, 0x80, 0x80, 0x03, 0x01, 0x00, 0x04,
  0x06, 0x00, 0x08, 0x08, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0x80,
  0x80, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xC0, 0x01, 0xFB, 0xF0, 0x0C, 0x20, 0x80, 0x60, 0x80, 0x03, 0x06, 0x00,
  0x08, 0x10, 0x00, 0x60, 0x40, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00, 0x18,
  0x30, 0x00, 0x60, 0x80, 0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x04, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x23, 0x00, 0x00, 0x86, 0x00, 0x02,
  0x08, 0x00, 0x18, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x0C,
  0x00, 0x30, 0x20, 0x00, 0xC1, 0x80, 0x02, 0x06, 0x00, 0x08, 0x30, 0x30,
  0x23, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0x81, 0x8C, 0x00, 0xC0, 0xC1, 0x00, 0x20, 0x60, 0x40, 0x18, 0x10,
  0x18, 0x04, 0x0C, 0x06, 0x03, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x10, 0x30, 0x18, 0x04, 0x08, 0x04, 0x01, 0x06, 0x01, 0x00, 0xC1,
  0x00, 0x40, 0x30, 0xC0, 0x30, 0x08, 0x20, 0x0C, 0x02, 0x10, 0x03, 0x01,
  0x8C, 0x3C, 0xC0, 0x62, 0x19, 0xB0, 0x11, 0x88, 0x3C, 0x0C, 0x46, 0x0F,
  0x02, 0x33, 0x01, 0xC1, 0x88, 0xC0, 0x58, 0xC6, 0x20, 0x13, 0xE3, 0x18,
  0x04, 0x00, 0x84, 0x03, 0x00, 0x61, 0x00, 0xC0, 0x10, 0xC0, 0x30, 0x0C,
  0x30, 0x08, 0x02, 0x0C, 0x02, 0x01, 0x82, 0x00, 0x80, 0xC0, 0x80, 0x60,
  0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x03, 0x03, 0x00, 0x80,
  0x80, 0x80, 0x20, 0x60, 0x60, 0x08, 0x10, 0x30, 0x03, 0x0C, 0x08, 0x00,
  0x7E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x86, 0x00, 0x18,
  0x10, 0x00, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80,
  0x10, 0x0C, 0x00, 0x80, 0x40, 0x04, 0x06, 0x00, 0x20, 0x30, 0x01, 0x03,
  0x00, 0x08, 0x10, 0x00, 0x41, 0x80, 0x03, 0x18, 0x00, 0x09, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x60, 0x00, 0x71, 0x00,
  0x06, 0x0C, 0x00, 0x20, 0x60, 0x23, 0x01, 0x03, 0x30, 0x0C, 0x11, 0x00,
  0x20, 0x98, 0x01, 0x0C, 0x80, 0x0C, 0x44, 0x00, 0x26, 0x60, 0x01, 0xA3,
  0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x14, 0x10, 0x01,
  0xB0, 0xC0, 0x18, 0x83, 0x03, 0x04, 0x0F, 0xF0, 0x30, 0x0C, 0x00, 0x00,
  0x11, 0x33, 0x22, 0x26, 0x64, 0x44, 0xC8, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0xC0, 0x80, 0x30,
  0x80, 0x08, 0x81, 0x06, 0x9F, 0x01, 0xE0, 0x03, 0x80, 0x04, 0x80, 0x08,
  0x40, 0x10, 0x60, 0x60, 0x20, 0x40, 0x30, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x04, 0x30, 0xC2,
  0x18, 0x43, 0x08, 0x21, 0x04, 0x20, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x30,
  0x06, 0x03, 0x00, 0x80, 0x20, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x18,
  0x60, 0x01, 0x08, 0x00, 0x23, 0x00, 0x04, 0x60, 0x01, 0x88, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x02, 0x60, 0x00, 0x4C,
  0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x64, 0x00, 0x0D, 0x80, 0x01, 0x30,
  0x00, 0x26, 0x00, 0x0C, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x01, 0x88, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x04, 0x00, 0x60, 0x80,
  0x08, 0x18, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x10, 0x03, 0x0C, 0x00, 0x3F,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x68, 0x32, 0x18, 0x98, 0x6C,
  0x1A, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC1, 0xC0, 0x0C, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x40, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x20, 0x01, 0x80, 0xE0, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x48, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x43, 0x00, 0x02, 0x0C, 0x00, 0x18,
  0x20, 0x00, 0xC0, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x40,
  0x02, 0x01, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x30, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x20, 0x10, 0x01, 0x80, 0xC0, 0x06,
  0x02, 0x00, 0x10, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F,
  0xF8, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x38, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x81, 0x00, 0x18, 0x0C, 0x03, 0x80, 0x3F,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0x81, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x1F, 0x80, 0x27, 0x0E, 0x06,
  0xC0, 0x30, 0x78, 0x01, 0x05, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x08,
  0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x01,
  0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00,
  0x20, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x40, 0x0C, 0x06, 0x01, 0x80, 0x30,
  0x30, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x81, 0x80,
  0x0C, 0x01, 0x00, 0x60, 0x06, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01,
  0x80, 0xC0, 0x04, 0x03, 0x00, 0x30, 0x04, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x30, 0x60, 0x00, 0x67, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x73,
  0x00, 0x03, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x60,
  0x20, 0x00, 0x81, 0x80, 0x03, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0xC0,
  0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x81, 0x00, 0x06, 0x06, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x1C, 0x01,
  0x80, 0x40, 0x30, 0x06, 0x06, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x30,
  0x80, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03,
  0x10, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x61, 0x00, 0x06, 0x10, 0x00, 0xE1, 0x80, 0x1E, 0x0C, 0x03, 0x40, 0x60,
  0xE4, 0x03, 0xF8, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x81, 0xC0, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x83, 0x06, 0x00, 0x00, 0x40, 0x1C,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x38,
  0x38, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x02, 0x10, 0x03, 0xF0, 0x11, 0x80, 0x71, 0xC0, 0x88, 0x06, 0x04, 0x04,
  0xC0, 0x60, 0x20, 0x26, 0x02, 0x03, 0x03, 0x20, 0x30, 0x18, 0x1B, 0x01,
  0x00, 0x80, 0xD8, 0x18, 0x04, 0x06, 0x80, 0x80, 0x60, 0x24, 0x0C, 0x02,
  0x01, 0x20, 0x60, 0x10, 0x1B, 0x02, 0x01, 0x80, 0xD8, 0x10, 0x0C, 0x04,
  0xC1, 0x80, 0x60, 0x64, 0x0C, 0x06, 0x03, 0x20, 0x60, 0x30, 0x11, 0x03,
  0x03, 0x81, 0x88, 0x08, 0x14, 0x18, 0x40, 0x41, 0xA0, 0x82, 0x03, 0x19,
  0x98, 0x10, 0x0F, 0x87, 0x80, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x0A, 0x00, 0x01, 0x20, 0x00, 0x12,
  0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x0C,
  0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x03,
  0x02, 0x00, 0x20, 0x30, 0x06, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x30, 0x18, 0x03, 0x01, 0xFF, 0xF0, 0x30, 0x03, 0x02, 0x00, 0x10,
  0x60, 0x01, 0x06, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01,
  0x18, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00,
  0x14, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0xFF, 0x80, 0x02,
  0x0F, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x02, 0x01, 0x00, 0x0C, 0x04, 0x00,
  0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x20, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x40,
  0x03, 0x01, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x02, 0x00, 0xE0, 0x08, 0x00, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x06, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00,
  0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x04, 0x18, 0x00, 0x30,
  0x40, 0x00, 0xC1, 0x00, 0x06, 0x04, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0,
  0x7C, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x70, 0x1C, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x60, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x87, 0xE0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x0C, 0x01, 0x00, 0x04, 0x01, 0x00, 0x06, 0x03, 0x00, 0x02, 0x03, 0x00,
  0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x0C, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00,
  0x0C, 0x10, 0x00, 0x08, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x20, 0x00,
  0x30, 0x20, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x01,
  0x80, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0xC1, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0x88, 0x00, 0x7F, 0xC4, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x20, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20,
  0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x08, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x10, 0x08, 0x00, 0x06, 0x01,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x30,
  0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08,
  0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x20, 0x18, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x30, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x10, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x21, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x40, 0x01, 0x00, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x08, 0x01, 0x80, 0x04, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x02, 0x68, 0x00, 0x01, 0x64,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0x40, 0x00, 0x20,
  0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x06,
  0x01, 0x80, 0x02, 0x00, 0x40, 0x01, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0xC0,
  0x18, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0x40,
  0x00, 0x02, 0x80, 0x50, 0x00, 0x01, 0xE0, 0x14, 0x00, 0x00, 0x58, 0x0D,
  0x80, 0x00, 0x34, 0x03, 0x60, 0x00, 0x09, 0x00, 0x98, 0x00, 0x06, 0x40,
  0x22, 0x00, 0x03, 0x30, 0x18, 0x80, 0x00, 0x8C, 0x06, 0x20, 0x00, 0x62,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x42, 0x00, 0x0C, 0x20, 0x10, 0x80, 0x02,
  0x18, 0x0C, 0x20, 0x01, 0x86, 0x03, 0x08, 0x00, 0x41, 0x00, 0x83, 0x00,
  0x30, 0x40, 0x20, 0xC0, 0x08, 0x10, 0x08, 0x30, 0x06, 0x0C, 0x06, 0x04,
  0x01, 0x03, 0x01, 0x81, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x18, 0x18, 0x0C, 0x04, 0x04, 0x06, 0x03, 0x01, 0x03, 0x01, 0x00,
  0xC0, 0x40, 0x80, 0x40, 0x20, 0x10, 0x60, 0x10, 0x08, 0x06, 0x10, 0x0C,
  0x06, 0x01, 0x8C, 0x03, 0x01, 0x80, 0x62, 0x00, 0x80, 0x40, 0x19, 0x80,
  0x20, 0x10, 0x02, 0x40, 0x08, 0x04, 0x00, 0xB0, 0x06, 0x03, 0x00, 0x28,
  0x01, 0x80, 0xC0, 0x0E, 0x00, 0x40, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x18, 0x00, 0x04, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x30, 0x16, 0x00, 0x04, 0x02, 0xC0, 0x00, 0x80, 0x48, 0x00, 0x30, 0x19,
  0x00, 0x06, 0x03, 0x30, 0x00, 0x80, 0x46, 0x00, 0x10, 0x08, 0x40, 0x02,
  0x03, 0x08, 0x00, 0xC0, 0x61, 0x80, 0x18, 0x08, 0x30, 0x02, 0x01, 0x02,
  0x00, 0x40, 0x20, 0x40, 0x08, 0x0C, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x60,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x60, 0x30, 0x0C,
  0x0C, 0x06, 0x00, 0x81, 0x80, 0x80, 0x10, 0x20, 0x10, 0x03, 0x04, 0x06,
  0x00, 0x21, 0x80, 0xC0, 0x04, 0x30, 0x18, 0x00, 0x84, 0x02, 0x00, 0x18,
  0x80, 0x40, 0x01, 0x10, 0x18, 0x00, 0x26, 0x03, 0x00, 0x06, 0xC0, 0x40,
  0x00, 0xD0, 0x08, 0x00, 0x0A, 0x01, 0x00, 0x01, 0x40, 0x60, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x70, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18,
  0x00, 0x02, 0x10, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x40,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x3E, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x10, 0x01, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20,
  0x60, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x0C, 0x00,
  0x10, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x06, 0x0C,
  0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x30, 0x10, 0x07, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x70, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02,
  0x18, 0x00, 0x02, 0x10, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0,
  0x40, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x3E, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x10, 0x01, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x20, 0x60, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x0C,
  0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x06,
  0x0C, 0x00, 0x60, 0x60, 0x06, 0x02, 0x00, 0x60, 0x10, 0x1E, 0x00, 0xFF,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x01, 0x00, 0x10, 0x08, 0x00,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06,
  0x00, 0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x0C,
  0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00, 0x06, 0x08, 0x00, 0x04, 0x18,
  0x00, 0x04, 0x18, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x10,
  0x00, 0x08, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x20, 0x00, 0x18, 0x20,
  0x00, 0x10, 0x60, 0x00, 0x10, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0x40,
  0x00, 0x30, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x40, 0x80, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x00, 0xC0,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06,
  0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01,
  0x88, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00,
  0x40, 0xC0, 0x0C, 0x0C, 0x00, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x40,
  0x30, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00, 0x40, 0x40, 0x04,
  0x0C, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00,
  0x42, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0x58, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x28, 0x00, 0x1C,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00,
  0xD0, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x22, 0x00, 0x19, 0x00, 0x18, 0x80,
  0x04, 0xC0, 0x06, 0x20, 0x01, 0x30, 0x01, 0x08, 0x00, 0xCC, 0x00, 0xC2,
  0x00, 0x23, 0x00, 0x20, 0x80, 0x18, 0xC0, 0x18, 0x20, 0x04, 0x30, 0x04,
  0x08, 0x03, 0x0C, 0x01, 0x02, 0x00, 0x83, 0x00, 0xC0, 0x80, 0x20, 0xC0,
  0x20, 0x20, 0x18, 0x30, 0x18, 0x08, 0x04, 0x0C, 0x04, 0x02, 0x03, 0x03,
  0x03, 0x00, 0xC0, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x30, 0x20, 0x0C, 0x18,
  0x0C, 0x18, 0x03, 0x04, 0x03, 0x04, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x30,
  0x80, 0x30, 0x80, 0x0C, 0x60, 0x0C, 0x20, 0x03, 0x10, 0x03, 0x18, 0x00,
  0xC4, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x0C, 0x80,
  0x03, 0x60, 0x03, 0x20, 0x00, 0xD0, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x34,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x02, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x02, 0x00,
  0x0C, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x10, 0x18,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x02, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x04,
  0x04, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x40, 0x00, 0x40, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x08,
  0x00, 0x80, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0xC0, 0x02, 0x30, 0x01,
  0x84, 0x00, 0x41, 0x00, 0x30, 0x40, 0x08, 0x10, 0x06, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x20, 0x60, 0x08, 0x10, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x21,
  0x80, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0x58, 0x00, 0x14, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x06, 0x02,
  0x02, 0x02, 0x02, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x28, 0x00, 0x06, 0xC0, 0x00, 0x44, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00,
  0x10, 0x20, 0x03, 0x03, 0x00, 0x20, 0x10, 0x06, 0x01, 0x80, 0x40, 0x18,
  0x0C, 0x00, 0x81, 0x80, 0x0C, 0x10, 0x00, 0x43, 0x00, 0x06, 0x20, 0x00,
  0x66, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFE, 0x86, 0x10,
  0x42, 0x08, 0x41, 0x00, 0xFE, 0x10, 0x18, 0x33, 0x03, 0x01, 0xA0, 0x60,
  0x0A, 0x0C, 0x00, 0xA0, 0x80, 0x0E, 0x18, 0x00, 0xC1, 0x00, 0x0C, 0x30,
  0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x40, 0x00, 0x84,
  0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x07, 0x08, 0x00, 0x60, 0xC0, 0x0E,
  0x0C, 0x00, 0xA0, 0x40, 0x16, 0x06, 0x03, 0x40, 0x30, 0x64, 0x01, 0xF8,
  0x40, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x3F,
  0x80, 0x66, 0x0C, 0x04, 0xC0, 0x60, 0x58, 0x02, 0x07, 0x00, 0x30, 0xE0,
  0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x23,
  0x00, 0x02, 0x30, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C,
  0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x06, 0x00, 0x30, 0xF0, 0x06,
  0x09, 0x00, 0xC0, 0x98, 0x18, 0x08, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0x01, 0x81, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x10, 0x1F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F, 0xE1, 0x00, 0x30,
  0x66, 0x00, 0xC0, 0x6C, 0x03, 0x00, 0x50, 0x0C, 0x00, 0xE0, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x04, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x03,
  0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0x40, 0x01, 0x80, 0x80, 0x07, 0x01, 0x00, 0x0E, 0x03, 0x00,
  0x38, 0x06, 0x00, 0x50, 0x04, 0x01, 0xA0, 0x0C, 0x06, 0x40, 0x0C, 0x19,
  0x80, 0x0F, 0xE2, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xC1, 0x80,
  0xC0, 0x40, 0xC0, 0x30, 0xC0, 0x18, 0x40, 0x0C, 0x40, 0x06, 0x60, 0x02,
  0x20, 0x03, 0x10, 0x01, 0x18, 0x01, 0x08, 0x03, 0x04, 0x07, 0x03, 0xFE,
  0x03, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x06, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x84, 0x01, 0x83, 0x10, 0x0C, 0x06, 0xC0, 0x60, 0x0A, 0x03, 0x00, 0x38,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x20,
  0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x00,
  0x83, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x01, 0x02,
  0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x01, 0xC0, 0x80, 0x07, 0x03, 0x00,
  0x38, 0x0C, 0x00, 0xA0, 0x10, 0x06, 0x80, 0x60, 0x36, 0x00, 0xC1, 0x98,
  0x01, 0xFC, 0x40, 0x01, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x3F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x23, 0xF8, 0x0C, 0xC1,
  0x81, 0x20, 0x18, 0x28, 0x03, 0x07, 0x00, 0x21, 0xC0, 0x04, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x02,
  0x10, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0x43, 0x00, 0x18,
  0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x61,
  0x00, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20, 0x01, 0x84,
  0x00, 0x20, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x06, 0x0C,
  0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x04, 0x06, 0x01, 0x80, 0x80, 0x30,
  0x20, 0x04, 0x0C, 0x00, 0x83, 0x00, 0x10, 0xC0, 0x06, 0x30, 0x00, 0xCC,
  0x00, 0x11, 0xC0, 0x02, 0x58, 0x00, 0x51, 0x00, 0x1E, 0x20, 0x03, 0x86,
  0x00, 0x60, 0x40, 0x08, 0x08, 0x03, 0x01, 0x00, 0x60, 0x30, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x10, 0x20, 0x02,
  0x04, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x02, 0x3F, 0x03, 0xF8, 0x0D, 0x83, 0x1C,
  0x18, 0x16, 0x03, 0x60, 0x10, 0x28, 0x02, 0x80, 0x20, 0x60, 0x06, 0x00,
  0x61, 0xC0, 0x0C, 0x00, 0x83, 0x00, 0x10, 0x01, 0x06, 0x00, 0x20, 0x02,
  0x0C, 0x00, 0xC0, 0x04, 0x10, 0x01, 0x80, 0x18, 0x60, 0x02, 0x00, 0x30,
  0xC0, 0x04, 0x00, 0x41, 0x00, 0x18, 0x00, 0x82, 0x00, 0x30, 0x01, 0x04,
  0x00, 0x40, 0x06, 0x18, 0x00, 0x80, 0x0C, 0x30, 0x01, 0x00, 0x10, 0x40,
  0x06, 0x00, 0x20, 0x80, 0x0C, 0x00, 0x41, 0x00, 0x10, 0x01, 0x86, 0x00,
  0x20, 0x02, 0x0C, 0x00, 0xC0, 0x04, 0x10, 0x01, 0x80, 0x08, 0x20, 0x02,
  0x00, 0x30, 0xC0, 0x04, 0x00, 0x61, 0x80, 0x08, 0x00, 0x82, 0x00, 0x30,
  0x01, 0x04, 0x00, 0x60, 0x06, 0x00, 0x02, 0x3F, 0x80, 0x8C, 0x18, 0x12,
  0x01, 0x82, 0x80, 0x30, 0x70, 0x02, 0x1C, 0x00, 0x43, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x00,
  0x0C, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x84, 0x00,
  0x30, 0x80, 0x04, 0x10, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x06, 0x10, 0x00,
  0xC2, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0x42, 0x00, 0x18, 0x40, 0x02,
  0x00, 0x00, 0xFE, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x18, 0x03, 0x0C, 0x00,
  0xC6, 0x00, 0x11, 0x80, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x16,
  0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x03,
  0x20, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x10, 0x40, 0x0C, 0x18, 0x06, 0x03,
  0x03, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x47, 0xF0, 0x01, 0x98,
  0x30, 0x02, 0x60, 0x30, 0x05, 0x80, 0x20, 0x0A, 0x00, 0x60, 0x1C, 0x00,
  0xC0, 0x70, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC0,
  0x80, 0x01, 0x03, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10,
  0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x08, 0x06, 0x00, 0x30, 0x1E, 0x00, 0xC0, 0x34, 0x03, 0x00, 0x6C, 0x0C,
  0x00, 0x8F, 0xF0, 0x01, 0x02, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFE, 0x10, 0x18, 0x31, 0x03, 0x01, 0xB0, 0x60, 0x0A,
  0x0C, 0x00, 0xE0, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00,
  0x42, 0x00, 0x04, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00,
  0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x10, 0x80,
  0x03, 0x08, 0x00, 0x30, 0x80, 0x07, 0x08, 0x00, 0x70, 0x80, 0x0E, 0x0C,
  0x00, 0xA0, 0x40, 0x1A, 0x06, 0x03, 0x60, 0x30, 0x66, 0x03, 0xFC, 0x40,
  0x04, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x02, 0x3F, 0x04, 0x60, 0x04, 0x80,
  0x05, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x01, 0xFF, 0x03, 0x81, 0xC1, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x30, 0x18, 0x1F,
  0xF8, 0x00, 0x60, 0x00, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x03, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x7E, 0x00, 0x80, 0x0C, 0x00,
  0x21, 0x80, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00,
  0x84, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x06,
  0x10, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0x43, 0x00, 0x18,
  0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0x61,
  0x00, 0x1C, 0x20, 0x03, 0x04, 0x00, 0xE0, 0x80, 0x14, 0x18, 0x05, 0x81,
  0x83, 0x20, 0x1F, 0xC4, 0x00, 0x40, 0x00, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0,
  0x10, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x40,
  0x80, 0x41, 0x80, 0x41, 0x00, 0x43, 0x00, 0x42, 0x00, 0x46, 0x00, 0x44,
  0x00, 0x4C, 0x00, 0x48, 0x00, 0x58, 0x00, 0x50, 0x00, 0x50, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x78, 0x01, 0x80, 0x0B, 0x00, 0x30,
  0x03, 0x60, 0x0E, 0x00, 0x4C, 0x01, 0x40, 0x19, 0x80, 0x28, 0x02, 0x30,
  0x0D, 0x00, 0xC6, 0x01, 0x20, 0x10, 0xC0, 0x64, 0x02, 0x18, 0x08, 0x80,
  0xC3, 0x03, 0x10, 0x10, 0x60, 0x43, 0x06, 0x0C, 0x18, 0x60, 0x81, 0x82,
  0x0C, 0x10, 0x30, 0x41, 0x86, 0x06, 0x18, 0x30, 0x80, 0xC2, 0x06, 0x30,
  0x18, 0xC0, 0xC4, 0x03, 0x10, 0x18, 0x80, 0x66, 0x03, 0x20, 0x0C, 0x80,
  0x64, 0x01, 0xB0, 0x0D, 0x80, 0x34, 0x01, 0xA0, 0x06, 0x80, 0x34, 0x00,
  0x70, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x20, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x08, 0x00, 0x80, 0x40, 0x0C, 0x03, 0x00,
  0xC0, 0x08, 0x04, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00, 0x18, 0x60, 0x00,
  0x42, 0x00, 0x02, 0x30, 0x00, 0x1B, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x0C,
  0xC0, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00,
  0x20, 0x10, 0x03, 0x00, 0x80, 0x30, 0x06, 0x01, 0x00, 0x10, 0x18, 0x00,
  0x81, 0x80, 0x06, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x02,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0x80,
  0x03, 0x00, 0x20, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x10, 0x00, 0x04,
  0x0C, 0x00, 0x01, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x40, 0x00,
  0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x58, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x70,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x17, 0x3C, 0x01, 0xC0, 0x70, 0x38, 0x01,
  0xFE,
};

const GFXglyph NotoSans_Condensed_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 38, 11, 1, -38 },
  { 49, 11, 14, 14, 5, -38 },
  { 69, 23, 38, 23, 1, -38 },
  { 179, 22, 43, 21, 0, -40 },
  { 298, 26, 39, 31, 3, -38 },
  { 425, 21, 39, 23, 0, -38 },
  { 528, 4, 14, 8, 5, -38 },
  { 535, 15, 46, 13, 1, -38 },
  { 622, 15, 46, 13, -4, -38 },
  { 709, 16, 16, 20, 6, -40 },
  { 741, 20, 24, 24, 2, -31 },
  { 801, 6, 12, 9, -2, -5 },
  { 810, 12, 1, 15, 1, -15 },
  { 812, 3, 3, 9, 1, -3 },
  { 814, 22, 38, 16, -2, -38 },
  { 919, 19, 39, 21, 2, -38 },
  { 1012, 10, 38, 21, 7, -38 },
  { 1060, 22, 38, 21, -1, -38 },
  { 1165, 22, 39, 21, -1, -38 },
  { 1273, 22, 38, 21, -1, -38 },
  { 1378, 21, 39, 21, 0, -38 },
  { 1481, 20, 39, 21, 2, -38 },
  { 1579, 20, 38, 21, 3, -38 },
  { 1674, 22, 39, 21, 0, -38 },
  { 1782, 20, 39, 21, 1, -38 },
  { 1880, 7, 28, 9, 1, -28 },
  { 1905, 11, 35, 9, -2, -28 },
  { 1954, 20, 22, 24, 2, -30 },
  { 2009, 20, 13, 24, 2, -25 },
  { 2042, 20, 22, 24, 2, -30 },
  { 2097, 15, 38, 15, 2, -38 },
  { 2169, 29, 43, 32, 2, -38 },
  { 2325, 20, 38, 21, -3, -38 },
  { 2420, 22, 38, 23, 1, -38 },
  { 2525, 23, 39, 22, 3, -38 },
  { 2638, 24, 38, 26, 1, -38 },
  { 2752, 22, 38, 21, 1, -38 },
  { 2857, 22, 38, 19, 1, -38 },
  { 2962, 25, 39, 28, 3, -38 },
  { 3084, 27, 38, 27, 1, -38 },
  { 3213, 16, 38, 11, -2, -38 },
  { 3289, 18, 47, 9, -8, -38 },
  { 3395, 25, 38, 21, 1, -38 },
  { 3514, 14, 38, 19, 1, -38 },
  { 3581, 34, 38, 35, 1, -38 },
  { 3743, 27, 38, 28, 1, -38 },
  { 3872, 24, 39, 28, 3, -38 },
  { 3989, 21, 38, 22, 1, -38 },
  { 4089, 24, 47, 28, 3, -38 },
  { 4230, 21, 38, 22, 1, -38 },
  { 4330, 23, 39, 21, -1, -38 },
  { 4443, 18, 38, 19, 5, -38 },
  { 4529, 24, 39, 27, 3, -38 },
  { 4646, 20, 38, 21, 5, -38 },
  { 4741, 34, 38, 35, 5, -38 },
  { 4903, 26, 38, 19, -3, -38 },
  { 5027, 18, 38, 18, 5, -38 },
  { 5113, 25, 38, 20, -2, -38 },
  { 5232, 19, 46, 15, -1, -38 },
  { 5342, 8, 38, 17, 5, -38 },
  { 5380, 19, 46, 15, -3, -38 },
  { 5490, 20, 20, 23, 2, -38 },
  { 5540, 15, 1, 16, -4, 5 },
  { 5542, 5, 8, 11, 8, -40 },
  { 5547, 20, 29, 23, 2, -28 },
  { 5620, 20, 41, 23, 1, -40 },
  { 5723, 16, 29, 17, 2, -28 },
  { 5781, 23, 41, 23, 2, -40 },
  { 5899, 17, 29, 20, 2, -28 },
  { 5961, 25, 54, 11, -7, -41 },
  { 6130, 22, 41, 23, 0, -28 },
  { 6243, 19, 40, 22, 1, -40 },
  { 6338, 9, 38, 9, 1, -38 },
  { 6381, 18, 51, 9, -7, -38 },
  { 6496, 19, 40, 18, 1, -40 },
  { 6591, 10, 40, 9, 1, -40 },
  { 6641, 31, 28, 34, 1, -28 },
  { 6750, 19, 28, 22, 1, -28 },
  { 6817, 18, 29, 22, 2, -28 },
  { 6883, 23, 40, 23, -2, -28 },
  { 6998, 20, 40, 23, 2, -28 },
  { 7098, 16, 28, 15, 1, -28 },
  { 7154, 17, 29, 17, 0, -28 },
  { 7216, 12, 36, 12, 1, -35 },
  { 7270, 19, 29, 22, 2, -28 },
  { 7339, 16, 28, 17, 3, -28 },
  { 7395, 27, 28, 27, 3, -28 },
  { 7490, 21, 28, 18, -2, -28 },
  { 7564, 26, 41, 17, -6, -28 },
  { 7698, 18, 28, 15, -1, -28 },
  { 7761, 18, 46, 17, 2, -38 },
  { 7865, 2, 53, 21, 10, -40 },
  { 7879, 18, 46, 17, -3, -38 },
  { 7983, 20, 4, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_THINITALIC53PT7B_H_
