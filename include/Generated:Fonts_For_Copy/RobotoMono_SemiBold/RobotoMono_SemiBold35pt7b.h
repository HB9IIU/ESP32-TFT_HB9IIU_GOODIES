#ifndef _ROBOTOMONO_SEMIBOLD35PT7B_H_
#define _ROBOTOMONO_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00,
  0x00, 0x06, 0x7F, 0xFF, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x83, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8,
  0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x38, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x7E, 0x7E, 0x3C, 0x0F,
  0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x7C, 0x0F, 0xBF, 0x0F,
  0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0x71,
  0xC3, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE7, 0x07, 0x1C, 0xE0, 0xFF,
  0xB8, 0x0F, 0xE7, 0x00, 0x21, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x80, 0x0C, 0xFE, 0x03, 0xBF, 0xE0, 0xE7, 0x1C, 0x1C,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x8E, 0x08, 0x71, 0xC0, 0x0F, 0x38, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xF3, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0,
  0x1E, 0x7C, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFE, 0x0E, 0x3F, 0xF1, 0xE7, 0xCF, 0x9E, 0x78, 0xF9, 0xEF, 0x87,
  0xFE, 0xF8, 0x3F, 0xCF, 0x81, 0xFC, 0x78, 0x1F, 0x87, 0xE3, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xF3, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xE0, 0x10, 0x40, 0x18, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x06, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07,
  0x0E, 0x1B, 0xE7, 0x3D, 0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xE7, 0x00, 0xF3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x18,
  0x18, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF7, 0x9E, 0x73, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x18, 0xF9, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xEF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x9E, 0xFF, 0xFE,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0xC1, 0xF1, 0xF1, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x20, 0x3C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3D, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xF0,
  0x40, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xE7, 0xC1, 0xF3, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x40, 0x7D, 0xFC, 0x3D,
  0xFF, 0x1F, 0xFF, 0xCF, 0xC3, 0xF7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF3, 0xF1,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xEF, 0xC7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F,
  0x3E, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xF1, 0xF0,
  0xF8, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xF3, 0xF1, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C,
  0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x07, 0x8F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0x80, 0x33, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x3E, 0xFF, 0xFF, 0xDE, 0x30, 0xFB, 0xF7, 0xF7, 0xCF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x78, 0xF1, 0xC1, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0,
  0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0x3E, 0x03, 0xFC, 0x3F, 0xF3, 0xFF, 0x8F, 0xF8, 0x1F, 0xC0, 0x3C, 0x00,
  0x60, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0xFE, 0xF8, 0x1E,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F,
  0x03, 0xC1, 0xC0, 0x1C, 0x70, 0x43, 0x9C, 0x3F, 0x33, 0x8F, 0xE7, 0x63,
  0x8C, 0xFC, 0x63, 0x9F, 0x9C, 0x71, 0xF3, 0x8E, 0x7E, 0x71, 0xCF, 0x8C,
  0x39, 0xF1, 0x87, 0x3F, 0x38, 0xC6, 0xE7, 0x39, 0xDC, 0xFF, 0xF3, 0x8F,
  0xBE, 0x38, 0x43, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC7, 0x00, 0x7F,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x07, 0xBE, 0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x0F,
  0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0,
  0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x87, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE,
  0xFE, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF7, 0xC0, 0x3D, 0xF0,
  0x1F, 0x3E, 0x07, 0xCF, 0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xE7,
  0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0x83, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xEF, 0xE7, 0xC0, 0xFB, 0xC0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0x7B, 0xF8, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xEF, 0x81, 0xF3, 0xF3, 0xF1, 0xFF, 0xF8, 0x7F,
  0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C,
  0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF9,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xF7, 0xC0, 0xFC, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0,
  0x3E, 0xF8, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xEE, 0xFF, 0xF7,
  0x77, 0xFB, 0xBB, 0xFD, 0xFD, 0xFE, 0x7C, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F,
  0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFE, 0xE3, 0xFF,
  0x79, 0xFF, 0x9C, 0xFF, 0xCF, 0x7F, 0xE7, 0xBF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x7F, 0x7F, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x07, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xE1, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x0F,
  0x87, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x7C, 0x03, 0xC7,
  0xC0, 0x7C, 0x3E, 0x0F, 0x83, 0xFB, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x1F,
  0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF,
  0x80, 0xFB, 0xE0, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF,
  0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFE, 0x7C, 0x0F, 0xBE, 0x01, 0xEF,
  0x80, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0x9F, 0x87, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF,
  0x01, 0xE7, 0xC1, 0xF3, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x8F, 0x01, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x7D, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xF0, 0xE1, 0xFF, 0x0E, 0x1E, 0xF0, 0xF1, 0xEF, 0x1F, 0x1E, 0xF1,
  0xF1, 0xEF, 0x1F, 0x1E, 0xF1, 0xF1, 0xE7, 0x9F, 0x1E, 0x79, 0xF3, 0xC7,
  0xBF, 0xBC, 0x7B, 0xBB, 0xC7, 0xBB, 0xBC, 0x7B, 0xBB, 0xC7, 0xBB, 0xBC,
  0x3B, 0xBB, 0xC3, 0xF9, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x1E, 0x0F, 0x81, 0xE0,
  0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xC3,
  0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xE0,
  0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0xF9,
  0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x3E,
  0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x0F,
  0x81, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xE0, 0x07, 0xBE, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFF, 0xF8, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0xC0, 0x77, 0x81, 0xDE, 0x0F, 0x38, 0x38, 0xF1, 0xE1, 0xC7,
  0x07, 0xBC, 0x1E, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x3C, 0x1E, 0x0F, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0x81, 0xF3, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x0F, 0xFF, 0x1F, 0xFF,
  0x9F, 0xC3, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7D, 0xF8,
  0xFE, 0x7F, 0xFF, 0x1F, 0xF7, 0x87, 0xF3, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0,
  0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xF7, 0xF0,
  0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x0F, 0x7C, 0x0F, 0x7E, 0x3F, 0x3F, 0xFE, 0x1F, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x07, 0x8F, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7E, 0x3F,
  0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xEF, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xC1, 0xF3, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x08, 0xFE, 0x3F, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xC1, 0xFB, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E, 0xFE, 0x7F, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFB, 0xE0, 0x01, 0xF0, 0x00, 0xF1, 0x80, 0xF8, 0xF0,
  0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0,
  0xF7, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xEF, 0xFD, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x1F, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x02, 0xF0, 0x3E, 0x78, 0x3E, 0x3C, 0x3E, 0x1E, 0x3F,
  0x0F, 0x3F, 0x07, 0xBF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0x3E, 0x0F, 0x0F, 0x87, 0x83, 0xE3, 0xC1, 0xF9,
  0xE0, 0x7C, 0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC7, 0x1E, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x9F, 0x3D, 0xE3,
  0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7,
  0x8F, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x8F,
  0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0x80, 0x01, 0xF0, 0xF7,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x03,
  0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0xFC, 0x7E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xF7, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xEF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xEF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xE7, 0xC0, 0xF3, 0xC0, 0x7D, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x20, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFC, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0x7F, 0xFF,
  0x7F, 0xDF, 0x1F, 0x8F, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1E,
  0x03, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF8, 0xF8, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07,
  0x70, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0,
  0xE1, 0xFE, 0x1C, 0x3F, 0xC7, 0x87, 0xF8, 0xF8, 0xEF, 0x1F, 0x1C, 0xE3,
  0xE7, 0x9E, 0x7C, 0xF3, 0xDD, 0x9E, 0x7B, 0xBB, 0xCF, 0x77, 0x70, 0xEC,
  0xEE, 0x1D, 0x8D, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC0, 0xF0,
  0xF8, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x0F, 0xDF, 0x03, 0xC3, 0xE1,
  0xF0, 0x78, 0xF8, 0x1F, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x7C, 0x07,
  0xCF, 0x83, 0xE1, 0xF1, 0xF0, 0x7C, 0x78, 0x0F, 0xBE, 0x01, 0xF0, 0xF8,
  0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0xC1,
  0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xE0,
  0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x1F, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0xFC, 0x3E, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x3E, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF9, 0xEE, 0x1F, 0xFD, 0xC0, 0xFF, 0x08, 0x0F, 0xC0,
};

const GFXglyph RobotoMono_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 25, 21, 8, -25 },
  { 17, 10, 9, 21, 5, -26 },
  { 29, 19, 25, 21, 1, -25 },
  { 89, 17, 33, 21, 2, -29 },
  { 160, 19, 25, 21, 1, -25 },
  { 220, 20, 25, 21, 1, -25 },
  { 283, 3, 9, 21, 8, -26 },
  { 287, 9, 36, 21, 6, -28 },
  { 328, 10, 36, 21, 5, -28 },
  { 373, 17, 18, 21, 3, -25 },
  { 412, 17, 19, 21, 2, -21 },
  { 453, 6, 11, 21, 6, -4 },
  { 462, 14, 4, 21, 5, -13 },
  { 469, 7, 6, 21, 7, -6 },
  { 475, 14, 27, 21, 4, -25 },
  { 523, 17, 25, 21, 2, -25 },
  { 577, 11, 25, 21, 3, -25 },
  { 612, 18, 25, 21, 1, -25 },
  { 669, 16, 25, 21, 2, -25 },
  { 719, 18, 25, 21, 1, -25 },
  { 776, 17, 25, 21, 2, -25 },
  { 830, 17, 25, 21, 2, -25 },
  { 884, 18, 25, 21, 1, -25 },
  { 941, 17, 25, 21, 2, -25 },
  { 995, 16, 25, 21, 2, -25 },
  { 1045, 6, 20, 21, 8, -20 },
  { 1060, 7, 27, 21, 8, -20 },
  { 1084, 15, 16, 21, 3, -19 },
  { 1114, 16, 11, 21, 3, -16 },
  { 1136, 15, 16, 21, 3, -19 },
  { 1166, 16, 25, 21, 3, -25 },
  { 1216, 19, 25, 21, 1, -25 },
  { 1276, 20, 25, 21, 1, -25 },
  { 1339, 18, 25, 21, 2, -25 },
  { 1396, 18, 25, 21, 1, -25 },
  { 1453, 17, 25, 21, 2, -25 },
  { 1507, 16, 25, 21, 3, -25 },
  { 1557, 16, 25, 21, 3, -25 },
  { 1607, 17, 25, 21, 2, -25 },
  { 1661, 17, 25, 21, 2, -25 },
  { 1715, 15, 25, 21, 3, -25 },
  { 1762, 17, 25, 21, 2, -25 },
  { 1816, 19, 25, 21, 2, -25 },
  { 1876, 16, 25, 21, 3, -25 },
  { 1926, 17, 25, 21, 2, -25 },
  { 1980, 17, 25, 21, 2, -25 },
  { 2034, 19, 25, 21, 1, -25 },
  { 2094, 17, 25, 21, 3, -25 },
  { 2148, 20, 29, 21, 1, -25 },
  { 2221, 18, 25, 21, 2, -25 },
  { 2278, 18, 25, 21, 2, -25 },
  { 2335, 19, 25, 21, 1, -25 },
  { 2395, 17, 25, 21, 2, -25 },
  { 2449, 19, 25, 21, 1, -25 },
  { 2509, 20, 25, 21, 1, -25 },
  { 2572, 20, 25, 21, 1, -25 },
  { 2635, 20, 25, 21, 1, -25 },
  { 2698, 17, 25, 21, 2, -25 },
  { 2752, 7, 35, 21, 7, -29 },
  { 2783, 14, 27, 21, 4, -25 },
  { 2831, 7, 35, 21, 7, -29 },
  { 2862, 14, 13, 21, 4, -25 },
  { 2885, 15, 3, 21, 3, 0 },
  { 2891, 8, 4, 21, 7, -25 },
  { 2895, 17, 19, 21, 2, -19 },
  { 2936, 16, 26, 21, 3, -26 },
  { 2988, 16, 19, 21, 2, -19 },
  { 3026, 16, 26, 21, 2, -26 },
  { 3078, 17, 19, 21, 2, -19 },
  { 3119, 18, 27, 21, 2, -27 },
  { 3180, 17, 26, 21, 2, -19 },
  { 3236, 16, 26, 21, 3, -26 },
  { 3288, 15, 26, 21, 4, -26 },
  { 3337, 11, 33, 21, 4, -26 },
  { 3383, 17, 26, 21, 3, -26 },
  { 3439, 16, 26, 21, 3, -26 },
  { 3491, 19, 19, 21, 1, -19 },
  { 3537, 16, 19, 21, 3, -19 },
  { 3575, 17, 19, 21, 2, -19 },
  { 3616, 16, 26, 21, 3, -19 },
  { 3668, 16, 26, 21, 2, -19 },
  { 3720, 14, 19, 21, 5, -19 },
  { 3754, 17, 19, 21, 2, -19 },
  { 3795, 17, 23, 21, 2, -23 },
  { 3844, 16, 18, 21, 3, -18 },
  { 3880, 19, 18, 21, 1, -18 },
  { 3923, 19, 18, 21, 1, -18 },
  { 3966, 18, 18, 21, 2, -18 },
  { 4007, 20, 25, 21, 1, -18 },
  { 4070, 17, 18, 21, 2, -18 },
  { 4109, 12, 33, 21, 5, -27 },
  { 4159, 3, 32, 21, 9, -25 },
  { 4171, 11, 33, 21, 6, -27 },
  { 4217, 19, 7, 21, 1, -14 },
};

const GFXfont RobotoMono_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold35pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_SEMIBOLD35PT7B_H_
