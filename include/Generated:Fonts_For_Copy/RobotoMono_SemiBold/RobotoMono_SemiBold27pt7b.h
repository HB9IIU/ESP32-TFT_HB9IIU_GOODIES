#ifndef _ROBOTOMONO_SEMIBOLD27PT7B_H_
#define _ROBOTOMONO_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0xFF, 0xF0, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xC6, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03,
  0x8C, 0x0E, 0x71, 0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x0C, 0x60, 0x73, 0x81,
  0x8E, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0x8C, 0x0E, 0x70, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0x83, 0xFF,
  0x3E, 0xF9, 0xC1, 0xFE, 0x0F, 0x70, 0x7B, 0xC0, 0x1F, 0x00, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1E, 0xFF,
  0xE7, 0xFF, 0x0F, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x67, 0x10, 0xE3, 0x38, 0xE3, 0x30, 0x67, 0x60, 0x7E, 0x60, 0x3C,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x3C, 0x07, 0x7E, 0x06,
  0xE7, 0x0C, 0xE7, 0x0C, 0xE7, 0x00, 0xE7, 0x00, 0x7E, 0x00, 0x3C, 0x0F,
  0xC0, 0x3F, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0F, 0x70,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x3B, 0xDC, 0x7F, 0x3D, 0xDE,
  0x3F, 0xBC, 0x3F, 0x78, 0x3C, 0x7F, 0xF8, 0xFF, 0xF8, 0x7E, 0x78, 0xFF,
  0xFF, 0xF0, 0x04, 0x1C, 0x71, 0xC3, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x10, 0x40, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0xE0, 0x40, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x86, 0x17,
  0x33, 0xFF, 0xFC, 0xFF, 0xC0, 0xE0, 0x0F, 0x80, 0xEE, 0x0E, 0x38, 0x71,
  0xE1, 0x04, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x77, 0x77, 0x7F, 0xEC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF7, 0xFF, 0xE0, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x1F, 0xC3, 0xFE, 0x79,
  0xEF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0xE3, 0xFE, 0xF7, 0xFC,
  0x7F, 0x87, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xE3, 0xFE, 0x1F,
  0x80, 0x01, 0x87, 0xDF, 0xFF, 0xFF, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1F,
  0xC1, 0xFF, 0x1F, 0x7D, 0xE0, 0xEF, 0x07, 0xF0, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0x9F, 0x3C, 0xE0,
  0xFF, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x00, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0xFE, 0x0F, 0x7F, 0xF1, 0xFF, 0x87,
  0xF0, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3B, 0x80,
  0xEE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x76, 0x0F, 0xFC, 0xFF,
  0xEF, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x7F, 0x0F, 0x7F,
  0xF7, 0xFE, 0x1F, 0x80, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x7C, 0x03, 0x80,
  0x3C, 0x01, 0xCF, 0x0E, 0xFC, 0x7F, 0xF7, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F,
  0x03, 0xB8, 0x1D, 0xC0, 0xEF, 0x0F, 0x3F, 0xF0, 0xFF, 0x83, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x3F, 0xC7, 0xFE, 0x79, 0xEF, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0xF7, 0x9E, 0x3F, 0xC3, 0xFC, 0x7F, 0xEF, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFF, 0x1F, 0x7C, 0xF0, 0xE7, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0x70, 0x7B, 0xC3, 0xCF, 0xFE, 0x7F, 0x70, 0xF7, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x1F, 0xE0, 0xFC, 0x07, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xEF, 0xFD, 0xC0, 0x7F, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x39, 0xCE, 0x73, 0xB9, 0x80, 0x00, 0x10, 0x07, 0x01, 0xF0, 0xFF, 0x3F,
  0xCF, 0xE0, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF0,
  0x3F, 0x1F, 0xEF, 0xF8, 0xFC, 0x0F, 0x00, 0x80, 0x00, 0x3F, 0xC7, 0xFE,
  0x79, 0xFF, 0x07, 0xF0, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x07, 0x63, 0xCD, 0x9F,
  0xBC, 0xE6, 0xF3, 0x13, 0xCC, 0xC7, 0x73, 0x3D, 0xCC, 0xF7, 0x33, 0xDC,
  0xCF, 0x3F, 0xEC, 0x67, 0x18, 0x00, 0x70, 0x40, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x03,
  0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x38, 0xE0, 0xF1, 0xC1, 0xC3, 0xC3, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFF, 0x38, 0x1E, 0xF0, 0x1D, 0xE0, 0x3F, 0x80, 0x78,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1E, 0xFF, 0xE7, 0xFF, 0x38, 0x7D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xFF, 0xF7, 0xFF, 0xBF, 0xF0, 0x0F, 0xE0, 0xFF, 0xC3, 0xCF,
  0x9E, 0x0E, 0x70, 0x3F, 0xC0, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xF7, 0x03, 0xDE, 0x0E, 0x3F,
  0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xEE,
  0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDC, 0x3E, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xCF, 0x9E, 0x0E, 0x70, 0x3F, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0,
  0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x3F, 0xFC, 0x7F, 0xE0, 0xFE, 0x00,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F,
  0x7F, 0xF1, 0xFF, 0x87, 0xF0, 0xE0, 0x7F, 0x81, 0xEE, 0x0F, 0x38, 0x78,
  0xE3, 0xE3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x3E, 0xF0, 0xF3, 0xC3, 0x87, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0x7B, 0x81,
  0xEE, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xFF,
  0x87, 0xFE, 0x3F, 0xF3, 0xFF, 0x9F, 0xFE, 0xDF, 0xFE, 0xFD, 0xF7, 0xEF,
  0x3F, 0x79, 0xF9, 0xCF, 0xCC, 0x7E, 0x63, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE, 0x7E, 0x77, 0xE7, 0x7E, 0x37, 0xE3,
  0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x70, 0x0F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0x03,
  0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x3F,
  0xFD, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF,
  0xBF, 0xF9, 0xFF, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0xFB, 0xE3, 0xC3, 0xC7, 0x03,
  0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0x77,
  0x80, 0xEF, 0x01, 0xDE, 0x07, 0x9C, 0x0F, 0x3C, 0x3C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0x80, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xEE, 0x07, 0xB8, 0x1E, 0xE0,
  0xF3, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38,
  0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xC0, 0x1F, 0xE0, 0xFF, 0xE7, 0xC7,
  0x9E, 0x0F, 0x70, 0x1D, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0x01, 0xDE, 0x0F, 0x7F,
  0xFC, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xF7, 0xFE, 0x1F, 0x80,
  0xE0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF3, 0x81, 0xE7, 0x83, 0x8F, 0x0F, 0x0E,
  0x1E, 0x1C, 0x38, 0x3C, 0x70, 0x79, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0xF1, 0x87, 0x71, 0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0xCE, 0x7B, 0xEE, 0x3B, 0xEE, 0x3F, 0x6E, 0x3F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x3C, 0x1C, 0x38,
  0x1C, 0x38, 0xF0, 0x3E, 0xF0, 0x79, 0xE1, 0xE1, 0xE3, 0xC3, 0xCF, 0x03,
  0xDE, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7F,
  0x01, 0xEE, 0x03, 0x9E, 0x0F, 0x1C, 0x1C, 0x3C, 0x78, 0x3D, 0xE0, 0x7B,
  0xC0, 0x78, 0xF0, 0x1F, 0xE0, 0x79, 0xC0, 0xF3, 0xC1, 0xC3, 0x87, 0x87,
  0x8E, 0x07, 0x3C, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0,
  0x1E, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF, 0xF0, 0x0E, 0x03, 0xC0,
  0x7C, 0x0F, 0x83, 0xB0, 0x67, 0x1C, 0x63, 0x8E, 0xE1, 0xDC, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x06, 0x03, 0xFC, 0x7F,
  0xEF, 0x1F, 0xE0, 0xF0, 0x0F, 0x0F, 0xF7, 0xFF, 0xF8, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0x3E, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x71, 0x83, 0xBF, 0x1F, 0xFC, 0xF9, 0xF7, 0x83, 0xB8,
  0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7, 0xFF,
  0xBF, 0xF9, 0xDF, 0x80, 0x06, 0x01, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0x7E,
  0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7F, 0x07, 0x7F, 0xF3,
  0xFE, 0x1F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x47,
  0x3F, 0x77, 0xFF, 0xF9, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xF3, 0xF7, 0x02, 0x00, 0xFE,
  0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x70, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x01, 0xE0, 0x47, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x3F, 0xC3, 0xFE, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x1F, 0xFE, 0xFF,
  0xF0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x04, 0x03, 0xF7,
  0x7F, 0xFF, 0x9F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0x7F, 0xF7, 0xFF, 0x1F, 0x70, 0x07, 0x40, 0xF7, 0x1F,
  0xFF, 0xE3, 0xFC, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x83, 0xBF, 0x9D, 0xFE, 0xF8, 0xF7, 0x83, 0xB8, 0x1D, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xF0, 0x06, 0x00, 0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0x81, 0xE0,
  0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x7F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3D, 0xFE, 0xFE,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x2E, 0x0F, 0x38, 0x78, 0xE3, 0xC3, 0x9E, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x38, 0xF0, 0xE1, 0xE3, 0x83, 0xCE, 0x0F, 0x38,
  0x1F, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x23, 0xBD, 0xEF, 0xFF,
  0xFD, 0xEF, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E,
  0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xC0, 0x01, 0x0E,
  0xFE, 0xFF, 0xFF, 0x8F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x03, 0x00, 0x7F,
  0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x39, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00,
  0x03, 0x07, 0x7E, 0x3F, 0xF9, 0xF3, 0xEF, 0x0F, 0x70, 0x3B, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xE1, 0xEF, 0xFF, 0x7F, 0xF3, 0xBF,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x04, 0x03, 0xF7,
  0x7F, 0xFF, 0x9F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0x7F, 0xF7, 0xFF, 0x3F, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x9C, 0xFF, 0xBF, 0x7F, 0xEF, 0x81, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x06, 0x01, 0xFE, 0x1F, 0xFD, 0xE1, 0xEF, 0x07, 0x78, 0x01, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xB8, 0x1F, 0xC0, 0xEF, 0x8F, 0x3F, 0xF0, 0x7F,
  0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01,
  0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xF3,
  0xF7, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E, 0x1E, 0x38, 0x70, 0xE1, 0xC1,
  0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF1, 0x8F, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0xCE, 0x33, 0xEC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0xF8, 0x3C, 0x70, 0xF0, 0xF1, 0xC0,
  0xF7, 0x80, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3D,
  0xC0, 0x73, 0xC1, 0xE3, 0xC7, 0x83, 0x9E, 0x07, 0xC0, 0xF0, 0x1F, 0xE0,
  0x39, 0xE0, 0xF3, 0xC1, 0xC3, 0x87, 0x87, 0x8E, 0x07, 0x1C, 0x0F, 0x78,
  0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x83,
  0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x0F, 0x8F,
  0x07, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38,
  0x0E, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x78,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xE0,
  0x78, 0x3C, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0,
  0xF0, 0xF0, 0x20, 0x00, 0x1C, 0x00, 0x7E, 0x0D, 0xFE, 0x3B, 0x1F, 0xFE,
  0x1F, 0xC0, 0x0F, 0x00,
};

const GFXglyph RobotoMono_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 7, 16, 4, -20 },
  { 18, 14, 19, 16, 1, -19 },
  { 52, 13, 25, 16, 2, -22 },
  { 93, 16, 19, 16, 0, -19 },
  { 131, 15, 19, 16, 1, -19 },
  { 167, 3, 7, 16, 6, -20 },
  { 170, 7, 27, 16, 5, -21 },
  { 194, 8, 27, 16, 4, -21 },
  { 221, 13, 13, 16, 2, -19 },
  { 243, 14, 14, 16, 1, -16 },
  { 268, 4, 8, 16, 5, -3 },
  { 272, 10, 3, 16, 4, -10 },
  { 276, 5, 4, 16, 6, -4 },
  { 279, 11, 21, 16, 3, -19 },
  { 308, 12, 19, 16, 2, -19 },
  { 337, 9, 19, 16, 2, -19 },
  { 359, 13, 19, 16, 1, -19 },
  { 390, 13, 19, 16, 1, -19 },
  { 421, 14, 19, 16, 1, -19 },
  { 455, 12, 19, 16, 2, -19 },
  { 484, 13, 19, 16, 1, -19 },
  { 515, 13, 19, 16, 1, -19 },
  { 546, 12, 19, 16, 2, -19 },
  { 575, 13, 19, 16, 1, -19 },
  { 606, 5, 15, 16, 6, -15 },
  { 616, 5, 20, 16, 6, -15 },
  { 629, 12, 13, 16, 2, -15 },
  { 649, 12, 8, 16, 2, -12 },
  { 661, 12, 13, 16, 2, -15 },
  { 681, 12, 19, 16, 2, -19 },
  { 710, 14, 19, 16, 1, -19 },
  { 744, 15, 19, 16, 1, -19 },
  { 780, 13, 19, 16, 2, -19 },
  { 811, 14, 19, 16, 1, -19 },
  { 845, 13, 19, 16, 2, -19 },
  { 876, 13, 19, 16, 2, -19 },
  { 907, 13, 19, 16, 2, -19 },
  { 938, 14, 19, 16, 1, -19 },
  { 972, 12, 19, 16, 2, -19 },
  { 1001, 12, 19, 16, 2, -19 },
  { 1030, 13, 19, 16, 1, -19 },
  { 1061, 14, 19, 16, 2, -19 },
  { 1095, 13, 19, 16, 2, -19 },
  { 1126, 13, 19, 16, 2, -19 },
  { 1157, 12, 19, 16, 2, -19 },
  { 1186, 14, 19, 16, 1, -19 },
  { 1220, 13, 19, 16, 2, -19 },
  { 1251, 15, 22, 16, 1, -19 },
  { 1293, 14, 19, 16, 2, -19 },
  { 1327, 14, 19, 16, 1, -19 },
  { 1361, 16, 19, 16, 0, -19 },
  { 1399, 12, 19, 16, 2, -19 },
  { 1428, 15, 19, 16, 1, -19 },
  { 1464, 16, 19, 16, 0, -19 },
  { 1502, 15, 19, 16, 1, -19 },
  { 1538, 15, 19, 16, 1, -19 },
  { 1574, 14, 19, 16, 1, -19 },
  { 1608, 6, 26, 16, 5, -22 },
  { 1628, 11, 21, 16, 3, -19 },
  { 1657, 6, 26, 16, 5, -22 },
  { 1677, 11, 10, 16, 3, -19 },
  { 1691, 12, 3, 16, 2, 0 },
  { 1696, 7, 4, 16, 5, -20 },
  { 1700, 12, 15, 16, 2, -15 },
  { 1723, 13, 20, 16, 2, -20 },
  { 1756, 12, 15, 16, 2, -15 },
  { 1779, 12, 20, 16, 2, -20 },
  { 1809, 13, 15, 16, 2, -15 },
  { 1834, 13, 21, 16, 2, -21 },
  { 1869, 12, 21, 16, 2, -15 },
  { 1901, 13, 20, 16, 2, -20 },
  { 1934, 12, 20, 16, 3, -20 },
  { 1964, 9, 26, 16, 3, -20 },
  { 1994, 14, 20, 16, 2, -20 },
  { 2029, 12, 20, 16, 3, -20 },
  { 2059, 14, 15, 16, 1, -15 },
  { 2086, 12, 15, 16, 2, -15 },
  { 2109, 14, 15, 16, 1, -15 },
  { 2136, 13, 20, 16, 2, -15 },
  { 2169, 12, 20, 16, 2, -15 },
  { 2199, 11, 15, 16, 4, -15 },
  { 2220, 13, 15, 16, 2, -15 },
  { 2245, 12, 18, 16, 2, -18 },
  { 2272, 12, 14, 16, 2, -14 },
  { 2293, 14, 14, 16, 1, -14 },
  { 2318, 16, 14, 16, 0, -14 },
  { 2346, 15, 14, 16, 1, -14 },
  { 2373, 15, 20, 16, 1, -14 },
  { 2411, 13, 14, 16, 2, -14 },
  { 2434, 9, 26, 16, 4, -21 },
  { 2464, 2, 24, 16, 7, -19 },
  { 2470, 9, 26, 16, 4, -21 },
  { 2500, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold27pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_SEMIBOLD27PT7B_H_
