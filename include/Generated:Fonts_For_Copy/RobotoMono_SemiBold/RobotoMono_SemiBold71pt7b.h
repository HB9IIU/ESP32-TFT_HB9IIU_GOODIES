#ifndef _ROBOTOMONO_SEMIBOLD71PT7B_H_
#define _ROBOTOMONO_SEMIBOLD71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold71pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xCF, 0xE0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x08, 0x00, 0xFE, 0x07, 0xF0, 0x0E, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00,
  0xFE, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0xF8, 0x00, 0x7E, 0x07,
  0xE1, 0xF8, 0x00, 0x7F, 0xDF, 0xE1, 0xF0, 0x00, 0x3F, 0xFF, 0xC3, 0xF0,
  0x00, 0x3F, 0xFF, 0xC3, 0xE0, 0x00, 0x1F, 0xFF, 0x87, 0xE0, 0x00, 0x07,
  0xFF, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xF8, 0x00,
  0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x07, 0xE3, 0xFF, 0xFE, 0x00, 0x07, 0xE3,
  0xFF, 0xFE, 0x00, 0x0F, 0xC7, 0xF8, 0x7F, 0x00, 0x0F, 0x87, 0xF0, 0x7F,
  0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x3F, 0x00, 0x3C, 0x07, 0xE0, 0x3F, 0x00, 0x0C, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x0F,
  0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xF3, 0xFF,
  0x03, 0xFC, 0x3F, 0xE3, 0xFF, 0x03, 0xFC, 0x7F, 0xE1, 0xFF, 0x83, 0xFC,
  0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0xFF, 0x80, 0x7F, 0xE7, 0xF8, 0xFF, 0x80,
  0x7F, 0xE7, 0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0xFD, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x04, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x06, 0x00, 0x3F, 0x00, 0x10, 0xF8, 0x07, 0xE0, 0x0F, 0x1F, 0xC0, 0xFC,
  0x07, 0xE7, 0xFE, 0x1F, 0x87, 0xFC, 0xFF, 0xF3, 0xE3, 0xFF, 0xDF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0x1C, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF,
  0x8F, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF7, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x60,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00, 0x07, 0xFC,
  0x3F, 0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xF0, 0x3F,
  0xEF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0,
  0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0x80, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF9, 0xFF, 0x87, 0xF8, 0x06, 0x00, 0x07, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x03, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0xF0, 0x7C, 0x0F,
  0xC0, 0x7F, 0xF8, 0x7C, 0x1F, 0x81, 0xFF, 0xFC, 0x3E, 0x1F, 0x81, 0xFF,
  0xFC, 0x3E, 0x1F, 0x03, 0xFF, 0xFC, 0x3E, 0x3F, 0x07, 0xF0, 0xFC, 0x3E,
  0x3E, 0x07, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1E, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x7E, 0x1F, 0x80, 0xF8,
  0x1F, 0x7C, 0x1F, 0x80, 0xF8, 0x1E, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x7C, 0x3F, 0x00,
  0xF8, 0x3E, 0x7C, 0x3F, 0x01, 0xF8, 0x3E, 0x7C, 0x3F, 0x01, 0xF8, 0x3E,
  0x7C, 0x3F, 0x01, 0xF0, 0x3C, 0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x7C, 0x1F,
  0x81, 0xF0, 0x7C, 0x7C, 0x1F, 0x83, 0xF0, 0x78, 0x7E, 0x1F, 0xC7, 0xF8,
  0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF, 0xFF, 0xF0, 0x3E,
  0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x00, 0x7F,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x1F,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF3, 0xFE, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0x0F, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0xE0, 0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0x3F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F,
  0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x07, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x3F,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xBF, 0xFF, 0xFF, 0x8F,
  0xEF, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0xFD, 0xF8, 0xFC, 0xFF, 0xFF, 0x7E,
  0x7F, 0x3F, 0xFF, 0xDF, 0xDF, 0xCF, 0xFF, 0xF7, 0xF7, 0xE3, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0x07, 0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0xFF, 0x03, 0xE0, 0x7F, 0xFF, 0xC0,
  0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0x81, 0xFF,
  0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xFC, 0xFF, 0x07,
  0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0xFF, 0xF0, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xF1, 0xFF, 0xFF, 0xC1,
  0xFE, 0x7F, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF,
  0x03, 0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xCF, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC7,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x01,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x9F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFF, 0x87, 0xFC, 0x1F, 0xE3,
  0xFF, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x7E, 0x3F, 0xC0,
  0xFF, 0x1F, 0xBF, 0x1F, 0xE0, 0x7F, 0x8F, 0xDF, 0x8F, 0xF0, 0x3F, 0xCF,
  0xEF, 0xC7, 0xF0, 0x0F, 0xE7, 0xE7, 0xF7, 0xF8, 0x07, 0xFB, 0xF3, 0xFB,
  0xFC, 0x03, 0xFD, 0xF8, 0xFD, 0xFE, 0x01, 0xFE, 0xFC, 0x7E, 0xFF, 0x00,
  0xFF, 0x7E, 0x3F, 0x7F, 0x80, 0x7F, 0xFF, 0x1F, 0xBF, 0xC0, 0x3F, 0xFF,
  0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xF8,
  0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x83,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0xF8,
  0x0F, 0xFB, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xC0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xFF,
  0x80, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xFE,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF,
  0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x07, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x02, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x7F, 0xF0,
  0x00, 0x3E, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x1F,
  0xF0, 0x00, 0x78, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x80, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x1F, 0xF8, 0x1E, 0x00,
  0x0F, 0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xC7, 0xFF, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0x1F,
  0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xB0, 0x7F, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF,
  0x80, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFB, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF,
  0x80, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF9,
  0xFF, 0x8F, 0xFC, 0x3F, 0xDF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xE3, 0xFE, 0xFF, 0x03, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x81, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x81, 0xFE,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0xF0, 0x3F, 0xC3,
  0xFF, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF,
  0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC7,
  0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xF8, 0x3F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xC0,
  0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0xFE, 0x0F, 0xF9,
  0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xFC, 0x03, 0xFE, 0x01, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xFE,
  0x3F, 0xC0, 0x7F, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC,
  0x1F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xCF, 0xF8, 0x03, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF,
  0xE1, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xEF, 0xF9, 0xFF, 0xFF, 0x7F, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xF0, 0x01, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0x8F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x3F, 0x81, 0xFF, 0x81,
  0xFE, 0x3F, 0xC1, 0xFF, 0x81, 0xFC, 0x3F, 0xC1, 0xFF, 0x81, 0xFC, 0x3F,
  0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF,
  0xC3, 0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8,
  0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x1F, 0xE3, 0xE7, 0xC3, 0xF8, 0x1F, 0xE3,
  0xE7, 0xE7, 0xF8, 0x0F, 0xE7, 0xE7, 0xE7, 0xF8, 0x0F, 0xE7, 0xE7, 0xE7,
  0xF0, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x0F,
  0xE7, 0xC3, 0xF7, 0xF0, 0x07, 0xFF, 0xC3, 0xF7, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x80, 0x3F, 0xFF, 0x80,
  0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF, 0xFF, 0xE0, 0xFF, 0x3F, 0xC3, 0xFF,
  0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0xF3,
  0xF0, 0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00,
};

const GFXglyph RobotoMono_SemiBold71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 10, 50, 43, 16, -50 },
  { 64, 21, 18, 43, 10, -53 },
  { 112, 38, 50, 43, 2, -50 },
  { 350, 34, 66, 43, 5, -59 },
  { 631, 40, 52, 43, 1, -51 },
  { 891, 40, 52, 43, 3, -51 },
  { 1151, 7, 18, 43, 16, -53 },
  { 1167, 19, 72, 43, 12, -56 },
  { 1338, 19, 72, 43, 11, -56 },
  { 1509, 35, 35, 43, 5, -50 },
  { 1663, 34, 37, 43, 4, -42 },
  { 1821, 12, 22, 43, 12, -8 },
  { 1854, 29, 7, 43, 9, -26 },
  { 1880, 13, 12, 43, 15, -11 },
  { 1900, 28, 54, 43, 8, -50 },
  { 2089, 33, 52, 43, 5, -51 },
  { 2304, 22, 50, 43, 6, -50 },
  { 2442, 35, 51, 43, 3, -51 },
  { 2666, 34, 52, 43, 3, -51 },
  { 2887, 37, 50, 43, 2, -50 },
  { 3119, 33, 51, 43, 5, -50 },
  { 3330, 34, 52, 43, 4, -51 },
  { 3551, 35, 50, 43, 3, -50 },
  { 3770, 34, 52, 43, 4, -51 },
  { 3991, 33, 51, 43, 4, -51 },
  { 4202, 13, 41, 43, 16, -40 },
  { 4269, 15, 54, 43, 15, -40 },
  { 4371, 30, 33, 43, 6, -38 },
  { 4495, 32, 23, 43, 6, -33 },
  { 4587, 31, 33, 43, 6, -38 },
  { 4715, 32, 51, 43, 6, -51 },
  { 4919, 40, 50, 43, 1, -50 },
  { 5169, 41, 50, 43, 1, -50 },
  { 5426, 35, 50, 43, 5, -50 },
  { 5645, 36, 52, 43, 3, -51 },
  { 5879, 34, 50, 43, 5, -50 },
  { 6092, 34, 50, 43, 5, -50 },
  { 6305, 34, 50, 43, 5, -50 },
  { 6518, 36, 52, 43, 3, -51 },
  { 6752, 34, 50, 43, 4, -50 },
  { 6965, 29, 50, 43, 7, -50 },
  { 7147, 34, 51, 43, 4, -50 },
  { 7364, 38, 50, 43, 5, -50 },
  { 7602, 32, 50, 43, 6, -50 },
  { 7802, 34, 50, 43, 5, -50 },
  { 8015, 34, 50, 43, 4, -50 },
  { 8228, 37, 52, 43, 3, -51 },
  { 8469, 35, 50, 43, 5, -50 },
  { 8688, 39, 60, 43, 3, -51 },
  { 8981, 36, 50, 43, 5, -50 },
  { 9206, 37, 52, 43, 3, -51 },
  { 9447, 40, 50, 43, 1, -50 },
  { 9697, 34, 51, 43, 4, -50 },
  { 9914, 40, 50, 43, 1, -50 },
  { 10164, 41, 50, 43, 1, -50 },
  { 10421, 41, 50, 43, 1, -50 },
  { 10678, 41, 50, 43, 1, -50 },
  { 10935, 36, 50, 43, 3, -50 },
  { 11160, 15, 69, 43, 14, -58 },
  { 11290, 28, 54, 43, 8, -50 },
  { 11479, 15, 69, 43, 14, -58 },
  { 11609, 28, 26, 43, 8, -50 },
  { 11700, 32, 7, 43, 5, 0 },
  { 11728, 16, 9, 43, 14, -51 },
  { 11746, 34, 39, 43, 4, -38 },
  { 11912, 34, 54, 43, 5, -53 },
  { 12142, 34, 39, 43, 4, -38 },
  { 12308, 33, 54, 43, 4, -53 },
  { 12531, 35, 39, 43, 4, -38 },
  { 12702, 35, 55, 43, 5, -55 },
  { 12943, 34, 53, 43, 4, -38 },
  { 13169, 33, 53, 43, 5, -53 },
  { 13388, 31, 52, 43, 7, -52 },
  { 13590, 22, 67, 43, 8, -52 },
  { 13775, 36, 53, 43, 5, -53 },
  { 14014, 32, 53, 43, 7, -53 },
  { 14226, 37, 38, 43, 3, -38 },
  { 14402, 33, 38, 43, 5, -38 },
  { 14559, 35, 39, 43, 4, -38 },
  { 14730, 33, 52, 43, 5, -38 },
  { 14945, 33, 52, 43, 4, -38 },
  { 15160, 29, 38, 43, 10, -38 },
  { 15298, 33, 39, 43, 5, -38 },
  { 15459, 34, 48, 43, 4, -47 },
  { 15663, 33, 39, 43, 5, -38 },
  { 15824, 37, 38, 43, 3, -38 },
  { 16000, 40, 38, 43, 1, -38 },
  { 16190, 38, 38, 43, 3, -38 },
  { 16371, 40, 53, 43, 2, -38 },
  { 16636, 35, 38, 43, 4, -38 },
  { 16803, 23, 68, 43, 11, -55 },
  { 16999, 5, 64, 43, 19, -50 },
  { 17039, 24, 68, 43, 11, -55 },
  { 17243, 39, 15, 43, 1, -28 },
};

const GFXfont RobotoMono_SemiBold71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold71pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_SEMIBOLD71PT7B_H_
