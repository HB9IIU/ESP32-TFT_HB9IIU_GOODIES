#ifndef _ROBOTOMONO_SEMIBOLD42PT7B_H_
#define _ROBOTOMONO_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xF9,
  0xFF, 0xF7, 0xCF, 0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F,
  0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0,
  0xFE, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x0E, 0x0C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x71,
  0xE0, 0xF1, 0xE3, 0x81, 0xF7, 0xCE, 0x01, 0xFF, 0x3C, 0x01, 0xFC, 0x70,
  0x00, 0xE1, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0xC0, 0x03, 0xCF, 0xE0, 0x07, 0x3F, 0xE0,
  0x1C, 0xFF, 0xE0, 0x79, 0xE3, 0xC0, 0xE3, 0xC3, 0x83, 0xC7, 0x87, 0x07,
  0x0F, 0x0E, 0x06, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x3C, 0xFF, 0xF0, 0x79, 0xF3, 0xF1, 0xF7,
  0xE3, 0xF3, 0xEF, 0x83, 0xF7, 0xDF, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x7C,
  0x07, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xEF, 0xC1, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xEE,
  0xEE, 0xE0, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x0C,
  0x60, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x80,
  0x70, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0xCF, 0x8E, 0x1E,
  0x7F, 0x77, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x80,
  0xF8, 0x3C, 0x07, 0x81, 0xF0, 0x1C, 0x07, 0x00, 0x40, 0x20, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xE7, 0xC3, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xF0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0xFF, 0xCF, 0x9F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0xC1, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0x7E, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF4, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0x0F, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x00,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1,
  0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x3C, 0x07, 0xDF, 0xF0, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xDF, 0xEF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x7E, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE1, 0xFC, 0xF8, 0x0F,
  0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F,
  0x3F, 0x07, 0xE3, 0xFB, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xC1, 0xFB, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFD,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0,
  0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7,
  0xF0, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7C,
  0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F,
  0x3E, 0x1C, 0x1F, 0x9F, 0xCF, 0xF7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xC0,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE7, 0xF0, 0xFE, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0x1F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00,
  0x07, 0x1E, 0x1F, 0x8E, 0x38, 0x7F, 0x9C, 0xE1, 0xFF, 0x1D, 0xC7, 0x8E,
  0x3B, 0x8E, 0x1C, 0x7F, 0x3C, 0x38, 0xFC, 0x78, 0x71, 0xF8, 0xE0, 0xE3,
  0xF1, 0xC1, 0xC7, 0xE3, 0x83, 0x8F, 0xC7, 0x0E, 0x1B, 0x8E, 0x1C, 0x77,
  0x1E, 0x38, 0xEF, 0x3F, 0xFB, 0x9E, 0x3F, 0xFF, 0x1C, 0x7E, 0xFC, 0x3C,
  0x30, 0x60, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x81, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xC0,
  0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xC0, 0xFF, 0xBF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x3F,
  0x7E, 0x01, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xF9, 0xFF, 0x8F, 0x81, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x87, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF8, 0x7F, 0x3F, 0x80, 0xF9, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xF9, 0xFC, 0x1F, 0xC7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0x7C, 0x03, 0xF7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7,
  0xC0, 0x3F, 0x8F, 0x80, 0xFE, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7C,
  0x1F, 0x80, 0xF8, 0x7F, 0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xCF,
  0xC0, 0x0F, 0xBF, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF1, 0xF8,
  0x0F, 0xC3, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F, 0xCF,
  0x80, 0x1F, 0xDF, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xF7, 0x9F, 0xFF, 0x7B, 0xDF, 0xF7, 0xBD,
  0xFF, 0x3B, 0xDF, 0xFB, 0xF9, 0xFF, 0xBF, 0x9F, 0xFB, 0xF9, 0xFF, 0x9F,
  0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8E, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFD, 0xE1, 0xFF, 0xBE, 0x3F, 0xF3, 0xC7, 0xFE, 0x78, 0xFF,
  0xCF, 0x9F, 0xF8, 0xF3, 0xFF, 0x1F, 0x7F, 0xE1, 0xEF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF8,
  0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC3, 0xFE, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x01, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x3E, 0x00,
  0xFC, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7E,
  0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7E,
  0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x83, 0xFE, 0x7C, 0x03, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF0, 0x7E, 0x0F,
  0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07,
  0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x83, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3F,
  0x7C, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xF9, 0xFC,
  0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x8F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xF0,
  0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3C,
  0x1F, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C,
  0x3E, 0xF8, 0x7C, 0x3E, 0x78, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFE,
  0x3E, 0x7C, 0xFE, 0x3C, 0x7C, 0xFE, 0x7C, 0x7C, 0xFE, 0x7C, 0x7C, 0xEF,
  0x7C, 0x3C, 0xEF, 0x7C, 0x3D, 0xEF, 0x7C, 0x3D, 0xEF, 0x7C, 0x3F, 0xEF,
  0x78, 0x3F, 0xE7, 0x78, 0x3F, 0xE7, 0x78, 0x3F, 0xC7, 0xF8, 0x3F, 0xC7,
  0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3,
  0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0x81, 0xF0, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF,
  0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x3C,
  0x0F, 0x1F, 0x07, 0x87, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0xC0, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF3, 0xFD, 0xF8, 0x1F, 0xBE, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xF7,
  0xC7, 0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x83, 0x00, 0xF9, 0xFE, 0x0F, 0xBF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFE, 0x0F, 0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xEF, 0xE0,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFB, 0xFF, 0x0F, 0x9F, 0xE0, 0x00,
  0x30, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xF0, 0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0x3F, 0x07, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0C, 0x1F, 0x07, 0xF9,
  0xF0, 0xFF, 0xDF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0x07, 0xF7, 0xE0,
  0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xE0, 0x1F, 0x7E, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF,
  0xC0, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x43, 0xF8, 0x03, 0x0F, 0xE0, 0x7C, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xDF, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF0, 0x7F, 0x7E, 0x01, 0xF7,
  0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01,
  0xF7, 0xE0, 0x3F, 0x3F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xF9, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x80, 0x3F, 0x1C,
  0x07, 0xE3, 0xFB, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x83, 0x80, 0xF8, 0xFF, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFD, 0xBF, 0xEF, 0xFE,
  0x7F, 0xF3, 0xFE, 0x1F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xFD, 0xF0, 0x1F,
  0x8F, 0x81, 0xFC, 0x7C, 0x1F, 0xC3, 0xE1, 0xFC, 0x1F, 0x1F, 0xC0, 0xF9,
  0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xC0, 0xFC, 0x7F, 0x07, 0xC1,
  0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x8F, 0x80, 0xFE, 0x7C, 0x03, 0xF3,
  0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0xC7,
  0x9F, 0xBF, 0xBD, 0xFD, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0x7F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC,
  0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1,
  0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1,
  0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xE0, 0x00, 0x18,
  0x0F, 0x8F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0,
  0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF9,
  0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x0F,
  0x9F, 0xE0, 0xFB, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE,
  0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0xFE, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xBF, 0xF0, 0xF9, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x9F, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF0, 0x7F, 0x7E, 0x03, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF7,
  0xE0, 0x3F, 0x3F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xDF,
  0x07, 0xF9, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x0C, 0x7C, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0x1F, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0x7C, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF,
  0xC1, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xBE, 0x1F, 0xE7, 0xC0,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7E,
  0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3C, 0x00, 0x7D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x38, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1,
  0xFF, 0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x3F, 0x8F, 0x3E, 0x7F, 0x3E,
  0x7C, 0xEE, 0x7C, 0xF9, 0xDC, 0xF0, 0xF3, 0xB9, 0xE1, 0xEF, 0x7B, 0xC3,
  0xDC, 0xF7, 0x87, 0xB8, 0xEF, 0x0F, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x3E, 0x01, 0xE0, 0x7C, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE3, 0xF0,
  0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0x7C,
  0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x17, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0x81, 0xFC, 0x1F,
  0xC1, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7E,
  0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x31, 0xFF, 0xC0,
  0x7B, 0xFF, 0xC1, 0xEF, 0xFF, 0xE7, 0xDE, 0x0F, 0xFF, 0xB8, 0x0F, 0xFE,
  0x70, 0x0F, 0xF8, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoMono_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 30, 25, 9, -30 },
  { 28, 12, 11, 25, 6, -32 },
  { 45, 23, 30, 25, 1, -30 },
  { 132, 20, 39, 25, 3, -35 },
  { 230, 23, 30, 25, 1, -30 },
  { 317, 23, 30, 25, 2, -30 },
  { 404, 4, 11, 25, 10, -32 },
  { 410, 11, 42, 25, 7, -33 },
  { 468, 12, 42, 25, 6, -33 },
  { 531, 21, 21, 25, 3, -30 },
  { 587, 21, 22, 25, 2, -25 },
  { 645, 7, 13, 25, 7, -5 },
  { 657, 16, 4, 25, 6, -15 },
  { 665, 7, 7, 25, 9, -7 },
  { 672, 16, 33, 25, 5, -30 },
  { 738, 19, 30, 25, 3, -30 },
  { 810, 13, 30, 25, 4, -30 },
  { 859, 21, 30, 25, 1, -30 },
  { 938, 20, 30, 25, 2, -30 },
  { 1013, 22, 30, 25, 1, -30 },
  { 1096, 19, 30, 25, 3, -30 },
  { 1168, 20, 30, 25, 2, -30 },
  { 1243, 20, 30, 25, 2, -30 },
  { 1318, 19, 30, 25, 3, -30 },
  { 1390, 20, 30, 25, 2, -30 },
  { 1465, 8, 24, 25, 9, -24 },
  { 1489, 9, 32, 25, 9, -24 },
  { 1525, 18, 20, 25, 3, -23 },
  { 1570, 19, 13, 25, 3, -19 },
  { 1601, 19, 20, 25, 3, -23 },
  { 1649, 19, 30, 25, 3, -30 },
  { 1721, 23, 30, 25, 1, -30 },
  { 1808, 24, 30, 25, 1, -30 },
  { 1898, 21, 30, 25, 3, -30 },
  { 1977, 21, 30, 25, 2, -30 },
  { 2056, 20, 30, 25, 3, -30 },
  { 2131, 20, 30, 25, 3, -30 },
  { 2206, 20, 30, 25, 3, -30 },
  { 2281, 21, 30, 25, 2, -30 },
  { 2360, 19, 30, 25, 3, -30 },
  { 2432, 17, 30, 25, 4, -30 },
  { 2496, 20, 30, 25, 2, -30 },
  { 2571, 23, 30, 25, 3, -30 },
  { 2658, 20, 30, 25, 3, -30 },
  { 2733, 20, 30, 25, 3, -30 },
  { 2808, 19, 30, 25, 3, -30 },
  { 2880, 21, 30, 25, 2, -30 },
  { 2959, 21, 30, 25, 3, -30 },
  { 3038, 23, 35, 25, 2, -30 },
  { 3139, 21, 30, 25, 3, -30 },
  { 3218, 22, 30, 25, 2, -30 },
  { 3301, 23, 30, 25, 1, -30 },
  { 3388, 20, 30, 25, 3, -30 },
  { 3463, 23, 30, 25, 1, -30 },
  { 3550, 24, 30, 25, 1, -30 },
  { 3640, 24, 30, 25, 1, -30 },
  { 3730, 24, 30, 25, 1, -30 },
  { 3820, 21, 30, 25, 2, -30 },
  { 3899, 9, 42, 25, 8, -35 },
  { 3947, 16, 33, 25, 5, -30 },
  { 4013, 9, 42, 25, 8, -35 },
  { 4061, 17, 16, 25, 4, -30 },
  { 4095, 19, 4, 25, 3, 0 },
  { 4105, 10, 5, 25, 8, -30 },
  { 4112, 19, 23, 25, 3, -23 },
  { 4167, 20, 32, 25, 3, -32 },
  { 4247, 20, 23, 25, 2, -23 },
  { 4305, 20, 32, 25, 2, -32 },
  { 4385, 21, 23, 25, 2, -23 },
  { 4446, 21, 32, 25, 3, -32 },
  { 4530, 20, 32, 25, 2, -23 },
  { 4610, 20, 32, 25, 3, -32 },
  { 4690, 19, 31, 25, 4, -31 },
  { 4764, 13, 40, 25, 5, -31 },
  { 4829, 21, 32, 25, 3, -32 },
  { 4913, 19, 32, 25, 4, -32 },
  { 4989, 21, 23, 25, 2, -23 },
  { 5050, 20, 23, 25, 3, -23 },
  { 5108, 21, 23, 25, 2, -23 },
  { 5169, 20, 32, 25, 3, -23 },
  { 5249, 20, 32, 25, 2, -23 },
  { 5329, 17, 23, 25, 6, -23 },
  { 5378, 20, 23, 25, 3, -23 },
  { 5436, 19, 28, 25, 3, -28 },
  { 5503, 19, 22, 25, 3, -22 },
  { 5556, 22, 22, 25, 2, -22 },
  { 5617, 23, 22, 25, 1, -22 },
  { 5681, 22, 22, 25, 2, -22 },
  { 5742, 24, 31, 25, 1, -22 },
  { 5835, 20, 22, 25, 3, -22 },
  { 5890, 14, 40, 25, 6, -33 },
  { 5960, 3, 38, 25, 11, -30 },
  { 5975, 13, 40, 25, 7, -33 },
  { 6040, 23, 9, 25, 1, -17 },
};

const GFXfont RobotoMono_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold42pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_SEMIBOLD42PT7B_H_
