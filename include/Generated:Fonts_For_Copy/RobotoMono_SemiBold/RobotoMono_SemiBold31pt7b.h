#ifndef _ROBOTOMONO_SEMIBOLD31PT7B_H_
#define _ROBOTOMONO_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x00,
  0x1D, 0xEF, 0xF8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0x03, 0x8C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E, 0x01,
  0xC6, 0x00, 0xC3, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1C, 0x60,
  0x0C, 0x30, 0x06, 0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF,
  0x3E, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0x03, 0xDE, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x39, 0xC4,
  0x18, 0xE3, 0x8C, 0x71, 0x86, 0x39, 0xC3, 0x9C, 0xC1, 0xFC, 0xE0, 0x7E,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x19, 0xF8,
  0x1D, 0xFC, 0x0C, 0xE7, 0x0E, 0x63, 0x8E, 0x71, 0xC3, 0x18, 0xE0, 0x0E,
  0x70, 0x07, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0xF1, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0x7B, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x0E, 0x3F, 0xC3, 0x9E, 0x79,
  0xE7, 0x9F, 0x7B, 0xC3, 0xFC, 0xF0, 0x7F, 0x3C, 0x0F, 0x87, 0x83, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0x01,
  0x81, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x3C, 0x0C, 0x02, 0x80, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C,
  0x3C, 0x38, 0x70, 0xF0, 0xE0, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x61, 0x82, 0x79, 0x9E, 0xFF, 0xFF, 0x3F, 0xFC, 0x03, 0xC0,
  0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x70, 0x1C, 0x78, 0x3C, 0x3C, 0x08, 0x10,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0xF3, 0xCF, 0x38, 0xE7, 0x9C,
  0xF0, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x9E, 0x1F, 0x78, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0x3D, 0xFD, 0xE7, 0xFE,
  0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0x87, 0xCF,
  0xFE, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3,
  0xC1, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xEF, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB,
  0xFF, 0xE3, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78, 0x0E, 0x78,
  0x1E, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x78, 0x78, 0x70, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF1, 0x83,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x3D, 0xE0, 0x79,
  0xE1, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xC0,
  0x7F, 0x81, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0xE0, 0xF7,
  0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x07,
  0xF8, 0x0E, 0xF0, 0x3D, 0xE0, 0x79, 0xE1, 0xF3, 0xFF, 0xC3, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE3, 0xC3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x3C,
  0x1E, 0x78, 0x78, 0x7F, 0xF0, 0x7F, 0x81, 0xFF, 0x87, 0xCF, 0x9F, 0x07,
  0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x3D, 0xE0, 0x7B, 0xE1, 0xF3, 0xFF, 0xC3,
  0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x3E, 0x1E, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDF,
  0x3F, 0x7F, 0xFC, 0xFF, 0xF0, 0xF3, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x3F, 0x07, 0xF8, 0x1F, 0xC0, 0x78, 0x00, 0x73, 0xEF, 0xFE, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBF, 0xF9, 0xE0, 0x79, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E,
  0x73, 0xCE, 0x10, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xF9,
  0xFF, 0x0F, 0xE0, 0x3C, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x03, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x0F, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0x3F, 0xC0, 0xFC, 0x03, 0x80, 0x08,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x7B, 0x80,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xCF, 0x87,
  0x80, 0xC3, 0x00, 0x73, 0x8F, 0x99, 0x8F, 0xCD, 0xCE, 0x67, 0xE6, 0x33,
  0xE7, 0x18, 0xF3, 0x8C, 0xF9, 0xC6, 0x7C, 0xC3, 0x36, 0x71, 0x9B, 0x39,
  0xCD, 0x8F, 0xFC, 0xE7, 0xBC, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x86, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0x1C, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC1, 0xC1, 0xE0, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFF, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3C, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xFC, 0xFF,
  0xF0, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3C,
  0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3D, 0xE0, 0xFB, 0xC3, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x1E, 0x7C, 0x0F, 0x78,
  0x0F, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C,
  0x0F, 0x3E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFE, 0x07, 0xF8, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87,
  0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x3C, 0x0F,
  0x9E, 0x0F, 0x8F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xF7,
  0xC0, 0x7B, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x03,
  0xE3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x3C, 0x0F, 0x9E, 0x03,
  0xCF, 0x01, 0xF7, 0x80, 0x7C, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFD, 0x9F, 0xFB, 0xBF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xEF, 0xBF, 0xDF, 0x7F, 0xBC, 0xFF, 0x39, 0xFE,
  0x73, 0xFC, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xEE, 0x3F,
  0xDE, 0x7F, 0x9C, 0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x77, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0x07,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C,
  0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0x87, 0xC7,
  0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x8F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x07, 0x9F, 0x07, 0xC7,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3D, 0xF0, 0x79, 0xE1, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xF0,
  0x07, 0xF8, 0x07, 0xFE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xE1, 0xC7,
  0xF0, 0xE3, 0xF8, 0xF1, 0xFE, 0x78, 0xFF, 0x3C, 0x7F, 0x9F, 0x3B, 0xCF,
  0x9C, 0xE7, 0xCE, 0x73, 0xE7, 0x3B, 0xB7, 0x9D, 0xDB, 0xCF, 0xEF, 0xE7,
  0xF7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF8, 0x0F, 0xBC,
  0x07, 0x9F, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE0, 0xF1, 0xE0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x3E, 0xF8, 0x1E, 0x3C, 0x1F, 0x1F, 0x0F,
  0x07, 0x8F, 0x83, 0xEF, 0x80, 0xF7, 0xC0, 0x7C, 0xF0, 0x07, 0xFC, 0x07,
  0xDE, 0x03, 0xCF, 0x03, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0x80, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C,
  0x38, 0xE3, 0x83, 0x9C, 0x1D, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x78, 0x70, 0x70, 0x03, 0x00, 0x3F, 0xE1, 0xFF, 0xE3, 0xE7,
  0xCF, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xFE, 0x3F, 0xFC, 0xFC, 0x7B,
  0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F,
  0xBE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x70, 0x7B, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xE0, 0xF7, 0x81, 0xEF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xF7, 0xC3, 0xEF, 0xFF, 0xDF, 0xFF, 0x3D, 0xF8, 0x00, 0x03, 0x80, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFF, 0x78, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0xF8, 0x3D, 0xE0, 0xF7, 0xFF, 0x8F,
  0xFC, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x63, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xDE, 0x1F, 0x7F, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x03, 0x80, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x8F, 0x83, 0x8F, 0xFF,
  0x8F, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0x10,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x7F, 0x73, 0xFF, 0xDF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x3D,
  0xE1, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x9C, 0x00, 0xF2, 0x03, 0xCC, 0x1F,
  0x7F, 0xF9, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x30, 0x7B, 0xFC, 0xFF, 0xFD, 0xFF,
  0xFB, 0xE0, 0xF7, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0x80, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0xF0, 0x3C, 0x0F,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF7, 0xFB, 0xFE, 0xFF, 0x1C, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x02, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x0C, 0xFF, 0xBE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0xF3, 0xC7,
  0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7,
  0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0x01, 0xC1,
  0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xCF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8,
  0x0F, 0xE0, 0x01, 0xC1, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x83, 0xDE,
  0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xDF, 0x0F, 0xBF, 0xFE, 0x7F, 0xFC, 0xF7, 0xE1, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x7F, 0x73, 0xFF, 0xDF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1F, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xF7, 0x9F, 0xFD, 0xFF, 0xFF, 0xEF, 0xE1, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE3, 0xE7, 0x83, 0xCE, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xDF, 0xFF, 0x1F,
  0xFC, 0x1F, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7B, 0xC1, 0xF7, 0x87, 0xEF, 0xFF, 0xCF, 0xF7, 0x8F, 0xCF, 0xF8,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E,
  0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0xE3, 0xDC, 0x38, 0xF7,
  0x1E, 0x39, 0xE7, 0x8E, 0x79, 0xE3, 0x8E, 0x7C, 0xE3, 0x9F, 0x78, 0xEE,
  0xDC, 0x3B, 0x37, 0x0E, 0xCD, 0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x1F,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0x0F, 0x9E, 0x0F, 0x07,
  0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x81, 0xE3, 0xC1, 0xE0,
  0xF1, 0xF0, 0x7D, 0xF0, 0x1F, 0xF0, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xC7,
  0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x0F, 0x38,
  0x07, 0xBC, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x81, 0xF0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x3C, 0x3F, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x78, 0x1E, 0x03, 0xF0, 0x3C, 0x1F, 0x0F, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x83, 0xE0, 0xF0,
  0x00, 0x3F, 0x01, 0x3F, 0xE1, 0xDF, 0xF8, 0xEE, 0x3F, 0xFE, 0x07, 0xF0,
  0x01, 0xF0,
};

const GFXglyph RobotoMono_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 9, 8, 19, 4, -23 },
  { 24, 17, 22, 19, 1, -22 },
  { 71, 15, 29, 19, 2, -26 },
  { 126, 17, 22, 19, 1, -22 },
  { 173, 18, 22, 19, 1, -22 },
  { 223, 3, 8, 19, 7, -23 },
  { 226, 9, 32, 19, 5, -25 },
  { 262, 8, 32, 19, 5, -25 },
  { 294, 16, 15, 19, 2, -22 },
  { 324, 15, 16, 19, 2, -18 },
  { 354, 6, 10, 19, 5, -4 },
  { 362, 12, 3, 19, 4, -11 },
  { 367, 5, 5, 19, 7, -5 },
  { 371, 13, 24, 19, 3, -22 },
  { 410, 14, 22, 19, 2, -22 },
  { 449, 9, 22, 19, 3, -22 },
  { 474, 15, 22, 19, 1, -22 },
  { 516, 15, 22, 19, 1, -22 },
  { 558, 16, 22, 19, 1, -22 },
  { 602, 15, 22, 19, 2, -22 },
  { 644, 15, 22, 19, 2, -22 },
  { 686, 16, 22, 19, 1, -22 },
  { 730, 15, 22, 19, 2, -22 },
  { 772, 14, 22, 19, 2, -22 },
  { 811, 6, 18, 19, 7, -18 },
  { 825, 6, 24, 19, 7, -18 },
  { 843, 14, 15, 19, 2, -17 },
  { 870, 15, 9, 19, 2, -14 },
  { 887, 14, 15, 19, 2, -17 },
  { 914, 14, 22, 19, 3, -22 },
  { 953, 17, 22, 19, 1, -22 },
  { 1000, 17, 22, 19, 1, -22 },
  { 1047, 16, 22, 19, 2, -22 },
  { 1091, 16, 22, 19, 1, -22 },
  { 1135, 15, 22, 19, 2, -22 },
  { 1177, 15, 22, 19, 2, -22 },
  { 1219, 15, 22, 19, 2, -22 },
  { 1261, 16, 22, 19, 1, -22 },
  { 1305, 15, 22, 19, 2, -22 },
  { 1347, 13, 22, 19, 3, -22 },
  { 1383, 14, 22, 19, 2, -22 },
  { 1422, 17, 22, 19, 2, -22 },
  { 1469, 15, 22, 19, 2, -22 },
  { 1511, 15, 22, 19, 2, -22 },
  { 1553, 15, 22, 19, 2, -22 },
  { 1595, 16, 22, 19, 1, -22 },
  { 1639, 16, 22, 19, 2, -22 },
  { 1683, 17, 26, 19, 1, -22 },
  { 1739, 16, 22, 19, 2, -22 },
  { 1783, 17, 22, 19, 1, -22 },
  { 1830, 17, 22, 19, 1, -22 },
  { 1877, 15, 22, 19, 2, -22 },
  { 1919, 17, 22, 19, 1, -22 },
  { 1966, 17, 22, 19, 1, -22 },
  { 2013, 17, 22, 19, 1, -22 },
  { 2060, 17, 22, 19, 1, -22 },
  { 2107, 16, 22, 19, 1, -22 },
  { 2151, 7, 31, 19, 6, -26 },
  { 2179, 12, 24, 19, 4, -22 },
  { 2215, 7, 31, 19, 6, -26 },
  { 2243, 13, 12, 19, 3, -22 },
  { 2263, 14, 3, 19, 2, 0 },
  { 2269, 7, 4, 19, 6, -22 },
  { 2273, 15, 17, 19, 2, -17 },
  { 2305, 15, 23, 19, 2, -23 },
  { 2349, 14, 17, 19, 2, -17 },
  { 2379, 14, 23, 19, 2, -23 },
  { 2420, 15, 17, 19, 2, -17 },
  { 2452, 15, 24, 19, 2, -24 },
  { 2497, 14, 23, 19, 2, -17 },
  { 2538, 15, 23, 19, 2, -23 },
  { 2582, 14, 23, 19, 3, -23 },
  { 2623, 10, 30, 19, 3, -23 },
  { 2661, 16, 23, 19, 2, -23 },
  { 2707, 14, 23, 19, 3, -23 },
  { 2748, 16, 17, 19, 1, -17 },
  { 2782, 15, 17, 19, 2, -17 },
  { 2814, 15, 17, 19, 2, -17 },
  { 2846, 15, 23, 19, 2, -17 },
  { 2890, 14, 23, 19, 2, -17 },
  { 2931, 13, 17, 19, 4, -17 },
  { 2959, 15, 17, 19, 2, -17 },
  { 2991, 15, 20, 19, 2, -20 },
  { 3029, 15, 16, 19, 2, -16 },
  { 3059, 16, 16, 19, 1, -16 },
  { 3091, 18, 16, 19, 0, -16 },
  { 3127, 17, 16, 19, 1, -16 },
  { 3161, 17, 23, 19, 1, -16 },
  { 3210, 15, 16, 19, 2, -16 },
  { 3240, 10, 29, 19, 5, -24 },
  { 3277, 3, 28, 19, 8, -22 },
  { 3288, 10, 29, 19, 5, -24 },
  { 3325, 17, 6, 19, 0, -12 },
};

const GFXfont RobotoMono_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold31pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_SEMIBOLD31PT7B_H_
