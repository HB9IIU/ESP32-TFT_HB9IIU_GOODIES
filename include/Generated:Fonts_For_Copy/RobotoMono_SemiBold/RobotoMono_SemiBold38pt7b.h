#ifndef _ROBOTOMONO_SEMIBOLD38PT7B_H_
#define _ROBOTOMONO_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xDF, 0xFF, 0xFC, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0x00, 0xE1, 0xC0,
  0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80,
  0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9E, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xC3, 0x86, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x83,
  0x87, 0x1C, 0x1C, 0x39, 0xC0, 0xF7, 0xCE, 0x03, 0xFC, 0xE0, 0x0F, 0xC7,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC7, 0xE0, 0x0E, 0x7F, 0x80, 0xE7, 0xBE, 0x07, 0x38,
  0x70, 0x71, 0xC3, 0x87, 0x8E, 0x1C, 0x18, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xCF, 0xFE,
  0x1E, 0xFD, 0xF8, 0xF7, 0xC7, 0xCF, 0xBE, 0x1F, 0x79, 0xE0, 0xFF, 0xCF,
  0x03, 0xFE, 0x7C, 0x0F, 0xE3, 0xE0, 0x7E, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFC, 0x7E, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x38, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x1C, 0x01, 0x80, 0x10, 0x40, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83,
  0xE0, 0xF0, 0x38, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x81, 0xC1, 0x9E, 0x38, 0xF7, 0xF7, 0x7E,
  0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x1E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xC0,
  0x10, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x9F, 0x7F, 0xDF, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7D, 0xF0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x01, 0xF7,
  0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80,
  0x3C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x87,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x1C, 0x03, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0x87, 0xE0, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF7, 0xE0,
  0xFC, 0xFE, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x3E, 0x0F, 0xBF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF7,
  0xE0, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07,
  0x9F, 0x03, 0xE3, 0xE1, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xF0, 0xF8, 0x7E, 0x7C, 0x0F, 0xDE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7C, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x03,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xF9, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x7E, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x7C, 0x78, 0xF0, 0x70, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF,
  0x0F, 0xFF, 0x3F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x01,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x0E, 0x1E, 0x00, 0x38, 0xE1, 0xF1, 0xCE, 0x1F, 0xC6,
  0x71, 0xFE, 0x33, 0x9E, 0x31, 0xF8, 0xE3, 0x8F, 0xC7, 0x1C, 0x7E, 0x70,
  0xE3, 0xF3, 0x87, 0x1F, 0x9C, 0x38, 0xDC, 0xE1, 0xC6, 0xE7, 0x0E, 0x77,
  0x3C, 0x73, 0xB8, 0xFF, 0xB9, 0xC7, 0xFF, 0xC7, 0x1E, 0x7C, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x40, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x03,
  0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3E,
  0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0x80, 0x7E, 0xF0, 0x07, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xBC, 0x03, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0x7C, 0xF8, 0x0F,
  0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E,
  0xF8, 0x0F, 0x9F, 0x81, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0x83, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x0F, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F,
  0xBF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7,
  0xC0, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xF0,
  0x07, 0xFF, 0x00, 0x7E, 0xF0, 0x0F, 0xCF, 0x01, 0xF8, 0xF0, 0x3F, 0x0F,
  0x03, 0xE0, 0xF0, 0x7E, 0x0F, 0x0F, 0xC0, 0xF1, 0xF8, 0x0F, 0x1F, 0x00,
  0xF3, 0xF0, 0x0F, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x0F, 0x03,
  0xE0, 0xF0, 0x3F, 0x0F, 0x01, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xFC, 0xF0,
  0x07, 0xEF, 0x00, 0x7E, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0x77, 0x7F, 0xEF, 0xEF, 0xFD, 0xFD,
  0xFF, 0xBF, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x9F, 0xF8, 0xE3,
  0xFF, 0x1C, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0x80, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xBC, 0x7F, 0xEF, 0x1F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x8F, 0x7F, 0xE3,
  0xDF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xF1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7E, 0x0F,
  0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x1F, 0xBC, 0x01,
  0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x07,
  0xCF, 0x03, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E,
  0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x0F,
  0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0,
  0x7E, 0xF8, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x0F, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xDF, 0x01, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0,
  0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xFC, 0x3E,
  0x1F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7D, 0xE3, 0xE3, 0xCF,
  0x3F, 0x1E, 0x79, 0xFC, 0xF3, 0xCF, 0xE7, 0x9E, 0x7F, 0x3C, 0xF3, 0xBB,
  0xE7, 0xDD, 0xDF, 0x3E, 0xEE, 0xF0, 0xFF, 0x77, 0x87, 0xFB, 0xFC, 0x3F,
  0x9F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC,
  0x7C, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x3E, 0x3F, 0x01, 0xF1,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F,
  0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x01, 0xF3, 0xE0, 0x0F,
  0xFF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xFC,
  0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xFE, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x3E,
  0x1F, 0x0F, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7E, 0x7C,
  0x0F, 0x9F, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x07, 0xFF, 0xC7, 0xFF,
  0xF3, 0xFF, 0xFD, 0xF0, 0x1F, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0x7F, 0x7F, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0x9F, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xFC, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3,
  0xDF, 0xF8, 0xF3, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFE, 0xFE, 0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x3F, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC3, 0xFD,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0x83, 0xF7, 0xC0, 0x7D,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x1F, 0x7E, 0x0F, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xE3, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0xDF, 0xC7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x00,
  0xF7, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x43, 0xF0, 0x1C, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xF3, 0xC7, 0xFE, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0x00, 0xFC, 0xF0, 0x7E, 0x7F,
  0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x78, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFB,
  0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x3E, 0x7E, 0x07,
  0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x81, 0xF9, 0xF0, 0x3E, 0x3F, 0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7E, 0x7C, 0x07, 0xEF, 0x80, 0x7E, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFB,
  0xE7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF,
  0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F,
  0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0,
  0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F,
  0x0F, 0xF1, 0xFC, 0x7B, 0xFF, 0xBD, 0xFF, 0xDF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xDF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x9F, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xBF,
  0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xF3, 0xF8, 0x3D, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0xF8,
  0x07, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xFF, 0x7F, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xEF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F,
  0xF3, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0xFF, 0x7E, 0x0F, 0xDF, 0x01,
  0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xDF, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0xFF, 0xF9, 0xFE, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0x86,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0xF8, 0xF8, 0x3F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xF7, 0x80, 0x3D, 0xF0, 0x1F, 0x7E, 0x0F, 0xCF, 0xFF, 0xE1, 0xFF,
  0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7F, 0xFF,
  0xBF, 0xFB, 0xCF, 0xFD, 0xE3, 0xF8, 0xF0, 0xFC, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE1, 0xE0, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF8, 0xF8, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x70, 0x7F,
  0x87, 0x87, 0xFC, 0x3C, 0x3D, 0xE1, 0xF1, 0xEF, 0x8F, 0x8F, 0x3C, 0x7C,
  0x79, 0xE7, 0xE3, 0xCF, 0x3F, 0x1E, 0x79, 0xDD, 0xE3, 0xCE, 0xEF, 0x0E,
  0x67, 0x78, 0x7F, 0x3B, 0xC3, 0xF9, 0xDE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F,
  0x07, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0, 0xF8,
  0x1F, 0x1F, 0x00, 0xFB, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0x9F, 0x01, 0xF1, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0x7C, 0x7C,
  0x03, 0xEF, 0x80, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x07, 0x80, 0x3F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x3F, 0x01, 0xF0, 0x06, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC,
  0x07, 0x7F, 0xE0, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0xFE, 0x07, 0xFE, 0xE0,
  0x3F, 0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoMono_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 27, 23, 9, -27 },
  { 18, 12, 10, 23, 5, -29 },
  { 33, 21, 27, 23, 1, -27 },
  { 104, 19, 35, 23, 2, -31 },
  { 188, 21, 27, 23, 1, -27 },
  { 259, 21, 27, 23, 2, -27 },
  { 330, 3, 10, 23, 9, -29 },
  { 334, 11, 39, 23, 6, -30 },
  { 388, 10, 39, 23, 6, -30 },
  { 437, 19, 19, 23, 3, -27 },
  { 483, 18, 19, 23, 2, -22 },
  { 526, 6, 11, 23, 7, -4 },
  { 535, 15, 4, 23, 5, -14 },
  { 543, 7, 6, 23, 8, -6 },
  { 549, 15, 29, 23, 4, -27 },
  { 604, 17, 27, 23, 3, -27 },
  { 662, 12, 27, 23, 3, -27 },
  { 703, 19, 27, 23, 1, -27 },
  { 768, 18, 27, 23, 2, -27 },
  { 829, 20, 27, 23, 1, -27 },
  { 897, 18, 27, 23, 2, -27 },
  { 958, 18, 27, 23, 2, -27 },
  { 1019, 19, 27, 23, 1, -27 },
  { 1084, 18, 27, 23, 2, -27 },
  { 1145, 18, 27, 23, 2, -27 },
  { 1206, 6, 22, 23, 9, -22 },
  { 1223, 8, 29, 23, 8, -22 },
  { 1252, 16, 17, 23, 3, -20 },
  { 1286, 17, 12, 23, 3, -18 },
  { 1312, 17, 17, 23, 3, -20 },
  { 1349, 17, 27, 23, 3, -27 },
  { 1407, 21, 27, 23, 1, -27 },
  { 1478, 22, 27, 23, 1, -27 },
  { 1553, 19, 27, 23, 3, -27 },
  { 1618, 19, 27, 23, 2, -27 },
  { 1683, 19, 27, 23, 2, -27 },
  { 1748, 18, 27, 23, 3, -27 },
  { 1809, 18, 27, 23, 3, -27 },
  { 1870, 19, 27, 23, 2, -27 },
  { 1935, 18, 27, 23, 2, -27 },
  { 1996, 16, 27, 23, 3, -27 },
  { 2050, 18, 27, 23, 2, -27 },
  { 2111, 20, 27, 23, 3, -27 },
  { 2179, 18, 27, 23, 3, -27 },
  { 2240, 19, 27, 23, 2, -27 },
  { 2305, 18, 27, 23, 2, -27 },
  { 2366, 19, 27, 23, 2, -27 },
  { 2431, 19, 27, 23, 3, -27 },
  { 2496, 20, 32, 23, 2, -27 },
  { 2576, 19, 27, 23, 3, -27 },
  { 2641, 19, 27, 23, 2, -27 },
  { 2706, 21, 27, 23, 1, -27 },
  { 2777, 18, 27, 23, 2, -27 },
  { 2838, 21, 27, 23, 1, -27 },
  { 2909, 21, 27, 23, 1, -27 },
  { 2980, 21, 27, 23, 1, -27 },
  { 3051, 21, 27, 23, 1, -27 },
  { 3122, 19, 27, 23, 2, -27 },
  { 3187, 8, 37, 23, 8, -31 },
  { 3224, 15, 29, 23, 4, -27 },
  { 3279, 9, 37, 23, 7, -31 },
  { 3321, 15, 14, 23, 4, -27 },
  { 3348, 17, 4, 23, 3, 0 },
  { 3357, 8, 5, 23, 8, -27 },
  { 3362, 18, 20, 23, 2, -20 },
  { 3407, 18, 29, 23, 3, -29 },
  { 3473, 18, 20, 23, 2, -20 },
  { 3518, 18, 29, 23, 2, -29 },
  { 3584, 19, 20, 23, 2, -20 },
  { 3632, 19, 29, 23, 2, -29 },
  { 3701, 18, 28, 23, 2, -20 },
  { 3764, 17, 29, 23, 3, -29 },
  { 3826, 16, 28, 23, 4, -28 },
  { 3882, 12, 36, 23, 4, -28 },
  { 3936, 19, 29, 23, 3, -29 },
  { 4005, 17, 29, 23, 4, -29 },
  { 4067, 20, 20, 23, 1, -20 },
  { 4117, 17, 20, 23, 3, -20 },
  { 4160, 19, 20, 23, 2, -20 },
  { 4208, 18, 28, 23, 3, -20 },
  { 4271, 18, 28, 23, 2, -20 },
  { 4334, 16, 20, 23, 5, -20 },
  { 4374, 18, 20, 23, 2, -20 },
  { 4419, 18, 25, 23, 2, -25 },
  { 4476, 17, 20, 23, 3, -20 },
  { 4519, 20, 20, 23, 1, -20 },
  { 4569, 21, 20, 23, 1, -20 },
  { 4622, 20, 20, 23, 2, -20 },
  { 4672, 22, 28, 23, 1, -20 },
  { 4749, 19, 20, 23, 2, -20 },
  { 4797, 12, 37, 23, 6, -30 },
  { 4853, 3, 35, 23, 10, -27 },
  { 4867, 13, 37, 23, 6, -30 },
  { 4928, 20, 8, 23, 1, -15 },
};

const GFXfont RobotoMono_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold38pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_SEMIBOLD38PT7B_H_
