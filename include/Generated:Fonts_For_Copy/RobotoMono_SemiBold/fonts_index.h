#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_SemiBold6pt7b, 6, "RobotoMono_SemiBold6pt7b" },
  { &RobotoMono_SemiBold7pt7b, 7, "RobotoMono_SemiBold7pt7b" },
  { &RobotoMono_SemiBold8pt7b, 8, "RobotoMono_SemiBold8pt7b" },
  { &RobotoMono_SemiBold9pt7b, 9, "RobotoMono_SemiBold9pt7b" },
  { &RobotoMono_SemiBold10pt7b, 10, "RobotoMono_SemiBold10pt7b" },
  { &RobotoMono_SemiBold11pt7b, 11, "RobotoMono_SemiBold11pt7b" },
  { &RobotoMono_SemiBold12pt7b, 12, "RobotoMono_SemiBold12pt7b" },
  { &RobotoMono_SemiBold13pt7b, 13, "RobotoMono_SemiBold13pt7b" },
  { &RobotoMono_SemiBold14pt7b, 14, "RobotoMono_SemiBold14pt7b" },
  { &RobotoMono_SemiBold15pt7b, 15, "RobotoMono_SemiBold15pt7b" },
  { &RobotoMono_SemiBold16pt7b, 16, "RobotoMono_SemiBold16pt7b" },
  { &RobotoMono_SemiBold17pt7b, 17, "RobotoMono_SemiBold17pt7b" },
  { &RobotoMono_SemiBold18pt7b, 18, "RobotoMono_SemiBold18pt7b" },
  { &RobotoMono_SemiBold19pt7b, 19, "RobotoMono_SemiBold19pt7b" },
  { &RobotoMono_SemiBold20pt7b, 20, "RobotoMono_SemiBold20pt7b" },
  { &RobotoMono_SemiBold21pt7b, 21, "RobotoMono_SemiBold21pt7b" },
  { &RobotoMono_SemiBold22pt7b, 22, "RobotoMono_SemiBold22pt7b" },
  { &RobotoMono_SemiBold23pt7b, 23, "RobotoMono_SemiBold23pt7b" },
  { &RobotoMono_SemiBold24pt7b, 24, "RobotoMono_SemiBold24pt7b" },
  { &RobotoMono_SemiBold25pt7b, 25, "RobotoMono_SemiBold25pt7b" },
  { &RobotoMono_SemiBold26pt7b, 26, "RobotoMono_SemiBold26pt7b" },
  { &RobotoMono_SemiBold27pt7b, 27, "RobotoMono_SemiBold27pt7b" },
  { &RobotoMono_SemiBold28pt7b, 28, "RobotoMono_SemiBold28pt7b" },
  { &RobotoMono_SemiBold29pt7b, 29, "RobotoMono_SemiBold29pt7b" },
  { &RobotoMono_SemiBold30pt7b, 30, "RobotoMono_SemiBold30pt7b" },
  { &RobotoMono_SemiBold31pt7b, 31, "RobotoMono_SemiBold31pt7b" },
  { &RobotoMono_SemiBold32pt7b, 32, "RobotoMono_SemiBold32pt7b" },
  { &RobotoMono_SemiBold33pt7b, 33, "RobotoMono_SemiBold33pt7b" },
  { &RobotoMono_SemiBold34pt7b, 34, "RobotoMono_SemiBold34pt7b" },
  { &RobotoMono_SemiBold35pt7b, 35, "RobotoMono_SemiBold35pt7b" },
  { &RobotoMono_SemiBold36pt7b, 36, "RobotoMono_SemiBold36pt7b" },
  { &RobotoMono_SemiBold37pt7b, 37, "RobotoMono_SemiBold37pt7b" },
  { &RobotoMono_SemiBold38pt7b, 38, "RobotoMono_SemiBold38pt7b" },
  { &RobotoMono_SemiBold39pt7b, 39, "RobotoMono_SemiBold39pt7b" },
  { &RobotoMono_SemiBold40pt7b, 40, "RobotoMono_SemiBold40pt7b" },
  { &RobotoMono_SemiBold41pt7b, 41, "RobotoMono_SemiBold41pt7b" },
  { &RobotoMono_SemiBold42pt7b, 42, "RobotoMono_SemiBold42pt7b" },
  { &RobotoMono_SemiBold43pt7b, 43, "RobotoMono_SemiBold43pt7b" },
  { &RobotoMono_SemiBold44pt7b, 44, "RobotoMono_SemiBold44pt7b" },
  { &RobotoMono_SemiBold45pt7b, 45, "RobotoMono_SemiBold45pt7b" },
  { &RobotoMono_SemiBold46pt7b, 46, "RobotoMono_SemiBold46pt7b" },
  { &RobotoMono_SemiBold47pt7b, 47, "RobotoMono_SemiBold47pt7b" },
  { &RobotoMono_SemiBold48pt7b, 48, "RobotoMono_SemiBold48pt7b" },
  { &RobotoMono_SemiBold49pt7b, 49, "RobotoMono_SemiBold49pt7b" },
  { &RobotoMono_SemiBold50pt7b, 50, "RobotoMono_SemiBold50pt7b" },
  { &RobotoMono_SemiBold51pt7b, 51, "RobotoMono_SemiBold51pt7b" },
  { &RobotoMono_SemiBold52pt7b, 52, "RobotoMono_SemiBold52pt7b" },
  { &RobotoMono_SemiBold53pt7b, 53, "RobotoMono_SemiBold53pt7b" },
  { &RobotoMono_SemiBold54pt7b, 54, "RobotoMono_SemiBold54pt7b" },
  { &RobotoMono_SemiBold55pt7b, 55, "RobotoMono_SemiBold55pt7b" },
  { &RobotoMono_SemiBold56pt7b, 56, "RobotoMono_SemiBold56pt7b" },
  { &RobotoMono_SemiBold57pt7b, 57, "RobotoMono_SemiBold57pt7b" },
  { &RobotoMono_SemiBold58pt7b, 58, "RobotoMono_SemiBold58pt7b" },
  { &RobotoMono_SemiBold59pt7b, 59, "RobotoMono_SemiBold59pt7b" },
  { &RobotoMono_SemiBold60pt7b, 60, "RobotoMono_SemiBold60pt7b" },
  { &RobotoMono_SemiBold61pt7b, 61, "RobotoMono_SemiBold61pt7b" },
  { &RobotoMono_SemiBold62pt7b, 62, "RobotoMono_SemiBold62pt7b" },
  { &RobotoMono_SemiBold63pt7b, 63, "RobotoMono_SemiBold63pt7b" },
  { &RobotoMono_SemiBold64pt7b, 64, "RobotoMono_SemiBold64pt7b" },
  { &RobotoMono_SemiBold65pt7b, 65, "RobotoMono_SemiBold65pt7b" },
  { &RobotoMono_SemiBold66pt7b, 66, "RobotoMono_SemiBold66pt7b" },
  { &RobotoMono_SemiBold67pt7b, 67, "RobotoMono_SemiBold67pt7b" },
  { &RobotoMono_SemiBold68pt7b, 68, "RobotoMono_SemiBold68pt7b" },
  { &RobotoMono_SemiBold69pt7b, 69, "RobotoMono_SemiBold69pt7b" },
  { &RobotoMono_SemiBold70pt7b, 70, "RobotoMono_SemiBold70pt7b" },
  { &RobotoMono_SemiBold71pt7b, 71, "RobotoMono_SemiBold71pt7b" },
  { &RobotoMono_SemiBold72pt7b, 72, "RobotoMono_SemiBold72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
