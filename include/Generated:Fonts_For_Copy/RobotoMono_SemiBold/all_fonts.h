#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoMono_SemiBold
// Headers: 67

#include "RobotoMono_SemiBold6pt7b.h"
#include "RobotoMono_SemiBold7pt7b.h"
#include "RobotoMono_SemiBold8pt7b.h"
#include "RobotoMono_SemiBold9pt7b.h"
#include "RobotoMono_SemiBold10pt7b.h"
#include "RobotoMono_SemiBold11pt7b.h"
#include "RobotoMono_SemiBold12pt7b.h"
#include "RobotoMono_SemiBold13pt7b.h"
#include "RobotoMono_SemiBold14pt7b.h"
#include "RobotoMono_SemiBold15pt7b.h"
#include "RobotoMono_SemiBold16pt7b.h"
#include "RobotoMono_SemiBold17pt7b.h"
#include "RobotoMono_SemiBold18pt7b.h"
#include "RobotoMono_SemiBold19pt7b.h"
#include "RobotoMono_SemiBold20pt7b.h"
#include "RobotoMono_SemiBold21pt7b.h"
#include "RobotoMono_SemiBold22pt7b.h"
#include "RobotoMono_SemiBold23pt7b.h"
#include "RobotoMono_SemiBold24pt7b.h"
#include "RobotoMono_SemiBold25pt7b.h"
#include "RobotoMono_SemiBold26pt7b.h"
#include "RobotoMono_SemiBold27pt7b.h"
#include "RobotoMono_SemiBold28pt7b.h"
#include "RobotoMono_SemiBold29pt7b.h"
#include "RobotoMono_SemiBold30pt7b.h"
#include "RobotoMono_SemiBold31pt7b.h"
#include "RobotoMono_SemiBold32pt7b.h"
#include "RobotoMono_SemiBold33pt7b.h"
#include "RobotoMono_SemiBold34pt7b.h"
#include "RobotoMono_SemiBold35pt7b.h"
#include "RobotoMono_SemiBold36pt7b.h"
#include "RobotoMono_SemiBold37pt7b.h"
#include "RobotoMono_SemiBold38pt7b.h"
#include "RobotoMono_SemiBold39pt7b.h"
#include "RobotoMono_SemiBold40pt7b.h"
#include "RobotoMono_SemiBold41pt7b.h"
#include "RobotoMono_SemiBold42pt7b.h"
#include "RobotoMono_SemiBold43pt7b.h"
#include "RobotoMono_SemiBold44pt7b.h"
#include "RobotoMono_SemiBold45pt7b.h"
#include "RobotoMono_SemiBold46pt7b.h"
#include "RobotoMono_SemiBold47pt7b.h"
#include "RobotoMono_SemiBold48pt7b.h"
#include "RobotoMono_SemiBold49pt7b.h"
#include "RobotoMono_SemiBold50pt7b.h"
#include "RobotoMono_SemiBold51pt7b.h"
#include "RobotoMono_SemiBold52pt7b.h"
#include "RobotoMono_SemiBold53pt7b.h"
#include "RobotoMono_SemiBold54pt7b.h"
#include "RobotoMono_SemiBold55pt7b.h"
#include "RobotoMono_SemiBold56pt7b.h"
#include "RobotoMono_SemiBold57pt7b.h"
#include "RobotoMono_SemiBold58pt7b.h"
#include "RobotoMono_SemiBold59pt7b.h"
#include "RobotoMono_SemiBold60pt7b.h"
#include "RobotoMono_SemiBold61pt7b.h"
#include "RobotoMono_SemiBold62pt7b.h"
#include "RobotoMono_SemiBold63pt7b.h"
#include "RobotoMono_SemiBold64pt7b.h"
#include "RobotoMono_SemiBold65pt7b.h"
#include "RobotoMono_SemiBold66pt7b.h"
#include "RobotoMono_SemiBold67pt7b.h"
#include "RobotoMono_SemiBold68pt7b.h"
#include "RobotoMono_SemiBold69pt7b.h"
#include "RobotoMono_SemiBold70pt7b.h"
#include "RobotoMono_SemiBold71pt7b.h"
#include "RobotoMono_SemiBold72pt7b.h"
