#ifndef _ROBOTOMONO_SEMIBOLD7PT7B_H_
#define _ROBOTOMONO_SEMIBOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x5F, 0x6F, 0x60, 0x27, 0x56, 0x97, 0x20, 0xCE, 0x27,
  0x30, 0x66, 0x4B, 0x70, 0xC0, 0x5A, 0xA5, 0xA5, 0x5A, 0x5F, 0x30, 0x2F,
  0x22, 0xC0, 0xE0, 0xC0, 0x69, 0x48, 0x69, 0xF9, 0x60, 0xF5, 0x40, 0x69,
  0x24, 0xF0, 0x69, 0x69, 0x60, 0x26, 0x6F, 0x20, 0x74, 0x79, 0x60, 0x64,
  0xF9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0x71, 0x60, 0x90,
  0x98, 0x3B, 0x80, 0xFC, 0x8F, 0x00, 0xE5, 0x24, 0x6B, 0xFF, 0x60, 0x26,
  0x67, 0x90, 0xF9, 0xE9, 0xF0, 0x69, 0x89, 0x60, 0xE9, 0x99, 0xE0, 0xF3,
  0x4E, 0xF3, 0xC8, 0x69, 0xB9, 0x70, 0x99, 0xF9, 0x90, 0xE9, 0x2E, 0x11,
  0x19, 0x60, 0x9A, 0xEA, 0x90, 0x92, 0x4E, 0xDF, 0xB9, 0x90, 0xDD, 0xBB,
  0x90, 0x69, 0x99, 0x60, 0xF7, 0xC8, 0x69, 0x99, 0x61, 0xF9, 0xFA, 0x90,
  0x78, 0x69, 0x70, 0xF2, 0x22, 0x20, 0x99, 0x99, 0x60, 0x95, 0x66, 0x20,
  0xBB, 0xF7, 0x50, 0x96, 0x26, 0x90, 0x96, 0x62, 0x20, 0xF2, 0x24, 0xF0,
  0xEA, 0xAC, 0x91, 0x26, 0xD5, 0x5C, 0x5A, 0x80, 0xE0, 0xC0, 0x69, 0xF7,
  0x9A, 0xDC, 0x69, 0x87, 0x17, 0x99, 0x70, 0x69, 0xE7, 0x3F, 0x44, 0x40,
  0x79, 0x97, 0x70, 0x8E, 0x99, 0x90, 0x59, 0x2E, 0x75, 0x58, 0x97, 0x6A,
  0xC9, 0x2E, 0xFB, 0xBB, 0xE9, 0x99, 0x69, 0x96, 0xD6, 0xE8, 0x79, 0x97,
  0x10, 0xF2, 0x40, 0x65, 0xB7, 0x4F, 0x44, 0x70, 0xB6, 0xF0, 0x95, 0x62,
  0xBB, 0x76, 0x96, 0x6D, 0x95, 0x62, 0x44, 0xF2, 0x4F, 0x5D, 0x50, 0xFC,
  0xD5, 0x60, 0xDA,
};

const GFXglyph RobotoMono_SemiBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 1, -5 },
  { 17, 2, 8, 4, 1, -6 },
  { 19, 2, 8, 4, 1, -6 },
  { 21, 3, 4, 4, 1, -5 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 1, 2, 4, 1, -1 },
  { 26, 3, 1, 4, 1, -3 },
  { 27, 2, 1, 4, 1, -1 },
  { 28, 3, 5, 4, 1, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 2, 5, 4, 1, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 1, 4, 4, 2, -4 },
  { 60, 1, 5, 4, 2, -4 },
  { 61, 3, 3, 4, 1, -4 },
  { 63, 3, 2, 4, 1, -3 },
  { 64, 3, 3, 4, 1, -4 },
  { 66, 3, 5, 4, 1, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 3, 5, 4, 1, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 6, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 2, 7, 4, 1, -6 },
  { 146, 3, 5, 4, 1, -5 },
  { 148, 2, 7, 4, 1, -6 },
  { 150, 3, 3, 4, 1, -5 },
  { 152, 3, 1, 4, 1, 0 },
  { 153, 2, 1, 4, 1, -5 },
  { 154, 4, 4, 4, 0, -4 },
  { 156, 3, 5, 4, 1, -5 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 4, 5, 4, 0, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 3, 5, 4, 1, -5 },
  { 176, 2, 7, 4, 1, -5 },
  { 178, 3, 5, 4, 1, -5 },
  { 180, 3, 5, 4, 1, -5 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 3, 5, 4, 1, -4 },
  { 190, 4, 5, 4, 0, -4 },
  { 193, 3, 4, 4, 1, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 5, 4, 0, -5 },
  { 200, 3, 4, 4, 1, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 4, 6, 4, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 2, 6, 4, 1, -5 },
  { 215, 1, 6, 4, 2, -5 },
  { 216, 2, 6, 4, 1, -5 },
  { 218, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_SemiBold7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold7pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_SEMIBOLD7PT7B_H_
