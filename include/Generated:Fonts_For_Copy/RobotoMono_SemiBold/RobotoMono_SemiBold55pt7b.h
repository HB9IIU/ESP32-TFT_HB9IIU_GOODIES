#ifndef _ROBOTOMONO_SEMIBOLD55PT7B_H_
#define _ROBOTOMONO_SEMIBOLD55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0x83, 0xFE, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x80, 0x3E, 0x0F, 0x81, 0xC0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xF0, 0x7C, 0x3E, 0x03,
  0xE0, 0xF8, 0x78, 0x07, 0xC1, 0xF1, 0xF0, 0x0F, 0xC3, 0xE3, 0xC0, 0x0F,
  0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0x1E, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x1F,
  0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x81, 0x80, 0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x3C,
  0x7F, 0xF0, 0x00, 0xF9, 0xFF, 0xF0, 0x01, 0xE3, 0xFF, 0xE0, 0x07, 0x8F,
  0x83, 0xE0, 0x1F, 0x1F, 0x07, 0xC0, 0x3C, 0x3E, 0x0F, 0x80, 0xF8, 0x7C,
  0x1F, 0x01, 0xE0, 0xF8, 0x3E, 0x01, 0xC1, 0xF0, 0x7C, 0x01, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0x87, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xE0, 0x7E, 0x3F, 0x9F, 0xE0,
  0xFC, 0xFF, 0x1F, 0xE3, 0xF9, 0xFC, 0x1F, 0xC7, 0xE7, 0xF8, 0x3F, 0xCF,
  0xCF, 0xE0, 0x3F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFE, 0x3F, 0x80, 0x3F, 0xFC,
  0x7F, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE,
  0xFB, 0xE0, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x06, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0x00, 0x78, 0x02, 0x78, 0x0F, 0x01, 0xCF, 0xE1, 0xE1, 0xF9, 0xFF,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x80,
  0x3E, 0x00, 0x70, 0x07, 0x80, 0x04, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x9F, 0xCF, 0xC7, 0xE7, 0xE3,
  0xE0, 0xE0, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x1F, 0xCF,
  0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x03, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF, 0xE7, 0xF3, 0xFF,
  0xF7, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xFB,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFC, 0x1F, 0xF1, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x78, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xE0, 0x3F, 0xE0, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0xFF, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x07, 0xE3, 0xFF, 0x81, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0x9F, 0xC0, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFE, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x7F, 0xCF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xDF, 0x81, 0xFF, 0xE7, 0xE0, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1E, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD,
  0xFE, 0x3F, 0x83, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFE, 0x7F, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xDF, 0xE3, 0xF8, 0x30, 0x0F, 0x07, 0xF8, 0xFF, 0x3F,
  0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F,
  0x07, 0xE0, 0x38, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0x87,
  0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0xE0, 0x78, 0x7C, 0x1F, 0xF1, 0xE1, 0xE0, 0xFF,
  0xE3, 0xCF, 0x07, 0xFF, 0x8F, 0x3C, 0x3F, 0x1E, 0x3D, 0xF0, 0xF8, 0x78,
  0xF7, 0x87, 0xC1, 0xE3, 0xDE, 0x1E, 0x0F, 0x07, 0x78, 0x78, 0x3C, 0x1D,
  0xE3, 0xE0, 0xF0, 0x7F, 0x8F, 0x83, 0xC3, 0xFE, 0x3C, 0x0F, 0x0F, 0xF8,
  0xF0, 0x3C, 0x3F, 0xC3, 0xC0, 0xF0, 0xFF, 0x0F, 0x03, 0xC3, 0xFE, 0x3C,
  0x0F, 0x0E, 0xF8, 0xF8, 0x3C, 0x7B, 0xE3, 0xE1, 0xF1, 0xE7, 0x8F, 0xCF,
  0xCF, 0x1E, 0x1F, 0xFF, 0xFC, 0x78, 0x7F, 0xDF, 0xE1, 0xF0, 0xFE, 0x7F,
  0x03, 0xC0, 0xC0, 0x70, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF,
  0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x9F,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x17, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0x80, 0xFF, 0x87, 0xF0, 0x0F, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x0F, 0xF8, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0,
  0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x02, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF,
  0x80, 0x0F, 0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0xC3, 0xF8, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF9, 0xFF, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0x81, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0,
  0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF9, 0xFC,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3E, 0xFF, 0xFF, 0x8F, 0xBF,
  0xFD, 0xF7, 0xEF, 0xFF, 0x7D, 0xF3, 0xFF, 0xDF, 0x7C, 0xFF, 0xF7, 0xDF,
  0x3F, 0xFC, 0xFF, 0x8F, 0xFF, 0x3F, 0xE3, 0xFF, 0xCF, 0xF8, 0xFF, 0xF1,
  0xFC, 0x3F, 0xFC, 0x7F, 0x0F, 0xFF, 0x1F, 0xC3, 0xFF, 0xC7, 0xF0, 0xFF,
  0xF0, 0xF8, 0x3F, 0xFC, 0x3E, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0xC1, 0xC1,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xBF,
  0x07, 0xFF, 0xEF, 0xC1, 0xFF, 0xF9, 0xF8, 0x7F, 0xFE, 0x7E, 0x1F, 0xFF,
  0x8F, 0x87, 0xFF, 0xE3, 0xF1, 0xFF, 0xF8, 0xFC, 0x7F, 0xFE, 0x1F, 0x9F,
  0xFF, 0x87, 0xE7, 0xFF, 0xE0, 0xFD, 0xFF, 0xF8, 0x3F, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFE, 0x00,
  0x7F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xFC, 0x0F, 0x80, 0xFF, 0xF8, 0x1F, 0x81,
  0xFF, 0xF0, 0x7F, 0x07, 0xF7, 0xE0, 0xFE, 0x0F, 0xEF, 0xC1, 0xFC, 0x1F,
  0xDF, 0x83, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFC,
  0xFE, 0x3F, 0xE1, 0xF9, 0xFC, 0x7F, 0xC3, 0xF1, 0xF8, 0xFF, 0x8F, 0xE3,
  0xF1, 0xFF, 0x1F, 0xC7, 0xE3, 0xFE, 0x3F, 0x0F, 0xC7, 0xFC, 0x7E, 0x1F,
  0x8F, 0x7C, 0xFC, 0x3F, 0x3E, 0xF9, 0xF8, 0x7E, 0x7D, 0xF3, 0xF0, 0xFE,
  0xFB, 0xE7, 0xE0, 0xFD, 0xF7, 0xCF, 0xC1, 0xFB, 0xEF, 0xBF, 0x03, 0xF7,
  0x8F, 0x7E, 0x07, 0xEF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xDF,
  0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE0,
  0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF1, 0xF8,
  0x07, 0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8,
  0x0F, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xF0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x81, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x7F, 0x0F, 0xFF,
  0x9F, 0xC1, 0xFF, 0x87, 0xF0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x08, 0x00, 0xFE,
  0x3F, 0xE0, 0x3F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xCF, 0xF8, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF8,
  0x07, 0xFB, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFB, 0xFF, 0xE0, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8,
  0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x7F, 0x01, 0xFF, 0x1F,
  0xC1, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFC, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFC, 0x07, 0xFC,
  0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x7F, 0x01, 0xFF, 0x1F, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFE,
  0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x04, 0x1F, 0xE0, 0x00, 0xC1, 0xFE, 0x00, 0x3C, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xC1, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE3,
  0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0xFF,
  0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xDF, 0xC0, 0x7F, 0xE7, 0xF0, 0x01, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0x00, 0x0F, 0xF0, 0xE0, 0x07, 0xF8,
  0x7E, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x04, 0x00, 0xFE,
  0x1F, 0xF0, 0x3F, 0x9F, 0xFF, 0x0F, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xEF, 0xF0, 0x07, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x0F, 0xF8, 0xFE, 0x01, 0xFF, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xCF,
  0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x02, 0x07, 0xE3, 0xF8, 0xFE, 0x3F,
  0x7F, 0xCF, 0xF9, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFC, 0xFF, 0x1F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFC, 0x1F, 0xC3,
  0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0x87, 0xFF,
  0xC1, 0xFC, 0x3F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0x83,
  0xF8, 0x7F, 0xFC, 0x1F, 0xC3, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x07, 0xF0,
  0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xC1, 0xFC, 0x3F, 0xFE, 0x0F, 0xE1, 0xFF,
  0xF0, 0x7F, 0x0F, 0xFF, 0x83, 0xF8, 0x7F, 0xFC, 0x1F, 0xC3, 0xFF, 0xE0,
  0xFE, 0x1F, 0xFF, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xC1, 0xFC,
  0x3F, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0x80, 0x7E, 0x0F, 0xFC, 0x3F,
  0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03,
  0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC,
  0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x3F, 0x8F, 0xF8, 0x0F, 0xEF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x07, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xF8, 0x3F, 0x8F,
  0xF8, 0x0F, 0xE0, 0x70, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x7F, 0xFC, 0xFC,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F,
  0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF,
  0xC0, 0x7F, 0xC7, 0xF0, 0x01, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xC3, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x9F, 0xFE, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFE, 0x0E, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF8,
  0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x7F,
  0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x1C, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0xFF, 0x83, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xEF, 0xC7, 0xFF, 0xE7, 0xE1, 0xFF, 0xE3,
  0xF0, 0x7F, 0xE1, 0xF8, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0xFF, 0xF8, 0x0F, 0x81,
  0xFF, 0xF8, 0x3F, 0x03, 0xF7, 0xF0, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x0F,
  0xCF, 0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x0F, 0xF0, 0xFC,
  0x7E, 0x1F, 0xE1, 0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0xFC, 0x7F, 0xC7, 0xE1,
  0xF8, 0xF7, 0x8F, 0xC3, 0xF1, 0xEF, 0x1F, 0x07, 0xE7, 0xDE, 0x3E, 0x07,
  0xCF, 0x3E, 0xFC, 0x0F, 0x9E, 0x7D, 0xF8, 0x1F, 0x3C, 0x7B, 0xF0, 0x3F,
  0x78, 0xF7, 0xE0, 0x7F, 0xE1, 0xEF, 0x80, 0xFF, 0xC3, 0xDF, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x83,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0x03, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0xC0, 0xFD,
  0xFF, 0xFF, 0x87, 0xEF, 0xC1, 0xFF, 0xFF, 0xBE, 0x01, 0xFF, 0xFE, 0xF8,
  0x03, 0xFF, 0xF3, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xC0,
};

const GFXglyph RobotoMono_SemiBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 8, 39, 33, 12, -39 },
  { 40, 16, 14, 33, 8, -41 },
  { 68, 30, 39, 33, 1, -39 },
  { 215, 26, 51, 33, 4, -45 },
  { 381, 31, 41, 33, 1, -40 },
  { 540, 31, 41, 33, 2, -40 },
  { 699, 6, 14, 33, 12, -41 },
  { 710, 15, 56, 33, 9, -44 },
  { 815, 14, 56, 33, 9, -44 },
  { 913, 27, 27, 33, 4, -39 },
  { 1005, 27, 28, 33, 3, -32 },
  { 1100, 9, 17, 33, 10, -6 },
  { 1120, 22, 6, 33, 7, -20 },
  { 1137, 10, 10, 33, 12, -9 },
  { 1150, 22, 42, 33, 6, -39 },
  { 1266, 25, 41, 33, 4, -40 },
  { 1395, 17, 39, 33, 5, -39 },
  { 1478, 27, 40, 33, 2, -40 },
  { 1613, 26, 41, 33, 3, -40 },
  { 1747, 28, 39, 33, 2, -39 },
  { 1884, 25, 40, 33, 4, -39 },
  { 2009, 26, 40, 33, 3, -39 },
  { 2139, 27, 39, 33, 2, -39 },
  { 2271, 26, 41, 33, 3, -40 },
  { 2405, 26, 40, 33, 3, -40 },
  { 2535, 10, 32, 33, 12, -31 },
  { 2575, 11, 42, 33, 12, -31 },
  { 2633, 24, 26, 33, 4, -30 },
  { 2711, 25, 17, 33, 4, -25 },
  { 2765, 25, 26, 33, 4, -30 },
  { 2847, 25, 40, 33, 4, -40 },
  { 2972, 30, 39, 33, 1, -39 },
  { 3119, 32, 39, 33, 1, -39 },
  { 3275, 27, 39, 33, 4, -39 },
  { 3407, 29, 41, 33, 2, -40 },
  { 3556, 27, 39, 33, 4, -39 },
  { 3688, 26, 39, 33, 4, -39 },
  { 3815, 26, 39, 33, 4, -39 },
  { 3942, 28, 41, 33, 2, -40 },
  { 4086, 26, 39, 33, 3, -39 },
  { 4213, 23, 39, 33, 5, -39 },
  { 4326, 26, 40, 33, 3, -39 },
  { 4456, 29, 39, 33, 4, -39 },
  { 4598, 26, 39, 33, 4, -39 },
  { 4725, 26, 39, 33, 4, -39 },
  { 4852, 26, 39, 33, 3, -39 },
  { 4979, 29, 41, 33, 2, -40 },
  { 5128, 27, 39, 33, 4, -39 },
  { 5260, 30, 47, 33, 2, -40 },
  { 5437, 28, 39, 33, 4, -39 },
  { 5574, 28, 41, 33, 3, -40 },
  { 5718, 31, 39, 33, 1, -39 },
  { 5870, 27, 40, 33, 3, -39 },
  { 6005, 31, 39, 33, 1, -39 },
  { 6157, 31, 39, 33, 1, -39 },
  { 6309, 32, 39, 33, 1, -39 },
  { 6465, 31, 39, 33, 1, -39 },
  { 6617, 28, 39, 33, 3, -39 },
  { 6754, 12, 54, 33, 11, -45 },
  { 6835, 22, 42, 33, 6, -39 },
  { 6951, 12, 54, 33, 11, -45 },
  { 7032, 22, 21, 33, 6, -39 },
  { 7090, 25, 5, 33, 4, 0 },
  { 7106, 13, 8, 33, 11, -40 },
  { 7119, 26, 31, 33, 3, -30 },
  { 7220, 26, 42, 33, 4, -41 },
  { 7357, 26, 31, 33, 3, -30 },
  { 7458, 26, 42, 33, 3, -41 },
  { 7595, 27, 31, 33, 3, -30 },
  { 7700, 27, 42, 33, 4, -42 },
  { 7842, 26, 41, 33, 3, -30 },
  { 7976, 26, 41, 33, 4, -41 },
  { 8110, 24, 40, 33, 6, -40 },
  { 8230, 18, 52, 33, 6, -40 },
  { 8347, 28, 41, 33, 4, -41 },
  { 8491, 25, 41, 33, 5, -41 },
  { 8620, 29, 30, 33, 2, -30 },
  { 8729, 25, 30, 33, 4, -30 },
  { 8823, 27, 31, 33, 3, -30 },
  { 8928, 26, 41, 33, 4, -30 },
  { 9062, 26, 41, 33, 3, -30 },
  { 9196, 22, 30, 33, 8, -30 },
  { 9279, 26, 31, 33, 4, -30 },
  { 9380, 26, 37, 33, 3, -36 },
  { 9501, 25, 30, 33, 4, -29 },
  { 9595, 29, 29, 33, 2, -29 },
  { 9701, 31, 29, 33, 1, -29 },
  { 9814, 30, 29, 33, 2, -29 },
  { 9923, 32, 41, 33, 1, -29 },
  { 10087, 27, 29, 33, 3, -29 },
  { 10185, 18, 53, 33, 8, -43 },
  { 10305, 5, 50, 33, 14, -39 },
  { 10337, 18, 53, 33, 9, -43 },
  { 10457, 30, 12, 33, 1, -22 },
};

const GFXfont RobotoMono_SemiBold55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold55pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_SEMIBOLD55PT7B_H_
