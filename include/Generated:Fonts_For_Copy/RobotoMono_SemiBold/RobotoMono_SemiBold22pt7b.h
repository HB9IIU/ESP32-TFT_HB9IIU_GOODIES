#ifndef _ROBOTOMONO_SEMIBOLD22PT7B_H_
#define _ROBOTOMONO_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xCF, 0x9F, 0x3E, 0x6C, 0xD9,
  0x80, 0x06, 0x60, 0x66, 0x04, 0x60, 0xC4, 0x0C, 0xC7, 0xFF, 0x7F, 0xF0,
  0xCC, 0x08, 0xC1, 0x98, 0xFF, 0xFF, 0xFF, 0x19, 0x81, 0x18, 0x31, 0x03,
  0x30, 0x06, 0x00, 0xC0, 0x3C, 0x1F, 0xE7, 0x9C, 0xE1, 0xDC, 0x3B, 0x80,
  0x78, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x0F, 0xC1, 0xD8, 0x3B, 0x87, 0x3F,
  0xC3, 0xF0, 0x18, 0x03, 0x00, 0x38, 0x03, 0xE0, 0x33, 0x11, 0x89, 0x8C,
  0xCC, 0x3E, 0xC0, 0xE4, 0x00, 0x60, 0x02, 0x00, 0x33, 0x03, 0x7C, 0x1B,
  0x31, 0x99, 0x84, 0xCC, 0x06, 0xE0, 0x1E, 0x0E, 0x03, 0xF0, 0x3B, 0x87,
  0x18, 0x71, 0x83, 0x30, 0x3F, 0x01, 0xC0, 0x3C, 0x77, 0xE7, 0xE7, 0x7E,
  0x3E, 0xE3, 0xEE, 0x1C, 0x7F, 0xE3, 0xF7, 0xFF, 0xF0, 0x08, 0x73, 0x1C,
  0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x61, 0x83, 0x0E,
  0x1C, 0x20, 0xC1, 0x83, 0x0E, 0x18, 0x71, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC7, 0x18, 0x63, 0x1C, 0xE1, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x46,
  0x2E, 0xDD, 0xFF, 0xC3, 0x00, 0xF0, 0x33, 0x0E, 0x70, 0x84, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x6D, 0xB7, 0xF0, 0xFF, 0xFF, 0xC0, 0x4E, 0xFE, 0x03,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x1E, 0x1F, 0xCF, 0x7B, 0x8E,
  0xC1, 0xF0, 0x7C, 0x3F, 0x3F, 0xDD, 0xFC, 0x7E, 0x1F, 0x07, 0xE1, 0xB8,
  0xE7, 0xF0, 0xF8, 0x02, 0x3D, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x0F, 0xF1, 0xEF, 0x70, 0xEE, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0,
  0x3F, 0xFF, 0xFF, 0x1F, 0x0F, 0xF1, 0xEF, 0x70, 0xE0, 0x0C, 0x03, 0x80,
  0x70, 0xFC, 0x1F, 0x80, 0x38, 0x03, 0x00, 0x7E, 0x0F, 0xE3, 0x9F, 0xF1,
  0xF8, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xC0, 0xF8, 0x3F, 0x0E, 0xE1, 0x9C,
  0x73, 0x8C, 0x73, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x1C, 0x3F,
  0xC7, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xE3, 0xFE, 0x21, 0xC0,
  0x1C, 0x03, 0x80, 0x7E, 0x0E, 0xE3, 0x9F, 0xF0, 0xFC, 0x03, 0x01, 0xE0,
  0xFC, 0x1C, 0x07, 0x00, 0xC0, 0x3B, 0xE7, 0xFE, 0xF1, 0xDC, 0x1F, 0x83,
  0xF0, 0x76, 0x0E, 0xE3, 0x8F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x1F, 0x07, 0xF1, 0xEF, 0x38, 0xE6, 0x0C,
  0xE3, 0x9C, 0x71, 0xFC, 0x3F, 0x8E, 0x39, 0x83, 0xF0, 0x7E, 0x0E, 0xE3,
  0x9F, 0xF1, 0xFC, 0x1E, 0x07, 0xF1, 0xEF, 0x30, 0xEE, 0x0D, 0xC1, 0xB8,
  0x3F, 0x0E, 0x73, 0xCF, 0xF8, 0x7B, 0x00, 0xE0, 0x18, 0x0F, 0x0F, 0xC1,
  0xE0, 0x4F, 0xFF, 0x00, 0x00, 0x04, 0xFF, 0xF0, 0x2F, 0xF7, 0x00, 0x00,
  0x00, 0x66, 0x66, 0x6E, 0xC0, 0x00, 0x81, 0xC3, 0xEF, 0xCF, 0x87, 0x03,
  0xF0, 0x7F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07, 0xE0, 0x78, 0x1C, 0x7F, 0xFC, 0xF0,
  0x60, 0x00, 0x3E, 0x1F, 0xEF, 0x7B, 0x87, 0x01, 0xC0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x01, 0x00,
  0x7E, 0x06, 0x18, 0x60, 0x66, 0x7D, 0x37, 0x49, 0x32, 0x69, 0x13, 0x48,
  0x92, 0x44, 0x93, 0x6C, 0x9F, 0xC6, 0x64, 0x38, 0x00, 0xFE, 0x01, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x06, 0xE0, 0x37, 0x03,
  0x98, 0x1C, 0xE0, 0xC7, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x38, 0x39, 0xC0,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1,
  0xEF, 0xFC, 0xFF, 0xCE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0xEE, 0x1E, 0xFF,
  0xCF, 0xF8, 0x0F, 0x07, 0xF9, 0xEF, 0x38, 0x7E, 0x0F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7E, 0x0E, 0xE3, 0xCF, 0xF0, 0xFC,
  0xFC, 0x1F, 0xE3, 0xFE, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1D, 0xC7, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x0F, 0x07, 0xF9, 0xEF, 0x38, 0x7E, 0x0F, 0xC0, 0x38, 0x07,
  0x00, 0xE3, 0xFC, 0x7F, 0x83, 0xF0, 0x76, 0x0E, 0xE1, 0xCF, 0xF8, 0xFC,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF,
  0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE3, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F,
  0xE1, 0xF8, 0xE0, 0x7E, 0x0E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x70, 0xEE,
  0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xF3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0,
  0xEE, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xF1, 0xFE,
  0x3F, 0xC7, 0xFC, 0xFF, 0xB7, 0xF7, 0xFB, 0xFF, 0x77, 0xEE, 0xFD, 0xDF,
  0x93, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3,
  0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x67, 0xE6, 0xFC, 0xDF, 0x9F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E,
  0xE3, 0x8F, 0xF0, 0xF8, 0xFC, 0x3F, 0xEF, 0xFF, 0x87, 0xE0, 0xF8, 0x3E,
  0x1F, 0x87, 0xFF, 0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0x6E, 0x06,
  0xE0, 0x6E, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xE7, 0x1C, 0x3F, 0xC1, 0xFC,
  0x00, 0xE0, 0x07, 0x00, 0x20, 0xFC, 0x1F, 0xF3, 0xFF, 0x60, 0xEC, 0x1D,
  0x83, 0xB0, 0x76, 0x1E, 0xFF, 0x9F, 0xC3, 0x1C, 0x61, 0xCC, 0x39, 0x83,
  0xB0, 0x76, 0x07, 0x0F, 0x07, 0xF9, 0xE7, 0xB8, 0x7E, 0x06, 0xE0, 0x1E,
  0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x06, 0xE1, 0xDF, 0xF0,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x76, 0x0E, 0xE3, 0x8F, 0xF0,
  0xF8, 0xF0, 0x3B, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x86, 0x1C, 0x70, 0xE3,
  0x83, 0x1C, 0x1D, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x07, 0xC0,
  0x1C, 0x00, 0xE0, 0xE3, 0x3B, 0x39, 0xD9, 0xCE, 0xCE, 0x66, 0x73, 0x3B,
  0x99, 0xDE, 0xCE, 0xBE, 0x7D, 0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xC3, 0xCE,
  0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0x3B, 0x83, 0x8E, 0x1C, 0x71, 0xC1,
  0xCE, 0x06, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3B,
  0x83, 0xCE, 0x1C, 0x79, 0xE1, 0xDE, 0x0F, 0xF0, 0x3B, 0x83, 0x9C, 0x1C,
  0x70, 0xC3, 0x8E, 0x0E, 0x60, 0x77, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFC, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x06,
  0x06, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCF, 0xFF, 0xFC, 0x0C, 0x0E, 0x07, 0x87, 0xC3, 0x61, 0x99, 0x8C,
  0xC7, 0xE1, 0x80, 0xFF, 0xFF, 0xC0, 0xF1, 0x86, 0x1F, 0x07, 0xF1, 0xCF,
  0x30, 0xE0, 0x0C, 0x7F, 0x9F, 0xF3, 0x06, 0xE0, 0xDC, 0x39, 0xFF, 0x1F,
  0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0x8F, 0xFB, 0xDE, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x3B, 0xFE, 0xDF, 0x00, 0x0F,
  0x07, 0xF1, 0xEF, 0x38, 0x6E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0x60, 0xEE,
  0x38, 0xFF, 0x0F, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x3D,
  0xCF, 0xFB, 0xDF, 0x70, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xC1, 0xDC,
  0x7B, 0xFF, 0x3E, 0xE0, 0x0F, 0x07, 0xF1, 0xEF, 0x38, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x0F, 0x18, 0xFF, 0x8F, 0xC0, 0x03, 0xE0, 0xFC,
  0x3C, 0x87, 0x01, 0xC1, 0xFF, 0xFF, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0xE7, 0xFD,
  0xEF, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xEE, 0x3C, 0xFF,
  0x8F, 0x70, 0x0E, 0x43, 0x9F, 0xF1, 0xFC, 0x0C, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x33, 0xCD, 0xFB, 0xDE, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0x0C, 0x07, 0x80, 0xC0, 0x00,
  0xFE, 0x3F, 0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x8F, 0xFF, 0xFF, 0x0E, 0x1C, 0x18, 0x07, 0xEF, 0xDF, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xEF, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0, 0xE6, 0x38, 0xCE, 0x1B, 0x83,
  0xF0, 0x7F, 0x0E, 0xE1, 0x8E, 0x30, 0xE6, 0x1E, 0xC1, 0xE0, 0xFE, 0x3F,
  0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0xDD, 0xDF, 0xFF, 0xBB,
  0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x73, 0xCE, 0x79, 0xCF, 0x39, 0xE7,
  0x30, 0xCF, 0x37, 0xEF, 0x7B, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x0F, 0x07, 0xF1, 0xEF, 0x38, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0xCE, 0x3F, 0xCF,
  0x7B, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xEF, 0xFB, 0x7C,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1E, 0xE7, 0xFD, 0xEF, 0xB8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xE7, 0xF7, 0xFF, 0xFE, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0xF9, 0xC7, 0x38, 0x77, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xEE, 0x1D, 0xFF, 0x0F, 0xC0, 0x1C, 0x03,
  0x83, 0xFF, 0x7F, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xFE, 0x0F, 0xC0, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0xFF, 0xFD, 0xF7, 0xE0, 0xFC, 0x1D,
  0x83, 0xB8, 0xE7, 0x1C, 0x63, 0x0E, 0xE0, 0xDC, 0x1B, 0x03, 0xE0, 0x38,
  0x07, 0x00, 0xE2, 0x3B, 0x39, 0xD9, 0xCC, 0xCE, 0x66, 0x53, 0x3A, 0xB9,
  0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC0, 0xE0, 0xF7,
  0x0E, 0x39, 0xC3, 0xB8, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x83,
  0x9C, 0x70, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0x60, 0xE7, 0x0E, 0x71, 0xC3,
  0x9C, 0x39, 0x81, 0xB8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x7C, 0x07, 0x80, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF0, 0x06,
  0x0F, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0xF8, 0xE0, 0x78, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0F, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0x3C, 0x39, 0xE3,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0C, 0x00, 0x38, 0x07, 0xE3, 0x7F,
  0x7C, 0x3F, 0x01, 0xE0,
};

const GFXglyph RobotoMono_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 6, 13, 3, -17 },
  { 13, 12, 16, 13, 0, -16 },
  { 37, 11, 20, 13, 1, -18 },
  { 65, 13, 16, 13, 0, -16 },
  { 91, 12, 16, 13, 1, -16 },
  { 115, 2, 6, 13, 5, -17 },
  { 117, 6, 22, 13, 4, -17 },
  { 134, 6, 22, 13, 3, -17 },
  { 151, 11, 11, 13, 2, -16 },
  { 167, 11, 11, 13, 1, -13 },
  { 183, 3, 7, 13, 4, -3 },
  { 186, 9, 2, 13, 3, -8 },
  { 189, 4, 4, 13, 5, -4 },
  { 191, 9, 17, 13, 2, -16 },
  { 211, 10, 16, 13, 2, -16 },
  { 231, 7, 16, 13, 2, -16 },
  { 245, 11, 16, 13, 1, -16 },
  { 267, 11, 16, 13, 1, -16 },
  { 289, 11, 16, 13, 1, -16 },
  { 311, 11, 16, 13, 1, -16 },
  { 333, 11, 16, 13, 1, -16 },
  { 355, 11, 16, 13, 1, -16 },
  { 377, 11, 16, 13, 1, -16 },
  { 399, 11, 16, 13, 1, -16 },
  { 421, 4, 13, 13, 5, -13 },
  { 428, 4, 17, 13, 5, -13 },
  { 437, 9, 10, 13, 2, -12 },
  { 449, 10, 7, 13, 2, -10 },
  { 458, 9, 10, 13, 2, -12 },
  { 470, 10, 16, 13, 2, -16 },
  { 490, 13, 16, 13, 0, -16 },
  { 516, 13, 16, 13, 0, -16 },
  { 542, 12, 16, 13, 1, -16 },
  { 566, 11, 16, 13, 1, -16 },
  { 588, 11, 16, 13, 1, -16 },
  { 610, 10, 16, 13, 2, -16 },
  { 630, 10, 16, 13, 2, -16 },
  { 650, 11, 16, 13, 1, -16 },
  { 672, 11, 16, 13, 1, -16 },
  { 694, 9, 16, 13, 2, -16 },
  { 712, 11, 16, 13, 1, -16 },
  { 734, 12, 16, 13, 1, -16 },
  { 758, 10, 16, 13, 2, -16 },
  { 778, 11, 16, 13, 1, -16 },
  { 800, 11, 16, 13, 1, -16 },
  { 822, 11, 16, 13, 1, -16 },
  { 844, 10, 16, 13, 2, -16 },
  { 864, 12, 19, 13, 1, -16 },
  { 893, 11, 16, 13, 2, -16 },
  { 915, 11, 16, 13, 1, -16 },
  { 937, 13, 16, 13, 0, -16 },
  { 963, 11, 16, 13, 1, -16 },
  { 985, 13, 16, 13, 0, -16 },
  { 1011, 13, 16, 13, 0, -16 },
  { 1037, 13, 16, 13, 0, -16 },
  { 1063, 13, 16, 13, 0, -16 },
  { 1089, 11, 16, 13, 1, -16 },
  { 1111, 5, 22, 13, 4, -18 },
  { 1125, 8, 17, 13, 3, -16 },
  { 1142, 5, 22, 13, 4, -18 },
  { 1156, 9, 9, 13, 2, -16 },
  { 1167, 9, 2, 13, 2, 0 },
  { 1170, 5, 3, 13, 4, -16 },
  { 1172, 11, 12, 13, 1, -12 },
  { 1189, 10, 17, 13, 2, -17 },
  { 1211, 11, 12, 13, 1, -12 },
  { 1228, 11, 17, 13, 1, -17 },
  { 1252, 11, 12, 13, 1, -12 },
  { 1269, 11, 17, 13, 1, -17 },
  { 1293, 11, 17, 13, 1, -12 },
  { 1317, 10, 17, 13, 2, -17 },
  { 1339, 10, 16, 13, 2, -16 },
  { 1359, 7, 21, 13, 2, -16 },
  { 1378, 11, 17, 13, 2, -17 },
  { 1402, 10, 17, 13, 2, -17 },
  { 1424, 11, 12, 13, 1, -12 },
  { 1441, 10, 12, 13, 2, -12 },
  { 1456, 11, 12, 13, 1, -12 },
  { 1473, 10, 16, 13, 2, -12 },
  { 1493, 11, 16, 13, 1, -12 },
  { 1515, 9, 12, 13, 3, -12 },
  { 1529, 11, 12, 13, 1, -12 },
  { 1546, 11, 14, 13, 1, -14 },
  { 1566, 10, 12, 13, 2, -12 },
  { 1581, 11, 12, 13, 1, -12 },
  { 1598, 13, 12, 13, 0, -12 },
  { 1618, 12, 12, 13, 1, -12 },
  { 1636, 12, 17, 13, 1, -12 },
  { 1662, 11, 12, 13, 1, -12 },
  { 1679, 8, 21, 13, 3, -17 },
  { 1700, 2, 20, 13, 6, -16 },
  { 1705, 7, 21, 13, 4, -17 },
  { 1724, 12, 5, 13, 0, -9 },
};

const GFXfont RobotoMono_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold22pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_SEMIBOLD22PT7B_H_
