#ifndef _ROBOTOMONO_SEMIBOLD20PT7B_H_
#define _ROBOTOMONO_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x60, 0x3E, 0xC0, 0xCF, 0x3C, 0xF3, 0xC8, 0x0C,
  0xC1, 0x98, 0x32, 0x06, 0x47, 0xFE, 0x13, 0x06, 0x60, 0xCC, 0xFF, 0xFF,
  0xFC, 0x4C, 0x19, 0x83, 0x30, 0x64, 0x00, 0x04, 0x01, 0x00, 0x40, 0xFC,
  0x7F, 0x9C, 0x76, 0x1D, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF8,
  0x36, 0x1D, 0xFE, 0x3F, 0x01, 0x00, 0x40, 0x78, 0x0C, 0xC8, 0xCC, 0xCC,
  0xD8, 0x7D, 0x03, 0xB0, 0x06, 0x00, 0x60, 0x0D, 0xE0, 0xBE, 0x1B, 0x31,
  0x33, 0x03, 0x20, 0x1E, 0x3E, 0x0F, 0xE1, 0xCC, 0x31, 0x87, 0x70, 0x7C,
  0x0E, 0x03, 0xE7, 0xEE, 0xF8, 0xDB, 0x1F, 0x71, 0xCF, 0xFC, 0xFD, 0xC0,
  0xFA, 0x80, 0x08, 0x71, 0x8C, 0x31, 0x86, 0x18, 0xE3, 0x8E, 0x38, 0x61,
  0x86, 0x18, 0x30, 0xC1, 0x83, 0x04, 0x83, 0x06, 0x0C, 0x30, 0x61, 0x86,
  0x18, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC6, 0x30, 0x80, 0x1C, 0x04,
  0x22, 0x3D, 0x7F, 0xF8, 0xE0, 0xD0, 0xEC, 0x63, 0x11, 0x00, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x77, 0x76, 0x6C, 0xFF, 0xFF, 0x7F, 0x70, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0xE0, 0x3F, 0x1F,
  0xE6, 0x19, 0x86, 0xE1, 0xF8, 0xFE, 0xFF, 0xE7, 0xF1, 0xF8, 0x76, 0x19,
  0xCE, 0x7F, 0x8F, 0xC0, 0x0D, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x70, 0x3F, 0x1F, 0xEE, 0x3B, 0x06, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xEE,
  0x18, 0x06, 0x01, 0x80, 0xE1, 0xF0, 0x7E, 0x01, 0x80, 0x7C, 0x1F, 0x8E,
  0x7F, 0x8F, 0xC0, 0x07, 0x01, 0xC0, 0xF0, 0x7C, 0x1B, 0x0C, 0xC7, 0x31,
  0x8C, 0xC3, 0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0x9F, 0xE7,
  0x01, 0x80, 0x60, 0x1F, 0xC7, 0xF8, 0x06, 0x01, 0xC0, 0x7E, 0x1D, 0x86,
  0x7F, 0x8F, 0xC0, 0x0F, 0x0F, 0xC7, 0x81, 0xC0, 0x60, 0x3F, 0xCF, 0xFB,
  0x86, 0xE1, 0xF8, 0x7E, 0x1D, 0x8E, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xF0,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x1C, 0x00, 0x3F, 0x1F, 0xE6, 0x19, 0x86, 0x61, 0x9C, 0xE3, 0xF1,
  0xFE, 0x61, 0xB8, 0x7E, 0x1F, 0x86, 0x7F, 0x8F, 0xC0, 0x3E, 0x3F, 0xB8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x86, 0xFF, 0x3F, 0x80, 0xC0, 0xE0, 0xE3, 0xE1,
  0xE0, 0x7F, 0x70, 0x00, 0x00, 0x7F, 0x70, 0x77, 0x70, 0x00, 0x00, 0x07,
  0x77, 0x66, 0xC0, 0x01, 0x07, 0x1F, 0xFC, 0xE0, 0xF0, 0x7E, 0x1F, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0xE0, 0xF8, 0x3F, 0x07,
  0x0F, 0x7E, 0xF0, 0xC0, 0x80, 0x7E, 0x7F, 0xB0, 0xE0, 0x70, 0x30, 0x38,
  0x38, 0x38, 0x18, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0xC0, 0x0F, 0x83, 0x18,
  0xC1, 0xB3, 0xD6, 0xDA, 0x93, 0x56, 0x4E, 0xC9, 0xD9, 0x2B, 0xED, 0x3F,
  0x30, 0x03, 0x90, 0x3F, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1D,
  0x81, 0xD8, 0x19, 0x81, 0x9C, 0x38, 0xC3, 0xFC, 0x3F, 0xE7, 0x0E, 0x60,
  0x6E, 0x07, 0xFF, 0x3F, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0xEF, 0xF3, 0xFE,
  0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xFF, 0xBF, 0xC0, 0x3F, 0x1F, 0xE6, 0x1F,
  0x87, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x1D, 0x87, 0x7F,
  0x8F, 0xC0, 0xFE, 0x3F, 0xCE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83,
  0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x3F, 0x1F, 0xE6, 0x1F, 0x87, 0xE0,
  0x30, 0x0C, 0x03, 0x1F, 0xC7, 0xF8, 0x7E, 0x1D, 0xC7, 0x7F, 0xC7, 0xC0,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7E, 0x1F, 0x8E, 0x7F,
  0x8F, 0x80, 0xE1, 0xFC, 0x3B, 0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F, 0x07,
  0xF0, 0xF7, 0x1C, 0xE3, 0x8E, 0x70, 0xEE, 0x1D, 0xC1, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xFF, 0xFC, 0xF1, 0xFC, 0xFF, 0x3F, 0xCB, 0xFE, 0xFF, 0xBF, 0xEF, 0xB3,
  0xEC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x30, 0xE1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF9, 0xFE, 0x7E, 0xDF, 0xB7, 0xE7, 0xF9, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0x70, 0x3F, 0x1F, 0xE6, 0x1B, 0x87, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x7E, 0x1D, 0x8E, 0x7F, 0x8F, 0xC0, 0xFE, 0x7F, 0xB0, 0xF8,
  0x3C, 0x1E, 0x1F, 0x1F, 0xFE, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00,
  0x3F, 0x0F, 0xF1, 0x87, 0x70, 0xEE, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0,
  0xDC, 0x1B, 0x87, 0x30, 0xC7, 0xF8, 0x7F, 0x00, 0x70, 0x07, 0xFF, 0x1F,
  0xF3, 0x87, 0x70, 0x6E, 0x0D, 0xC3, 0xB9, 0xE7, 0xF8, 0xFF, 0x1C, 0x63,
  0x8E, 0x70, 0xCE, 0x1D, 0xC1, 0xC0, 0x3F, 0x1F, 0xEE, 0x1F, 0x83, 0xE0,
  0x1E, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x3E, 0x0F, 0x87, 0x7F, 0xCF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x8E,
  0x7F, 0x8F, 0xC0, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x9C,
  0x39, 0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60,
  0xE6, 0x76, 0x67, 0x66, 0x66, 0x76, 0x6F, 0x66, 0xF6, 0x6F, 0x67, 0xFE,
  0x39, 0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x70, 0xF7, 0x0E,
  0x39, 0xC1, 0x9C, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xD8,
  0x39, 0xC3, 0x8C, 0x70, 0xEF, 0x07, 0xE0, 0x77, 0x0E, 0x30, 0xC3, 0x9C,
  0x19, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0x60, 0x70, 0x30, 0x30,
  0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0xFF, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18, 0x1C, 0x3C, 0x36,
  0x66, 0x66, 0xE3, 0xFF, 0xFF, 0xC0, 0xE1, 0xC0, 0x1E, 0x1F, 0xC6, 0x3B,
  0x86, 0x01, 0x9F, 0xE6, 0x1B, 0x86, 0xE3, 0x9F, 0xE7, 0xDC, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xEE, 0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xBF, 0xEE, 0xF0, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE0, 0x38,
  0x0E, 0x03, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x31,
  0xDB, 0xFD, 0xCF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x36, 0x1B, 0xFC, 0xF6,
  0x0E, 0x0F, 0xE7, 0x39, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x9F,
  0xF1, 0xF0, 0x07, 0xC3, 0xF1, 0xC0, 0x70, 0xFF, 0xBF, 0xE1, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x1D, 0xCF, 0xF7,
  0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xF3, 0xFC, 0x07,
  0x63, 0x9F, 0xE3, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3F, 0xEF,
  0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x08,
  0x0E, 0x07, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC7, 0xFF, 0xFE, 0x0C, 0x1C, 0x30, 0x07, 0xCF, 0x9F, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1D, 0xFB, 0xE0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x1D, 0xC7, 0x39, 0xC7, 0x70, 0xFC, 0x1F, 0x83, 0xF8,
  0x73, 0x8E, 0x39, 0xC7, 0x38, 0x78, 0xFC, 0x7E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0xD9,
  0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C,
  0xCC, 0xE7, 0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1C, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0x61, 0x9F, 0xE3, 0xF0, 0xEE, 0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xBF, 0xEF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x1D, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x61, 0xDF,
  0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xCF, 0xDF, 0xFF, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1E, 0x0F, 0xE7, 0x19, 0x87, 0x70,
  0x0F, 0xC0, 0xF8, 0x07, 0xE1, 0xDF, 0xE3, 0xF0, 0x18, 0x06, 0x0F, 0xFB,
  0xFE, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x7F, 0x0F,
  0xC0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF,
  0xDE, 0xE0, 0xC0, 0xF8, 0x76, 0x19, 0x86, 0x73, 0x8C, 0xC3, 0x30, 0xFC,
  0x1E, 0x07, 0x80, 0xC0, 0xE6, 0x7E, 0x66, 0x66, 0x66, 0xE6, 0x6F, 0x66,
  0xF6, 0x6B, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC0, 0xE0, 0xDC, 0x77,
  0x38, 0xFC, 0x1F, 0x03, 0x81, 0xE0, 0xFC, 0x33, 0x9C, 0x6E, 0x1C, 0xC0,
  0xFC, 0x1B, 0x87, 0x38, 0xE7, 0x38, 0x67, 0x0E, 0xC0, 0xF8, 0x1E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0x04, 0x1C,
  0x60, 0xC1, 0x83, 0x06, 0x1C, 0x31, 0xC3, 0xC1, 0x83, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x38, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x81, 0xC0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x38, 0x3C, 0x79, 0xC3, 0x06, 0x0C, 0x18, 0x30,
  0xE3, 0x84, 0x00, 0x38, 0x4F, 0xCF, 0x1F, 0xE1, 0xE0,
};

const GFXglyph RobotoMono_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 14, 12, 4, -14 },
  { 7, 6, 5, 12, 3, -15 },
  { 11, 11, 14, 12, 0, -14 },
  { 31, 10, 19, 12, 1, -17 },
  { 55, 12, 14, 12, 0, -14 },
  { 76, 11, 14, 12, 1, -14 },
  { 96, 2, 5, 12, 5, -15 },
  { 98, 6, 21, 12, 3, -16 },
  { 114, 6, 21, 12, 3, -16 },
  { 130, 9, 10, 12, 2, -14 },
  { 142, 10, 11, 12, 1, -12 },
  { 156, 4, 6, 12, 3, -2 },
  { 159, 8, 2, 12, 3, -7 },
  { 161, 4, 3, 12, 4, -3 },
  { 163, 8, 15, 12, 2, -14 },
  { 178, 10, 14, 12, 1, -14 },
  { 196, 6, 14, 12, 2, -14 },
  { 207, 10, 14, 12, 1, -14 },
  { 225, 10, 14, 12, 1, -14 },
  { 243, 10, 14, 12, 1, -14 },
  { 261, 10, 14, 12, 1, -14 },
  { 279, 10, 14, 12, 1, -14 },
  { 297, 10, 14, 12, 1, -14 },
  { 315, 10, 14, 12, 1, -14 },
  { 333, 9, 14, 12, 1, -14 },
  { 349, 4, 11, 12, 4, -11 },
  { 355, 4, 15, 12, 4, -11 },
  { 363, 8, 9, 12, 2, -11 },
  { 372, 9, 6, 12, 2, -9 },
  { 379, 8, 10, 12, 2, -11 },
  { 389, 9, 14, 12, 2, -14 },
  { 405, 11, 14, 12, 0, -14 },
  { 425, 12, 14, 12, 0, -14 },
  { 446, 10, 14, 12, 1, -14 },
  { 464, 10, 14, 12, 1, -14 },
  { 482, 10, 14, 12, 1, -14 },
  { 500, 10, 14, 12, 1, -14 },
  { 518, 9, 14, 12, 2, -14 },
  { 534, 10, 14, 12, 1, -14 },
  { 552, 10, 14, 12, 1, -14 },
  { 570, 8, 14, 12, 2, -14 },
  { 584, 10, 14, 12, 1, -14 },
  { 602, 11, 14, 12, 1, -14 },
  { 622, 9, 14, 12, 2, -14 },
  { 638, 10, 14, 12, 1, -14 },
  { 656, 10, 14, 12, 1, -14 },
  { 674, 10, 14, 12, 1, -14 },
  { 692, 9, 14, 12, 2, -14 },
  { 708, 11, 16, 12, 1, -14 },
  { 730, 11, 14, 12, 1, -14 },
  { 750, 10, 14, 12, 1, -14 },
  { 768, 12, 14, 12, 0, -14 },
  { 789, 10, 14, 12, 1, -14 },
  { 807, 12, 14, 12, 0, -14 },
  { 828, 12, 14, 12, 0, -14 },
  { 849, 12, 14, 12, 0, -14 },
  { 870, 12, 14, 12, 0, -14 },
  { 891, 10, 14, 12, 1, -14 },
  { 909, 4, 19, 12, 4, -16 },
  { 919, 8, 15, 12, 2, -14 },
  { 934, 4, 19, 12, 4, -16 },
  { 944, 8, 7, 12, 2, -14 },
  { 951, 9, 2, 12, 1, 0 },
  { 954, 5, 2, 12, 4, -14 },
  { 956, 10, 11, 12, 1, -11 },
  { 970, 10, 15, 12, 1, -15 },
  { 989, 10, 11, 12, 1, -11 },
  { 1003, 9, 15, 12, 1, -15 },
  { 1020, 10, 11, 12, 1, -11 },
  { 1034, 10, 15, 12, 1, -15 },
  { 1053, 10, 15, 12, 1, -11 },
  { 1072, 10, 15, 12, 1, -15 },
  { 1091, 9, 15, 12, 2, -15 },
  { 1108, 7, 19, 12, 2, -15 },
  { 1125, 11, 15, 12, 1, -15 },
  { 1146, 9, 15, 12, 2, -15 },
  { 1163, 10, 11, 12, 1, -11 },
  { 1177, 10, 11, 12, 1, -11 },
  { 1191, 10, 11, 12, 1, -11 },
  { 1205, 10, 15, 12, 1, -11 },
  { 1224, 10, 15, 12, 1, -11 },
  { 1243, 8, 11, 12, 3, -11 },
  { 1254, 10, 11, 12, 1, -11 },
  { 1268, 10, 13, 12, 1, -13 },
  { 1285, 9, 11, 12, 2, -11 },
  { 1298, 10, 11, 12, 1, -11 },
  { 1312, 12, 11, 12, 0, -11 },
  { 1329, 10, 11, 12, 1, -11 },
  { 1343, 11, 15, 12, 1, -11 },
  { 1364, 10, 11, 12, 1, -11 },
  { 1378, 7, 20, 12, 3, -16 },
  { 1396, 2, 18, 12, 5, -14 },
  { 1401, 7, 20, 12, 3, -16 },
  { 1419, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold20pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_SEMIBOLD20PT7B_H_
