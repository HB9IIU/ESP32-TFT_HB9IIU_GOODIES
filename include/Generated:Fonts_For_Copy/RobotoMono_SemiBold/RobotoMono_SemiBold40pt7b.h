#ifndef _ROBOTOMONO_SEMIBOLD40PT7B_H_
#define _ROBOTOMONO_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xE1, 0xE0, 0x03, 0x87, 0x80,
  0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01,
  0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0x9F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x7E, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0xF0, 0x00, 0xE1, 0xE1, 0x83, 0x87,
  0x87, 0x0E, 0x1E, 0x38, 0x38, 0x79, 0xE0, 0xE1, 0xE7, 0x03, 0xEF, 0x3C,
  0x07, 0xFC, 0xE0, 0x0F, 0xE7, 0x80, 0x04, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x8F, 0x80, 0x1E,
  0x7F, 0x80, 0x73, 0xFF, 0x03, 0xCE, 0x3C, 0x0E, 0x78, 0x70, 0x71, 0xE1,
  0xC3, 0xC7, 0x87, 0x02, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xF7, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x1E, 0x3F, 0xF0, 0x79, 0xFF, 0xE1, 0xEF, 0xCF, 0xCF, 0xBE, 0x1F, 0xBE,
  0xF8, 0x3E, 0xF3, 0xE0, 0xFF, 0xCF, 0x81, 0xFF, 0x3E, 0x03, 0xF8, 0xFC,
  0x0F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0x7E, 0x0F, 0xF8,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x30, 0x3C, 0x1F, 0x07,
  0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x40, 0x40, 0x0C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3E, 0x03, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x06, 0x0E, 0x06, 0x78, 0xE1,
  0xEF, 0xF6, 0x7E, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x1E, 0x01, 0xF0, 0xF0, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x04, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF3, 0xE3, 0x82, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFB,
  0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF,
  0x9F, 0x7F, 0xEF, 0x9F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x7E, 0x0F,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x70,
  0x3F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xEF, 0xC0, 0x1F, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0x1F, 0x80, 0xF8, 0xFC,
  0x0F, 0x87, 0xE0, 0x78, 0x3F, 0x07, 0xC1, 0xF8, 0x3C, 0x0F, 0xC3, 0xC0,
  0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x1C, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x9F, 0xE1,
  0x80, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x3E, 0xFF, 0x8F,
  0xBF, 0xF9, 0xFF, 0xFF, 0xBF, 0xC7, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0xFC,
  0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF8,
  0x1F, 0x1F, 0x07, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFF, 0xCF, 0xC0, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF8, 0xFC, 0x1F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0xFF, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x3F, 0xEF, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF,
  0x80, 0x3E, 0x7E, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x3F, 0xDF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0x87, 0xE3, 0x9E,
  0x3F, 0xC6, 0x71, 0xFF, 0x1D, 0xC7, 0x1C, 0x7F, 0x3C, 0x71, 0xF8, 0xE1,
  0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0xF9, 0xE1, 0xC6,
  0xE7, 0x87, 0x1B, 0x8E, 0x18, 0xEE, 0x38, 0xF3, 0xB8, 0xFF, 0xFC, 0xF1,
  0xFF, 0xE1, 0xC3, 0x8F, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x01,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x87, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0x9F, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0x83, 0xF9, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x07, 0xE7,
  0xC3, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0x9F, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xE0, 0x1F, 0x3F, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x01,
  0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE,
  0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x3E, 0x03, 0xF9, 0xF0, 0x1F, 0x8F,
  0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC,
  0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x07, 0xF3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xF7, 0x3F, 0xFE, 0xFF, 0x7F, 0xDF, 0xEF,
  0xFB, 0xFD, 0xFF, 0x3F, 0x3F, 0xE7, 0xE7, 0xFC, 0xFC, 0xFF, 0x8F, 0x1F,
  0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC3, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFE, 0xF1, 0xFF, 0xDE, 0x3F,
  0xF9, 0xE7, 0xFF, 0x3C, 0xFF, 0xE3, 0xDF, 0xFC, 0x7B, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x7E, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xEF,
  0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0xFE, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xEF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0x7E, 0x03,
  0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF0, 0x7E, 0x7F,
  0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xF8, 0x78, 0x3F, 0xE1, 0xE0, 0xFF, 0x87, 0x87, 0xFE, 0x1F, 0x1F,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xF7, 0x8F, 0xC7, 0xDE, 0x3F, 0x1E, 0x78,
  0xFC, 0x79, 0xF3, 0xF1, 0xE7, 0xDF, 0xEF, 0x9F, 0x7F, 0xBE, 0x7D, 0xFE,
  0xF8, 0xF7, 0xBB, 0xE3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCF, 0xF0,
  0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF0,
  0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x03,
  0xE1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xBE,
  0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF7,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x3C,
  0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00,
  0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0xF8,
  0x0F, 0x9F, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9F, 0xFF, 0xF7, 0xF0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF,
  0xBE, 0x1F, 0xE7, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x20, 0x1F, 0x3F, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8,
  0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xDF, 0xC1, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xF3, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7C, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x7E, 0x03, 0xE7, 0xC0, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x83, 0xE0, 0xFE, 0x7C, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x07, 0xEF, 0xC1, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xE7, 0xC0, 0x00, 0x20, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x7E, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0xC3, 0xF0, 0x1E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xC2, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x3C, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x0F, 0xDF, 0x80, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x03, 0xEF, 0xE0,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xE7, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x18, 0x07, 0xE3, 0x81, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x10, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xF8, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x03, 0xF3, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xF8, 0x18, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFE, 0xF8,
  0x1F, 0x8F, 0x83, 0xF8, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F,
  0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3F,
  0x0F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x81, 0x0F,
  0x7E, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0x00, 0x30, 0x3E, 0x7F, 0x8F, 0xBF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x20, 0x1F, 0x7F, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xF8, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x83, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xF3, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xE7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0xF8, 0xFF, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x01,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1, 0xFD, 0xF8, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF7, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0xF9, 0xF8, 0x7F, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0x7C, 0x0F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xCF, 0x0F, 0xE3,
  0xC0, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01,
  0xE7, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x78, 0x7F,
  0xC1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x3E, 0x1E, 0xF8, 0xF8, 0x79, 0xE3,
  0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x3E, 0x79, 0xFC, 0xF9, 0xF7, 0x73,
  0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0xC3,
  0xF8, 0xEE, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0,
  0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0xFC, 0x01, 0xFB, 0xF0, 0x1F,
  0x8F, 0x81, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x1F,
  0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xF1,
  0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xEF,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF1,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x07, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x03, 0xE0, 0x3F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x83, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0x80, 0x38, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0xF7, 0xFE, 0x03, 0xBF, 0xFE, 0x1E, 0xF9, 0xFF, 0xFB, 0xC1,
  0xFF, 0xEE, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x00,
};

const GFXglyph RobotoMono_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 28, 24, 9, -28 },
  { 22, 11, 10, 24, 6, -30 },
  { 36, 22, 28, 24, 1, -28 },
  { 113, 19, 37, 24, 3, -33 },
  { 201, 22, 29, 24, 1, -29 },
  { 281, 22, 29, 24, 2, -29 },
  { 361, 4, 10, 24, 9, -30 },
  { 366, 10, 41, 24, 7, -32 },
  { 418, 11, 41, 24, 6, -32 },
  { 475, 20, 19, 24, 3, -28 },
  { 523, 20, 21, 24, 2, -24 },
  { 576, 7, 13, 24, 7, -5 },
  { 588, 16, 5, 24, 5, -15 },
  { 598, 7, 6, 24, 9, -6 },
  { 604, 16, 30, 24, 4, -28 },
  { 664, 18, 29, 24, 3, -29 },
  { 730, 12, 28, 24, 4, -28 },
  { 772, 20, 29, 24, 1, -29 },
  { 845, 19, 29, 24, 2, -29 },
  { 914, 21, 28, 24, 1, -28 },
  { 988, 18, 28, 24, 3, -28 },
  { 1051, 19, 29, 24, 2, -29 },
  { 1120, 19, 28, 24, 2, -28 },
  { 1187, 19, 29, 24, 2, -29 },
  { 1256, 19, 29, 24, 2, -29 },
  { 1325, 7, 22, 24, 9, -22 },
  { 1345, 8, 30, 24, 9, -22 },
  { 1375, 17, 19, 24, 3, -22 },
  { 1416, 18, 12, 24, 3, -18 },
  { 1443, 18, 19, 24, 3, -22 },
  { 1486, 18, 29, 24, 3, -29 },
  { 1552, 22, 28, 24, 1, -28 },
  { 1629, 23, 28, 24, 1, -28 },
  { 1710, 20, 28, 24, 3, -28 },
  { 1780, 20, 29, 24, 2, -29 },
  { 1853, 19, 28, 24, 3, -28 },
  { 1920, 19, 28, 24, 3, -28 },
  { 1987, 19, 28, 24, 3, -28 },
  { 2054, 20, 29, 24, 2, -29 },
  { 2127, 19, 28, 24, 2, -28 },
  { 2194, 16, 28, 24, 4, -28 },
  { 2250, 19, 28, 24, 2, -28 },
  { 2317, 21, 28, 24, 3, -28 },
  { 2391, 19, 28, 24, 3, -28 },
  { 2458, 19, 28, 24, 3, -28 },
  { 2525, 19, 28, 24, 2, -28 },
  { 2592, 20, 29, 24, 2, -29 },
  { 2665, 20, 28, 24, 3, -28 },
  { 2735, 22, 34, 24, 2, -29 },
  { 2829, 20, 28, 24, 3, -28 },
  { 2899, 21, 29, 24, 2, -29 },
  { 2976, 22, 28, 24, 1, -28 },
  { 3053, 18, 28, 24, 3, -28 },
  { 3116, 22, 28, 24, 1, -28 },
  { 3193, 22, 28, 24, 1, -28 },
  { 3270, 23, 28, 24, 1, -28 },
  { 3351, 23, 28, 24, 1, -28 },
  { 3432, 20, 28, 24, 2, -28 },
  { 3502, 8, 39, 24, 8, -33 },
  { 3541, 15, 30, 24, 5, -28 },
  { 3598, 8, 39, 24, 8, -33 },
  { 3637, 16, 15, 24, 4, -28 },
  { 3667, 18, 4, 24, 3, 0 },
  { 3676, 9, 6, 24, 8, -29 },
  { 3683, 19, 22, 24, 2, -22 },
  { 3736, 19, 30, 24, 3, -30 },
  { 3808, 19, 22, 24, 2, -22 },
  { 3861, 19, 30, 24, 2, -30 },
  { 3933, 20, 22, 24, 2, -22 },
  { 3988, 19, 31, 24, 3, -31 },
  { 4062, 19, 30, 24, 2, -22 },
  { 4134, 19, 30, 24, 3, -30 },
  { 4206, 17, 29, 24, 4, -29 },
  { 4268, 13, 38, 24, 4, -29 },
  { 4330, 20, 30, 24, 3, -30 },
  { 4405, 18, 30, 24, 4, -30 },
  { 4473, 20, 22, 24, 2, -22 },
  { 4528, 18, 22, 24, 3, -22 },
  { 4578, 20, 22, 24, 2, -22 },
  { 4633, 19, 30, 24, 3, -22 },
  { 4705, 19, 30, 24, 2, -22 },
  { 4777, 16, 22, 24, 6, -22 },
  { 4821, 19, 22, 24, 3, -22 },
  { 4874, 18, 26, 24, 3, -26 },
  { 4933, 18, 21, 24, 3, -21 },
  { 4981, 21, 21, 24, 1, -21 },
  { 5037, 22, 21, 24, 1, -21 },
  { 5095, 21, 21, 24, 2, -21 },
  { 5151, 23, 30, 24, 1, -21 },
  { 5238, 20, 21, 24, 2, -21 },
  { 5291, 13, 38, 24, 6, -31 },
  { 5353, 4, 36, 24, 10, -28 },
  { 5371, 13, 38, 24, 6, -31 },
  { 5433, 22, 9, 24, 1, -16 },
};

const GFXfont RobotoMono_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold40pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_SEMIBOLD40PT7B_H_
