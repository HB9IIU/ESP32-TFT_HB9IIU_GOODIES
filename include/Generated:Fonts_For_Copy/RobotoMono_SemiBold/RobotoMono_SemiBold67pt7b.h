#ifndef _ROBOTOMONO_SEMIBOLD67PT7B_H_
#define _ROBOTOMONO_SEMIBOLD67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x7F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8,
  0xFC, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x03,
  0x00, 0x3F, 0x01, 0xF8, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x3E, 0x00, 0x1F, 0xEF, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xC0,
  0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xFF,
  0x07, 0xE0, 0x00, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0x87, 0xFF, 0x80, 0x00, 0x7E, 0x3F, 0xFF, 0x00, 0x01, 0xF1, 0xFF, 0xFC,
  0x00, 0x0F, 0x8F, 0xFF, 0xF8, 0x00, 0x7E, 0x3F, 0x87, 0xE0, 0x01, 0xF0,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0xFC,
  0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x3F, 0x03,
  0xE0, 0x3F, 0x00, 0x38, 0x0F, 0x80, 0xFC, 0x00, 0x20, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0xFC,
  0x01, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F,
  0xF3, 0xFF, 0x07, 0xF9, 0xFF, 0x0F, 0xFC, 0x3F, 0x9F, 0xF0, 0x3F, 0xE1,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xE7, 0xF8, 0x07, 0xFE, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xF8,
  0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x02, 0x20, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x10, 0x01, 0xF0, 0x01, 0x0E, 0x00, 0xF8, 0x03, 0x8F,
  0xE0, 0x7C, 0x07, 0xE7, 0xFC, 0x3E, 0x0F, 0xF3, 0xFF, 0x9F, 0x3F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0x1E, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x03,
  0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7,
  0xFE, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0x1F, 0xE3,
  0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x70, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0xC0, 0xFF, 0x3F,
  0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xE1, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3F, 0xC7, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x06,
  0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF1, 0xFF, 0x87, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x01, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x1F, 0xF0, 0x7C, 0x1F, 0x01, 0xFF,
  0xC3, 0xE1, 0xF8, 0x1F, 0xFF, 0x0F, 0x0F, 0x81, 0xFF, 0xF8, 0x7C, 0xFC,
  0x1F, 0xE7, 0xC3, 0xE7, 0xC1, 0xFC, 0x3E, 0x1F, 0x3E, 0x0F, 0xC1, 0xF0,
  0xF9, 0xF0, 0xFC, 0x0F, 0x87, 0xDF, 0x07, 0xE0, 0x7C, 0x1E, 0xF8, 0x3E,
  0x03, 0xC0, 0xF7, 0xC1, 0xF0, 0x1E, 0x07, 0xBE, 0x1F, 0x81, 0xF0, 0x7D,
  0xF0, 0xF8, 0x0F, 0x83, 0xEF, 0x87, 0xC0, 0x7C, 0x1F, 0x7C, 0x3E, 0x03,
  0xE0, 0xFB, 0xE1, 0xF0, 0x1F, 0x07, 0xDF, 0x0F, 0x80, 0xF8, 0x3C, 0xF8,
  0x7C, 0x07, 0xC1, 0xE7, 0xC3, 0xE0, 0x3E, 0x0F, 0x3E, 0x1F, 0x81, 0xF0,
  0xF9, 0xF0, 0xFC, 0x1F, 0x87, 0x8F, 0x87, 0xF1, 0xFC, 0x7C, 0x7C, 0x1F,
  0xFF, 0xFF, 0xC3, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xFF, 0x7F, 0xE0,
  0x7C, 0x0F, 0xF1, 0xFE, 0x03, 0xF0, 0x1E, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xFC, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x9F, 0xE0, 0x01, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xCF, 0xF0, 0x00,
  0x3F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0x00, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xFC, 0x00,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0x00,
  0x07, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFB,
  0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xF0, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x00,
  0x01, 0xFF, 0xCF, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xEF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFB, 0xFF, 0xFD, 0xF8, 0xFD, 0xFF,
  0xFE, 0xFC, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E, 0x7F, 0xFF, 0xBF, 0xBF, 0x3F,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFE, 0x3F, 0xF0,
  0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F,
  0x03, 0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0x03,
  0xC0, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xBF, 0x81, 0xFF,
  0xFF, 0x9F, 0xC1, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF, 0x8F, 0xE1, 0xFF,
  0xFF, 0x8F, 0xE1, 0xFF, 0xFF, 0x87, 0xF1, 0xFF, 0xFF, 0x87, 0xF1, 0xFF,
  0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0x83, 0xF9, 0xFF, 0xFF, 0x83, 0xF9, 0xFF,
  0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x01, 0xFF,
  0xF8, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x3F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFF,
  0x8F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01,
  0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0x80,
  0xFF, 0x7F, 0x81, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x0F, 0xF7, 0xF8,
  0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFF, 0x07,
  0xF9, 0xFE, 0x07, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xF0, 0x7F, 0x8F, 0xE0,
  0xFF, 0xC1, 0xFE, 0x3F, 0x83, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFC, 0x1F,
  0xE3, 0xFC, 0x3F, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F, 0xC3,
  0xFF, 0x87, 0xF0, 0xFF, 0x1F, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0xF8, 0xFF,
  0x07, 0xF1, 0xFF, 0xE3, 0xFC, 0x1F, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F,
  0xBF, 0x3F, 0x81, 0xFE, 0x7C, 0xFC, 0xFE, 0x07, 0xF9, 0xF3, 0xF3, 0xF8,
  0x1F, 0xEF, 0xCF, 0xCF, 0xE0, 0x3F, 0xBF, 0x3F, 0x3F, 0x80, 0xFE, 0xFC,
  0xFD, 0xFE, 0x03, 0xFB, 0xF1, 0xFF, 0xF8, 0x0F, 0xEF, 0xC7, 0xFF, 0xE0,
  0x3F, 0xBE, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xE1,
  0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0,
  0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xF1, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0x81,
  0xFE, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80, 0x0F,
  0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F,
  0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0xF8, 0xFF, 0x03, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x03,
  0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF,
  0xE1, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xF9, 0xFE, 0x01, 0xFF,
  0xC3, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x06, 0x07, 0xFE, 0x00,
  0x07, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x0E, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x3F, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFD, 0xFF,
  0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x06, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x04, 0x00, 0x03, 0xFE,
  0x06, 0x00, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0xFC, 0x1F, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0xE1, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFD, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x13, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xC0,
  0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0x00,
  0x0F, 0xF1, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x03,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0x00,
  0x03, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x3F, 0x8F, 0xF8, 0xFF, 0x8F, 0xE7, 0xFE, 0x7F, 0xF3, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF,
  0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81,
  0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07,
  0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x0F,
  0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x0F,
  0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x3F, 0xFE, 0x03,
  0xFC, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFE, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0xF0, 0x0F,
  0xF0, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0xE1, 0xFC, 0x0F, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x07,
  0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFF,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFF,
  0x83, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x07, 0xFF,
  0x0F, 0xF0, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xBF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0x8F, 0xBF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xE0, 0x07,
  0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x3E, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0xFC,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0x07,
  0xF8, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xE7, 0xF0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x01, 0xFE, 0x7F, 0x01,
  0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F,
  0x1F, 0xE0, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0x7C, 0x3F, 0x81, 0xFC, 0x7D,
  0xF8, 0xFE, 0x07, 0xF1, 0xF3, 0xE3, 0xF8, 0x1F, 0xC7, 0xCF, 0x8F, 0xE0,
  0x7F, 0x1F, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0xF9, 0xFC, 0x03, 0xF3, 0xE3,
  0xF7, 0xF0, 0x0F, 0xEF, 0x87, 0xDF, 0xC0, 0x3F, 0xBE, 0x1F, 0x7F, 0x00,
  0xFE, 0xF8, 0x7D, 0xF8, 0x03, 0xFF, 0xC1, 0xF7, 0xE0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF8, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x3F, 0xFF,
  0xC0, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xFF, 0xFC, 0x01, 0xF9,
  0xFF, 0xFF, 0xF8, 0x1F, 0xCF, 0xF1, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFF,
  0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x1F, 0xFF, 0xF1, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00,
};

const GFXglyph RobotoMono_SemiBold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 10, 48, 40, 15, -48 },
  { 61, 19, 17, 40, 10, -50 },
  { 102, 37, 48, 40, 1, -48 },
  { 324, 33, 62, 40, 4, -55 },
  { 580, 38, 49, 40, 1, -48 },
  { 813, 37, 49, 40, 3, -48 },
  { 1040, 7, 17, 40, 15, -50 },
  { 1055, 18, 68, 40, 11, -53 },
  { 1208, 19, 68, 40, 10, -53 },
  { 1370, 33, 34, 40, 5, -48 },
  { 1511, 33, 34, 40, 3, -39 },
  { 1652, 11, 21, 40, 12, -8 },
  { 1681, 27, 6, 40, 9, -24 },
  { 1702, 12, 12, 40, 14, -11 },
  { 1720, 27, 52, 40, 7, -48 },
  { 1896, 31, 49, 40, 5, -48 },
  { 2086, 21, 48, 40, 6, -48 },
  { 2212, 34, 48, 40, 2, -48 },
  { 2416, 32, 49, 40, 3, -48 },
  { 2612, 35, 48, 40, 2, -48 },
  { 2822, 32, 49, 40, 4, -48 },
  { 3018, 32, 49, 40, 4, -48 },
  { 3214, 33, 48, 40, 3, -48 },
  { 3412, 32, 49, 40, 4, -48 },
  { 3608, 31, 48, 40, 4, -48 },
  { 3794, 12, 39, 40, 15, -38 },
  { 3853, 13, 51, 40, 15, -38 },
  { 3936, 29, 31, 40, 5, -36 },
  { 4049, 31, 21, 40, 5, -31 },
  { 4131, 30, 31, 40, 5, -36 },
  { 4248, 31, 48, 40, 5, -48 },
  { 4434, 37, 47, 40, 1, -47 },
  { 4652, 39, 48, 40, 1, -48 },
  { 4886, 33, 48, 40, 5, -48 },
  { 5084, 34, 49, 40, 3, -48 },
  { 5293, 33, 48, 40, 4, -48 },
  { 5491, 32, 48, 40, 5, -48 },
  { 5683, 32, 48, 40, 5, -48 },
  { 5875, 34, 49, 40, 3, -48 },
  { 6084, 32, 48, 40, 4, -48 },
  { 6276, 28, 48, 40, 6, -48 },
  { 6444, 32, 49, 40, 4, -48 },
  { 6640, 36, 48, 40, 5, -48 },
  { 6856, 31, 48, 40, 5, -48 },
  { 7042, 33, 48, 40, 4, -48 },
  { 7240, 32, 48, 40, 4, -48 },
  { 7432, 34, 49, 40, 3, -48 },
  { 7641, 33, 48, 40, 5, -48 },
  { 7839, 36, 56, 40, 3, -48 },
  { 8091, 34, 48, 40, 5, -48 },
  { 8295, 35, 49, 40, 3, -48 },
  { 8510, 38, 48, 40, 1, -48 },
  { 8738, 32, 49, 40, 4, -48 },
  { 8934, 38, 48, 40, 1, -48 },
  { 9162, 38, 48, 40, 1, -48 },
  { 9390, 39, 48, 40, 1, -48 },
  { 9624, 38, 48, 40, 1, -48 },
  { 9852, 34, 48, 40, 3, -48 },
  { 10056, 15, 66, 40, 13, -55 },
  { 10180, 26, 52, 40, 8, -48 },
  { 10349, 14, 66, 40, 13, -55 },
  { 10465, 27, 26, 40, 7, -48 },
  { 10553, 30, 7, 40, 5, 0 },
  { 10580, 16, 9, 40, 13, -48 },
  { 10598, 32, 37, 40, 4, -36 },
  { 10746, 31, 51, 40, 5, -50 },
  { 10944, 31, 37, 40, 4, -36 },
  { 11088, 31, 51, 40, 4, -50 },
  { 11286, 33, 37, 40, 4, -36 },
  { 11439, 34, 52, 40, 4, -52 },
  { 11660, 32, 50, 40, 4, -36 },
  { 11860, 31, 50, 40, 5, -50 },
  { 12054, 29, 49, 40, 7, -49 },
  { 12232, 22, 63, 40, 7, -49 },
  { 12406, 34, 50, 40, 5, -50 },
  { 12619, 29, 50, 40, 7, -50 },
  { 12801, 34, 36, 40, 3, -36 },
  { 12954, 31, 36, 40, 5, -36 },
  { 13094, 34, 37, 40, 3, -36 },
  { 13252, 31, 50, 40, 5, -36 },
  { 13446, 31, 50, 40, 4, -36 },
  { 13640, 26, 36, 40, 10, -36 },
  { 13757, 32, 37, 40, 4, -36 },
  { 13905, 32, 45, 40, 4, -44 },
  { 14085, 31, 36, 40, 5, -35 },
  { 14225, 35, 35, 40, 3, -35 },
  { 14379, 38, 35, 40, 1, -35 },
  { 14546, 35, 35, 40, 3, -35 },
  { 14700, 38, 49, 40, 2, -35 },
  { 14933, 33, 35, 40, 4, -35 },
  { 15078, 22, 64, 40, 10, -52 },
  { 15254, 6, 61, 40, 17, -48 },
  { 15300, 22, 64, 40, 11, -52 },
  { 15476, 37, 14, 40, 1, -27 },
};

const GFXfont RobotoMono_SemiBold67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold67pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_SEMIBOLD67PT7B_H_
