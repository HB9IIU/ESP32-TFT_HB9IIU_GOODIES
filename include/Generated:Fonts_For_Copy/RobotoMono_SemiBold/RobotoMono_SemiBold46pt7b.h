#ifndef _ROBOTOMONO_SEMIBOLD46PT7B_H_
#define _ROBOTOMONO_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE7, 0xFF, 0xFF, 0xBF, 0x7C, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x0F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x38, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0x7F, 0x01, 0xFD, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF0,
  0x20, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x03, 0xC3, 0xC3, 0xC0, 0xF0,
  0xF0, 0xE0, 0x3C, 0x3C, 0x78, 0x0F, 0x9F, 0x3C, 0x01, 0xFF, 0x8F, 0x00,
  0x3F, 0xE7, 0x80, 0x07, 0xE1, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x79, 0xFF, 0x00, 0x3C, 0xFF, 0xE0, 0x0F, 0x3F, 0xF8,
  0x07, 0x9F, 0x1F, 0x01, 0xC7, 0x83, 0xC0, 0xF1, 0xE0, 0xF0, 0x38, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x87, 0x83, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xE3, 0xFF, 0xC0, 0xF8, 0xFD,
  0xF8, 0x3E, 0x7E, 0x7F, 0x1F, 0x3F, 0x0F, 0xE7, 0xCF, 0xC1, 0xF9, 0xF3,
  0xF0, 0x3F, 0xFC, 0xFC, 0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0xFC, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x06, 0x60, 0x03, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x07, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x08, 0x0F,
  0x01, 0x1C, 0x1E, 0x0E, 0x7E, 0x3C, 0x7C, 0xFF, 0x73, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xF7, 0x80, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x80,
  0x7C, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xE0, 0x3C, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x70, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3F,
  0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xDF, 0xFC, 0xFC, 0xFF,
  0xEF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFE, 0x07, 0xE3, 0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC1,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3F, 0x7C, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x87, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xF0,
  0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x83, 0xF0,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x0F, 0xF0, 0x30, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F,
  0x80, 0xFE, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x78, 0x0F,
  0xCF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0x07,
  0xF7, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE3, 0xFC, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0xC3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFE, 0x07, 0xE7, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF7, 0xF8, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC,
  0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xF9, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x01, 0xFC, 0xFF, 0x1F, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC, 0x0F, 0xF3, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xF3, 0xF8, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC7, 0xF7, 0xFB, 0xFF, 0xFE, 0x7F, 0x1F, 0x00, 0x3F, 0x3F,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x38,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0xF8, 0x00,
  0x78, 0x78, 0x1C, 0x1C, 0x78, 0x3F, 0x8E, 0x38, 0x7F, 0xE7, 0xBC, 0x3F,
  0xF1, 0xDE, 0x3C, 0x78, 0xEE, 0x1E, 0x3C, 0x77, 0x1E, 0x1E, 0x3F, 0x8F,
  0x0F, 0x1F, 0xC7, 0x07, 0x0F, 0xE3, 0x83, 0x87, 0xF3, 0xC1, 0xC3, 0xF9,
  0xE0, 0xE1, 0xFC, 0xF0, 0x70, 0xFE, 0x78, 0x38, 0xEF, 0x1E, 0x3C, 0x77,
  0x8F, 0xBE, 0x79, 0xC7, 0xFF, 0xF8, 0xE1, 0xF9, 0xF8, 0x78, 0x78, 0x78,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x1C,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF,
  0x80, 0x7F, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF3, 0xF0, 0x1F, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xE7, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0x83, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x7F, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7,
  0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D,
  0xFC, 0x00, 0xF9, 0xFC, 0x03, 0xF1, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x7E, 0x3F, 0xCF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xBF,
  0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x83,
  0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x3F, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3D, 0xFF, 0xBC, 0xF7, 0xFE, 0xF7,
  0xDF, 0xFB, 0xFE, 0x7F, 0xE7, 0xF9, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x1F,
  0xF9, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F, 0xF8,
  0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x7F,
  0xF7, 0xC3, 0xFF, 0x9F, 0x1F, 0xFC, 0xF8, 0xFF, 0xE3, 0xE7, 0xFF, 0x1F,
  0x3F, 0xF8, 0x79, 0xFF, 0xC3, 0xEF, 0xFE, 0x1F, 0x7F, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F,
  0x01, 0xFC, 0x3F, 0xEF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x1F, 0xEF, 0x80, 0x1F,
  0xBE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xBE, 0x01,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01,
  0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x3F,
  0x07, 0xF0, 0x3F, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x10, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x7E, 0x3F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0,
  0xFE, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x83, 0xE0,
  0xFF, 0xF0, 0xF8, 0x3F, 0xFC, 0x3F, 0x0F, 0xBF, 0x0F, 0xC3, 0xE7, 0xC3,
  0xF0, 0xF9, 0xF0, 0xFC, 0x3E, 0x7C, 0x7F, 0x0F, 0x9F, 0x1F, 0xC7, 0xE7,
  0xC7, 0xF9, 0xF9, 0xF9, 0xFE, 0x7C, 0x7E, 0x7F, 0x9F, 0x0F, 0x9F, 0xE7,
  0xC3, 0xE7, 0xF9, 0xF0, 0xFB, 0xDE, 0x7C, 0x3E, 0xF7, 0xDF, 0x0F, 0xBC,
  0xF7, 0xC3, 0xEF, 0x3F, 0xF0, 0xFB, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07,
  0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xE1, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0x80,
  0x7F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x3E, 0xF0, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xE1, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x0F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x1E, 0xF8, 0x07, 0xFE,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFE, 0x0F, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0x7E, 0x0F, 0xF9, 0xFC, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC3, 0xC0, 0x3F, 0x3F, 0xE0, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFE, 0xFE, 0x03, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xF8, 0x7F, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0x0F, 0xCF, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x3F, 0xC3, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xDF, 0x80,
  0x7E, 0xFE, 0x03, 0xF3, 0xF8, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x78, 0x7E, 0x0F, 0xFB,
  0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0x7E,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD,
  0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC1, 0xFE,
  0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x02, 0x1F, 0xC0, 0x1C, 0x3F, 0xE3, 0xFC, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xE0, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE7, 0xC7,
  0xFF, 0xBE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xF8,
  0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xDF, 0x07, 0xFC, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x20, 0x03, 0xF1, 0x80, 0x3F, 0x9F, 0x07,
  0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x18, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x3F, 0x1F, 0xF0, 0xFD,
  0xFF, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xE0, 0xFE, 0xFE, 0x01,
  0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00,
  0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x70, 0xFB,
  0xF9, 0xFC, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC,
  0x7E, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0x00,
  0x0F, 0x03, 0xF1, 0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFE, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xFC, 0x3F, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x03, 0xF3,
  0xFE, 0x0F, 0xDF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F,
  0xCF, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x80, 0xFE, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0x7F, 0xF0, 0xFC, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE7, 0xC7,
  0xFF, 0xBE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xF8,
  0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xF9, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x3E, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xF8, 0x0B, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x7F, 0x01, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E,
  0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0x7C, 0x7F, 0xF3, 0xE0, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x1E, 0x0F, 0xFE,
  0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xF0, 0xF8, 0x3E, 0x7C, 0x3F, 0x0F,
  0x9F, 0x0F, 0xC3, 0xE7, 0xC7, 0xF1, 0xF1, 0xF1, 0xFC, 0x7C, 0x7C, 0x77,
  0x1F, 0x0F, 0x1D, 0xE7, 0xC3, 0xC7, 0x79, 0xF0, 0xFB, 0xDE, 0x78, 0x3E,
  0xF3, 0x9E, 0x0F, 0xB8, 0xEF, 0x83, 0xEE, 0x3F, 0xE0, 0x7B, 0x8F, 0xF8,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x03,
  0xDF, 0xFE, 0x03, 0xEF, 0xFF, 0xC1, 0xFF, 0xCF, 0xFB, 0xF7, 0xC1, 0xFF,
  0xFB, 0xC0, 0x7F, 0xF9, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph RobotoMono_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 33, 28, 10, -33 },
  { 30, 13, 12, 28, 7, -35 },
  { 50, 25, 33, 28, 1, -33 },
  { 154, 22, 43, 28, 3, -38 },
  { 273, 26, 33, 28, 1, -33 },
  { 381, 26, 33, 28, 2, -33 },
  { 489, 5, 12, 28, 10, -35 },
  { 497, 12, 46, 28, 8, -36 },
  { 566, 13, 46, 28, 7, -36 },
  { 641, 23, 23, 28, 3, -33 },
  { 708, 23, 24, 28, 2, -27 },
  { 777, 8, 14, 28, 8, -5 },
  { 791, 18, 5, 28, 6, -17 },
  { 803, 8, 7, 28, 10, -7 },
  { 810, 18, 36, 28, 5, -33 },
  { 891, 21, 33, 28, 3, -33 },
  { 978, 14, 33, 28, 4, -33 },
  { 1036, 22, 33, 28, 2, -33 },
  { 1127, 22, 33, 28, 2, -33 },
  { 1218, 24, 33, 28, 1, -33 },
  { 1317, 22, 33, 28, 3, -33 },
  { 1408, 21, 33, 28, 3, -33 },
  { 1495, 23, 33, 28, 2, -33 },
  { 1590, 21, 33, 28, 3, -33 },
  { 1677, 22, 33, 28, 2, -33 },
  { 1768, 9, 26, 28, 10, -26 },
  { 1798, 9, 35, 28, 10, -26 },
  { 1838, 19, 22, 28, 4, -25 },
  { 1891, 21, 14, 28, 4, -21 },
  { 1928, 20, 22, 28, 4, -25 },
  { 1983, 21, 33, 28, 4, -33 },
  { 2070, 25, 32, 28, 1, -32 },
  { 2170, 26, 33, 28, 1, -33 },
  { 2278, 23, 33, 28, 3, -33 },
  { 2373, 24, 33, 28, 2, -33 },
  { 2472, 23, 33, 28, 3, -33 },
  { 2567, 22, 33, 28, 3, -33 },
  { 2658, 21, 33, 28, 4, -33 },
  { 2745, 23, 33, 28, 2, -33 },
  { 2840, 22, 33, 28, 3, -33 },
  { 2931, 19, 33, 28, 4, -33 },
  { 3010, 22, 33, 28, 2, -33 },
  { 3101, 25, 33, 28, 3, -33 },
  { 3205, 21, 33, 28, 4, -33 },
  { 3292, 22, 33, 28, 3, -33 },
  { 3383, 21, 33, 28, 3, -33 },
  { 3470, 24, 33, 28, 2, -33 },
  { 3569, 22, 33, 28, 4, -33 },
  { 3660, 25, 39, 28, 2, -33 },
  { 3782, 24, 33, 28, 3, -33 },
  { 3881, 24, 33, 28, 2, -33 },
  { 3980, 26, 33, 28, 1, -33 },
  { 4088, 22, 33, 28, 3, -33 },
  { 4179, 26, 33, 28, 1, -33 },
  { 4287, 26, 33, 28, 1, -33 },
  { 4395, 26, 33, 28, 1, -33 },
  { 4503, 26, 33, 28, 1, -33 },
  { 4611, 24, 33, 28, 2, -33 },
  { 4710, 10, 45, 28, 9, -38 },
  { 4767, 18, 36, 28, 5, -33 },
  { 4848, 10, 45, 28, 9, -38 },
  { 4905, 18, 18, 28, 5, -33 },
  { 4946, 21, 5, 28, 3, 0 },
  { 4960, 11, 6, 28, 9, -33 },
  { 4969, 22, 25, 28, 3, -25 },
  { 5038, 22, 35, 28, 3, -35 },
  { 5135, 21, 25, 28, 3, -25 },
  { 5201, 21, 35, 28, 3, -35 },
  { 5293, 22, 25, 28, 3, -25 },
  { 5362, 23, 36, 28, 3, -36 },
  { 5466, 21, 35, 28, 3, -25 },
  { 5558, 22, 35, 28, 3, -35 },
  { 5655, 20, 34, 28, 5, -34 },
  { 5740, 15, 44, 28, 5, -34 },
  { 5823, 24, 35, 28, 3, -35 },
  { 5928, 21, 35, 28, 4, -35 },
  { 6020, 24, 25, 28, 2, -25 },
  { 6095, 22, 25, 28, 3, -25 },
  { 6164, 23, 25, 28, 2, -25 },
  { 6236, 22, 34, 28, 3, -25 },
  { 6330, 21, 34, 28, 3, -25 },
  { 6420, 18, 25, 28, 7, -25 },
  { 6477, 22, 25, 28, 3, -25 },
  { 6546, 22, 30, 28, 3, -30 },
  { 6629, 21, 24, 28, 3, -24 },
  { 6692, 24, 24, 28, 2, -24 },
  { 6764, 26, 24, 28, 1, -24 },
  { 6842, 24, 24, 28, 2, -24 },
  { 6914, 26, 34, 28, 1, -24 },
  { 7025, 22, 24, 28, 3, -24 },
  { 7091, 15, 44, 28, 7, -36 },
  { 7174, 4, 42, 28, 12, -33 },
  { 7195, 15, 44, 28, 7, -36 },
  { 7278, 25, 9, 28, 1, -18 },
};

const GFXfont RobotoMono_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBold46pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_SEMIBOLD46PT7B_H_
