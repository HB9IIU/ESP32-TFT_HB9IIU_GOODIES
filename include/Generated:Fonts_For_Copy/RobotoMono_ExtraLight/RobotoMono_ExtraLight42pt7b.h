#ifndef _ROBOTOMONO_EXTRALIGHT42PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x00, 0x2F,
  0xC0, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x00, 0x20, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x03, 0x01, 0x00, 0x04, 0x06, 0x00,
  0x08, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x40, 0x7F,
  0xFF, 0xFC, 0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x81, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00,
  0x10, 0x18, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x03,
  0xC7, 0x81, 0x80, 0x70, 0xC0, 0x0E, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x18, 0xE0, 0x0C,
  0x1E, 0x1E, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x3F, 0x00, 0x00, 0xE7, 0x00, 0x01, 0x02, 0x00, 0x06, 0x06,
  0x02, 0x0C, 0x0C, 0x04, 0x10, 0x18, 0x18, 0x20, 0x30, 0x60, 0x40, 0x60,
  0xC0, 0xC0, 0xC3, 0x01, 0x81, 0x84, 0x01, 0x02, 0x18, 0x03, 0x0C, 0x20,
  0x03, 0xF0, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC1, 0xF0, 0x01, 0x86, 0x70, 0x06, 0x18, 0x20,
  0x08, 0x60, 0x60, 0x30, 0xC0, 0x40, 0x41, 0x80, 0x81, 0x83, 0x01, 0x02,
  0x06, 0x02, 0x0C, 0x0C, 0x04, 0x10, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x38, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x39, 0xC0, 0x03, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x10, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x0C, 0x00, 0x19, 0xC0,
  0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xB8, 0x00, 0x18,
  0xC0, 0x01, 0x83, 0x01, 0x98, 0x0C, 0x0C, 0xC0, 0x30, 0x6C, 0x01, 0xC3,
  0x60, 0x06, 0x13, 0x00, 0x19, 0x98, 0x00, 0x6C, 0xC0, 0x01, 0xC3, 0x00,
  0x0E, 0x18, 0x00, 0xF0, 0x60, 0x0E, 0xC1, 0xE1, 0xC3, 0x07, 0xFC, 0x0C,
  0xFF, 0xFA, 0x80, 0x00, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x1E,
  0x0C, 0x1D, 0xF1, 0x3E, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x04,
  0xC0, 0x03, 0x18, 0x01, 0x87, 0x00, 0xC0, 0xC0, 0x70, 0x18, 0x18, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x33,
  0x33, 0x33, 0x66, 0xC4, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xE3, 0xC0, 0x70,
  0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x02, 0x40, 0x00, 0xE8, 0x00, 0x3F, 0x00, 0x0D, 0xE0, 0x07, 0x3C, 0x01,
  0xC7, 0x80, 0x70, 0xF0, 0x18, 0x1E, 0x06, 0x03, 0xC1, 0x80, 0x78, 0x60,
  0x0F, 0x18, 0x01, 0xE6, 0x00, 0x35, 0x80, 0x06, 0xE0, 0x00, 0xD8, 0x00,
  0x13, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x06, 0x0E, 0x01,
  0x80, 0xF0, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x40, 0xF0, 0xFC, 0xF3, 0xE0,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x07, 0xF8, 0x01, 0xC7,
  0xC0, 0x60, 0x1C, 0x18, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xE3,
  0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00,
  0x32, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x19, 0xC0, 0x06,
  0x1C, 0x01, 0xC1, 0xF0, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x60,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x30, 0x7F, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x3F, 0xFF, 0x9F, 0xFF, 0xC8, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0xFC, 0x05, 0xFF, 0x83, 0x80, 0xF1, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0x98, 0x01,
  0xC7, 0x01, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x23, 0xFE, 0x0C,
  0xE0, 0xE1, 0xB0, 0x06, 0x3C, 0x00, 0x67, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xB0,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x0E,
  0x01, 0x80, 0xF0, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xE7, 0xC0,
  0xE0, 0x1C, 0x18, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x90, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xC8, 0x00, 0x19, 0x80, 0x06, 0x18, 0x00, 0xC3,
  0x80, 0x30, 0x3C, 0x1C, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x38, 0x07, 0x0E,
  0x00, 0x31, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x06, 0x18,
  0x01, 0xC1, 0xE1, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xE3, 0xC0,
  0x70, 0x1C, 0x18, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x32,
  0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x0F, 0x30, 0x01, 0x63,
  0x00, 0xC8, 0x38, 0xF1, 0x03, 0xFC, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x8C, 0x63, 0x18, 0xC4, 0x66, 0x10, 0x00, 0x00, 0x40, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x1E, 0x78, 0x30, 0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x7F, 0x80, 0x03, 0xE7, 0xC0, 0x0E, 0x01, 0xC0, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x84, 0x07, 0x83, 0x18, 0x3F, 0x82,
  0x20, 0xC1, 0x86, 0xC1, 0x02, 0x0D, 0x06, 0x04, 0x1A, 0x08, 0x08, 0x14,
  0x10, 0x10, 0x38, 0x60, 0x20, 0x70, 0xC0, 0x40, 0xE1, 0x00, 0x83, 0xC2,
  0x03, 0x07, 0x84, 0x06, 0x0F, 0x08, 0x0C, 0x16, 0x18, 0x38, 0x2C, 0x30,
  0x70, 0xC8, 0x21, 0xA1, 0x10, 0x7E, 0x66, 0x30, 0x78, 0x78, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x04, 0x00, 0x78, 0x3C,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x58, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x23, 0x00, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC0,
  0xC0, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x10, 0x01, 0x80, 0x60,
  0x04, 0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x1F,
  0xFF, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x08, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0x30, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x00, 0x38, 0x60, 0x01,
  0x8C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x00,
  0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x38,
  0x3F, 0xFE, 0x06, 0x01, 0xF0, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x03, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xE3, 0xC0, 0x70, 0x0C, 0x1C, 0x00,
  0xC3, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x46, 0x00, 0x18, 0xE0, 0x06, 0x0E, 0x01, 0xC0, 0xF0, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0x00, 0x70, 0x60, 0x03,
  0x0C, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0E, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xF3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xF3, 0xC0, 0x70, 0x0E, 0x1C, 0x00,
  0xC3, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0B, 0x00, 0x01,
  0x60, 0x00, 0x26, 0x00, 0x04, 0xE0, 0x01, 0x8E, 0x00, 0x60, 0xF0, 0x78,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xF0,
  0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x06, 0x0C,
  0x01, 0x80, 0xE1, 0xE0, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0C,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x1C,
  0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18,
  0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xCF, 0x00, 0x0D, 0xD8, 0x00, 0xF8,
  0xC0, 0x0F, 0x0E, 0x00, 0xE0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1E, 0x80, 0x0F, 0xB0,
  0x03, 0xEC, 0x01, 0xB9, 0x00, 0x6E, 0x60, 0x13, 0x98, 0x0C, 0xE2, 0x03,
  0x38, 0xC0, 0x8E, 0x30, 0x63, 0x86, 0x10, 0xE1, 0x8C, 0x38, 0x23, 0x0E,
  0x0C, 0x83, 0x83, 0x60, 0xE0, 0x58, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3D, 0x80, 0x07, 0xB0, 0x00,
  0xF3, 0x00, 0x1E, 0x60, 0x03, 0xC6, 0x00, 0x78, 0x40, 0x0F, 0x0C, 0x01,
  0xE0, 0xC0, 0x3C, 0x18, 0x07, 0x81, 0x80, 0xF0, 0x30, 0x1E, 0x03, 0x03,
  0xC0, 0x60, 0x78, 0x06, 0x0F, 0x00, 0x41, 0xE0, 0x0C, 0x3C, 0x00, 0xC7,
  0x80, 0x18, 0xF0, 0x01, 0x9E, 0x00, 0x33, 0xC0, 0x03, 0x78, 0x00, 0x6F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x03, 0xF8,
  0x01, 0xF3, 0xC0, 0x70, 0x1C, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x01,
  0x98, 0x00, 0x32, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC6, 0x00, 0x30,
  0xE0, 0x06, 0x0E, 0x01, 0x80, 0xF1, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0x08, 0x00, 0xE2, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x32, 0x00, 0x38, 0xFF, 0xFC,
  0x3F, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3E, 0x78, 0x03,
  0x80, 0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x30, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x12, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x34, 0x00,
  0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x30, 0x00, 0x61,
  0xC0, 0x03, 0x06, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x78, 0x70, 0x00, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x00, 0x38, 0x60, 0x01, 0x8C,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x07, 0x30,
  0x01, 0xC6, 0x00, 0xF0, 0xFF, 0xF8, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x00, 0xC0, 0x03, 0xFC, 0x00, 0xF8, 0xF0, 0x1C, 0x03, 0x83, 0x00, 0x1C,
  0x60, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x80, 0x1C,
  0x0F, 0x0F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x06, 0x0E, 0x01, 0x80, 0xF0, 0xE0, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x40,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x10, 0x01, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x10, 0x04, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10, 0x10, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x11, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x78, 0x09, 0x01, 0xE0, 0x26,
  0x07, 0x80, 0x98, 0x12, 0x06, 0x60, 0x48, 0x19, 0x83, 0x30, 0x66, 0x0C,
  0xC1, 0x88, 0x33, 0x04, 0x20, 0x84, 0x10, 0xC2, 0x10, 0x43, 0x18, 0x63,
  0x0C, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xC4, 0x08, 0xC1, 0x10, 0x22, 0x04,
  0xC0, 0xC8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0x80,
  0x58, 0x0A, 0x01, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x06, 0x00, 0x18, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x61,
  0x80, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x60,
  0x00, 0x3B, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xE0, 0x00, 0xC3, 0x00, 0x06, 0x1C, 0x00, 0x60, 0x60, 0x03, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x1B, 0x00, 0x00,
  0xD0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xFF, 0x01, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x6C,
  0x00, 0x8C, 0x03, 0x18, 0x06, 0x10, 0x18, 0x30, 0x30, 0x60, 0x40, 0x61,
  0x80, 0xC3, 0x00, 0x8C, 0x01, 0x98, 0x03, 0x60, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x00, 0x80, 0x03, 0xFF, 0x03,
  0xC0, 0xE1, 0xC0, 0x1C, 0x60, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xF8, 0x3F, 0xFE, 0x3C, 0x01,
  0x98, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x3B, 0x00, 0x1E, 0x60, 0x0D, 0x9E, 0x1E, 0x61, 0xFE, 0x0C, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x0C, 0x7F, 0x83,
  0x30, 0x78, 0xD8, 0x06, 0x38, 0x00, 0xCE, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x80, 0x0C, 0xE0, 0x03, 0x36, 0x01, 0x8C, 0xE3, 0xC3, 0x1F, 0xE0, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0x38, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0x60,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x28, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x03, 0x1C, 0x00, 0xC1, 0xC0,
  0x38, 0x1E, 0x1E, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x30, 0x7F, 0x8C, 0x38, 0x3B, 0x18, 0x03, 0xCC,
  0x00, 0x73, 0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x34, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xC6,
  0x00, 0xF0, 0xE1, 0xEC, 0x1F, 0xE3, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x38,
  0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x01, 0x98, 0x00, 0x13, 0x00,
  0x03, 0x40, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x21, 0xC0, 0x1C, 0x0E, 0x0F, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x03, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x30, 0xE0, 0xEC,
  0x60, 0x0F, 0x30, 0x01, 0xCC, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00,
  0x34, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x07, 0x18, 0x03, 0xC3, 0x87, 0xB0, 0x7F, 0x8C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x80, 0x06, 0x30, 0x03, 0x07, 0x01,
  0x80, 0xFF, 0xC0, 0x07, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x30, 0x30, 0xFF, 0x19, 0xC1, 0xCD, 0x80, 0x36, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x1C, 0x7F, 0xC3, 0xF8, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x2C, 0x00, 0x73, 0x00, 0x38,
  0xC0, 0x1C, 0x30, 0x0E, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30,
  0xC0, 0x0C, 0x60, 0x03, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0xC0, 0x0E, 0x18,
  0x03, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x0C, 0x03, 0x83, 0x00, 0x70,
  0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x84, 0xFE, 0x3F, 0xAC, 0x3B,
  0x0F, 0xC0, 0xF0, 0x3C, 0x03, 0x01, 0xE0, 0x18, 0x06, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x00, 0xE0, 0x61, 0xFE, 0x33, 0x83,
  0x9B, 0x00, 0x6D, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x38, 0x3C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x36,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x6C,
  0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x1C, 0x1C, 0x01,
  0xFF, 0x00, 0x00, 0xC0, 0x31, 0xFE, 0x0D, 0xC1, 0xC3, 0xC0, 0x18, 0xE0,
  0x03, 0x38, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x33, 0x80, 0x0C, 0xF0,
  0x06, 0x37, 0x87, 0x0C, 0x7F, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x30, 0xE0, 0xEC, 0x60, 0x0F, 0x30,
  0x01, 0xCC, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x18,
  0x03, 0xC3, 0x83, 0xB0, 0x7F, 0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x72, 0x0F, 0xF8, 0xF0, 0x36, 0x00, 0xF0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01,
  0xC0, 0xF0, 0xC0, 0x0E, 0x60, 0x01, 0x98, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0D, 0x80, 0x06, 0x70, 0x03, 0x8F, 0x03, 0xC0, 0xFF, 0xC0, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x03,
  0xFF, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x20, 0x0F, 0xF0, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xB0,
  0x01, 0xD8, 0x00, 0xE6, 0x00, 0xF1, 0xC3, 0xD8, 0x7F, 0x8C, 0xE0, 0x00,
  0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x01, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x04,
  0x18, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x06, 0xC0,
  0x30, 0x0D, 0x80, 0xE0, 0x13, 0x01, 0xC0, 0x26, 0x02, 0xC0, 0xC4, 0x05,
  0x81, 0x8C, 0x19, 0x03, 0x18, 0x32, 0x04, 0x30, 0x46, 0x18, 0x20, 0x8C,
  0x30, 0x63, 0x08, 0x60, 0xC6, 0x10, 0x81, 0x88, 0x31, 0x01, 0x10, 0x66,
  0x02, 0x60, 0x4C, 0x06, 0xC0, 0x98, 0x0D, 0x01, 0xA0, 0x1A, 0x03, 0x40,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0xE0, 0x00, 0x63, 0x00, 0x0C, 0x38, 0x01, 0x81, 0x80, 0x38, 0x0C, 0x03,
  0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x01, 0xB8, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x19, 0x80, 0x03,
  0x0C, 0x00, 0x60, 0x60, 0x0C, 0x07, 0x01, 0xC0, 0x30, 0x18, 0x01, 0x83,
  0x00, 0x0C, 0x60, 0x00, 0xEC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x08, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x0F, 0x00, 0x78, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x80, 0x3C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x80, 0x0D, 0xC1, 0xC0, 0x1B, 0x01, 0xC0, 0x24, 0x01,
  0xC0, 0xD8, 0x00, 0xFF, 0x10, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoMono_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 3, 30, 25, 11, -30 },
  { 13, 7, 9, 25, 9, -32 },
  { 21, 23, 30, 25, 1, -30 },
  { 108, 18, 38, 25, 4, -34 },
  { 194, 23, 30, 25, 1, -30 },
  { 281, 21, 30, 25, 3, -30 },
  { 360, 2, 9, 25, 11, -32 },
  { 363, 9, 43, 25, 8, -33 },
  { 412, 10, 43, 25, 7, -33 },
  { 466, 18, 17, 25, 4, -30 },
  { 505, 21, 22, 25, 2, -25 },
  { 563, 4, 10, 25, 8, -4 },
  { 568, 15, 1, 25, 5, -14 },
  { 570, 3, 3, 25, 12, -3 },
  { 572, 14, 33, 25, 6, -30 },
  { 630, 19, 30, 25, 3, -30 },
  { 702, 10, 30, 25, 5, -30 },
  { 740, 19, 30, 25, 2, -30 },
  { 812, 19, 30, 25, 2, -30 },
  { 884, 21, 30, 25, 2, -30 },
  { 963, 17, 30, 25, 5, -30 },
  { 1027, 19, 30, 25, 3, -30 },
  { 1099, 19, 30, 25, 3, -30 },
  { 1171, 19, 30, 25, 4, -30 },
  { 1243, 19, 30, 25, 3, -30 },
  { 1315, 3, 21, 25, 13, -21 },
  { 1323, 5, 27, 25, 11, -21 },
  { 1340, 18, 17, 25, 3, -22 },
  { 1379, 18, 10, 25, 4, -19 },
  { 1402, 18, 17, 25, 4, -22 },
  { 1441, 16, 30, 25, 5, -30 },
  { 1501, 23, 30, 25, 1, -30 },
  { 1588, 22, 30, 25, 2, -30 },
  { 1671, 19, 30, 25, 4, -30 },
  { 1743, 19, 30, 25, 3, -30 },
  { 1815, 19, 30, 25, 4, -30 },
  { 1887, 18, 30, 25, 4, -30 },
  { 1955, 17, 30, 25, 5, -30 },
  { 2019, 19, 30, 25, 3, -30 },
  { 2091, 19, 30, 25, 3, -30 },
  { 2163, 17, 30, 25, 4, -30 },
  { 2227, 19, 30, 25, 2, -30 },
  { 2299, 20, 30, 25, 4, -30 },
  { 2374, 17, 30, 25, 5, -30 },
  { 2438, 18, 30, 25, 4, -30 },
  { 2506, 19, 30, 25, 3, -30 },
  { 2578, 19, 30, 25, 3, -30 },
  { 2650, 18, 30, 25, 5, -30 },
  { 2718, 21, 35, 25, 2, -30 },
  { 2810, 19, 30, 25, 4, -30 },
  { 2882, 20, 30, 25, 3, -30 },
  { 2957, 21, 30, 25, 2, -30 },
  { 3036, 19, 30, 25, 3, -30 },
  { 3108, 21, 30, 25, 2, -30 },
  { 3187, 22, 30, 25, 2, -30 },
  { 3270, 22, 30, 25, 2, -30 },
  { 3353, 21, 30, 25, 2, -30 },
  { 3432, 19, 30, 25, 3, -30 },
  { 3504, 6, 40, 25, 10, -34 },
  { 3534, 14, 33, 25, 6, -30 },
  { 3592, 7, 40, 25, 9, -34 },
  { 3627, 15, 16, 25, 5, -30 },
  { 3657, 17, 2, 25, 4, 0 },
  { 3662, 6, 6, 25, 10, -31 },
  { 3667, 18, 23, 25, 4, -23 },
  { 3719, 18, 32, 25, 4, -32 },
  { 3791, 19, 23, 25, 3, -23 },
  { 3846, 18, 32, 25, 3, -32 },
  { 3918, 19, 23, 25, 3, -23 },
  { 3973, 19, 32, 25, 4, -32 },
  { 4049, 18, 32, 25, 3, -23 },
  { 4121, 17, 32, 25, 4, -32 },
  { 4189, 17, 30, 25, 5, -30 },
  { 4253, 13, 39, 25, 4, -30 },
  { 4317, 18, 32, 25, 5, -32 },
  { 4389, 17, 32, 25, 5, -32 },
  { 4457, 21, 23, 25, 2, -23 },
  { 4518, 17, 23, 25, 4, -23 },
  { 4567, 19, 23, 25, 3, -23 },
  { 4622, 18, 32, 25, 4, -23 },
  { 4694, 18, 32, 25, 3, -23 },
  { 4766, 14, 23, 25, 8, -23 },
  { 4807, 18, 23, 25, 4, -23 },
  { 4859, 17, 28, 25, 4, -28 },
  { 4919, 17, 22, 25, 4, -22 },
  { 4966, 21, 22, 25, 2, -22 },
  { 5024, 23, 22, 25, 1, -22 },
  { 5088, 20, 22, 25, 3, -22 },
  { 5143, 21, 31, 25, 2, -22 },
  { 5225, 20, 22, 25, 3, -22 },
  { 5280, 13, 42, 25, 7, -33 },
  { 5349, 1, 36, 25, 12, -30 },
  { 5354, 13, 42, 25, 7, -33 },
  { 5423, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight42pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_EXTRALIGHT42PT7B_H_
