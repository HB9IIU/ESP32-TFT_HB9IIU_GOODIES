#ifndef _ROBOTOMONO_EXTRALIGHT21PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight21pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x54, 0x0C, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22,
  0x04, 0x4F, 0xFE, 0x22, 0x04, 0x40, 0x88, 0x11, 0x04, 0x23, 0xFF, 0x11,
  0x02, 0x20, 0x44, 0x08, 0x80, 0x08, 0x04, 0x0F, 0x88, 0x24, 0x0C, 0x06,
  0x00, 0x80, 0x20, 0x0E, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x02, 0x82, 0x3E,
  0x04, 0x02, 0x00, 0x78, 0x04, 0x80, 0x84, 0x48, 0x48, 0x85, 0x04, 0x90,
  0x32, 0x00, 0x20, 0x04, 0x60, 0x49, 0x09, 0x10, 0x91, 0x11, 0x11, 0x11,
  0x00, 0xE0, 0x3C, 0x10, 0x84, 0x21, 0x08, 0x44, 0x0A, 0x03, 0x00, 0xC0,
  0x48, 0x61, 0x18, 0x4A, 0x0A, 0x81, 0x20, 0xE7, 0xC4, 0xF8, 0x08, 0x88,
  0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x08, 0x41, 0x04,
  0x88, 0x42, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x88, 0x08,
  0x04, 0x02, 0x1D, 0x31, 0xE0, 0xA0, 0x48, 0x44, 0x41, 0x00, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x55, 0x80, 0xFE, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x3E, 0x20, 0xA0, 0x50, 0x18, 0x1C,
  0x16, 0x13, 0x11, 0x90, 0xD0, 0x70, 0x30, 0x18, 0x12, 0x08, 0xF8, 0x09,
  0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x3E, 0x10, 0x48,
  0x0A, 0x02, 0x00, 0x80, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x0F, 0xFC, 0x3E, 0x20, 0x90, 0x30, 0x10, 0x08, 0x04, 0x0C,
  0x3C, 0x01, 0x00, 0x40, 0x30, 0x18, 0x0A, 0x0C, 0xF8, 0x01, 0x00, 0xC0,
  0x50, 0x14, 0x09, 0x04, 0x41, 0x10, 0x84, 0x41, 0x10, 0x4F, 0xFC, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x41, 0xDC,
  0x02, 0x00, 0x80, 0x40, 0x30, 0x14, 0x0A, 0x08, 0xF8, 0x0E, 0x18, 0x10,
  0x08, 0x08, 0x04, 0xE3, 0x89, 0x02, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x12,
  0x08, 0xF8, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x3E, 0x20, 0xA0,
  0x30, 0x18, 0x0A, 0x05, 0x8C, 0x7C, 0x41, 0x40, 0x60, 0x30, 0x18, 0x0A,
  0x0C, 0xF8, 0x3E, 0x21, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x42,
  0x9E, 0x40, 0x40, 0x20, 0x20, 0x30, 0xE0, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x16, 0xA0, 0x01, 0x83, 0x06, 0x1C, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x38, 0x03, 0x00, 0x60, 0x18, 0x30,
  0xE1, 0x80, 0x3E, 0x41, 0x41, 0x81, 0x01, 0x01, 0x02, 0x04, 0x08, 0x08,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x04, 0x19, 0x01, 0x27, 0x19, 0x13,
  0x22, 0x64, 0x4D, 0x09, 0xA1, 0x34, 0x46, 0x49, 0x4E, 0xE8, 0x00, 0x80,
  0x0F, 0xC0, 0x04, 0x00, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x40,
  0x88, 0x20, 0x84, 0x10, 0xFE, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x08, 0xFC,
  0x41, 0xA0, 0x50, 0x18, 0x0C, 0x0A, 0x0D, 0xFC, 0x81, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x0B, 0xF8, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x40, 0x60, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x05, 0x01, 0x40, 0x48, 0x21, 0xF0, 0xFC,
  0x41, 0x20, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x14, 0x13, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x87, 0xE0, 0x18, 0x05, 0x01, 0x40, 0x48, 0x11, 0xF8, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x14, 0x0A, 0x08, 0xF8,
  0x80, 0xE0, 0x48, 0x22, 0x18, 0x84, 0x22, 0x09, 0x02, 0xC0, 0xC8, 0x21,
  0x08, 0x22, 0x08, 0x81, 0x20, 0x28, 0x04, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE,
  0x80, 0xE0, 0xF0, 0x78, 0x5A, 0x2D, 0x16, 0x93, 0x29, 0x98, 0xC4, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x80, 0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86,
  0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x1C, 0x0E, 0x02, 0x1F, 0x08,
  0x24, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05,
  0x01, 0x40, 0x88, 0x21, 0xF0, 0xFE, 0x20, 0x48, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x0A, 0x04, 0xFE, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00,
  0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0x20, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x04, 0x00, 0x40,
  0x08, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x0C, 0xFC,
  0x20, 0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0C, 0x1F, 0x08, 0x24, 0x05,
  0x01, 0x40, 0x08, 0x01, 0x00, 0x38, 0x01, 0x80, 0x18, 0x05, 0x01, 0x40,
  0x48, 0x31, 0xF0, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x12, 0x08, 0xF8, 0x80, 0x70, 0x09, 0x01, 0x20, 0x44, 0x08,
  0x41, 0x08, 0x41, 0x08, 0x11, 0x02, 0x20, 0x48, 0x05, 0x00, 0xA0, 0x18,
  0x01, 0x00, 0x84, 0x30, 0x86, 0x10, 0xC5, 0x14, 0xA4, 0x94, 0x92, 0x92,
  0x52, 0x51, 0x4A, 0x29, 0x45, 0x18, 0xC3, 0x18, 0x41, 0x08, 0x20, 0xC0,
  0x68, 0x08, 0x82, 0x08, 0x81, 0x10, 0x14, 0x02, 0x80, 0x20, 0x0A, 0x01,
  0x40, 0x44, 0x10, 0x42, 0x08, 0x80, 0xB0, 0x18, 0x80, 0x50, 0x14, 0x08,
  0x82, 0x21, 0x04, 0x41, 0x20, 0x28, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x7F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x0F, 0xFC, 0xF2, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x70, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01, 0xE4, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0xF0, 0x10, 0x60, 0xA2, 0x44, 0x48, 0xA1, 0x41, 0xFF,
  0x80, 0xCC, 0x3E, 0x20, 0xA0, 0x40, 0x10, 0x0B, 0xFE, 0x03, 0x01, 0x81,
  0xC1, 0x5F, 0x20, 0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xF3, 0x05, 0x02,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0B, 0x05, 0x7C, 0x3E, 0x20, 0xA0,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0xA0, 0x8F, 0x80, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x3F, 0x3E, 0x20, 0xA0, 0x30, 0x1F, 0xFC, 0x02, 0x01, 0x00, 0x80,
  0x20, 0xCF, 0x80, 0x07, 0x84, 0x04, 0x02, 0x01, 0x07, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x3F, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x01, 0x01, 0x81, 0x7E,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xF3, 0x05, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x0C, 0x04, 0x00, 0x00, 0x0F, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x04,
  0x10, 0x00, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x1F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x0E, 0x09, 0x08, 0x88,
  0x58, 0x3C, 0x11, 0x08, 0x44, 0x12, 0x05, 0x01, 0xF8, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x21, 0xFF, 0xFB, 0xD0, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x84, 0x30, 0x86, 0x10, 0x80, 0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x1F, 0x08, 0x24, 0x05, 0x01,
  0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x48, 0x21, 0xF0, 0xBE, 0x60, 0xA0,
  0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x60, 0xAF, 0x90, 0x08, 0x04,
  0x02, 0x00, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x3F, 0x01, 0x01, 0x01, 0x01, 0xBF, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x3E, 0x20, 0xA0, 0x28, 0x06, 0x00, 0xF0, 0x04, 0x01,
  0x80, 0xA0, 0xCF, 0x80, 0x10, 0x08, 0x04, 0x1F, 0xE1, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7C, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xA0, 0xCF, 0xA0, 0x80, 0x50, 0x14,
  0x08, 0x82, 0x21, 0x08, 0x41, 0x10, 0x48, 0x0A, 0x03, 0x00, 0x40, 0x84,
  0x30, 0x86, 0x30, 0xC5, 0x24, 0xA4, 0x94, 0x94, 0x92, 0x8C, 0x31, 0x84,
  0x30, 0x82, 0x00, 0x40, 0x48, 0x21, 0x10, 0x68, 0x0A, 0x01, 0x00, 0xA0,
  0x44, 0x21, 0x08, 0x2C, 0x04, 0x80, 0x68, 0x09, 0x01, 0x20, 0x42, 0x08,
  0x42, 0x04, 0x40, 0x90, 0x0A, 0x01, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x1C, 0x00, 0x7F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x0F, 0xFC, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x11,
  0xC1, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x30, 0xFF, 0xFF,
  0xC0, 0xE0, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x0C, 0x18, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x00, 0x70, 0x31, 0x86, 0x09, 0x00,
  0xC0,
};

const GFXglyph RobotoMono_ExtraLight21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 2, 15, 13, 5, -15 },
  { 5, 4, 5, 13, 4, -16 },
  { 8, 11, 15, 13, 1, -15 },
  { 29, 9, 19, 13, 2, -17 },
  { 51, 12, 15, 13, 0, -15 },
  { 74, 10, 15, 13, 2, -15 },
  { 93, 1, 5, 13, 5, -16 },
  { 94, 5, 22, 13, 4, -17 },
  { 108, 4, 22, 13, 4, -17 },
  { 119, 9, 9, 13, 2, -15 },
  { 130, 10, 11, 13, 1, -12 },
  { 144, 2, 5, 13, 4, -2 },
  { 146, 7, 1, 13, 3, -7 },
  { 147, 1, 2, 13, 6, -2 },
  { 148, 7, 16, 13, 3, -15 },
  { 162, 9, 15, 13, 2, -15 },
  { 179, 5, 15, 13, 2, -15 },
  { 189, 10, 15, 13, 1, -15 },
  { 208, 9, 15, 13, 1, -15 },
  { 225, 10, 15, 13, 1, -15 },
  { 244, 9, 15, 13, 2, -15 },
  { 261, 9, 15, 13, 2, -15 },
  { 278, 10, 15, 13, 1, -15 },
  { 297, 9, 15, 13, 2, -15 },
  { 314, 9, 15, 13, 2, -15 },
  { 331, 2, 11, 13, 6, -11 },
  { 334, 2, 14, 13, 6, -11 },
  { 338, 9, 8, 13, 2, -11 },
  { 347, 9, 5, 13, 2, -9 },
  { 353, 9, 8, 13, 2, -11 },
  { 362, 8, 15, 13, 2, -15 },
  { 377, 11, 15, 13, 1, -15 },
  { 398, 11, 15, 13, 1, -15 },
  { 419, 9, 15, 13, 2, -15 },
  { 436, 10, 15, 13, 1, -15 },
  { 455, 9, 15, 13, 2, -15 },
  { 472, 9, 15, 13, 2, -15 },
  { 489, 9, 15, 13, 2, -15 },
  { 506, 10, 15, 13, 1, -15 },
  { 525, 9, 15, 13, 2, -15 },
  { 542, 9, 15, 13, 2, -15 },
  { 559, 9, 15, 13, 1, -15 },
  { 576, 10, 15, 13, 2, -15 },
  { 595, 9, 15, 13, 2, -15 },
  { 612, 9, 15, 13, 2, -15 },
  { 629, 9, 15, 13, 2, -15 },
  { 646, 10, 15, 13, 1, -15 },
  { 665, 10, 15, 13, 2, -15 },
  { 684, 11, 18, 13, 1, -15 },
  { 709, 10, 15, 13, 2, -15 },
  { 728, 10, 15, 13, 1, -15 },
  { 747, 11, 15, 13, 1, -15 },
  { 768, 9, 15, 13, 2, -15 },
  { 785, 11, 15, 13, 1, -15 },
  { 806, 11, 15, 13, 1, -15 },
  { 827, 11, 15, 13, 1, -15 },
  { 848, 10, 15, 13, 1, -15 },
  { 867, 10, 15, 13, 1, -15 },
  { 886, 3, 20, 13, 5, -17 },
  { 894, 7, 16, 13, 3, -15 },
  { 908, 3, 20, 13, 5, -17 },
  { 916, 7, 8, 13, 3, -15 },
  { 923, 9, 1, 13, 2, 0 },
  { 925, 3, 2, 13, 5, -15 },
  { 926, 9, 11, 13, 2, -11 },
  { 939, 9, 16, 13, 2, -16 },
  { 957, 9, 11, 13, 2, -11 },
  { 970, 8, 16, 13, 2, -16 },
  { 986, 9, 11, 13, 2, -11 },
  { 999, 9, 16, 13, 2, -16 },
  { 1017, 8, 15, 13, 2, -11 },
  { 1032, 9, 16, 13, 2, -16 },
  { 1050, 9, 15, 13, 2, -15 },
  { 1067, 6, 19, 13, 2, -15 },
  { 1082, 9, 16, 13, 2, -16 },
  { 1100, 9, 16, 13, 2, -16 },
  { 1118, 11, 11, 13, 1, -11 },
  { 1134, 9, 11, 13, 2, -11 },
  { 1147, 10, 11, 13, 1, -11 },
  { 1161, 9, 15, 13, 2, -11 },
  { 1178, 8, 15, 13, 2, -11 },
  { 1193, 7, 11, 13, 4, -11 },
  { 1203, 9, 11, 13, 2, -11 },
  { 1216, 9, 14, 13, 2, -14 },
  { 1232, 9, 11, 13, 2, -11 },
  { 1245, 10, 11, 13, 1, -11 },
  { 1259, 11, 11, 13, 1, -11 },
  { 1275, 10, 11, 13, 1, -11 },
  { 1289, 11, 15, 13, 1, -11 },
  { 1310, 10, 11, 13, 1, -11 },
  { 1324, 7, 20, 13, 3, -16 },
  { 1342, 1, 18, 13, 6, -15 },
  { 1345, 7, 20, 13, 3, -16 },
  { 1363, 11, 4, 13, 1, -8 },
};

const GFXfont RobotoMono_ExtraLight21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight21pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_EXTRALIGHT21PT7B_H_
