#ifndef _ROBOTOMONO_EXTRALIGHT29PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x2E, 0x8C, 0x63, 0x18,
  0xC4, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x18, 0x04,
  0x10, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x08, 0x60, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00,
  0xF8, 0x30, 0xC6, 0x06, 0x40, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0x40, 0x06,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x03, 0x60, 0x61, 0xFC, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x38, 0x00, 0xCC, 0x00, 0x84, 0x00, 0x86, 0x10, 0x82, 0x10, 0x82, 0x20,
  0x84, 0x60, 0x84, 0x40, 0x78, 0x80, 0x10, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x3C, 0x02, 0x62, 0x04, 0x42, 0x0C, 0x41, 0x08, 0x41, 0x18, 0x41,
  0x10, 0x43, 0x00, 0x62, 0x00, 0x3C, 0x0F, 0x00, 0x33, 0x00, 0xC1, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x0C, 0x20, 0x08, 0x80, 0x1A, 0x00, 0x18,
  0x00, 0x70, 0x01, 0x90, 0x06, 0x30, 0x48, 0x30, 0xB0, 0x23, 0x40, 0x24,
  0x80, 0x29, 0x80, 0x61, 0x00, 0xE3, 0x03, 0x61, 0xF8, 0x60, 0x55, 0x70,
  0x04, 0x21, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x20, 0x81, 0x06, 0x0C, 0x10, 0x81,
  0x02, 0x0C, 0x10, 0x60, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x30, 0x82, 0x18, 0x42, 0x18, 0xC2, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x82, 0x1F, 0x2F, 0x0F, 0x80, 0x60, 0x09, 0x01,
  0x88, 0x30, 0xC2, 0x06, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x55, 0xA0, 0xFF, 0xE0, 0xF0,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x08, 0x00, 0x0F, 0x80, 0xC7, 0x0C, 0x08, 0xC0, 0x24,
  0x01, 0x20, 0x07, 0x00, 0xF8, 0x0D, 0xC0, 0xCE, 0x0C, 0x70, 0xC3, 0x8C,
  0x1C, 0xC0, 0xEC, 0x07, 0xC0, 0x2C, 0x01, 0x40, 0x1B, 0x00, 0x88, 0x0C,
  0x20, 0xC0, 0xFC, 0x00, 0x02, 0x1C, 0xEF, 0x18, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x0F,
  0x80, 0x63, 0x82, 0x03, 0x10, 0x04, 0x40, 0x11, 0x00, 0x68, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x7F, 0xFC,
  0x07, 0x80, 0xC3, 0x08, 0x0C, 0xC0, 0x24, 0x01, 0xA0, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x03, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x38, 0x01, 0x40, 0x0A, 0x00, 0x58, 0x04, 0x60, 0x60, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00, 0x88,
  0x03, 0x10, 0x04, 0x20, 0x10, 0x40, 0x60, 0x80, 0x81, 0x02, 0x02, 0x0C,
  0x04, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x3F, 0xF3, 0xFF, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x5F, 0x87, 0x0C, 0x40, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x14, 0x03, 0x60, 0x23, 0x0E, 0x1F, 0x80, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x60,
  0xDF, 0xC5, 0x81, 0x30, 0x0D, 0x80, 0x28, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0x40, 0x1A, 0x00, 0x88, 0x0C, 0x60, 0xC0, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x07, 0x80, 0x61,
  0x83, 0x03, 0x18, 0x06, 0x40, 0x09, 0x00, 0x24, 0x00, 0x98, 0x06, 0x20,
  0x10, 0x61, 0x80, 0xFC, 0x06, 0x0C, 0x20, 0x19, 0x00, 0x24, 0x00, 0xF0,
  0x03, 0x40, 0x0D, 0x00, 0x26, 0x01, 0x8C, 0x0C, 0x1F, 0xE0, 0x0F, 0x80,
  0xC6, 0x08, 0x08, 0xC0, 0x24, 0x01, 0x60, 0x0F, 0x00, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0x50, 0x06, 0xC0, 0x53, 0x06, 0x8F, 0xCC, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x03, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x6C, 0x00, 0x00, 0x00, 0x04, 0x92, 0xD0, 0x00, 0x18, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x10, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x00, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xC0, 0x00, 0x0F, 0x06, 0x39,
  0x81, 0xA0, 0x1C, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x60, 0x01, 0xE0, 0x0E, 0x38, 0x18, 0x0C, 0x30, 0x04, 0x20, 0x02,
  0x43, 0xE2, 0x44, 0x22, 0x84, 0x22, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21,
  0x88, 0x22, 0x88, 0x62, 0x88, 0x42, 0x88, 0xA2, 0x8C, 0xA4, 0xC7, 0x18,
  0x40, 0x00, 0x20, 0x00, 0x38, 0x10, 0x0F, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x60, 0x04, 0x80, 0x12, 0x00, 0xCC, 0x02, 0x10, 0x08, 0x40,
  0x61, 0x81, 0x02, 0x04, 0x08, 0x30, 0x20, 0x80, 0x43, 0xFF, 0x18, 0x04,
  0x40, 0x09, 0x00, 0x2C, 0x00, 0xA0, 0x03, 0x80, 0x04, 0xFC, 0x07, 0xFE,
  0x20, 0x19, 0x00, 0x48, 0x03, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0x80, 0x64,
  0x06, 0x3F, 0xE1, 0x00, 0xC8, 0x03, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80,
  0x14, 0x00, 0xA0, 0x0D, 0x01, 0xCF, 0xF8, 0x00, 0x07, 0x80, 0xC3, 0x08,
  0x0C, 0xC0, 0x34, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x01, 0x40, 0x0A,
  0x00, 0xC8, 0x04, 0x60, 0xC0, 0xFC, 0x00, 0xFC, 0x04, 0x3C, 0x20, 0x31,
  0x00, 0xC8, 0x03, 0x40, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x50, 0x02, 0x80, 0x34, 0x01,
  0x20, 0x11, 0x03, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0x80,
  0xC7, 0x08, 0x0C, 0xC0, 0x34, 0x00, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0x40, 0x0A, 0x00, 0x48, 0x02, 0x30, 0x30, 0xFE, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x7F, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0xFF, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x26, 0x0C, 0x1F, 0x80,
  0x80, 0x1A, 0x00, 0x48, 0x02, 0x20, 0x10, 0x80, 0x82, 0x06, 0x08, 0x30,
  0x21, 0x80, 0x8C, 0x02, 0x60, 0x0B, 0xC0, 0x29, 0x00, 0xC2, 0x02, 0x0C,
  0x08, 0x18, 0x20, 0x20, 0x80, 0x42, 0x01, 0x88, 0x03, 0x20, 0x06, 0x80,
  0x0C, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7F, 0x02, 0xE8, 0x17, 0x41, 0x39, 0x09, 0xC8, 0xCE,
  0x64, 0x71, 0x23, 0x8A, 0x1C, 0x70, 0xE1, 0x87, 0x08, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x80, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1D, 0x00, 0xE8, 0x07, 0x20, 0x39, 0x81, 0xC4, 0x0E, 0x30,
  0x70, 0x83, 0x82, 0x1C, 0x10, 0xE0, 0x47, 0x03, 0x38, 0x09, 0xC0, 0x6E,
  0x01, 0x70, 0x0F, 0x80, 0x3C, 0x00, 0x80, 0x0F, 0x80, 0x63, 0x82, 0x02,
  0x18, 0x04, 0x40, 0x1B, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xB0, 0x02, 0x40,
  0x19, 0x00, 0x42, 0x03, 0x0C, 0x18, 0x0F, 0xC0, 0xFE, 0x04, 0x0E, 0x20,
  0x0D, 0x00, 0x28, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xA0, 0x09, 0xFF, 0x88, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x63, 0x82, 0x03,
  0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x02, 0xC0,
  0x09, 0x00, 0x66, 0x01, 0x0C, 0x18, 0x0F, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x08, 0xFC, 0x04, 0x1E, 0x20, 0x19, 0x00, 0x48, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x34, 0x01, 0x20, 0x11, 0xFF, 0x08, 0x10,
  0x40, 0xC2, 0x02, 0x10, 0x08, 0x80, 0x64, 0x01, 0x20, 0x0D, 0x00, 0x28,
  0x01, 0x80, 0x07, 0x80, 0x61, 0x82, 0x01, 0x10, 0x06, 0x40, 0x09, 0x00,
  0x24, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xA0, 0x03, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x8C,
  0x0C, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00,
  0x88, 0x0C, 0x60, 0xC0, 0xFC, 0x00, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x13,
  0x00, 0x22, 0x00, 0xC4, 0x01, 0x0C, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x30,
  0x20, 0x20, 0xC0, 0x41, 0x00, 0xC2, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20,
  0x02, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x81, 0x83,
  0xC1, 0x82, 0x41, 0x82, 0x41, 0x82, 0x41, 0x82, 0x43, 0xC2, 0x42, 0x42,
  0x62, 0x46, 0x62, 0x44, 0x22, 0x44, 0x26, 0x64, 0x24, 0x24, 0x24, 0x24,
  0x24, 0x24, 0x34, 0x2C, 0x1C, 0x28, 0x18, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x80, 0x0D, 0x00, 0x26, 0x01, 0x88, 0x04, 0x30,
  0x20, 0x41, 0x80, 0x84, 0x03, 0x30, 0x04, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x04, 0x80, 0x33, 0x00, 0x84, 0x04, 0x18, 0x30, 0x20, 0x80, 0x46,
  0x01, 0x90, 0x02, 0x80, 0x0C, 0xC0, 0x06, 0x80, 0x09, 0x80, 0x31, 0x00,
  0x43, 0x01, 0x82, 0x02, 0x06, 0x0C, 0x04, 0x10, 0x0C, 0x60, 0x08, 0x80,
  0x1B, 0x00, 0x14, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xFF, 0xF7, 0xFF,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x0C, 0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xF0, 0x08, 0x03, 0x01,
  0xC0, 0x58, 0x12, 0x08, 0x82, 0x31, 0x04, 0x41, 0xB0, 0x28, 0x0A, 0x01,
  0xFF, 0xF0, 0xC4, 0x30, 0x03, 0x00, 0xFF, 0x08, 0x0C, 0xC0, 0x24, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0xFF, 0x3C, 0x1B, 0x00, 0xD0, 0x06, 0x80, 0x3C,
  0x01, 0xA0, 0x1D, 0x81, 0x67, 0xF3, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x86, 0x09, 0xF8, 0xA0, 0x4C, 0x02, 0x80, 0x28, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x2C, 0x06,
  0xA0, 0xC9, 0xF8, 0x03, 0x00, 0xFF, 0x0C, 0x0C, 0x40, 0x24, 0x01, 0xA0,
  0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x16, 0x01,
  0x90, 0x08, 0x40, 0x81, 0xF8, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x07, 0x11, 0xFD, 0x30, 0x76, 0x03, 0x40, 0x14, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x12, 0x03, 0x30,
  0x70, 0xF9, 0x03, 0x00, 0xFF, 0x0C, 0x0C, 0x40, 0x24, 0x01, 0xA0, 0x07,
  0x00, 0x3F, 0xFF, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x04, 0x60, 0xC1, 0xFC, 0x01, 0xF8, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x1F, 0xFC, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x03, 0x01, 0xFD, 0x30, 0x76, 0x03, 0x40, 0x14,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x12,
  0x03, 0x30, 0x70, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x16, 0x02, 0x30, 0x60,
  0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x82, 0x09,
  0xFC, 0xA0, 0x6C, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x02, 0x00,
  0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x01, 0x01, 0xC0, 0x40, 0x00, 0x00,
  0x01, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x03, 0x3F,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x58, 0x0C, 0xC0, 0xC6, 0x0C, 0x30, 0xC1, 0x8C, 0x0C, 0xC0, 0x6C, 0x03,
  0xB0, 0x18, 0xC0, 0xC3, 0x06, 0x0C, 0x30, 0x21, 0x80, 0x8C, 0x02, 0x60,
  0x1C, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x0C, 0x11,
  0x7E, 0xFB, 0x06, 0x0E, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x02, 0x09, 0xFC, 0xA0, 0x6C, 0x02, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x07, 0x00, 0xFE, 0x0C, 0x08, 0xC0, 0x24, 0x01,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x14,
  0x01, 0xB0, 0x18, 0xC1, 0x81, 0xF8, 0x06, 0x09, 0xF8, 0xE0, 0x4C, 0x02,
  0x80, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x2C, 0x06, 0xA0, 0xC9, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x07, 0x01, 0xFD, 0x30, 0x76, 0x03, 0x40, 0x14, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x12, 0x03,
  0x30, 0x70, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x01, 0xB3, 0xFD, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x06, 0x03, 0xFC, 0x60,
  0x6C, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x03, 0x60, 0x63, 0xFC, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0xFF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x03,
  0xF0, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x40, 0x76, 0x0F, 0x3F, 0x30,
  0x80, 0x0F, 0x00, 0x24, 0x01, 0x98, 0x04, 0x20, 0x30, 0x80, 0x83, 0x02,
  0x04, 0x10, 0x18, 0x40, 0x23, 0x00, 0x88, 0x01, 0x60, 0x05, 0x00, 0x1C,
  0x00, 0x20, 0x00, 0x81, 0x83, 0xC1, 0x82, 0x41, 0x82, 0x42, 0x82, 0x42,
  0xC6, 0x42, 0x44, 0x22, 0x44, 0x24, 0x44, 0x24, 0x64, 0x24, 0x28, 0x34,
  0x28, 0x18, 0x28, 0x18, 0x28, 0x18, 0x18, 0x18, 0x10, 0xC0, 0x18, 0x80,
  0x43, 0x02, 0x06, 0x10, 0x0C, 0xC0, 0x16, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x80, 0x32, 0x00, 0x84, 0x04, 0x18, 0x20, 0x31, 0x80, 0x6C, 0x00, 0xC0,
  0xC0, 0x06, 0x80, 0x09, 0x80, 0x11, 0x00, 0x63, 0x00, 0x82, 0x03, 0x06,
  0x04, 0x04, 0x18, 0x0C, 0x20, 0x08, 0xC0, 0x19, 0x00, 0x12, 0x00, 0x28,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x81, 0x81, 0x81, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x01, 0x83, 0x00,
  0xC0, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x60, 0x18, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x70, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x30,
  0x06, 0x06, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x0C, 0x0C, 0x08, 0x00, 0x3C, 0x02, 0x8E, 0x06, 0x06, 0x0C, 0x06,
  0x20, 0x03, 0x80,
};

const GFXglyph RobotoMono_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 21, 17, 7, -21 },
  { 9, 5, 6, 17, 6, -22 },
  { 13, 16, 21, 17, 1, -21 },
  { 55, 12, 27, 17, 3, -24 },
  { 96, 16, 21, 17, 1, -21 },
  { 138, 15, 21, 17, 2, -21 },
  { 178, 2, 6, 17, 7, -22 },
  { 180, 6, 30, 17, 6, -23 },
  { 203, 6, 30, 17, 5, -23 },
  { 226, 12, 12, 17, 3, -21 },
  { 244, 14, 15, 17, 2, -17 },
  { 271, 2, 6, 17, 6, -2 },
  { 273, 11, 1, 17, 3, -10 },
  { 275, 2, 2, 17, 8, -2 },
  { 276, 10, 23, 17, 4, -21 },
  { 305, 13, 21, 17, 2, -21 },
  { 340, 7, 21, 17, 3, -21 },
  { 359, 14, 21, 17, 1, -21 },
  { 396, 13, 21, 17, 1, -21 },
  { 431, 15, 21, 17, 1, -21 },
  { 471, 12, 21, 17, 3, -21 },
  { 503, 13, 21, 17, 2, -21 },
  { 538, 13, 21, 17, 2, -21 },
  { 573, 14, 21, 17, 2, -21 },
  { 610, 13, 21, 17, 2, -21 },
  { 645, 2, 14, 17, 9, -14 },
  { 649, 3, 18, 17, 8, -14 },
  { 656, 13, 12, 17, 2, -15 },
  { 676, 13, 7, 17, 2, -13 },
  { 688, 12, 11, 17, 3, -15 },
  { 705, 11, 21, 17, 3, -21 },
  { 734, 16, 21, 17, 1, -21 },
  { 776, 14, 21, 17, 2, -21 },
  { 813, 13, 21, 17, 3, -21 },
  { 848, 13, 21, 17, 2, -21 },
  { 883, 13, 21, 17, 3, -21 },
  { 918, 12, 21, 17, 3, -21 },
  { 950, 12, 21, 17, 3, -21 },
  { 982, 13, 21, 17, 2, -21 },
  { 1017, 13, 21, 17, 2, -21 },
  { 1052, 12, 21, 17, 3, -21 },
  { 1084, 12, 21, 17, 2, -21 },
  { 1116, 14, 21, 17, 3, -21 },
  { 1153, 12, 21, 17, 3, -21 },
  { 1185, 13, 21, 17, 2, -21 },
  { 1220, 13, 21, 17, 2, -21 },
  { 1255, 14, 21, 17, 2, -21 },
  { 1292, 13, 21, 17, 3, -21 },
  { 1327, 14, 25, 17, 2, -21 },
  { 1371, 13, 21, 17, 3, -21 },
  { 1406, 14, 21, 17, 2, -21 },
  { 1443, 15, 21, 17, 1, -21 },
  { 1483, 13, 21, 17, 2, -21 },
  { 1518, 15, 21, 17, 1, -21 },
  { 1558, 16, 21, 17, 1, -21 },
  { 1600, 14, 21, 17, 2, -21 },
  { 1637, 15, 21, 17, 1, -21 },
  { 1677, 13, 21, 17, 2, -21 },
  { 1712, 4, 28, 17, 7, -24 },
  { 1726, 10, 23, 17, 4, -21 },
  { 1755, 5, 28, 17, 6, -24 },
  { 1773, 10, 12, 17, 4, -21 },
  { 1788, 12, 1, 17, 3, 0 },
  { 1790, 4, 3, 17, 7, -21 },
  { 1792, 13, 16, 17, 2, -16 },
  { 1818, 12, 22, 17, 3, -22 },
  { 1851, 13, 16, 17, 2, -16 },
  { 1877, 12, 22, 17, 2, -22 },
  { 1910, 13, 16, 17, 2, -16 },
  { 1936, 13, 22, 17, 3, -22 },
  { 1972, 12, 22, 17, 2, -16 },
  { 2005, 12, 22, 17, 3, -22 },
  { 2038, 12, 21, 17, 3, -21 },
  { 2070, 9, 27, 17, 3, -21 },
  { 2101, 13, 22, 17, 3, -22 },
  { 2137, 12, 22, 17, 3, -22 },
  { 2170, 15, 16, 17, 1, -16 },
  { 2200, 12, 16, 17, 3, -16 },
  { 2224, 13, 16, 17, 2, -16 },
  { 2250, 12, 22, 17, 3, -16 },
  { 2283, 12, 22, 17, 2, -16 },
  { 2316, 10, 16, 17, 5, -16 },
  { 2336, 12, 16, 17, 3, -16 },
  { 2360, 12, 19, 17, 3, -19 },
  { 2389, 12, 15, 17, 3, -15 },
  { 2412, 14, 15, 17, 2, -15 },
  { 2439, 16, 15, 17, 1, -15 },
  { 2469, 14, 15, 17, 2, -15 },
  { 2496, 15, 21, 17, 1, -15 },
  { 2536, 14, 15, 17, 2, -15 },
  { 2563, 9, 29, 17, 5, -23 },
  { 2596, 1, 25, 17, 8, -21 },
  { 2600, 9, 29, 17, 5, -23 },
  { 2633, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight29pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_EXTRALIGHT29PT7B_H_
