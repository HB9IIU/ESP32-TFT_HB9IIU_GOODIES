#ifndef _ROBOTOMONO_EXTRALIGHT58PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x07,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x03, 0xC0,
  0xF8, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0xE0, 0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00,
  0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x0C, 0x0C, 0x00, 0x60, 0x0C, 0x0C, 0x00,
  0x60, 0x18, 0x18, 0x00, 0x70, 0x18, 0x38, 0x00, 0x38, 0x70, 0x30, 0x00,
  0x1F, 0xE0, 0x70, 0x00, 0x0F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0xF8, 0x00, 0x06, 0x07, 0xFC,
  0x00, 0x0E, 0x0E, 0x0E, 0x00, 0x0C, 0x0C, 0x06, 0x00, 0x1C, 0x18, 0x03,
  0x00, 0x18, 0x18, 0x03, 0x00, 0x38, 0x18, 0x03, 0x00, 0x30, 0x38, 0x03,
  0x00, 0x60, 0x38, 0x03, 0x00, 0x60, 0x38, 0x03, 0x00, 0xC0, 0x38, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x18, 0x03, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x31, 0xC0, 0x38, 0x01, 0x8E, 0x00, 0xE0, 0x1C, 0xE0, 0x03,
  0x80, 0xE6, 0x00, 0x0E, 0x07, 0x30, 0x00, 0x70, 0x33, 0x80, 0x01, 0xC3,
  0x9C, 0x00, 0x07, 0x1C, 0xE0, 0x00, 0x1C, 0xC7, 0x00, 0x00, 0x7E, 0x18,
  0x00, 0x03, 0xE0, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0xF3, 0x83, 0xE0, 0x1F, 0x1C, 0x07, 0xFF, 0xE0,
  0x70, 0x1F, 0xFC, 0x01, 0xC0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x08, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x00, 0x30,
  0x02, 0xF0, 0x18, 0x0F, 0xFF, 0x0C, 0x1F, 0xC7, 0xF6, 0x7F, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x08, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x67, 0x39, 0x9D, 0xC4,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0xFC,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x9C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF8,
  0x3F, 0x71, 0xF8, 0xEF, 0x81, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x3C, 0x01, 0xE0,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x61,
  0xFF, 0x00, 0x37, 0xFF, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0x00, 0x3E, 0x07,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0D, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xF0, 0x03, 0xE0, 0x3F,
  0x07, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0xFF, 0x00, 0x61, 0xFF, 0xF0, 0x18, 0xF8, 0x3E, 0x06, 0x70,
  0x03, 0xC1, 0xB0, 0x00, 0x38, 0xF8, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x03, 0xC0,
  0x0F, 0x87, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x07,
  0x80, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x7C, 0x70, 0x00, 0x37,
  0x0E, 0x00, 0x1D, 0xC1, 0xE0, 0x1E, 0x70, 0x3F, 0xFE, 0x18, 0x07, 0xFF,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x0C, 0x71, 0x8E, 0x30, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xFC, 0x0F, 0x00, 0x78, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18,
  0x30, 0x03, 0xE0, 0x18, 0xE0, 0x1F, 0xE0, 0x31, 0x80, 0x70, 0xE0, 0x63,
  0x01, 0xC0, 0xC0, 0x6C, 0x07, 0x01, 0x80, 0xD8, 0x0C, 0x03, 0x01, 0xB0,
  0x30, 0x06, 0x03, 0xC0, 0x60, 0x0C, 0x07, 0x80, 0xC0, 0x18, 0x0F, 0x03,
  0x00, 0x30, 0x1E, 0x06, 0x00, 0x60, 0x3C, 0x0C, 0x00, 0x80, 0x78, 0x18,
  0x01, 0x00, 0xF0, 0x30, 0x06, 0x01, 0xE0, 0x60, 0x0C, 0x03, 0xC0, 0xC0,
  0x18, 0x07, 0x81, 0x80, 0x30, 0x0B, 0x03, 0x00, 0xE0, 0x36, 0x06, 0x01,
  0xC0, 0x6C, 0x0C, 0x07, 0x80, 0xD8, 0x18, 0x0F, 0x03, 0x30, 0x18, 0x33,
  0x06, 0x30, 0x39, 0xC7, 0x38, 0x60, 0x3F, 0x07, 0xE0, 0xC0, 0x38, 0x07,
  0x80, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x03,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x18, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0xFC, 0x18, 0x00,
  0x0F, 0x0C, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x38, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x78, 0x30, 0x01, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x06, 0x00, 0x07, 0xC3, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xD8, 0x00, 0x01, 0xEC, 0x00, 0x01, 0xE6, 0x00, 0x01, 0xE3,
  0x00, 0x07, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0x80, 0x0F, 0x80, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x01, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03,
  0xC0, 0x1F, 0x00, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x78,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x73, 0xF0, 0x00, 0x0E, 0xF7,
  0x00, 0x01, 0xDC, 0xE0, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFD, 0x80, 0x00, 0xFE,
  0xC0, 0x00, 0x6F, 0x70, 0x00, 0x77, 0x98, 0x00, 0x33, 0xCE, 0x00, 0x19,
  0xE3, 0x00, 0x1C, 0xF1, 0x80, 0x0C, 0x78, 0xE0, 0x0E, 0x3C, 0x30, 0x06,
  0x1E, 0x18, 0x03, 0x0F, 0x0E, 0x03, 0x87, 0x83, 0x01, 0x83, 0xC1, 0xC1,
  0xC1, 0xE0, 0xE0, 0xC0, 0xF0, 0x30, 0x60, 0x78, 0x1C, 0x70, 0x3C, 0x06,
  0x30, 0x1E, 0x03, 0x18, 0x0F, 0x01, 0xDC, 0x07, 0x80, 0x6C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xF0, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0x0E, 0x00,
  0x0F, 0x03, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x18,
  0x00, 0xF0, 0x0E, 0x00, 0x78, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0x60, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x0C, 0x03, 0xC0, 0x07, 0x01, 0xE0,
  0x01, 0xC0, 0xF0, 0x00, 0x60, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0C, 0x1E,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0x87, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x31,
  0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xBC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00,
  0x07, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x07, 0x80, 0x01, 0xC0,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0E, 0x00,
  0x1F, 0x03, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x38, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xE0,
  0x3C, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x18, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80,
  0x1F, 0x80, 0x1E, 0x00, 0x66, 0x00, 0x78, 0x01, 0x98, 0x03, 0xF0, 0x06,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x67, 0x00, 0xCC, 0x03, 0x9C,
  0x03, 0x30, 0x0E, 0x70, 0x1C, 0xE0, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01,
  0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xE0, 0xE1,
  0xC1, 0xC3, 0x83, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0xC1, 0x81, 0x87, 0x03, 0x06, 0x06, 0x1C, 0x0E, 0x18,
  0x1C, 0x60, 0x18, 0xE0, 0x71, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03,
  0x38, 0x06, 0x30, 0x0C, 0xE0, 0x1C, 0xC0, 0x33, 0x00, 0x33, 0x00, 0xCC,
  0x00, 0xDC, 0x03, 0xB0, 0x03, 0x70, 0x0E, 0xC0, 0x0D, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0xFF,
  0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xB0,
  0x00, 0x1D, 0x80, 0x00, 0xCE, 0x00, 0x06, 0x30, 0x00, 0x71, 0xC0, 0x03,
  0x06, 0x00, 0x38, 0x30, 0x01, 0x81, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x38,
  0x06, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC1, 0xC0,
  0x07, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xE6, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x07, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x03, 0x1E, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0x9C, 0x00, 0x06, 0xCF, 0x00, 0x0E, 0x63, 0xC0, 0x1E, 0x38, 0xFF, 0xFE,
  0x1C, 0x1F, 0xFC, 0x0E, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF,
  0x00, 0xC3, 0xFF, 0xC0, 0xC7, 0x81, 0xE0, 0xCE, 0x00, 0x70, 0xD8, 0x00,
  0x38, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0C, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x38, 0xDC, 0x00, 0x78, 0xCF, 0x00,
  0xF0, 0xC7, 0xFF, 0xE0, 0xC1, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x07, 0x81, 0xC0,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x06, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x03, 0x81, 0xC0,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x07, 0x03, 0xFF, 0xC7, 0x0F,
  0x81, 0xE7, 0x1E, 0x00, 0x77, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x30,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x1C,
  0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x0F, 0x00, 0xF7, 0x07, 0xFF, 0xE7, 0x01,
  0xFF, 0x87, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x1E,
  0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x04, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0x07, 0x03, 0xFF, 0xC7, 0x07, 0x81, 0xE7, 0x0E, 0x00, 0x77,
  0x1C, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x1E, 0x00, 0x3F,
  0x0F, 0x00, 0xF7, 0x07, 0xFF, 0xE7, 0x01, 0xFF, 0x87, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x0F, 0x01, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x7F, 0x80, 0xC1, 0xFF, 0xE0, 0xC3, 0xC0, 0xF8, 0xC7, 0x00, 0x38,
  0xCC, 0x00, 0x1C, 0xD8, 0x00, 0x0C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0xC0,
  0x00, 0x3C, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0,
  0x03, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x3C, 0x00, 0xC0,
  0x78, 0x00, 0xC0, 0xF0, 0x00, 0xC1, 0xE0, 0x00, 0xC3, 0xC0, 0x00, 0xC7,
  0x80, 0x00, 0xCF, 0xC0, 0x00, 0xDD, 0xC0, 0x00, 0xF8, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x07, 0x80, 0xC0, 0x03, 0xC0, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xE3, 0x9F, 0xF8, 0xFF,
  0xCE, 0xE0, 0xE7, 0x07, 0xBE, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x1F,
  0xC0, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0,
  0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38,
  0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F,
  0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0,
  0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38,
  0x00, 0xC0, 0xC0, 0x7F, 0x81, 0x83, 0xFF, 0xC3, 0x0F, 0x03, 0xC6, 0x38,
  0x01, 0xCC, 0xC0, 0x01, 0xDB, 0x00, 0x01, 0xBC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xC0, 0xFF, 0x00, 0xC3,
  0xFF, 0xC0, 0xCF, 0x83, 0xE0, 0xDC, 0x00, 0x70, 0xD8, 0x00, 0x38, 0xF0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x38, 0xDC, 0x00, 0x78, 0xCE, 0x00, 0xF0, 0xC7,
  0xFF, 0xC0, 0xC1, 0xFF, 0x80, 0xC0, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x07, 0x03, 0xFF, 0xC7, 0x0F,
  0x81, 0xE7, 0x1E, 0x00, 0x77, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x30,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x1C,
  0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x0F, 0x00, 0xF7, 0x07, 0xFF, 0xE7, 0x01,
  0xFF, 0x87, 0x00, 0x30, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xC0, 0xE3, 0x80, 0x0C,
  0xE0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xD9, 0xC0, 0x03,
  0xB1, 0xE0, 0x1E, 0x61, 0xFF, 0xF0, 0xC1, 0xFF, 0xC1, 0x80, 0x10, 0x00,
  0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x07, 0x00,
  0x0F, 0x80, 0x0E, 0x00, 0x3B, 0x00, 0x1C, 0x00, 0x76, 0x00, 0x3C, 0x00,
  0xCC, 0x00, 0xD8, 0x01, 0x9C, 0x01, 0xB0, 0x03, 0x18, 0x03, 0x60, 0x0E,
  0x30, 0x06, 0xE0, 0x18, 0x60, 0x1C, 0xC0, 0x30, 0xE0, 0x31, 0x80, 0x61,
  0xC0, 0x63, 0x01, 0xC1, 0x80, 0xC7, 0x03, 0x83, 0x03, 0x06, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0E, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x38, 0x70, 0x18,
  0x60, 0x30, 0xC0, 0x30, 0xC0, 0x61, 0x80, 0x71, 0x80, 0xC3, 0x00, 0x63,
  0x00, 0xC6, 0x00, 0xCC, 0x01, 0x98, 0x01, 0x98, 0x03, 0x30, 0x03, 0x30,
  0x06, 0x60, 0x07, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0xF0, 0xF0, 0x00,
  0x1B, 0x80, 0x78, 0x00, 0x76, 0x00, 0x78, 0x00, 0xDC, 0x00, 0x78, 0x03,
  0xB0, 0x00, 0x3C, 0x0E, 0x60, 0x00, 0x3F, 0xF8, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoMono_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 4, 41, 35, 15, -41 },
  { 22, 10, 13, 35, 12, -44 },
  { 39, 31, 41, 35, 2, -41 },
  { 198, 25, 53, 35, 5, -47 },
  { 364, 32, 43, 35, 1, -42 },
  { 536, 29, 43, 35, 4, -42 },
  { 692, 2, 13, 35, 15, -44 },
  { 696, 13, 59, 35, 11, -46 },
  { 792, 13, 59, 35, 10, -46 },
  { 888, 25, 24, 35, 6, -41 },
  { 963, 29, 30, 35, 3, -34 },
  { 1072, 5, 13, 35, 11, -5 },
  { 1081, 21, 2, 35, 7, -20 },
  { 1087, 5, 4, 35, 16, -4 },
  { 1090, 20, 45, 35, 8, -41 },
  { 1203, 25, 43, 35, 5, -42 },
  { 1338, 15, 41, 35, 6, -41 },
  { 1415, 26, 42, 35, 3, -42 },
  { 1552, 26, 43, 35, 3, -42 },
  { 1692, 28, 41, 35, 3, -41 },
  { 1836, 25, 42, 35, 6, -41 },
  { 1968, 26, 43, 35, 4, -42 },
  { 2108, 26, 41, 35, 4, -41 },
  { 2242, 26, 43, 35, 5, -42 },
  { 2382, 26, 42, 35, 4, -42 },
  { 2519, 4, 29, 35, 18, -29 },
  { 2534, 6, 37, 35, 16, -29 },
  { 2562, 24, 24, 35, 5, -31 },
  { 2634, 25, 14, 35, 5, -26 },
  { 2678, 25, 24, 35, 5, -31 },
  { 2753, 22, 42, 35, 7, -42 },
  { 2869, 31, 42, 35, 2, -42 },
  { 3032, 29, 41, 35, 3, -41 },
  { 3181, 25, 41, 35, 6, -41 },
  { 3310, 27, 43, 35, 4, -42 },
  { 3456, 27, 41, 35, 5, -41 },
  { 3595, 24, 41, 35, 6, -41 },
  { 3718, 24, 41, 35, 6, -41 },
  { 3841, 27, 43, 35, 4, -42 },
  { 3987, 25, 41, 35, 5, -41 },
  { 4116, 23, 41, 35, 6, -41 },
  { 4234, 26, 42, 35, 3, -41 },
  { 4371, 27, 41, 35, 6, -41 },
  { 4510, 23, 41, 35, 7, -41 },
  { 4628, 25, 41, 35, 5, -41 },
  { 4757, 25, 41, 35, 5, -41 },
  { 4886, 27, 43, 35, 4, -42 },
  { 5032, 26, 41, 35, 6, -41 },
  { 5166, 29, 49, 35, 3, -42 },
  { 5344, 26, 41, 35, 6, -41 },
  { 5478, 27, 43, 35, 4, -42 },
  { 5624, 29, 41, 35, 3, -41 },
  { 5773, 25, 42, 35, 5, -41 },
  { 5905, 29, 41, 35, 3, -41 },
  { 6054, 30, 41, 35, 3, -41 },
  { 6208, 29, 41, 35, 3, -41 },
  { 6357, 30, 41, 35, 2, -41 },
  { 6511, 26, 41, 35, 4, -41 },
  { 6645, 9, 56, 35, 13, -47 },
  { 6708, 19, 45, 35, 8, -41 },
  { 6815, 9, 56, 35, 13, -47 },
  { 6878, 21, 22, 35, 7, -41 },
  { 6936, 25, 2, 35, 5, 0 },
  { 6943, 8, 8, 35, 13, -43 },
  { 6951, 25, 32, 35, 5, -31 },
  { 7051, 24, 45, 35, 6, -44 },
  { 7186, 25, 32, 35, 5, -31 },
  { 7286, 24, 45, 35, 5, -44 },
  { 7421, 26, 32, 35, 4, -31 },
  { 7525, 26, 44, 35, 6, -44 },
  { 7668, 24, 43, 35, 5, -31 },
  { 7797, 24, 44, 35, 6, -44 },
  { 7929, 24, 42, 35, 7, -42 },
  { 8055, 18, 54, 35, 5, -42 },
  { 8177, 24, 44, 35, 7, -44 },
  { 8309, 24, 44, 35, 7, -44 },
  { 8441, 30, 31, 35, 2, -31 },
  { 8558, 23, 31, 35, 6, -31 },
  { 8648, 27, 32, 35, 4, -31 },
  { 8756, 24, 43, 35, 6, -31 },
  { 8885, 24, 43, 35, 5, -31 },
  { 9014, 19, 31, 35, 11, -31 },
  { 9088, 24, 32, 35, 6, -31 },
  { 9184, 24, 40, 35, 5, -39 },
  { 9304, 23, 32, 35, 6, -31 },
  { 9396, 29, 31, 35, 3, -31 },
  { 9509, 31, 31, 35, 2, -31 },
  { 9630, 28, 31, 35, 4, -31 },
  { 9739, 30, 43, 35, 2, -31 },
  { 9901, 27, 31, 35, 4, -31 },
  { 10006, 19, 57, 35, 9, -45 },
  { 10142, 3, 50, 35, 16, -41 },
  { 10161, 19, 57, 35, 9, -45 },
  { 10297, 31, 10, 35, 2, -22 },
};

const GFXfont RobotoMono_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight58pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_EXTRALIGHT58PT7B_H_
