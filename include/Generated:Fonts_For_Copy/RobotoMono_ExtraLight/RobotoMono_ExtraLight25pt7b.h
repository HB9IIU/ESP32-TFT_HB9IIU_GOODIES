#ifndef _ROBOTOMONO_EXTRALIGHT25PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight25pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x40, 0x70, 0x8C, 0x63, 0x18, 0xC4, 0x04, 0x20,
  0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x3F, 0xFC, 0x21, 0x01, 0x08, 0x08,
  0x40, 0x42, 0x04, 0x20, 0x21, 0x0F, 0xFF, 0x08, 0x40, 0x42, 0x04, 0x10,
  0x21, 0x01, 0x08, 0x00, 0x04, 0x00, 0x80, 0x7C, 0x18, 0x66, 0x04, 0x80,
  0x50, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x28, 0x04, 0x81, 0x0F, 0xC0, 0x20, 0x04, 0x00, 0x80,
  0x70, 0x04, 0x40, 0x22, 0x19, 0x08, 0x88, 0x44, 0x44, 0x42, 0x24, 0x0E,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x1C, 0x09, 0x10, 0x88, 0x84, 0x84, 0x44,
  0x26, 0x21, 0x00, 0x88, 0x03, 0x80, 0x1E, 0x03, 0x10, 0x21, 0x06, 0x10,
  0x61, 0x02, 0x30, 0x26, 0x01, 0xC0, 0x18, 0x02, 0xC0, 0x44, 0x1C, 0x21,
  0x81, 0x38, 0x1A, 0x80, 0xE8, 0x04, 0x40, 0xA3, 0xF1, 0x5A, 0xA0, 0x08,
  0x44, 0x42, 0x21, 0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x30, 0x84,
  0x10, 0x82, 0x08, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x08, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x08, 0x42, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x42, 0x1F, 0x4E, 0x1E, 0x01, 0x80, 0x48, 0x11,
  0x86, 0x18, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03,
  0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x55, 0x80, 0xFF, 0x80, 0xF0, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x03, 0x00, 0xE0, 0x2C, 0x09,
  0x82, 0x30, 0x86, 0x20, 0xC8, 0x1E, 0x03, 0x80, 0x50, 0x12, 0x02, 0x20,
  0x83, 0xE0, 0x04, 0x7E, 0x61, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x1F, 0x02, 0x08, 0x40, 0x44, 0x06, 0xC0, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x07, 0xFF, 0x1F, 0x06, 0x19, 0x01, 0x20,
  0x14, 0x02, 0x00, 0x40, 0x18, 0x02, 0x0F, 0x80, 0x70, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x70, 0x0A, 0x01, 0x20, 0x43, 0xF0, 0x00, 0xC0, 0x06, 0x00,
  0x50, 0x04, 0x80, 0x24, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10, 0x41, 0x02,
  0x08, 0x10, 0x80, 0x8F, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x7F, 0xD0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0xFC,
  0xC1, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x07, 0x03, 0x61, 0x8F,
  0xC0, 0x07, 0x83, 0x80, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x23, 0x85, 0x9C,
  0xC0, 0xD0, 0x0A, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x12, 0x02, 0x20,
  0x83, 0xE0, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x1F, 0x06, 0x19, 0x01, 0x20, 0x14, 0x02, 0x80, 0x50,
  0x19, 0x02, 0x1F, 0x87, 0x31, 0x81, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0A,
  0x01, 0x60, 0x43, 0xF0, 0x1F, 0x04, 0x31, 0x01, 0x60, 0x28, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x28, 0x0D, 0x82, 0x8F, 0x90, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x03, 0x07, 0x80, 0xB0, 0x00, 0x02, 0xC0, 0x4C, 0x00, 0x00,
  0x00, 0x24, 0xB4, 0x00, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0xC0,
  0xE0, 0x70, 0x10, 0x00, 0x3E, 0x30, 0xB0, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x03, 0x03, 0x03, 0x01, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0xC0, 0x14, 0x78, 0xC4, 0x26, 0x22,
  0x32, 0x11, 0x90, 0x8C, 0x84, 0x64, 0x23, 0x21, 0x19, 0x18, 0xC5, 0x6A,
  0x10, 0x88, 0x00, 0x20, 0x40, 0xFC, 0x00, 0x02, 0x00, 0x18, 0x01, 0x40,
  0x0A, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x08, 0x18, 0x40, 0x82, 0x04,
  0x18, 0x60, 0x43, 0xFE, 0x10, 0x18, 0x80, 0x48, 0x02, 0x40, 0x1E, 0x00,
  0x40, 0xFC, 0x20, 0xC8, 0x0A, 0x03, 0x80, 0x60, 0x38, 0x0A, 0x06, 0xFE,
  0x20, 0xC8, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x81, 0xBF, 0x80,
  0x1F, 0x04, 0x11, 0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x70, 0x0A, 0x02, 0x20, 0xC3,
  0xE0, 0xFC, 0x08, 0x38, 0x80, 0xC8, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x02, 0x80, 0x48,
  0x0C, 0x81, 0x8F, 0xE0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x1F, 0x06, 0x19, 0x01, 0x60, 0x18, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0A, 0x01,
  0x20, 0x63, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x1F, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x80,
  0x50, 0x0A, 0x03, 0x20, 0xC3, 0xF0, 0x80, 0x70, 0x1A, 0x06, 0x40, 0x88,
  0x21, 0x08, 0x22, 0x04, 0x80, 0xB0, 0x1D, 0x03, 0x30, 0x42, 0x08, 0x21,
  0x02, 0x20, 0x64, 0x04, 0x80, 0x50, 0x04, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xC0, 0x38, 0x0F, 0x01, 0xD0, 0x5A,
  0x0B, 0x61, 0x64, 0x4C, 0x89, 0x8A, 0x31, 0x46, 0x28, 0xC2, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x80, 0x38, 0x07, 0x00, 0xD0,
  0x1B, 0x03, 0x20, 0x66, 0x0C, 0x41, 0x84, 0x30, 0x86, 0x08, 0xC1, 0x18,
  0x13, 0x03, 0x60, 0x2C, 0x07, 0x80, 0x70, 0x04, 0x1F, 0x04, 0x31, 0x01,
  0x20, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x1A, 0x02, 0x20, 0x83, 0xE0, 0xFE, 0x10, 0x32,
  0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xD0, 0x73, 0xF0,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x0F, 0x80,
  0x82, 0x08, 0x08, 0xC0, 0x24, 0x01, 0x20, 0x0B, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x44, 0x04,
  0x10, 0x60, 0x7E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0xFC, 0x10, 0x62,
  0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x90, 0xE3, 0xF8,
  0x41, 0x08, 0x11, 0x02, 0x20, 0x24, 0x04, 0x80, 0x50, 0x0C, 0x1F, 0x02,
  0x0C, 0x40, 0x6C, 0x02, 0x80, 0x2C, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xC0, 0x02, 0x00, 0x28, 0x03, 0x80, 0x2C, 0x02, 0x60, 0x41,
  0xF8, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x1A, 0x02, 0x20, 0x83, 0xE0, 0x80, 0x1A, 0x00, 0x90,
  0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40, 0x82,
  0x06, 0x20, 0x11, 0x00, 0x88, 0x06, 0x80, 0x14, 0x00, 0xA0, 0x06, 0x00,
  0x10, 0x00, 0x82, 0x0C, 0x10, 0x60, 0xC2, 0x86, 0x14, 0x50, 0xA2, 0x85,
  0x14, 0x48, 0x92, 0x44, 0x93, 0x44, 0x8A, 0x24, 0x51, 0x22, 0x85, 0x14,
  0x30, 0xA1, 0x86, 0x0C, 0x10, 0x60, 0x81, 0x00, 0x40, 0x1B, 0x00, 0x88,
  0x08, 0x20, 0x41, 0x84, 0x04, 0x60, 0x12, 0x00, 0xA0, 0x03, 0x00, 0x18,
  0x01, 0x40, 0x19, 0x00, 0x8C, 0x08, 0x20, 0x40, 0x84, 0x04, 0x60, 0x16,
  0x00, 0xC0, 0x80, 0x1A, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x08, 0x20,
  0x42, 0x01, 0x10, 0x09, 0x00, 0x28, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x1F, 0xFC, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x04, 0x05, 0x02,
  0x82, 0x21, 0x11, 0x8C, 0x82, 0x41, 0x40, 0x40, 0xFF, 0xE0, 0xC8, 0x80,
  0x3F, 0x8C, 0x19, 0x01, 0x40, 0x30, 0x06, 0x0F, 0xCE, 0x1A, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xA0, 0x73, 0xF2, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0B, 0xF3, 0x06, 0x80, 0xA0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xB0, 0x4B, 0xE0, 0x1F, 0x84, 0x19, 0x01, 0x60, 0x18,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x05, 0x01, 0x10, 0x61, 0xF8,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x13, 0xF5, 0x83, 0x40, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0x40, 0x48, 0x31, 0xF4,
  0x1F, 0x84, 0x19, 0x01, 0x60, 0x18, 0x03, 0xFF, 0xE0, 0x04, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x90, 0x21, 0xF8, 0x03, 0xF0, 0x60, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0xFF, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x3F,
  0x58, 0x34, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14,
  0x04, 0x83, 0x1F, 0x40, 0x10, 0x05, 0x01, 0x60, 0x8F, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x37, 0xE7, 0x02, 0xC0, 0x58, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x80, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x06, 0xFC, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x0A, 0x04, 0x86, 0x23, 0x09,
  0x82, 0xC0, 0xD8, 0x23, 0x08, 0x42, 0x08, 0x81, 0x20, 0x28, 0x04, 0xFC,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0xBD,
  0xF6, 0x18, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41,
  0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0x80, 0xDF, 0x94, 0x0B,
  0x01, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x02, 0x3F, 0x8C, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x05, 0x01, 0x30, 0x61, 0xF0, 0xBF, 0x30, 0x68,
  0x0A, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0B, 0x04,
  0xBE, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x3F, 0x58, 0x34, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x14, 0x04, 0x83, 0x1F,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x9F, 0xE0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x8C, 0x09, 0x00,
  0xA0, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x05, 0x00, 0xB0,
  0x23, 0xF8, 0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xFC, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60,
  0x07, 0xE0, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x05, 0x7E, 0x40, 0xC0, 0x1A, 0x00, 0x88, 0x08,
  0x40, 0x43, 0x06, 0x08, 0x20, 0x41, 0x01, 0x10, 0x08, 0x80, 0x68, 0x01,
  0x40, 0x0A, 0x00, 0x20, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x42, 0x8A, 0x14,
  0x51, 0x22, 0x89, 0x22, 0x45, 0x12, 0x28, 0xA1, 0x45, 0x0C, 0x18, 0x60,
  0xC1, 0x04, 0x00, 0xC0, 0x66, 0x04, 0x20, 0x81, 0x10, 0x0B, 0x00, 0xE0,
  0x04, 0x00, 0xA0, 0x19, 0x03, 0x08, 0x20, 0xC4, 0x04, 0x80, 0x30, 0xC0,
  0x1A, 0x00, 0x90, 0x04, 0x40, 0x42, 0x02, 0x08, 0x20, 0x41, 0x01, 0x18,
  0x08, 0x80, 0x6C, 0x01, 0x40, 0x0E, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x0F, 0xFE, 0x01,
  0x02, 0x04, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0xE0,
  0x60, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x04, 0x03,
  0xFF, 0xFF, 0xFC, 0x80, 0x60, 0x30, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x0C, 0x03, 0x06, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x20, 0xC0, 0x10, 0x03, 0xE0, 0x60, 0x83, 0x03, 0x20, 0x06,
  0x00,
};

const GFXglyph RobotoMono_ExtraLight25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 2, 18, 15, 6, -18 },
  { 6, 5, 6, 15, 5, -19 },
  { 10, 13, 18, 15, 1, -18 },
  { 40, 11, 23, 15, 2, -20 },
  { 72, 13, 18, 15, 1, -18 },
  { 102, 12, 18, 15, 2, -18 },
  { 129, 2, 6, 15, 6, -19 },
  { 131, 5, 26, 15, 5, -20 },
  { 148, 6, 26, 15, 4, -20 },
  { 168, 11, 10, 15, 2, -18 },
  { 182, 13, 13, 15, 1, -15 },
  { 204, 2, 5, 15, 5, -2 },
  { 206, 9, 1, 15, 3, -9 },
  { 208, 2, 2, 15, 7, -2 },
  { 209, 8, 20, 15, 4, -18 },
  { 229, 11, 18, 15, 2, -18 },
  { 254, 6, 18, 15, 3, -18 },
  { 268, 12, 18, 15, 1, -18 },
  { 295, 11, 18, 15, 1, -18 },
  { 320, 13, 18, 15, 1, -18 },
  { 350, 10, 18, 15, 3, -18 },
  { 373, 11, 18, 15, 2, -18 },
  { 398, 11, 18, 15, 2, -18 },
  { 423, 11, 18, 15, 2, -18 },
  { 448, 11, 18, 15, 2, -18 },
  { 473, 2, 13, 15, 8, -13 },
  { 477, 3, 16, 15, 7, -13 },
  { 483, 11, 10, 15, 2, -13 },
  { 497, 11, 6, 15, 2, -11 },
  { 506, 11, 10, 15, 2, -13 },
  { 520, 9, 18, 15, 3, -18 },
  { 541, 13, 18, 15, 1, -18 },
  { 571, 13, 18, 15, 1, -18 },
  { 601, 10, 18, 15, 3, -18 },
  { 624, 11, 18, 15, 2, -18 },
  { 649, 12, 18, 15, 2, -18 },
  { 676, 10, 18, 15, 3, -18 },
  { 699, 10, 18, 15, 3, -18 },
  { 722, 11, 18, 15, 2, -18 },
  { 747, 11, 18, 15, 2, -18 },
  { 772, 11, 18, 15, 2, -18 },
  { 797, 11, 18, 15, 1, -18 },
  { 822, 11, 18, 15, 3, -18 },
  { 847, 10, 18, 15, 3, -18 },
  { 870, 11, 18, 15, 2, -18 },
  { 895, 11, 18, 15, 2, -18 },
  { 920, 11, 18, 15, 2, -18 },
  { 945, 11, 18, 15, 3, -18 },
  { 970, 13, 21, 15, 1, -18 },
  { 1005, 11, 18, 15, 3, -18 },
  { 1030, 12, 18, 15, 2, -18 },
  { 1057, 13, 18, 15, 1, -18 },
  { 1087, 11, 18, 15, 2, -18 },
  { 1112, 13, 18, 15, 1, -18 },
  { 1142, 13, 18, 15, 1, -18 },
  { 1172, 13, 18, 15, 1, -18 },
  { 1202, 13, 18, 15, 1, -18 },
  { 1232, 11, 18, 15, 2, -18 },
  { 1257, 4, 24, 15, 6, -20 },
  { 1269, 9, 20, 15, 3, -18 },
  { 1292, 4, 24, 15, 5, -20 },
  { 1304, 9, 10, 15, 3, -18 },
  { 1316, 11, 1, 15, 2, 0 },
  { 1318, 3, 3, 15, 6, -18 },
  { 1320, 11, 13, 15, 2, -13 },
  { 1338, 10, 19, 15, 3, -19 },
  { 1362, 11, 13, 15, 2, -13 },
  { 1380, 10, 19, 15, 2, -19 },
  { 1404, 11, 13, 15, 2, -13 },
  { 1422, 12, 19, 15, 2, -19 },
  { 1451, 10, 18, 15, 2, -13 },
  { 1474, 11, 19, 15, 2, -19 },
  { 1501, 10, 18, 15, 3, -18 },
  { 1524, 8, 23, 15, 2, -18 },
  { 1547, 10, 19, 15, 3, -19 },
  { 1571, 10, 19, 15, 3, -19 },
  { 1595, 13, 13, 15, 1, -13 },
  { 1617, 11, 13, 15, 2, -13 },
  { 1635, 11, 13, 15, 2, -13 },
  { 1653, 10, 18, 15, 3, -13 },
  { 1676, 10, 18, 15, 2, -13 },
  { 1699, 8, 13, 15, 5, -13 },
  { 1712, 11, 13, 15, 2, -13 },
  { 1730, 11, 17, 15, 2, -17 },
  { 1754, 10, 13, 15, 3, -13 },
  { 1771, 13, 13, 15, 1, -13 },
  { 1793, 13, 13, 15, 1, -13 },
  { 1815, 12, 13, 15, 2, -13 },
  { 1835, 13, 18, 15, 1, -13 },
  { 1865, 11, 13, 15, 2, -13 },
  { 1883, 8, 25, 15, 4, -20 },
  { 1908, 1, 22, 15, 7, -18 },
  { 1911, 8, 25, 15, 4, -20 },
  { 1936, 13, 5, 15, 1, -10 },
};

const GFXfont RobotoMono_ExtraLight25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight25pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_EXTRALIGHT25PT7B_H_
