#ifndef _ROBOTOMONO_EXTRALIGHT13PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xFC, 0x12, 0x29, 0xF9, 0x22, 0x44, 0xBE, 0x94, 0x48,
  0x10, 0xC4, 0xA1, 0x81, 0x03, 0x81, 0x86, 0x16, 0x84, 0xE0, 0x94, 0x98,
  0x68, 0x10, 0x16, 0x29, 0x29, 0x06, 0x71, 0x25, 0x18, 0x62, 0x58, 0xE1,
  0x7C, 0xE0, 0x29, 0x29, 0x24, 0x89, 0x12, 0xC8, 0x92, 0x49, 0x24, 0xA8,
  0x12, 0x57, 0x8C, 0x48, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xE0, 0xF0,
  0x80, 0x11, 0x22, 0x24, 0x44, 0x88, 0x7A, 0x18, 0xE5, 0xA7, 0x18, 0x61,
  0x78, 0x79, 0x11, 0x11, 0x11, 0x10, 0xFA, 0x20, 0x82, 0x10, 0x84, 0x10,
  0xFC, 0xFC, 0x42, 0x13, 0x06, 0x31, 0x78, 0x18, 0x62, 0x92, 0x4A, 0x2F,
  0xC2, 0x08, 0x7D, 0x04, 0x1E, 0x04, 0x10, 0x61, 0x78, 0x39, 0x08, 0x3E,
  0x86, 0x18, 0x61, 0x78, 0xFC, 0x20, 0x82, 0x10, 0x42, 0x08, 0x40, 0x7A,
  0x18, 0x52, 0x7A, 0x18, 0x61, 0x78, 0x7A, 0x18, 0x61, 0x85, 0xF0, 0x42,
  0x70, 0x82, 0x40, 0x05, 0x80, 0x0C, 0xCC, 0x18, 0x1C, 0xFC, 0x0F, 0xC0,
  0x81, 0xC0, 0xC6, 0xE0, 0x7C, 0x42, 0x11, 0x10, 0x00, 0x20, 0x3E, 0x96,
  0x5D, 0x3A, 0x75, 0x6F, 0xA0, 0x3C, 0x30, 0xC3, 0x12, 0x49, 0x2B, 0x61,
  0x84, 0xFA, 0x18, 0x62, 0xFA, 0x18, 0x61, 0xF8, 0x7A, 0x18, 0x60, 0x82,
  0x08, 0x61, 0x78, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x62, 0xF0, 0xFE, 0x08,
  0x20, 0xFA, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x80,
  0x7A, 0x18, 0x20, 0x9A, 0x18, 0x61, 0x78, 0x86, 0x18, 0x61, 0xFE, 0x18,
  0x61, 0x84, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x08, 0x42, 0x10,
  0x86, 0x31, 0x70, 0x86, 0x29, 0x28, 0xE2, 0x48, 0xA2, 0x84, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xFC, 0x87, 0x3C, 0xF5, 0xB6, 0x98, 0x61, 0x84,
  0x87, 0x1C, 0x69, 0xA6, 0x58, 0xE3, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x78, 0xFA, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x7A, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0x20, 0x40, 0xFA, 0x18, 0x61, 0xEA, 0x48, 0xA1,
  0x84, 0x7A, 0x18, 0x10, 0x38, 0x18, 0x61, 0x78, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x86, 0x18,
  0x92, 0x49, 0x43, 0x0C, 0x20, 0x96, 0xDB, 0x6D, 0xB7, 0x34, 0x92, 0x48,
  0x85, 0x24, 0x8C, 0x10, 0xC4, 0xA1, 0x84, 0x86, 0x24, 0x94, 0x30, 0x82,
  0x08, 0x20, 0xFC, 0x21, 0x04, 0x21, 0x04, 0x20, 0xFC, 0xEA, 0xAA, 0xAA,
  0xC0, 0x88, 0x44, 0x42, 0x22, 0x11, 0xD5, 0x55, 0x55, 0xC0, 0x46, 0xA9,
  0x90, 0xFC, 0x90, 0x7A, 0x10, 0x5F, 0x86, 0x17, 0xC0, 0x82, 0x08, 0x3E,
  0x86, 0x18, 0x61, 0x87, 0xE0, 0x7A, 0x18, 0x20, 0x82, 0x17, 0x80, 0x08,
  0x42, 0xF8, 0xC6, 0x31, 0x8B, 0xC0, 0x7A, 0x18, 0x7E, 0x82, 0x17, 0x80,
  0x1C, 0x82, 0x3E, 0x20, 0x82, 0x08, 0x20, 0x80, 0x7C, 0x63, 0x18, 0xC5,
  0xE1, 0x8B, 0x80, 0x82, 0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x10, 0x10,
  0x0E, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x10, 0x71, 0x11, 0x11, 0x11, 0x1E,
  0x82, 0x08, 0x23, 0x92, 0x8E, 0x24, 0x8A, 0x10, 0xF0, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x13, 0xF0, 0xFE, 0x9A, 0x69, 0xA6, 0x9A, 0x40, 0xFA, 0x18,
  0x61, 0x86, 0x18, 0x40, 0x7A, 0x18, 0x61, 0x86, 0x17, 0x80, 0xFA, 0x28,
  0x61, 0x86, 0x1F, 0xA0, 0x82, 0x00, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x08,
  0x40, 0xBE, 0x21, 0x08, 0x42, 0x00, 0x7A, 0x1C, 0x0E, 0x06, 0x17, 0x80,
  0x20, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x1C, 0x86, 0x18, 0x61, 0x86, 0x17,
  0xC0, 0x86, 0x14, 0x92, 0x50, 0xC2, 0x00, 0x92, 0xB5, 0x6A, 0xD6, 0x44,
  0x89, 0x00, 0x85, 0x23, 0x08, 0x31, 0x28, 0x40, 0x86, 0x18, 0x92, 0x48,
  0xC2, 0x08, 0x23, 0x00, 0xFC, 0x21, 0x08, 0x41, 0x0F, 0xC0, 0x12, 0x22,
  0x24, 0xC2, 0x22, 0x22, 0x10, 0xFF, 0xE0, 0xC4, 0x22, 0x22, 0x12, 0x22,
  0x24, 0x80, 0x73, 0x1C,
};

const GFXglyph RobotoMono_ExtraLight13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 9, 8, 3, -9 },
  { 3, 2, 3, 8, 3, -10 },
  { 4, 7, 9, 8, 0, -9 },
  { 12, 6, 12, 8, 1, -11 },
  { 21, 8, 9, 8, 0, -9 },
  { 30, 6, 9, 8, 1, -9 },
  { 37, 1, 3, 8, 3, -10 },
  { 38, 3, 13, 8, 2, -10 },
  { 43, 3, 13, 8, 2, -10 },
  { 48, 6, 5, 8, 1, -9 },
  { 52, 6, 7, 8, 1, -8 },
  { 58, 1, 3, 8, 3, -1 },
  { 59, 4, 1, 8, 2, -5 },
  { 60, 1, 1, 8, 4, -1 },
  { 61, 4, 10, 8, 2, -9 },
  { 66, 6, 9, 8, 1, -9 },
  { 73, 4, 9, 8, 1, -9 },
  { 78, 6, 9, 8, 1, -9 },
  { 85, 5, 9, 8, 1, -9 },
  { 91, 6, 9, 8, 1, -9 },
  { 98, 6, 9, 8, 1, -9 },
  { 105, 6, 9, 8, 1, -9 },
  { 112, 6, 9, 8, 1, -9 },
  { 119, 6, 9, 8, 1, -9 },
  { 126, 6, 9, 8, 1, -9 },
  { 133, 1, 7, 8, 4, -7 },
  { 134, 2, 9, 8, 3, -7 },
  { 137, 6, 5, 8, 1, -7 },
  { 141, 6, 3, 8, 1, -6 },
  { 144, 6, 5, 8, 1, -7 },
  { 148, 5, 9, 8, 1, -9 },
  { 154, 7, 9, 8, 0, -9 },
  { 162, 6, 9, 8, 1, -9 },
  { 169, 6, 9, 8, 1, -9 },
  { 176, 6, 9, 8, 1, -9 },
  { 183, 6, 9, 8, 1, -9 },
  { 190, 6, 9, 8, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 6, 9, 8, 1, -9 },
  { 211, 6, 9, 8, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 5, 9, 8, 1, -9 },
  { 231, 6, 9, 8, 1, -9 },
  { 238, 6, 9, 8, 1, -9 },
  { 245, 6, 9, 8, 1, -9 },
  { 252, 6, 9, 8, 1, -9 },
  { 259, 6, 9, 8, 1, -9 },
  { 266, 6, 9, 8, 1, -9 },
  { 273, 6, 11, 8, 1, -9 },
  { 282, 6, 9, 8, 1, -9 },
  { 289, 6, 9, 8, 1, -9 },
  { 296, 6, 9, 8, 1, -9 },
  { 303, 6, 9, 8, 1, -9 },
  { 310, 6, 9, 8, 1, -9 },
  { 317, 6, 9, 8, 1, -9 },
  { 324, 6, 9, 8, 1, -9 },
  { 331, 6, 9, 8, 1, -9 },
  { 338, 6, 9, 8, 1, -9 },
  { 345, 2, 13, 8, 3, -11 },
  { 349, 4, 10, 8, 2, -9 },
  { 354, 2, 13, 8, 3, -11 },
  { 358, 4, 5, 8, 2, -9 },
  { 361, 6, 1, 8, 1, 0 },
  { 362, 2, 2, 8, 3, -10 },
  { 363, 6, 7, 8, 1, -7 },
  { 369, 6, 10, 8, 1, -10 },
  { 377, 6, 7, 8, 1, -7 },
  { 383, 5, 10, 8, 1, -10 },
  { 390, 6, 7, 8, 1, -7 },
  { 396, 6, 10, 8, 1, -10 },
  { 404, 5, 10, 8, 1, -7 },
  { 411, 6, 10, 8, 1, -10 },
  { 419, 6, 9, 8, 1, -9 },
  { 426, 4, 12, 8, 1, -9 },
  { 432, 6, 10, 8, 1, -10 },
  { 440, 6, 10, 8, 1, -10 },
  { 448, 6, 7, 8, 1, -7 },
  { 454, 6, 7, 8, 1, -7 },
  { 460, 6, 7, 8, 1, -7 },
  { 466, 6, 10, 8, 1, -7 },
  { 474, 5, 10, 8, 1, -7 },
  { 481, 5, 7, 8, 2, -7 },
  { 486, 6, 7, 8, 1, -7 },
  { 492, 6, 9, 8, 1, -9 },
  { 499, 6, 7, 8, 1, -7 },
  { 505, 6, 7, 8, 1, -7 },
  { 511, 7, 7, 8, 0, -7 },
  { 518, 6, 7, 8, 1, -7 },
  { 524, 6, 10, 8, 1, -7 },
  { 532, 6, 7, 8, 1, -7 },
  { 538, 4, 13, 8, 2, -10 },
  { 545, 1, 11, 8, 3, -9 },
  { 547, 4, 13, 8, 2, -10 },
  { 554, 7, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_ExtraLight13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight13pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_EXTRALIGHT13PT7B_H_
