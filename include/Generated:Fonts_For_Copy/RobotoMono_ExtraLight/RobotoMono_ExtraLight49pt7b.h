#ifndef _ROBOTOMONO_EXTRALIGHT49PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x08, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x07, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x10, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0x80,
  0x78, 0x1C, 0x00, 0x70, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x77, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x78, 0x03, 0x80,
  0xFC, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x00, 0xC1,
  0x80, 0x60, 0x30, 0x30, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x30,
  0x30, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC1, 0x80, 0x20, 0x30, 0x60, 0x06,
  0x06, 0x08, 0x00, 0x61, 0x83, 0x00, 0x07, 0xE0, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x83, 0xF0, 0x00, 0x30, 0xE7, 0x80, 0x0C, 0x38,
  0x30, 0x03, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x60, 0x18, 0x10, 0x0C, 0x03,
  0x06, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x18, 0x18, 0x06, 0x06, 0x01, 0x00,
  0xC0, 0xC0, 0x30, 0x18, 0x08, 0x06, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x38, 0x00,
  0x06, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x30, 0x38, 0x06,
  0x60, 0x18, 0x06, 0xE0, 0x0C, 0x06, 0xC0, 0x0E, 0x06, 0xC0, 0x07, 0x0C,
  0xC0, 0x03, 0x8C, 0xC0, 0x01, 0x9C, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0xF8,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0xD8, 0x38, 0x03, 0x8C,
  0x1F, 0x3F, 0x06, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xA8, 0x00, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x40, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x02, 0x00, 0x80, 0x3C, 0x04, 0x0F,
  0xFC, 0x21, 0xF8, 0xFD, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x00,
  0x70, 0x1C, 0x07, 0x00, 0x70, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x33, 0x33, 0x37, 0x66, 0xCC, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x5F, 0xF0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xEC, 0x00, 0x07, 0xB0, 0x00, 0x3E, 0xC0, 0x01, 0x9F,
  0x00, 0x0C, 0x7C, 0x00, 0x61, 0xF0, 0x03, 0x07, 0xC0, 0x18, 0x1F, 0x00,
  0xC0, 0x7C, 0x06, 0x01, 0xF0, 0x30, 0x07, 0xC1, 0x80, 0x1F, 0x0C, 0x00,
  0x7C, 0x60, 0x01, 0xF3, 0x00, 0x06, 0xF8, 0x00, 0x1B, 0xC0, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x1E, 0x3E, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0xFB, 0x3E, 0x3F, 0x03, 0xC0, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01,
  0xC0, 0x38, 0x0C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0x80, 0x01, 0x8C, 0x00,
  0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xE7,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x1E,
  0x00, 0xE0, 0x1F, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x1C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xC0, 0xF8, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0xC0, 0x00, 0x66,
  0x00, 0x03, 0x38, 0x00, 0x38, 0xC0, 0x01, 0x87, 0x00, 0x1C, 0x1E, 0x03,
  0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x0F, 0xC0, 0x61, 0xFF, 0x83, 0x3C, 0x0E, 0x1B, 0x80, 0x38,
  0xF0, 0x00, 0x67, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x38, 0x00,
  0x18, 0xC0, 0x01, 0x83, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x3C, 0x7C, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xE0, 0x1E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xE7,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x9C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xC1, 0xC0, 0x06,
  0x03, 0xC0, 0x70, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xF0, 0x3C, 0x07,
  0x00, 0x18, 0x38, 0x00, 0x31, 0xC0, 0x00, 0x66, 0x00, 0x01, 0xD8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x77, 0x00, 0x01, 0x8E, 0x00, 0x0E, 0x1C,
  0x00, 0xF0, 0x3F, 0x9F, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00, 0x06, 0x38, 0x00, 0x39,
  0x80, 0x00, 0xDC, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x1E, 0x70, 0x01,
  0xB1, 0xC0, 0x19, 0x87, 0x87, 0x8C, 0x1F, 0xF8, 0x60, 0x1C, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x4F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0xFF, 0xE0, 0x10, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x71, 0x8C, 0x10, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0x80, 0x71, 0xC0, 0x0E, 0x60, 0x01, 0xB0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0xC0, 0x3C, 0x06, 0x18, 0x1F,
  0xE0, 0xC6, 0x07, 0x0E, 0x08, 0xC0, 0xC0, 0x81, 0x90, 0x30, 0x10, 0x36,
  0x04, 0x02, 0x06, 0xC1, 0x80, 0x40, 0xD8, 0x30, 0x08, 0x1A, 0x04, 0x03,
  0x03, 0x41, 0x80, 0x60, 0x78, 0x30, 0x0C, 0x0F, 0x06, 0x01, 0x81, 0xE0,
  0xC0, 0x30, 0x3C, 0x18, 0x04, 0x07, 0x83, 0x01, 0x80, 0xB0, 0x60, 0x30,
  0x12, 0x0C, 0x0E, 0x06, 0x60, 0xC1, 0x60, 0x8C, 0x18, 0x6C, 0x31, 0x81,
  0xF8, 0xFC, 0x10, 0x1E, 0x0F, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x30, 0x03, 0xE1, 0x80,
  0x03, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00,
  0x06, 0x60, 0x00, 0x73, 0x00, 0x07, 0x18, 0x00, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x30, 0x00, 0xF1, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x01,
  0xD8, 0x00, 0x1C, 0xC0, 0x03, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x03, 0x81, 0xC0,
  0x03, 0x83, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC7, 0x00,
  0x03, 0x86, 0x00, 0x06, 0x06, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x07, 0xCF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x0C, 0x01, 0xE0, 0x30, 0x01, 0xE0, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0xC0,
  0x0F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x03,
  0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x03,
  0x38, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x67, 0x00, 0x00, 0xC7, 0x00, 0x01, 0x87, 0x00, 0x07,
  0x07, 0x00, 0x3C, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x03, 0x30, 0x00, 0x19, 0xC0, 0x01, 0xC7, 0x00, 0x1C, 0x1C, 0x01, 0xC0,
  0x7C, 0xFC, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00,
  0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xE0, 0x60, 0x03, 0x80, 0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x00, 0xE0,
  0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00,
  0x61, 0xC0, 0x00, 0xC7, 0x80, 0x01, 0x9F, 0x80, 0x03, 0x73, 0x80, 0x07,
  0xC3, 0x00, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x0E, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x60, 0x00,
  0x1C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xD8, 0x00, 0x6F, 0x60, 0x01, 0xBD, 0x80, 0x0C, 0xF3, 0x00, 0x33,
  0xCC, 0x00, 0xCF, 0x30, 0x06, 0x3C, 0x60, 0x18, 0xF1, 0x80, 0xC3, 0xC3,
  0x03, 0x0F, 0x0C, 0x0C, 0x3C, 0x30, 0x60, 0xF0, 0x61, 0x83, 0xC1, 0x8C,
  0x0F, 0x06, 0x30, 0x3C, 0x0C, 0xC0, 0xF0, 0x36, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xEC, 0x00, 0x0F, 0x70, 0x00, 0x79, 0x80, 0x03,
  0xC6, 0x00, 0x1E, 0x30, 0x00, 0xF0, 0xC0, 0x07, 0x86, 0x00, 0x3C, 0x18,
  0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x00, 0x78, 0x1C, 0x03, 0xC0, 0x60, 0x1E,
  0x01, 0x80, 0xF0, 0x0C, 0x07, 0x80, 0x30, 0x3C, 0x01, 0x81, 0xE0, 0x06,
  0x0F, 0x00, 0x38, 0x78, 0x00, 0xC3, 0xC0, 0x07, 0x1E, 0x00, 0x18, 0xF0,
  0x00, 0x67, 0x80, 0x03, 0x3C, 0x00, 0x0D, 0xE0, 0x00, 0x6F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x07, 0x80, 0x70, 0x03, 0x81, 0xC0,
  0x03, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x87, 0x00,
  0x03, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x07, 0xDF,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0E, 0x00, 0x3C,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0xFC, 0x3F, 0xFF, 0xC0, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0x00, 0xE0, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x38, 0x38, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x03, 0xEF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x0C, 0x00, 0x78, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x07, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x0E, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x30,
  0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x01, 0xE0, 0x1E, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x39, 0x80,
  0x00, 0x66, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x37, 0x00, 0x01, 0x8E, 0x00,
  0x0E, 0x1C, 0x00, 0xF0, 0x3F, 0xBF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0xB8, 0x00, 0x18, 0xC0, 0x01, 0xC3, 0x00, 0x1C,
  0x1E, 0x01, 0xC0, 0x3E, 0xFC, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x70, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0xF0, 0x03, 0x00, 0x36, 0x00, 0xE0, 0x0D, 0x80, 0x38, 0x03, 0x60,
  0x1E, 0x00, 0x98, 0x07, 0x80, 0x66, 0x01, 0xE0, 0x19, 0x80, 0x6C, 0x06,
  0x60, 0x13, 0x01, 0x8C, 0x0C, 0xC0, 0x63, 0x03, 0x30, 0x18, 0xC0, 0xCC,
  0x04, 0x30, 0x31, 0x83, 0x0C, 0x0C, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x18, 0x61, 0x83, 0x06, 0x18, 0x20, 0xC1, 0x86, 0x0C, 0x20,
  0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x80, 0x8C, 0x0C,
  0x60, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x64, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x3C, 0x01, 0x60, 0x0F, 0x00,
  0x70, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x01, 0x81,
  0xC0, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3,
  0x80, 0x01, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x9C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x30, 0x0C,
  0x18, 0x06, 0x0C, 0x03, 0x03, 0x03, 0x01, 0x81, 0x80, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x06, 0x60, 0x03, 0x30, 0x00, 0xF0, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0x00, 0x78, 0x70, 0x00, 0xC3, 0x00, 0x07,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0x8F, 0x80, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xB0, 0x00, 0x3D, 0xC0, 0x07, 0x67,
  0x00, 0x73, 0x1F, 0x3F, 0x18, 0x7F, 0xE0, 0xC0, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x3F, 0xC0, 0xC7, 0xFF, 0x0D, 0xC0, 0x38, 0xD8, 0x01, 0xCF, 0x00, 0x0C,
  0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xCF, 0x00, 0x1C, 0xDC, 0x03, 0x8C,
  0xFF, 0xF0, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0x80,
  0x70, 0x38, 0x00, 0xC3, 0x80, 0x07, 0x18, 0x00, 0x19, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x03,
  0x9C, 0x00, 0x18, 0x60, 0x01, 0x81, 0xC0, 0x1C, 0x07, 0xCF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x3F, 0xC3, 0x0F, 0xFF, 0x31, 0xE0,
  0x3B, 0x18, 0x00, 0xF3, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x03, 0x60,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x03, 0x30, 0x00,
  0x71, 0x80, 0x0F, 0x1C, 0x01, 0xB0, 0xFD, 0xF3, 0x03, 0xFE, 0x30, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x41,
  0xC0, 0x03, 0x83, 0x80, 0x1C, 0x07, 0xE7, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFC, 0x30, 0x7F, 0xF3, 0x1E, 0x03,
  0xB1, 0x80, 0x0F, 0x30, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x33, 0x00, 0x07,
  0x18, 0x00, 0xF1, 0xC0, 0x1B, 0x0F, 0xDF, 0x30, 0x3F, 0xE3, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x63, 0x00,
  0x06, 0x38, 0x00, 0xC1, 0xC0, 0x3C, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x1F, 0xE0, 0xC7, 0xFF, 0x8C, 0xE0, 0x1C, 0xD8, 0x00,
  0xED, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x78, 0x63, 0xF0, 0xFF, 0xC0, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x07, 0x0C,
  0x00, 0xC0, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00,
  0xC3, 0x80, 0x0C, 0x70, 0x00, 0xCF, 0x00, 0x0D, 0xF0, 0x00, 0xF1, 0x80,
  0x0E, 0x1C, 0x00, 0xC0, 0xE0, 0x0C, 0x07, 0x00, 0xC0, 0x38, 0x0C, 0x01,
  0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0xC0,
  0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xCF, 0xE0, 0xFE,
  0x6F, 0xF8, 0xFF, 0xBC, 0x0E, 0xC0, 0xDC, 0x03, 0xC0, 0x3E, 0x01, 0xC0,
  0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03, 0xC0, 0x0C,
  0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80, 0x3C, 0x00,
  0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03, 0xC0,
  0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80, 0x3C,
  0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03,
  0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xC0, 0xC1, 0xFE, 0x0C, 0x7F, 0xF8,
  0xCE, 0x01, 0xCD, 0x80, 0x0E, 0xD0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x03, 0x80, 0xE0, 0x03, 0x81,
  0x80, 0x03, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x87, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0xE7, 0xC0,
  0x03, 0xFE, 0x00, 0xC3, 0xFC, 0x0C, 0xFF, 0xF0, 0xDC, 0x03, 0x8F, 0x80,
  0x1C, 0xF0, 0x00, 0xCE, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x0C, 0xF0, 0x01,
  0xCD, 0x80, 0x38, 0xCF, 0x9F, 0x0C, 0x3F, 0xC0, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x30,
  0xFF, 0xF3, 0x1E, 0x03, 0xB1, 0x80, 0x0F, 0x38, 0x00, 0x77, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x70,
  0x00, 0x33, 0x00, 0x07, 0x18, 0x00, 0xF1, 0xC0, 0x1F, 0x0F, 0xDF, 0x30,
  0x3F, 0xE3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0xFF, 0xE1, 0xFF, 0xF1, 0xC0, 0x19, 0x80, 0x0D,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xF8, 0x3C, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x76,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x70, 0x00, 0x73, 0x80, 0x1E, 0x1F,
  0x9F, 0xC0, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xC6, 0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x60, 0x00, 0x76,
  0x00, 0x0F, 0x70, 0x01, 0xB3, 0x80, 0x33, 0x1F, 0x7E, 0x30, 0xFF, 0xC3,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x38, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00,
  0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x06, 0x60, 0x1E, 0x01, 0x98, 0x05,
  0x80, 0x66, 0x03, 0x60, 0x19, 0x80, 0xCC, 0x04, 0x30, 0x33, 0x03, 0x0C,
  0x0C, 0xC0, 0xC3, 0x06, 0x30, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x86,
  0x06, 0x10, 0x61, 0x81, 0x8C, 0x18, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0xC4, 0x02, 0x20, 0x33, 0x00, 0xD8, 0x04, 0xC0, 0x36, 0x01, 0xB0, 0x0D,
  0x80, 0x68, 0x03, 0x40, 0x1A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE7,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xC3,
  0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x38,
  0x00, 0x18, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0B,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00,
  0x1F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x37, 0x8F, 0x00, 0x0D, 0x80, 0xE0, 0x02, 0xC0, 0x1C, 0x01,
  0xB0, 0x03, 0xC0, 0xEC, 0x00, 0x3C, 0xF2, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x38, 0x00,
};

const GFXglyph RobotoMono_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 3, 35, 29, 13, -35 },
  { 15, 9, 11, 29, 10, -37 },
  { 28, 27, 35, 29, 1, -35 },
  { 147, 22, 45, 29, 4, -40 },
  { 271, 27, 36, 29, 1, -35 },
  { 393, 24, 35, 29, 4, -35 },
  { 498, 2, 11, 29, 13, -37 },
  { 501, 11, 50, 29, 9, -39 },
  { 570, 11, 50, 29, 8, -39 },
  { 639, 21, 20, 29, 5, -35 },
  { 692, 24, 26, 29, 3, -29 },
  { 770, 4, 11, 29, 10, -4 },
  { 776, 17, 2, 29, 6, -17 },
  { 781, 3, 4, 29, 14, -4 },
  { 783, 17, 38, 29, 7, -35 },
  { 864, 22, 35, 29, 4, -35 },
  { 961, 12, 35, 29, 5, -35 },
  { 1014, 22, 35, 29, 3, -35 },
  { 1111, 22, 35, 29, 2, -35 },
  { 1208, 25, 35, 29, 2, -35 },
  { 1318, 21, 35, 29, 5, -35 },
  { 1410, 21, 35, 29, 4, -35 },
  { 1502, 23, 35, 29, 3, -35 },
  { 1603, 22, 35, 29, 4, -35 },
  { 1700, 21, 35, 29, 4, -35 },
  { 1792, 4, 25, 29, 15, -25 },
  { 1805, 6, 32, 29, 13, -25 },
  { 1829, 21, 20, 29, 4, -26 },
  { 1882, 22, 12, 29, 4, -22 },
  { 1915, 21, 20, 29, 4, -26 },
  { 1968, 18, 35, 29, 6, -35 },
  { 2047, 27, 35, 29, 1, -35 },
  { 2166, 24, 35, 29, 3, -35 },
  { 2271, 21, 35, 29, 5, -35 },
  { 2363, 23, 36, 29, 3, -35 },
  { 2467, 22, 35, 29, 5, -35 },
  { 2564, 20, 35, 29, 5, -35 },
  { 2652, 20, 35, 29, 5, -35 },
  { 2740, 23, 35, 29, 3, -35 },
  { 2841, 21, 35, 29, 4, -35 },
  { 2933, 20, 35, 29, 5, -35 },
  { 3021, 21, 35, 29, 3, -35 },
  { 3113, 23, 35, 29, 5, -35 },
  { 3214, 20, 35, 29, 6, -35 },
  { 3302, 22, 35, 29, 4, -35 },
  { 3399, 21, 35, 29, 4, -35 },
  { 3491, 23, 35, 29, 3, -35 },
  { 3592, 22, 35, 29, 5, -35 },
  { 3689, 24, 41, 29, 3, -35 },
  { 3812, 22, 35, 29, 5, -35 },
  { 3909, 22, 35, 29, 4, -35 },
  { 4006, 25, 35, 29, 2, -35 },
  { 4116, 21, 35, 29, 4, -35 },
  { 4208, 25, 35, 29, 2, -35 },
  { 4318, 26, 35, 29, 2, -35 },
  { 4432, 24, 35, 29, 3, -35 },
  { 4537, 25, 35, 29, 2, -35 },
  { 4647, 22, 35, 29, 3, -35 },
  { 4744, 8, 47, 29, 11, -40 },
  { 4791, 17, 38, 29, 6, -35 },
  { 4872, 7, 47, 29, 11, -40 },
  { 4914, 17, 19, 29, 6, -35 },
  { 4955, 21, 2, 29, 4, 0 },
  { 4961, 7, 6, 29, 11, -36 },
  { 4967, 21, 26, 29, 4, -26 },
  { 5036, 20, 37, 29, 5, -37 },
  { 5129, 21, 26, 29, 4, -26 },
  { 5198, 20, 37, 29, 4, -37 },
  { 5291, 22, 26, 29, 4, -26 },
  { 5363, 22, 37, 29, 5, -37 },
  { 5465, 20, 36, 29, 4, -26 },
  { 5555, 20, 37, 29, 5, -37 },
  { 5648, 21, 35, 29, 5, -35 },
  { 5740, 16, 45, 29, 4, -35 },
  { 5830, 20, 37, 29, 6, -37 },
  { 5923, 21, 37, 29, 5, -37 },
  { 6021, 25, 26, 29, 2, -26 },
  { 6103, 20, 26, 29, 5, -26 },
  { 6168, 23, 26, 29, 3, -26 },
  { 6243, 20, 36, 29, 5, -26 },
  { 6333, 20, 36, 29, 4, -26 },
  { 6423, 17, 26, 29, 9, -26 },
  { 6479, 20, 26, 29, 5, -26 },
  { 6544, 21, 33, 29, 4, -33 },
  { 6631, 20, 26, 29, 5, -26 },
  { 6696, 24, 26, 29, 3, -26 },
  { 6774, 26, 26, 29, 2, -26 },
  { 6859, 24, 26, 29, 3, -26 },
  { 6937, 25, 36, 29, 2, -26 },
  { 7050, 23, 26, 29, 3, -26 },
  { 7125, 16, 48, 29, 8, -38 },
  { 7221, 2, 42, 29, 14, -35 },
  { 7232, 16, 48, 29, 8, -38 },
  { 7328, 26, 9, 29, 2, -19 },
};

const GFXfont RobotoMono_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight49pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_EXTRALIGHT49PT7B_H_
