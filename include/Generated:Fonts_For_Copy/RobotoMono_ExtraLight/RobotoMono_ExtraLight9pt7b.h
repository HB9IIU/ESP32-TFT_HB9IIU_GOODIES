#ifndef _ROBOTOMONO_EXTRALIGHT9PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x2B, 0xD4, 0xAF, 0xA8, 0x69, 0x84, 0x39, 0xB4, 0xF5,
  0x98, 0x75, 0x8C, 0xEA, 0x4D, 0xBF, 0xC0, 0x6A, 0xAA, 0x40, 0xA5, 0x56,
  0x80, 0x4F, 0xE0, 0x44, 0xF4, 0xC0, 0xE0, 0x80, 0x24, 0xA5, 0x20, 0xF9,
  0xBD, 0x9E, 0xD5, 0x50, 0xF0, 0x84, 0x44, 0x7C, 0xF1, 0x31, 0x97, 0x11,
  0x95, 0x27, 0x88, 0xF8, 0xE1, 0x9E, 0xEC, 0xA9, 0x9E, 0xF2, 0x24, 0x48,
  0xF9, 0x69, 0x9F, 0xF9, 0x9F, 0x16, 0x88, 0x8C, 0x34, 0xC3, 0xFF, 0x86,
  0x78, 0xE4, 0xA0, 0x80, 0x7D, 0xF7, 0xBA, 0xB8, 0x21, 0x94, 0xF4, 0xC4,
  0xF9, 0xE9, 0x9E, 0xF9, 0x88, 0x9E, 0xF9, 0x99, 0x9E, 0xF8, 0xE8, 0x8F,
  0xF8, 0xE8, 0x88, 0xF8, 0x8B, 0x9F, 0x99, 0xF9, 0x99, 0xF4, 0x44, 0x4F,
  0x24, 0x9B, 0xC0, 0xBA, 0xCA, 0xA9, 0x88, 0x88, 0x8F, 0x9B, 0xBD, 0x99,
  0x99, 0xDB, 0xB9, 0xF9, 0x99, 0x9E, 0xF9, 0x9E, 0x88, 0x7C, 0x63, 0x18,
  0xB8, 0x20, 0xF9, 0x9E, 0xA9, 0xF8, 0x61, 0x9F, 0xF9, 0x08, 0x42, 0x10,
  0x99, 0x99, 0x9E, 0x8A, 0x54, 0xA2, 0x10, 0xAD, 0x56, 0xB5, 0x28, 0x9A,
  0x44, 0xA9, 0xCA, 0x88, 0x42, 0x10, 0xF2, 0x44, 0x8F, 0xFF, 0x89, 0x22,
  0x48, 0xFF, 0x56, 0x80, 0xF0, 0xC0, 0x69, 0x79, 0xF0, 0x88, 0xE9, 0x99,
  0xE0, 0x69, 0x89, 0xE0, 0x25, 0xDB, 0x78, 0x69, 0xF8, 0xF0, 0x34, 0xE4,
  0x44, 0x40, 0x76, 0xDE, 0x78, 0x88, 0xE9, 0x99, 0x90, 0x0C, 0x44, 0x4F,
  0x38, 0x92, 0x4E, 0x88, 0x9E, 0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xFD,
  0x6B, 0x5A, 0x80, 0xE9, 0x99, 0x90, 0x69, 0x99, 0xE0, 0xE9, 0x99, 0xE8,
  0x80, 0x76, 0xDE, 0x48, 0xF2, 0x48, 0x69, 0x61, 0xF0, 0x4E, 0x44, 0x47,
  0x99, 0x99, 0xF0, 0x8A, 0x54, 0x62, 0x00, 0xAD, 0x6A, 0xA5, 0x00, 0x9A,
  0x46, 0x90, 0x8A, 0x54, 0x62, 0x11, 0x00, 0xF2, 0x48, 0xF0, 0x29, 0x28,
  0x92, 0x20, 0xFE, 0xC9, 0x22, 0x92, 0xC0, 0xF8,
};

const GFXglyph RobotoMono_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 4, 6, 5, 1, -6 },
  { 18, 1, 2, 5, 2, -7 },
  { 19, 2, 9, 5, 2, -7 },
  { 22, 2, 9, 5, 2, -7 },
  { 25, 4, 3, 5, 1, -6 },
  { 27, 4, 4, 5, 1, -5 },
  { 29, 1, 2, 5, 2, -1 },
  { 30, 3, 1, 5, 1, -3 },
  { 31, 1, 1, 5, 2, -1 },
  { 32, 3, 7, 5, 1, -6 },
  { 35, 4, 6, 5, 1, -6 },
  { 38, 2, 6, 5, 1, -6 },
  { 40, 5, 6, 5, 0, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 4, 6, 5, 1, -6 },
  { 54, 4, 6, 5, 1, -6 },
  { 57, 4, 6, 5, 1, -6 },
  { 60, 4, 6, 5, 1, -6 },
  { 63, 4, 6, 5, 1, -6 },
  { 66, 1, 5, 5, 3, -5 },
  { 67, 1, 6, 5, 2, -5 },
  { 68, 4, 4, 5, 1, -5 },
  { 70, 4, 2, 5, 1, -4 },
  { 71, 4, 4, 5, 1, -5 },
  { 73, 3, 6, 5, 1, -6 },
  { 76, 5, 6, 5, 0, -6 },
  { 80, 5, 6, 5, 0, -6 },
  { 84, 4, 6, 5, 1, -6 },
  { 87, 4, 6, 5, 1, -6 },
  { 90, 4, 6, 5, 1, -6 },
  { 93, 4, 6, 5, 1, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 4, 6, 5, 1, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 4, 6, 5, 1, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 5, 7, 5, 0, -6 },
  { 134, 4, 6, 5, 1, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 4, 6, 5, 1, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 4, 6, 5, 1, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 4, 6, 5, 1, -6 },
  { 165, 1, 8, 5, 2, -7 },
  { 166, 3, 7, 5, 1, -6 },
  { 169, 1, 8, 5, 2, -7 },
  { 170, 3, 3, 5, 1, -6 },
  { 172, 4, 1, 5, 1, 0 },
  { 173, 1, 2, 5, 2, -7 },
  { 174, 4, 5, 5, 1, -5 },
  { 177, 4, 7, 5, 1, -7 },
  { 181, 4, 5, 5, 1, -5 },
  { 184, 3, 7, 5, 1, -7 },
  { 187, 4, 5, 5, 1, -5 },
  { 190, 4, 7, 5, 1, -7 },
  { 194, 3, 7, 5, 1, -5 },
  { 197, 4, 7, 5, 1, -7 },
  { 201, 4, 6, 5, 1, -6 },
  { 204, 3, 8, 5, 1, -6 },
  { 207, 4, 7, 5, 1, -7 },
  { 211, 4, 7, 5, 1, -7 },
  { 215, 5, 5, 5, 0, -5 },
  { 219, 4, 5, 5, 1, -5 },
  { 222, 4, 5, 5, 1, -5 },
  { 225, 4, 7, 5, 1, -5 },
  { 229, 3, 7, 5, 1, -5 },
  { 232, 3, 5, 5, 2, -5 },
  { 234, 4, 5, 5, 1, -5 },
  { 237, 4, 6, 5, 1, -6 },
  { 240, 4, 5, 5, 1, -5 },
  { 243, 5, 5, 5, 0, -5 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 4, 5, 5, 1, -5 },
  { 254, 5, 7, 5, 0, -5 },
  { 259, 4, 5, 5, 1, -5 },
  { 262, 3, 9, 5, 1, -7 },
  { 266, 1, 7, 5, 2, -6 },
  { 267, 3, 9, 5, 1, -7 },
  { 271, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight9pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_EXTRALIGHT9PT7B_H_
