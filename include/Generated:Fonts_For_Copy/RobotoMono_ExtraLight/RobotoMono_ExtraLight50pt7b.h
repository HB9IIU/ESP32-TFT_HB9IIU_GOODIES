#ifndef _ROBOTOMONO_EXTRALIGHT50PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x61, 0xB0, 0xD8, 0x6C, 0x34, 0x1A, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x18, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x20, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xE0, 0x78, 0x1C, 0x00, 0xE1, 0xC0, 0x03,
  0x1C, 0x00, 0x1C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x1C,
  0x00, 0x38, 0x70, 0x07, 0x81, 0xFB, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x40, 0x30, 0x08, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30,
  0x60, 0x0C, 0x03, 0x06, 0x00, 0x60, 0x60, 0xC0, 0x07, 0x06, 0x0C, 0x00,
  0x3F, 0xC1, 0x80, 0x01, 0xF8, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x0F,
  0x00, 0x01, 0x83, 0xF8, 0x00, 0x18, 0x70, 0xC0, 0x03, 0x06, 0x06, 0x00,
  0x30, 0xC0, 0x60, 0x06, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30,
  0x30, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x38,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC1,
  0xC0, 0x00, 0x31, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x83, 0x00, 0x31, 0x80, 0xC0, 0x19, 0x80, 0x70, 0x19, 0xC0, 0x1C, 0x0C,
  0xC0, 0x07, 0x06, 0x60, 0x01, 0x83, 0x30, 0x00, 0x63, 0x98, 0x00, 0x39,
  0x8C, 0x00, 0x0F, 0xC6, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0xFC, 0x1C, 0x01, 0xE7, 0x07, 0xEF, 0xC1, 0xC0, 0xFF,
  0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x0C, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x0C,
  0x06, 0xF8, 0x30, 0xFC, 0xFC, 0xCF, 0xC0, 0x7F, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x70, 0x00, 0x18, 0xC0, 0x00, 0xE1, 0x80, 0x03,
  0x03, 0x00, 0x18, 0x0E, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x08, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x33, 0x33, 0x33, 0x76, 0x6C, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x3C,
  0x07, 0x00, 0x38, 0x18, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xEF, 0x00, 0x06, 0x3C, 0x00, 0x30, 0xF0, 0x01, 0x83,
  0xC0, 0x0C, 0x0F, 0x00, 0x60, 0x3C, 0x03, 0x00, 0xF0, 0x18, 0x03, 0xC0,
  0xC0, 0x0F, 0x06, 0x00, 0x3C, 0x30, 0x00, 0xF3, 0x80, 0x03, 0xDC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x19,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x38,
  0x07, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E,
  0x0F, 0xB1, 0xF1, 0xBC, 0x0F, 0x80, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01,
  0xE0, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x00, 0xE1, 0x80, 0x01, 0xCE, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03, 0x86,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x9C,
  0x00, 0x03, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1F,
  0x9F, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x38, 0x00, 0xCF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3C, 0x03, 0xC1, 0x80, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x36,
  0x00, 0x03, 0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xC7, 0x00, 0x0E, 0x1C, 0x00,
  0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x87, 0xF8, 0x0C,
  0x7F, 0xF8, 0x33, 0x80, 0x70, 0xD8, 0x00, 0xE3, 0xC0, 0x01, 0xCE, 0x00,
  0x03, 0x38, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0x87, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x07, 0x00, 0x70, 0x07, 0x83, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x78, 0x07, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x03, 0x1C,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00,
  0x03, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x3F, 0x9F,
  0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x3C,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x03, 0xCC, 0x00, 0x1B, 0x38,
  0x00, 0xCC, 0x78, 0x07, 0x60, 0xFF, 0xF1, 0x80, 0xFF, 0x86, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x70, 0x18, 0xF3, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x61, 0x86, 0x18, 0xE3, 0x8C, 0x31, 0x8E, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xF0, 0x1C, 0x18, 0x01,
  0xC6, 0x00, 0x1D, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x18, 0x0F, 0xE0,
  0x63, 0x01, 0xEF, 0x06, 0x30, 0x30, 0x30, 0x63, 0x06, 0x03, 0x06, 0x60,
  0x60, 0x30, 0x26, 0x04, 0x03, 0x02, 0x60, 0xC0, 0x30, 0x26, 0x0C, 0x02,
  0x03, 0x40, 0x80, 0x20, 0x34, 0x08, 0x02, 0x03, 0xC1, 0x80, 0x20, 0x2C,
  0x18, 0x06, 0x02, 0xC1, 0x80, 0x60, 0x2C, 0x18, 0x06, 0x06, 0xC1, 0x80,
  0x60, 0x64, 0x18, 0x0E, 0x06, 0x40, 0x80, 0xE0, 0x46, 0x0C, 0x1E, 0x0C,
  0x60, 0xE3, 0x31, 0x86, 0x07, 0xE3, 0xF0, 0x30, 0x3C, 0x1E, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x01, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x30, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0C, 0x03, 0xF8,
  0x30, 0x00, 0xF0, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x30, 0x00, 0x70,
  0xC0, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x30, 0x00, 0x78, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0xE3, 0x00,
  0x0F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x70, 0x03, 0xE3, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0C, 0x07, 0xE0, 0x30, 0x01, 0xE0, 0xC0, 0x01, 0xC3,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x30,
  0x00, 0x70, 0xC0, 0x03, 0x83, 0x00, 0x3C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x78, 0x1C,
  0x00, 0x18, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x3C, 0x03, 0xF3, 0xF8, 0x00, 0xFF, 0xC0, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0x80, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0,
  0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0xC7, 0xC0, 0x00, 0xCE, 0xC0, 0x00, 0xDC, 0xE0, 0x00, 0xF8,
  0x70, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xD8, 0x00, 0x3F, 0x60, 0x01, 0xBD, 0x80, 0x06,
  0xF3, 0x00, 0x1B, 0xCC, 0x00, 0xCF, 0x38, 0x03, 0x3C, 0x60, 0x18, 0xF1,
  0x80, 0x63, 0xC3, 0x01, 0x8F, 0x0C, 0x0C, 0x3C, 0x30, 0x30, 0xF0, 0x61,
  0x83, 0xC1, 0x86, 0x0F, 0x06, 0x18, 0x3C, 0x0C, 0xC0, 0xF0, 0x33, 0x03,
  0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x60, 0x00,
  0x3D, 0xC0, 0x00, 0xF3, 0x00, 0x03, 0xCE, 0x00, 0x0F, 0x18, 0x00, 0x3C,
  0x30, 0x00, 0xF0, 0xC0, 0x03, 0xC1, 0x80, 0x0F, 0x07, 0x00, 0x3C, 0x0C,
  0x00, 0xF0, 0x38, 0x03, 0xC0, 0x60, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x00,
  0xF0, 0x06, 0x03, 0xC0, 0x18, 0x0F, 0x00, 0x30, 0x3C, 0x00, 0xE0, 0xF0,
  0x01, 0x83, 0xC0, 0x07, 0x0F, 0x00, 0x0C, 0x3C, 0x00, 0x38, 0xF0, 0x00,
  0x63, 0xC0, 0x00, 0xCF, 0x00, 0x03, 0x3C, 0x00, 0x06, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0xF8, 0x30, 0x00, 0x78, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00, 0x03,
  0x8C, 0x00, 0x3C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x07, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x0C, 0x00, 0xF8, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x38,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x30,
  0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xD8, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x3C, 0x00,
  0xE0, 0x3F, 0xBF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x19, 0x80, 0x00, 0x67, 0x00,
  0x03, 0x8E, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x38, 0x07, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xE0, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0x00,
  0x07, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x78,
  0x01, 0xC0, 0x0D, 0x80, 0x38, 0x03, 0x30, 0x07, 0x00, 0x66, 0x00, 0xE0,
  0x0C, 0xC0, 0x14, 0x01, 0x98, 0x06, 0xC0, 0x33, 0x00, 0xD8, 0x06, 0x60,
  0x1B, 0x00, 0xC6, 0x03, 0x60, 0x30, 0xC0, 0x4C, 0x06, 0x18, 0x18, 0xC0,
  0xC3, 0x03, 0x18, 0x18, 0x60, 0x63, 0x03, 0x0C, 0x0C, 0x60, 0x61, 0x81,
  0x8C, 0x08, 0x18, 0x60, 0xC3, 0x03, 0x0C, 0x18, 0x60, 0x61, 0x83, 0x0C,
  0x0C, 0x30, 0x61, 0x81, 0x86, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x02, 0x30,
  0x19, 0x80, 0x66, 0x03, 0x30, 0x0C, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0xC0,
  0x36, 0x01, 0x98, 0x06, 0xC0, 0x1B, 0x00, 0xD8, 0x03, 0x40, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0x60, 0x30, 0x00, 0x38, 0x38, 0x00,
  0x0C, 0x18, 0x00, 0x07, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x83,
  0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x30,
  0x00, 0x18, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x18, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x30, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x1C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x06,
  0x18, 0x03, 0x87, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x06, 0x06, 0x01,
  0x83, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1B,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x87, 0x0C, 0x18,
  0x30, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x31, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xE0, 0x01, 0x8E, 0x00, 0x06, 0x70, 0x00,
  0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0xE6, 0x00, 0x07, 0x9C, 0x00, 0x36, 0x38, 0x03, 0x98, 0x7E,
  0xFC, 0x70, 0xFF, 0xC1, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x81, 0xF0,
  0x0C, 0x7F, 0xF0, 0x67, 0x83, 0xC3, 0x70, 0x07, 0x1E, 0x00, 0x1C, 0xF0,
  0x00, 0x67, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xE0, 0x00, 0x67, 0x80, 0x07, 0x3E, 0x00,
  0x31, 0xB8, 0x07, 0x8C, 0xFF, 0xF0, 0x61, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x38, 0x18, 0x00, 0x70, 0xC0,
  0x00, 0xE3, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x07, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x80, 0x03,
  0x87, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x1F, 0xBF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xF0, 0x30, 0x7F, 0xF1, 0x87, 0x83,
  0xCC, 0x70, 0x07, 0x67, 0x00, 0x0F, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03,
  0x30, 0x00, 0x39, 0xC0, 0x01, 0xC6, 0x00, 0x1E, 0x1C, 0x03, 0xB0, 0x7F,
  0xF9, 0x81, 0xFF, 0x0C, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x3C,
  0x03, 0x80, 0x38, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x87, 0x00, 0x06, 0x0F, 0x00,
  0x70, 0x1F, 0x8F, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0xC3, 0xC1, 0xE6,
  0x38, 0x03, 0xB3, 0x80, 0x07, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0xEC, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x98,
  0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x00, 0x0F, 0x0E, 0x01, 0xD8, 0x3F, 0xFC,
  0xC0, 0xFF, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x70,
  0x1F, 0x1F, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x07, 0xE0, 0xC3, 0xFF, 0x8C, 0x78, 0x3C, 0xCC, 0x00, 0xED, 0x80, 0x06,
  0xD0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x88,
  0x3E, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x2C, 0x00, 0x0E, 0x60, 0x00, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0xC0,
  0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x30, 0x1C, 0x01, 0x81, 0xC0, 0x0C, 0x1C,
  0x00, 0x61, 0xC0, 0x03, 0x1C, 0x00, 0x19, 0xE0, 0x00, 0xDF, 0x80, 0x07,
  0x8E, 0x00, 0x38, 0x38, 0x01, 0x80, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x30,
  0x00, 0x71, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7C,
  0x33, 0xFC, 0x3F, 0xCD, 0x83, 0xB8, 0x3B, 0xC0, 0x6C, 0x06, 0xE0, 0x0E,
  0x01, 0xF8, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F,
  0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0,
  0x0C, 0x00, 0x7E, 0x0C, 0x3F, 0xF8, 0xC7, 0x03, 0xCC, 0xC0, 0x0E, 0xD8,
  0x00, 0x6F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0,
  0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x06, 0x3F, 0xF8, 0x33,
  0x81, 0xE1, 0xB0, 0x03, 0x8F, 0x00, 0x0E, 0x70, 0x00, 0x33, 0x80, 0x01,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x07, 0x70, 0x00, 0x33, 0x80, 0x03, 0x9E, 0x00, 0x38, 0xDC, 0x03, 0x86,
  0x7E, 0xF8, 0x30, 0xFF, 0x81, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xF8, 0xC3, 0xC0, 0xE6, 0x38, 0x01, 0xB3, 0x80, 0x07, 0x98, 0x00, 0x1D,
  0xC0, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x0E,
  0x01, 0xD8, 0x3E, 0xFC, 0xC0, 0xFF, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0xE0, 0xFF, 0xF0, 0xF8, 0x39, 0xC0, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0x80, 0xF0, 0x70, 0x01, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00, 0x0E, 0x38,
  0x00, 0xE0, 0xFE, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xEF, 0x00, 0x1F, 0xF8, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x0F, 0x30, 0x01, 0xB3, 0x80, 0x3B, 0x1F, 0xFF,
  0x30, 0x7F, 0xC3, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xF8, 0x01, 0xC0, 0x1B, 0x00, 0x38, 0x03, 0x30, 0x0F, 0x00, 0x66, 0x01,
  0xE0, 0x0C, 0xC0, 0x36, 0x03, 0x18, 0x04, 0xC0, 0x63, 0x81, 0x98, 0x0C,
  0x30, 0x33, 0x01, 0x86, 0x06, 0x30, 0x60, 0xC0, 0x86, 0x0C, 0x18, 0x30,
  0xC1, 0x81, 0x86, 0x18, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x10, 0x31, 0x80,
  0xC6, 0x06, 0x30, 0x08, 0xC0, 0xC6, 0x01, 0x98, 0x0C, 0xC0, 0x32, 0x01,
  0x90, 0x06, 0xC0, 0x36, 0x00, 0xD8, 0x06, 0xC0, 0x0B, 0x00, 0x58, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x0E, 0x00,
  0x38, 0x06, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x01, 0xC1,
  0x80, 0x00, 0xC3, 0x80, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x67,
  0x00, 0x00, 0xE3, 0x80, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x0C, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x06,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0C,
  0x01, 0x80, 0x07, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x30, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x40, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x37,
  0x07, 0x80, 0x0D, 0x80, 0x70, 0x03, 0xC0, 0x0E, 0x01, 0xF0, 0x01, 0xC0,
  0xEC, 0x00, 0x3F, 0xF2, 0x00, 0x03, 0xF8,
};

const GFXglyph RobotoMono_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 3, 36, 30, 13, -36 },
  { 15, 9, 11, 30, 10, -38 },
  { 28, 28, 36, 30, 1, -36 },
  { 154, 21, 46, 30, 5, -41 },
  { 275, 28, 37, 30, 1, -36 },
  { 405, 25, 36, 30, 4, -36 },
  { 518, 2, 11, 30, 13, -38 },
  { 521, 11, 51, 30, 10, -40 },
  { 592, 11, 51, 30, 9, -40 },
  { 663, 22, 21, 30, 5, -36 },
  { 721, 24, 25, 30, 3, -29 },
  { 796, 4, 11, 30, 10, -4 },
  { 802, 18, 2, 30, 6, -17 },
  { 807, 4, 4, 30, 14, -4 },
  { 809, 17, 39, 30, 7, -36 },
  { 892, 22, 36, 30, 4, -36 },
  { 991, 13, 36, 30, 5, -36 },
  { 1050, 22, 36, 30, 3, -36 },
  { 1149, 23, 36, 30, 2, -36 },
  { 1253, 25, 36, 30, 2, -36 },
  { 1366, 21, 36, 30, 5, -36 },
  { 1461, 22, 36, 30, 4, -36 },
  { 1560, 23, 36, 30, 3, -36 },
  { 1664, 23, 36, 30, 4, -36 },
  { 1768, 22, 36, 30, 4, -36 },
  { 1867, 4, 25, 30, 15, -25 },
  { 1880, 6, 32, 30, 13, -25 },
  { 1904, 21, 20, 30, 4, -26 },
  { 1957, 22, 12, 30, 4, -22 },
  { 1990, 21, 20, 30, 5, -26 },
  { 2043, 19, 36, 30, 6, -36 },
  { 2129, 28, 36, 30, 1, -36 },
  { 2255, 25, 36, 30, 3, -36 },
  { 2368, 22, 36, 30, 5, -36 },
  { 2467, 24, 37, 30, 3, -36 },
  { 2578, 22, 36, 30, 5, -36 },
  { 2677, 21, 36, 30, 5, -36 },
  { 2772, 21, 36, 30, 5, -36 },
  { 2867, 24, 36, 30, 3, -36 },
  { 2975, 22, 36, 30, 4, -36 },
  { 3074, 20, 36, 30, 5, -36 },
  { 3164, 22, 36, 30, 3, -36 },
  { 3263, 24, 36, 30, 5, -36 },
  { 3371, 20, 36, 30, 6, -36 },
  { 3461, 22, 36, 30, 4, -36 },
  { 3560, 22, 36, 30, 4, -36 },
  { 3659, 24, 36, 30, 3, -36 },
  { 3767, 22, 36, 30, 6, -36 },
  { 3866, 24, 42, 30, 3, -36 },
  { 3992, 22, 36, 30, 5, -36 },
  { 4091, 23, 36, 30, 4, -36 },
  { 4195, 25, 36, 30, 3, -36 },
  { 4308, 22, 36, 30, 4, -36 },
  { 4407, 25, 36, 30, 2, -36 },
  { 4520, 27, 36, 30, 2, -36 },
  { 4642, 25, 36, 30, 3, -36 },
  { 4755, 25, 36, 30, 2, -36 },
  { 4868, 23, 36, 30, 3, -36 },
  { 4972, 8, 49, 30, 11, -41 },
  { 5021, 17, 39, 30, 7, -36 },
  { 5104, 8, 49, 30, 11, -41 },
  { 5153, 18, 20, 30, 6, -36 },
  { 5198, 22, 2, 30, 4, 0 },
  { 5204, 6, 7, 30, 12, -37 },
  { 5210, 22, 27, 30, 4, -27 },
  { 5285, 21, 38, 30, 5, -38 },
  { 5385, 22, 27, 30, 4, -27 },
  { 5460, 21, 38, 30, 4, -38 },
  { 5560, 22, 27, 30, 4, -27 },
  { 5635, 22, 38, 30, 5, -38 },
  { 5740, 21, 38, 30, 4, -27 },
  { 5840, 20, 38, 30, 5, -38 },
  { 5935, 20, 36, 30, 6, -36 },
  { 6025, 15, 47, 30, 5, -36 },
  { 6114, 21, 38, 30, 6, -38 },
  { 6214, 20, 38, 30, 6, -38 },
  { 6309, 26, 27, 30, 2, -27 },
  { 6397, 20, 27, 30, 5, -27 },
  { 6465, 24, 27, 30, 3, -27 },
  { 6546, 21, 37, 30, 5, -27 },
  { 6644, 21, 37, 30, 4, -27 },
  { 6742, 17, 27, 30, 9, -27 },
  { 6800, 21, 27, 30, 5, -27 },
  { 6871, 21, 33, 30, 4, -33 },
  { 6958, 20, 26, 30, 5, -26 },
  { 7023, 24, 26, 30, 3, -26 },
  { 7101, 27, 26, 30, 2, -26 },
  { 7189, 24, 26, 30, 3, -26 },
  { 7267, 26, 37, 30, 2, -26 },
  { 7388, 24, 26, 30, 3, -26 },
  { 7466, 16, 49, 30, 8, -39 },
  { 7564, 2, 43, 30, 14, -36 },
  { 7575, 16, 49, 30, 8, -39 },
  { 7673, 26, 8, 30, 2, -19 },
};

const GFXfont RobotoMono_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight50pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_EXTRALIGHT50PT7B_H_
