#ifndef _ROBOTOMONO_EXTRALIGHT68PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0x80,
  0x0E, 0x03, 0x80, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x70,
  0x00, 0x70, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x30, 0x00, 0x07, 0x8F, 0x01, 0xC0, 0x00, 0x0F, 0xF8, 0x0E, 0x00,
  0x00, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x3F, 0xC0, 0x00, 0x03, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x0F, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x18, 0x00, 0x1C,
  0x0E, 0x00, 0x70, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x03, 0x00, 0x0C,
  0x01, 0xC0, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x02, 0x1E, 0x03, 0xC0, 0x03, 0x07, 0x00,
  0x70, 0x00, 0xC3, 0x80, 0x0E, 0x00, 0x31, 0xE0, 0x01, 0xC0, 0x1C, 0x70,
  0x00, 0x78, 0x07, 0x1C, 0x00, 0x0F, 0x01, 0xCE, 0x00, 0x01, 0xC0, 0x73,
  0x80, 0x00, 0x38, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x38, 0x00, 0x01, 0xE7,
  0x8E, 0x00, 0x00, 0x3D, 0xC3, 0x80, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x00,
  0xF8, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x07, 0xF0, 0x3C, 0x00, 0x03, 0xDE, 0x07, 0xC0, 0x03, 0xE3, 0x80, 0xFC,
  0x03, 0xE0, 0x70, 0x1F, 0xFF, 0xF0, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB7, 0xC0, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x40, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x80, 0x07, 0x00, 0x17, 0x80, 0x38, 0x03, 0xFF, 0x01,
  0xC0, 0xFE, 0xFF, 0x0E, 0x1F, 0xE0, 0xFF, 0x77, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xC0,
  0x04, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x73, 0x8E, 0x73, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x7E, 0x70,
  0x00, 0x01, 0xDC, 0xC0, 0x00, 0x07, 0x39, 0x80, 0x00, 0x1C, 0x77, 0x00,
  0x00, 0x70, 0x6E, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x07, 0x01, 0xF8, 0x00,
  0x3C, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F,
  0x00, 0x1F, 0x80, 0x3C, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7E, 0x03, 0xC0,
  0x00, 0xFC, 0x0F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0x38, 0xE0, 0x00,
  0x06, 0x73, 0x80, 0x00, 0x1C, 0xEE, 0x00, 0x00, 0x39, 0xF8, 0x00, 0x00,
  0x73, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0x38, 0xFC, 0x1D,
  0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x20,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x7C, 0x00, 0x0E, 0x3F, 0xFE, 0x00, 0x77, 0xFF, 0xF8, 0x03,
  0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0x01, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x07, 0x03, 0xFF, 0xC0, 0x1C, 0x3F, 0xFF, 0x80,
  0x63, 0xE0, 0x1F, 0x81, 0x9E, 0x00, 0x1F, 0x0E, 0xE0, 0x00, 0x1E, 0x3F,
  0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x1E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F,
  0xC7, 0x80, 0x00, 0x77, 0x0F, 0x00, 0x03, 0x9C, 0x1F, 0x00, 0x3C, 0x70,
  0x3F, 0x8F, 0xE1, 0x80, 0x3F, 0xFE, 0x06, 0x00, 0x3F, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF,
  0x80, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0xF0, 0x60, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x07, 0x00,
  0x18, 0x38, 0x01, 0xFE, 0x00, 0xE1, 0xC0, 0x1F, 0xFC, 0x07, 0x0C, 0x01,
  0xC0, 0xF0, 0x18, 0xE0, 0x1C, 0x03, 0x00, 0xC6, 0x01, 0xC0, 0x18, 0x06,
  0x70, 0x0C, 0x00, 0xC0, 0x33, 0x80, 0xE0, 0x06, 0x01, 0xD8, 0x06, 0x00,
  0x30, 0x0E, 0xC0, 0x30, 0x01, 0x80, 0x76, 0x03, 0x80, 0x0C, 0x01, 0xF0,
  0x18, 0x00, 0x60, 0x0F, 0x80, 0xC0, 0x07, 0x00, 0x78, 0x06, 0x00, 0x38,
  0x03, 0xC0, 0x30, 0x01, 0x80, 0x3E, 0x03, 0x80, 0x0C, 0x01, 0xF0, 0x1C,
  0x00, 0x60, 0x0F, 0x80, 0xE0, 0x03, 0x00, 0x6C, 0x07, 0x00, 0x18, 0x03,
  0x60, 0x38, 0x01, 0xC0, 0x1B, 0x01, 0xC0, 0x0E, 0x00, 0xDC, 0x0E, 0x00,
  0x70, 0x0E, 0xE0, 0x30, 0x07, 0x80, 0x67, 0x01, 0x80, 0x3C, 0x03, 0x38,
  0x0E, 0x03, 0x60, 0x38, 0xC0, 0x70, 0x33, 0x83, 0x86, 0x01, 0xC7, 0x8E,
  0x38, 0x38, 0x07, 0xF8, 0x7F, 0xC1, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1F, 0x03, 0x80, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0xFF, 0x03, 0x80, 0x00, 0x3E, 0x0E, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x83, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x07,
  0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x07, 0xF0, 0x07, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE1,
  0xF0, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x00, 0xE7,
  0x9C, 0x00, 0x00, 0xEF, 0x1E, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0xFC,
  0x07, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x7F, 0xC0, 0x00,
  0x1D, 0xFB, 0x80, 0x00, 0x77, 0xEE, 0x00, 0x03, 0x9F, 0x98, 0x00, 0x0E,
  0x7E, 0x70, 0x00, 0x71, 0xF9, 0xC0, 0x01, 0xC7, 0xE3, 0x00, 0x07, 0x1F,
  0x8E, 0x00, 0x38, 0x7E, 0x38, 0x00, 0xE1, 0xF8, 0x70, 0x07, 0x07, 0xE1,
  0xC0, 0x1C, 0x1F, 0x83, 0x00, 0x70, 0x7E, 0x0E, 0x03, 0x81, 0xF8, 0x38,
  0x0E, 0x07, 0xE0, 0x60, 0x30, 0x1F, 0x81, 0xC1, 0xC0, 0x7E, 0x07, 0x07,
  0x01, 0xF8, 0x0E, 0x38, 0x07, 0xE0, 0x38, 0xE0, 0x1F, 0x80, 0x63, 0x00,
  0x7E, 0x01, 0xDC, 0x01, 0xF8, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x3E, 0x00, 0x7E, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0,
  0x07, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00,
  0xF9, 0xC0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x1F, 0x03, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x3E, 0x03, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x7C,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x1F, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0xE0, 0x07, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0xE0,
  0x0F, 0xC0, 0x03, 0x80, 0x7E, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x70, 0x1F,
  0x80, 0x01, 0xC0, 0xFC, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x38, 0x3F, 0x00,
  0x01, 0xC1, 0xF8, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x38, 0x7E, 0x00, 0x00,
  0xE3, 0xF0, 0x00, 0x03, 0x9F, 0x80, 0x00, 0x1C, 0xFC, 0x00, 0x00, 0x77,
  0xE0, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1F, 0xC1,
  0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x1F, 0x87, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x76, 0x00, 0x0F, 0x00,
  0x06, 0x60, 0x00, 0xF0, 0x00, 0x67, 0x00, 0x0F, 0x80, 0x06, 0x70, 0x01,
  0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x80, 0x0E, 0x70, 0x01, 0xD8, 0x00, 0xE7,
  0x00, 0x19, 0x80, 0x0E, 0x30, 0x01, 0x98, 0x00, 0xC3, 0x80, 0x39, 0xC0,
  0x0C, 0x38, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x1C, 0x38, 0x03,
  0x0C, 0x01, 0xC3, 0x80, 0x30, 0xC0, 0x1C, 0x18, 0x03, 0x0E, 0x01, 0xC1,
  0x80, 0x70, 0xE0, 0x18, 0x1C, 0x07, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x60,
  0x38, 0x1C, 0x06, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x0C, 0x0E, 0x03, 0x03, 0x00,
  0xE0, 0xC0, 0x30, 0x30, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xC6, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x0C,
  0xE0, 0x03, 0x30, 0x00, 0xCE, 0x00, 0x37, 0x00, 0x0E, 0xC0, 0x03, 0xF0,
  0x00, 0xEC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01,
  0xC1, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x00, 0xE1, 0xF0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x07, 0x71, 0xE0, 0x00, 0xF3,
  0x87, 0xC0, 0x3F, 0x1E, 0x1F, 0xFF, 0xE0, 0x70, 0x3F, 0xFC, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0xE1,
  0xFF, 0xF8, 0x0E, 0x3E, 0x07, 0xE0, 0xE7, 0x00, 0x1F, 0x0E, 0xE0, 0x00,
  0x70, 0xFC, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x38, 0xFC, 0x00, 0x07, 0x8E,
  0xF0, 0x01, 0xF0, 0xE7, 0xC0, 0x7E, 0x0E, 0x1F, 0xFF, 0x80, 0xE0, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x70, 0x0F, 0xFE, 0x07, 0x03, 0xFF, 0xF8, 0x70, 0x7E,
  0x07, 0xC7, 0x0F, 0x80, 0x0E, 0x71, 0xE0, 0x00, 0x77, 0x1C, 0x00, 0x03,
  0xF3, 0x80, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0xF7, 0x07,
  0xE0, 0x3E, 0x70, 0x3F, 0xFF, 0x87, 0x00, 0xFF, 0xE0, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x04, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x01,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xFE, 0x07, 0x01, 0xFF, 0xF8, 0x70, 0x7E, 0x07, 0xC7, 0x0F, 0x80,
  0x0E, 0x71, 0xE0, 0x00, 0x77, 0x1C, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1F,
  0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0xF7, 0x07, 0xE0, 0x3E, 0x70, 0x3F,
  0xFF, 0x87, 0x00, 0xFF, 0xF0, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE1, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x03, 0xFF, 0x80, 0xE0, 0xFF, 0xFE, 0x0E, 0x1F, 0x03, 0xF0, 0xE3, 0x80,
  0x07, 0x8E, 0x70, 0x00, 0x3C, 0xEE, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x08,
  0x03, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x7E,
  0x00, 0x00, 0xEF, 0xF0, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x30,
  0x1C, 0x7F, 0xC0, 0x7F, 0xC3, 0x9F, 0xFE, 0x1F, 0xFC, 0x77, 0x03, 0xC7,
  0x83, 0xCF, 0xC0, 0x3D, 0xC0, 0x3D, 0xF0, 0x03, 0xF0, 0x03, 0xBC, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00,
  0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0x80, 0xE0, 0xFF, 0xFE,
  0x0E, 0x1F, 0x03, 0xF0, 0xE3, 0x80, 0x07, 0x8E, 0x70, 0x00, 0x38, 0xEE,
  0x00, 0x01, 0xCF, 0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x07, 0xFE, 0x00, 0xE1,
  0xFF, 0xF8, 0x0E, 0x7C, 0x07, 0xE0, 0xEF, 0x00, 0x1F, 0x0F, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x78, 0xFC, 0x00, 0x07, 0x0E,
  0xE0, 0x01, 0xF0, 0xE7, 0xC0, 0x7E, 0x0E, 0x3F, 0xFF, 0x80, 0xE0, 0xFF,
  0xF0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0x03, 0xFF,
  0xF8, 0x70, 0x7E, 0x07, 0xC7, 0x0F, 0x80, 0x0E, 0x71, 0xE0, 0x00, 0x77,
  0x1C, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0xF7, 0x07, 0xC0, 0x3E, 0x70, 0x3F, 0xFF, 0x87, 0x00, 0xFF, 0xF0,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFE, 0x06, 0xE1, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x77, 0x1E,
  0x00, 0x1C, 0xE1, 0xF0, 0x1F, 0x1C, 0x1F, 0xFF, 0xC3, 0x81, 0xFF, 0xE0,
  0x70, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3B, 0x00, 0x03, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0x00, 0x0C, 0xE0,
  0x00, 0xF0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x07, 0x18, 0x00, 0x6C, 0x00,
  0x38, 0xE0, 0x03, 0x60, 0x01, 0xC7, 0x00, 0x1B, 0x80, 0x0C, 0x38, 0x01,
  0xDC, 0x00, 0xE1, 0xC0, 0x0E, 0x60, 0x07, 0x06, 0x00, 0x63, 0x00, 0x38,
  0x38, 0x03, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0xE0, 0x0C, 0x0E, 0x01, 0xC3,
  0x00, 0xE0, 0x30, 0x0C, 0x18, 0x07, 0x01, 0x80, 0x60, 0xE0, 0x38, 0x0E,
  0x07, 0x07, 0x01, 0x80, 0x70, 0x38, 0x18, 0x1C, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x0C, 0x0C, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x38, 0x30, 0x03, 0x87,
  0x00, 0xC1, 0x80, 0x1C, 0x30, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x38, 0xE0,
  0x03, 0x1C, 0x01, 0xC6, 0x00, 0x1C, 0xE0, 0x06, 0x30, 0x00, 0xE6, 0x00,
  0x31, 0x80, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x00,
  0xDC, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC7, 0xFF, 0xC0,
  0x00, 0x0C, 0x78, 0x0F, 0x80, 0x00, 0x63, 0x80, 0x3E, 0x00, 0x07, 0x38,
  0x00, 0x78, 0x00, 0x39, 0xC0, 0x01, 0xE0, 0x03, 0x8C, 0x00, 0x07, 0xC0,
  0x3C, 0xE0, 0x00, 0x1F, 0x83, 0xC7, 0x00, 0x00, 0x3F, 0xFC, 0x38, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
};

const GFXglyph RobotoMono_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 4, 48, 41, 18, -48 },
  { 25, 12, 14, 41, 14, -51 },
  { 46, 37, 48, 41, 2, -48 },
  { 268, 30, 62, 41, 6, -55 },
  { 501, 38, 50, 41, 1, -49 },
  { 739, 34, 50, 41, 5, -49 },
  { 952, 3, 14, 41, 17, -51 },
  { 958, 15, 70, 41, 13, -54 },
  { 1090, 15, 70, 41, 12, -54 },
  { 1222, 29, 28, 41, 7, -48 },
  { 1324, 33, 35, 41, 4, -40 },
  { 1469, 6, 15, 41, 13, -6 },
  { 1481, 24, 2, 41, 8, -23 },
  { 1487, 5, 5, 41, 19, -5 },
  { 1491, 23, 52, 41, 10, -48 },
  { 1641, 31, 50, 41, 5, -49 },
  { 1835, 17, 48, 41, 7, -48 },
  { 1937, 31, 49, 41, 3, -49 },
  { 2127, 30, 50, 41, 3, -49 },
  { 2315, 34, 48, 41, 3, -48 },
  { 2519, 29, 49, 41, 7, -48 },
  { 2697, 30, 50, 41, 5, -49 },
  { 2885, 32, 48, 41, 4, -48 },
  { 3077, 31, 50, 41, 6, -49 },
  { 3271, 30, 50, 41, 5, -49 },
  { 3459, 5, 34, 41, 21, -34 },
  { 3481, 8, 43, 41, 18, -34 },
  { 3524, 29, 28, 41, 5, -36 },
  { 3626, 29, 16, 41, 6, -30 },
  { 3684, 29, 28, 41, 6, -36 },
  { 3786, 26, 49, 41, 8, -49 },
  { 3946, 37, 49, 41, 2, -49 },
  { 4173, 34, 48, 41, 4, -48 },
  { 4377, 30, 48, 41, 7, -48 },
  { 4557, 32, 50, 41, 4, -49 },
  { 4757, 31, 48, 41, 6, -48 },
  { 4943, 28, 48, 41, 7, -48 },
  { 5111, 28, 48, 41, 7, -48 },
  { 5279, 32, 50, 41, 4, -49 },
  { 5479, 29, 48, 41, 6, -48 },
  { 5653, 27, 48, 41, 7, -48 },
  { 5815, 30, 49, 41, 4, -48 },
  { 5999, 32, 48, 41, 7, -48 },
  { 6191, 28, 48, 41, 8, -48 },
  { 6359, 30, 48, 41, 6, -48 },
  { 6539, 29, 48, 41, 6, -48 },
  { 6713, 32, 50, 41, 4, -49 },
  { 6913, 29, 48, 41, 8, -48 },
  { 7087, 33, 58, 41, 4, -49 },
  { 7327, 30, 48, 41, 7, -48 },
  { 7507, 32, 50, 41, 5, -49 },
  { 7707, 35, 48, 41, 3, -48 },
  { 7917, 29, 49, 41, 6, -48 },
  { 8095, 34, 48, 41, 3, -48 },
  { 8299, 36, 48, 41, 3, -48 },
  { 8515, 34, 48, 41, 4, -48 },
  { 8719, 34, 48, 41, 3, -48 },
  { 8923, 30, 48, 41, 5, -48 },
  { 9103, 11, 65, 41, 15, -55 },
  { 9193, 23, 52, 41, 9, -48 },
  { 9343, 10, 65, 41, 15, -55 },
  { 9425, 24, 26, 41, 8, -48 },
  { 9503, 29, 3, 41, 6, 0 },
  { 9514, 9, 9, 41, 16, -50 },
  { 9525, 29, 38, 41, 6, -37 },
  { 9663, 28, 52, 41, 7, -51 },
  { 9845, 29, 38, 41, 6, -37 },
  { 9983, 28, 52, 41, 6, -51 },
  { 10165, 31, 38, 41, 5, -37 },
  { 10313, 30, 52, 41, 7, -52 },
  { 10508, 28, 51, 41, 6, -37 },
  { 10687, 28, 51, 41, 7, -51 },
  { 10866, 28, 49, 41, 8, -49 },
  { 11038, 21, 64, 41, 6, -49 },
  { 11206, 28, 51, 41, 8, -51 },
  { 11385, 28, 51, 41, 8, -51 },
  { 11564, 35, 37, 41, 3, -37 },
  { 11726, 28, 37, 41, 7, -37 },
  { 11856, 31, 38, 41, 5, -37 },
  { 12004, 28, 51, 41, 7, -37 },
  { 12183, 28, 51, 41, 6, -37 },
  { 12362, 24, 37, 41, 12, -37 },
  { 12473, 28, 38, 41, 7, -37 },
  { 12606, 28, 46, 41, 6, -45 },
  { 12767, 27, 37, 41, 7, -36 },
  { 12892, 33, 36, 41, 4, -36 },
  { 13041, 37, 36, 41, 2, -36 },
  { 13208, 32, 36, 41, 5, -36 },
  { 13352, 35, 51, 41, 3, -36 },
  { 13576, 32, 36, 41, 5, -36 },
  { 13720, 22, 67, 41, 11, -53 },
  { 13905, 3, 58, 41, 19, -48 },
  { 13927, 22, 67, 41, 11, -53 },
  { 14112, 37, 12, 41, 2, -26 },
};

const GFXfont RobotoMono_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight68pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_EXTRALIGHT68PT7B_H_
