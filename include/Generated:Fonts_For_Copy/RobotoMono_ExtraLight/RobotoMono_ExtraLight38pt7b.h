#ifndef _ROBOTOMONO_EXTRALIGHT38PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0xC7, 0x8F, 0x1C, 0x38,
  0x70, 0xE1, 0x42, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01,
  0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20,
  0x3F, 0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x20, 0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x06, 0x00,
  0x30, 0x30, 0x3F, 0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x02,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F,
  0x80, 0x70, 0xE0, 0x60, 0x18, 0x60, 0x06, 0x20, 0x03, 0x30, 0x00, 0x98,
  0x00, 0x6C, 0x00, 0x32, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x63, 0x00, 0x70, 0xE0, 0xF0, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x03, 0x18, 0x00, 0x30, 0x40,
  0x01, 0x03, 0x03, 0x08, 0x08, 0x10, 0x40, 0x41, 0x82, 0x02, 0x18, 0x10,
  0x30, 0x80, 0xC1, 0x8C, 0x02, 0x08, 0x40, 0x1D, 0xC6, 0x00, 0x78, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x78, 0x00,
  0xC7, 0x70, 0x0C, 0x60, 0x80, 0x42, 0x06, 0x06, 0x10, 0x30, 0x20, 0x80,
  0x83, 0x04, 0x04, 0x10, 0x20, 0x61, 0x81, 0x03, 0x00, 0x0C, 0x10, 0x00,
  0x31, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0x86, 0x00, 0x60, 0x40, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x18,
  0x60, 0x03, 0x18, 0x00, 0x36, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x0E, 0x60, 0x01, 0x86, 0x06, 0x60, 0xC0, 0xD8, 0x0C, 0x1B, 0x00,
  0xC3, 0x40, 0x0C, 0x48, 0x00, 0xD9, 0x00, 0x0A, 0x30, 0x01, 0xC6, 0x00,
  0x38, 0x60, 0x0D, 0x87, 0x07, 0x18, 0x7F, 0x81, 0x80, 0xFF, 0x01, 0x81,
  0x81, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x0C, 0x02, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC1, 0x83, 0xF9, 0x9F, 0x1F,
  0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x18,
  0x18, 0x30, 0x0C, 0x10, 0x08, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x33, 0x33, 0x26, 0x6C, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D,
  0x80, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x07, 0xF0, 0x0E, 0x0E, 0x0C, 0x03, 0x86, 0x00, 0xC6, 0x00, 0x32,
  0x00, 0x19, 0x00, 0x05, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0xF0, 0x06,
  0x78, 0x06, 0x3C, 0x06, 0x1E, 0x06, 0x0F, 0x06, 0x07, 0x84, 0x03, 0xCC,
  0x01, 0xEC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x34, 0x00, 0x13, 0x00, 0x19,
  0x80, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x0E, 0x0E, 0x01, 0xFC, 0x00, 0x00,
  0x81, 0xC7, 0xAF, 0x1C, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xF0, 0x0E, 0x1C, 0x0C, 0x03,
  0x0C, 0x00, 0xC4, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x0E, 0x0E, 0x0C, 0x01, 0x8C, 0x00,
  0x46, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x04, 0xC0, 0x06, 0x30, 0x06, 0x0E, 0x0E, 0x03,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00,
  0x06, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x0C, 0x20, 0x01, 0x04, 0x00,
  0x60, 0x80, 0x18, 0x10, 0x02, 0x02, 0x00, 0xC0, 0x40, 0x30, 0x08, 0x04,
  0x01, 0x01, 0x80, 0x20, 0x60, 0x04, 0x08, 0x00, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x6F, 0xE0, 0x7E, 0xF8, 0x70, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1E, 0x78, 0x0F,
  0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC3, 0xE0, 0xCF, 0xF8, 0xD8,
  0x1C, 0xF0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x03, 0x60,
  0x06, 0x30, 0x0C, 0x1C, 0x1C, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x07, 0xF8, 0x0E, 0x0E,
  0x0E, 0x01, 0x86, 0x00, 0x66, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0x90, 0x01, 0x8C, 0x00, 0xC3, 0x01, 0xC0, 0xFF, 0x80,
  0x3F, 0xC0, 0x70, 0x38, 0x60, 0x06, 0x60, 0x01, 0xA0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x06, 0xC0, 0x03, 0x30,
  0x03, 0x0E, 0x07, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0E, 0x1C, 0x0C, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02, 0xC0,
  0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x1D,
  0x80, 0x1E, 0x60, 0x1A, 0x1C, 0x79, 0x07, 0xF0, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xDF, 0x00,
  0x31, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0x8C,
  0x42, 0x31, 0x18, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x0F, 0xE0, 0x70, 0x70, 0xC0, 0x33, 0x00, 0x64, 0x00, 0x78, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x1C, 0x1C, 0x01, 0x80, 0x30,
  0x18, 0x00, 0xC1, 0x80, 0x02, 0x18, 0x0C, 0x18, 0x81, 0xF0, 0x4C, 0x10,
  0x42, 0x41, 0x02, 0x12, 0x18, 0x10, 0xD0, 0x81, 0x87, 0x84, 0x0C, 0x3C,
  0x20, 0x41, 0xC3, 0x02, 0x0E, 0x18, 0x10, 0x70, 0xC0, 0x82, 0x86, 0x0C,
  0x16, 0x30, 0x60, 0xB0, 0x87, 0x0D, 0x86, 0x2C, 0x44, 0x1E, 0x3C, 0x30,
  0x40, 0xC0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x78, 0x38,
  0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x58,
  0x00, 0x1B, 0x00, 0x03, 0x20, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x03, 0x08,
  0x00, 0x41, 0x80, 0x18, 0x30, 0x03, 0x02, 0x00, 0x40, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0x80, 0x40, 0x18, 0x18, 0x03, 0x03, 0x00, 0x20, 0x7F, 0xFE,
  0x08, 0x00, 0xC3, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0x48, 0x00, 0x0F, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x81, 0xF0,
  0x80, 0x1C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0xFF, 0xF0, 0xFF, 0xF0,
  0x80, 0x1C, 0x80, 0x06, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0C, 0x80, 0xF8,
  0xFF, 0xE0, 0x03, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30, 0x40, 0x06, 0x30,
  0x01, 0x88, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x03, 0x60,
  0x00, 0xC8, 0x00, 0x33, 0x00, 0x18, 0x60, 0x06, 0x18, 0x03, 0x03, 0x83,
  0x80, 0x3F, 0x80, 0xFF, 0xC0, 0x30, 0x3C, 0x0C, 0x01, 0xC3, 0x00, 0x18,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0,
  0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x1C, 0x30,
  0x7C, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0x83, 0x81, 0xC0, 0x30, 0x40,
  0x06, 0x30, 0x01, 0x98, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x05, 0x80,
  0x01, 0x60, 0x00, 0x48, 0x00, 0x13, 0x00, 0x04, 0x60, 0x03, 0x0C, 0x01,
  0xC1, 0xC1, 0xC0, 0x3F, 0xE0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1A, 0x00, 0x09, 0x80, 0x0C, 0xC0, 0x04, 0x30, 0x0E, 0x0E,
  0x0E, 0x03, 0xFC, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0x00,
  0x30, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0xC0,
  0x30, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x37, 0xC0, 0x0F,
  0x30, 0x03, 0x86, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03,
  0x30, 0x00, 0x6C, 0x00, 0x1C, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFD, 0x00, 0x7E, 0x80, 0x2F,
  0x60, 0x37, 0x90, 0x13, 0xCC, 0x19, 0xE6, 0x0C, 0xF1, 0x04, 0x78, 0xC6,
  0x3C, 0x22, 0x1E, 0x13, 0x0F, 0x0D, 0x87, 0x82, 0x83, 0xC1, 0xC1, 0xE0,
  0xC0, 0xF0, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3D, 0x00, 0x1E, 0xC0, 0x0F, 0x20, 0x07,
  0x98, 0x03, 0xC4, 0x01, 0xE3, 0x00, 0xF0, 0xC0, 0x78, 0x60, 0x3C, 0x18,
  0x1E, 0x04, 0x0F, 0x03, 0x07, 0x80, 0x83, 0xC0, 0x61, 0xE0, 0x18, 0xF0,
  0x0C, 0x78, 0x03, 0x3C, 0x01, 0x9E, 0x00, 0x6F, 0x00, 0x17, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x60, 0x03, 0xF8, 0x03, 0x87, 0x81,
  0x80, 0x60, 0x60, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x66, 0x00, 0x0D, 0x80,
  0x03, 0x40, 0x00, 0xD0, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x18, 0x60,
  0x0C, 0x1C, 0x06, 0x03, 0xC7, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x60, 0x3E,
  0x30, 0x03, 0x98, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x76,
  0x00, 0x73, 0xFF, 0xE1, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC3, 0xC0, 0x60,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x32, 0x00,
  0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xA0, 0x00, 0x26, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00,
  0x61, 0x80, 0x0C, 0x18, 0x03, 0x01, 0xC1, 0xC0, 0x0F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0xFF, 0xE0,
  0x60, 0x7C, 0x30, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x98, 0x00, 0xCC,
  0x00, 0xC6, 0x00, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x18,
  0x30, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x63, 0x00, 0x11, 0x80,
  0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x60, 0x07, 0xF8, 0x07, 0x07,
  0x03, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x64, 0x00, 0x09,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x02, 0x80, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19,
  0x80, 0x06, 0x30, 0x03, 0x07, 0x03, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xE0,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x12, 0x00,
  0x09, 0x80, 0x0C, 0x40, 0x0C, 0x30, 0x0E, 0x0E, 0x0E, 0x01, 0xFC, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08,
  0x40, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x08, 0x10, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x00,
  0x20, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x08, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x60, 0x38, 0x06, 0x03, 0xC0, 0x60,
  0x2C, 0x0E, 0x02, 0xC0, 0xE0, 0x24, 0x0B, 0x02, 0x40, 0xB0, 0x64, 0x0B,
  0x06, 0x41, 0x90, 0x66, 0x19, 0x04, 0x61, 0x18, 0x46, 0x11, 0x84, 0x21,
  0x18, 0xC2, 0x30, 0x8C, 0x23, 0x08, 0xC3, 0x30, 0xC8, 0x32, 0x0C, 0x83,
  0x20, 0xC8, 0x36, 0x04, 0x81, 0x60, 0x58, 0x16, 0x05, 0x81, 0x40, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x30, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x03,
  0x00, 0xE0, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x02, 0x0C, 0x00, 0xC1, 0x80,
  0x30, 0x18, 0x06, 0x01, 0x01, 0x80, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x63,
  0x00, 0x06, 0x40, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0D, 0x80, 0x01, 0x98, 0x00, 0x61, 0x00, 0x18, 0x30, 0x03, 0x03,
  0x00, 0xC0, 0x60, 0x10, 0x06, 0x06, 0x00, 0x41, 0x80, 0x0C, 0x30, 0x00,
  0xCC, 0x00, 0x1B, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x78, 0x00, 0x19, 0x80,
  0x02, 0x30, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x06, 0x00, 0x80, 0xC0,
  0x30, 0x0C, 0x04, 0x00, 0x81, 0x80, 0x18, 0x20, 0x01, 0x0C, 0x00, 0x33,
  0x00, 0x02, 0x60, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xF8, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0xFC, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0xFF, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x7F, 0xFC, 0x02, 0x00, 0x38, 0x01, 0x40, 0x1B, 0x00,
  0x98, 0x0C, 0x40, 0x63, 0x02, 0x08, 0x30, 0x61, 0x03, 0x18, 0x08, 0xC0,
  0x64, 0x01, 0x60, 0x0E, 0x00, 0x60, 0xFF, 0xFF, 0xC3, 0x08, 0x61, 0x80,
  0x0F, 0xF8, 0x0E, 0x0E, 0x0C, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x07, 0xFF, 0x8F, 0x00, 0xCE,
  0x00, 0x66, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x40, 0x07,
  0x30, 0x07, 0x8E, 0x0E, 0x43, 0xFC, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xCF, 0xF0, 0xD8, 0x38, 0xF0, 0x0C, 0xE0, 0x0C, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xE0,
  0x1C, 0xD8, 0x38, 0x8F, 0xE0, 0x07, 0xF8, 0x1C, 0x1C, 0x38, 0x06, 0x30,
  0x03, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x01, 0x60,
  0x03, 0x30, 0x03, 0x38, 0x06, 0x1C, 0x1C, 0x07, 0xF8, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x0F, 0xF3, 0x1C, 0x1B, 0x30, 0x0F, 0x20, 0x07, 0x60,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x20,
  0x07, 0x30, 0x0F, 0x1C, 0x3B, 0x0F, 0xF3, 0x07, 0xF8, 0x0E, 0x0E, 0x0E,
  0x01, 0x86, 0x00, 0x66, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x0C, 0x01, 0x83, 0x83, 0x80,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x0F, 0xF3, 0x1C, 0x1B, 0x30, 0x0F, 0x20, 0x07,
  0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x20, 0x07, 0x30, 0x0F, 0x1C, 0x3B, 0x07, 0xF3, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1E, 0x78, 0x07, 0xE0,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x0F, 0xE2, 0x70, 0x75, 0x80, 0x6A, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0xC8, 0x78, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0x80,
  0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDE, 0x00, 0xF3, 0x00, 0xE1, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x06, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x9F, 0xD4, 0x36, 0x1B, 0x03, 0x81, 0xE0, 0x70, 0x38,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x87, 0xF1, 0x38, 0x3A, 0xC0, 0x35, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x0F, 0xF0, 0x0E, 0x0E, 0x0C, 0x01, 0x8C, 0x00,
  0x64, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06,
  0xC0, 0x06, 0x60, 0x03, 0x18, 0x03, 0x07, 0x07, 0x00, 0xFE, 0x00, 0x8F,
  0xE0, 0x98, 0x38, 0xA0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xA0, 0x1C, 0x98,
  0x38, 0x8F, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x0F, 0xF3, 0x1C, 0x1B, 0x30,
  0x0F, 0x20, 0x07, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x60, 0x03, 0x20, 0x07, 0x30, 0x0F, 0x1C, 0x1B, 0x0F, 0xF3, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0xC7, 0xFE, 0x70, 0x36, 0x01, 0xE0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x1F, 0xF0, 0x38, 0x1C, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x03, 0xC0, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x02, 0x60, 0x06,
  0x38, 0x1C, 0x1F, 0xF0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0xFF, 0xFE, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x40, 0x0E, 0xC0, 0x34, 0xE1, 0xC8, 0xFF, 0x10, 0xC0, 0x00, 0x68, 0x00,
  0x19, 0x80, 0x03, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x02, 0x06, 0x00,
  0xC0, 0xC0, 0x10, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x10, 0x30, 0x03, 0x06,
  0x00, 0x60, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x09, 0x80, 0x01, 0xB0,
  0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x1A, 0x01,
  0x80, 0x90, 0x1C, 0x04, 0xC0, 0xA0, 0x66, 0x05, 0x03, 0x10, 0x2C, 0x18,
  0x83, 0x60, 0x86, 0x11, 0x04, 0x30, 0x88, 0x61, 0x84, 0x63, 0x04, 0x63,
  0x10, 0x22, 0x08, 0x81, 0x90, 0x44, 0x0C, 0x83, 0x60, 0x2C, 0x1A, 0x01,
  0x40, 0x50, 0x0A, 0x02, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x08, 0x02,
  0x00, 0xC0, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x30, 0x0C, 0x0C,
  0x03, 0x06, 0x00, 0x63, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0D, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x60,
  0x30, 0x30, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x07, 0xE0, 0x00,
  0x36, 0x00, 0x03, 0x30, 0x00, 0x63, 0x00, 0x06, 0x10, 0x00, 0xC1, 0x80,
  0x0C, 0x08, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x06,
  0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x0C, 0x80, 0x00, 0xD8, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x4F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x10, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xF0, 0x0F, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xF0,
  0x07, 0x01, 0xC0, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x00, 0x3F, 0x80, 0x1B, 0x8E, 0x00, 0x90, 0x18, 0x05,
  0x80, 0x70, 0x6C, 0x01, 0xFE, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 2, 27, 23, 10, -27 },
  { 8, 7, 8, 23, 8, -29 },
  { 15, 21, 27, 23, 1, -27 },
  { 86, 17, 35, 23, 3, -31 },
  { 161, 21, 27, 23, 1, -27 },
  { 232, 19, 27, 23, 3, -27 },
  { 297, 1, 8, 23, 10, -29 },
  { 298, 9, 39, 23, 7, -30 },
  { 342, 8, 39, 23, 7, -30 },
  { 381, 16, 16, 23, 4, -27 },
  { 413, 19, 19, 23, 2, -22 },
  { 459, 4, 8, 23, 7, -3 },
  { 463, 13, 2, 23, 5, -13 },
  { 467, 3, 3, 23, 10, -3 },
  { 469, 13, 29, 23, 5, -27 },
  { 517, 17, 27, 23, 3, -27 },
  { 575, 9, 27, 23, 4, -27 },
  { 606, 17, 27, 23, 2, -27 },
  { 664, 17, 27, 23, 2, -27 },
  { 722, 19, 27, 23, 2, -27 },
  { 787, 16, 27, 23, 4, -27 },
  { 841, 16, 27, 23, 3, -27 },
  { 895, 18, 27, 23, 2, -27 },
  { 956, 17, 27, 23, 3, -27 },
  { 1014, 17, 27, 23, 3, -27 },
  { 1072, 3, 19, 23, 12, -19 },
  { 1080, 5, 24, 23, 10, -19 },
  { 1095, 16, 15, 23, 3, -20 },
  { 1125, 17, 9, 23, 3, -17 },
  { 1145, 17, 15, 23, 3, -20 },
  { 1177, 15, 27, 23, 4, -27 },
  { 1228, 21, 27, 23, 1, -27 },
  { 1299, 19, 27, 23, 2, -27 },
  { 1364, 16, 27, 23, 4, -27 },
  { 1418, 18, 27, 23, 2, -27 },
  { 1479, 18, 27, 23, 3, -27 },
  { 1540, 16, 27, 23, 4, -27 },
  { 1594, 16, 27, 23, 4, -27 },
  { 1648, 18, 27, 23, 2, -27 },
  { 1709, 17, 27, 23, 3, -27 },
  { 1767, 15, 27, 23, 4, -27 },
  { 1818, 17, 27, 23, 2, -27 },
  { 1876, 18, 27, 23, 4, -27 },
  { 1937, 16, 27, 23, 4, -27 },
  { 1991, 17, 27, 23, 3, -27 },
  { 2049, 17, 27, 23, 3, -27 },
  { 2107, 18, 27, 23, 2, -27 },
  { 2168, 17, 27, 23, 4, -27 },
  { 2226, 19, 32, 23, 2, -27 },
  { 2302, 17, 27, 23, 4, -27 },
  { 2360, 18, 27, 23, 3, -27 },
  { 2421, 19, 27, 23, 2, -27 },
  { 2486, 17, 27, 23, 3, -27 },
  { 2544, 19, 27, 23, 2, -27 },
  { 2609, 20, 27, 23, 2, -27 },
  { 2677, 19, 27, 23, 2, -27 },
  { 2742, 19, 27, 23, 2, -27 },
  { 2807, 17, 27, 23, 3, -27 },
  { 2865, 6, 37, 23, 9, -31 },
  { 2893, 13, 29, 23, 5, -27 },
  { 2941, 6, 37, 23, 8, -31 },
  { 2969, 13, 15, 23, 5, -27 },
  { 2994, 16, 1, 23, 3, 0 },
  { 2996, 5, 5, 23, 9, -28 },
  { 3000, 17, 20, 23, 3, -20 },
  { 3043, 16, 29, 23, 4, -29 },
  { 3101, 16, 20, 23, 3, -20 },
  { 3141, 16, 29, 23, 3, -29 },
  { 3199, 17, 20, 23, 3, -20 },
  { 3242, 17, 29, 23, 4, -29 },
  { 3304, 16, 28, 23, 3, -20 },
  { 3360, 15, 29, 23, 4, -29 },
  { 3415, 16, 27, 23, 4, -27 },
  { 3469, 12, 35, 23, 3, -27 },
  { 3522, 16, 29, 23, 4, -29 },
  { 3580, 16, 29, 23, 4, -29 },
  { 3638, 19, 20, 23, 2, -20 },
  { 3686, 15, 20, 23, 4, -20 },
  { 3724, 17, 20, 23, 3, -20 },
  { 3767, 16, 28, 23, 4, -20 },
  { 3823, 16, 28, 23, 3, -20 },
  { 3879, 13, 20, 23, 7, -20 },
  { 3912, 16, 20, 23, 4, -20 },
  { 3952, 16, 25, 23, 3, -25 },
  { 4002, 15, 20, 23, 4, -20 },
  { 4040, 19, 20, 23, 2, -20 },
  { 4088, 21, 20, 23, 1, -20 },
  { 4141, 18, 20, 23, 3, -20 },
  { 4186, 20, 28, 23, 1, -20 },
  { 4256, 18, 20, 23, 3, -20 },
  { 4301, 12, 38, 23, 6, -30 },
  { 4358, 1, 33, 23, 11, -27 },
  { 4363, 12, 38, 23, 6, -30 },
  { 4420, 21, 6, 23, 1, -14 },
};

const GFXfont RobotoMono_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight38pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_EXTRALIGHT38PT7B_H_
