#ifndef _ROBOTOMONO_EXTRALIGHT71PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0xFF, 0xFB, 0xC0, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x02, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x38,
  0x03, 0x00, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0x38, 0x07, 0x00, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x38,
  0x00, 0x70, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x38,
  0x00, 0x03, 0xFF, 0xC0, 0x70, 0x00, 0x01, 0xFF, 0x01, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0xF8, 0x00, 0x00, 0x70, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x78, 0x3C,
  0x00, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x38, 0x00, 0x1C,
  0x06, 0x00, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x08, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x01, 0xC3, 0xC0, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0x01, 0xC7, 0x80, 0x03, 0xC0, 0x1C, 0x70,
  0x00, 0x1E, 0x03, 0xC7, 0x00, 0x00, 0xE0, 0x38, 0xE0, 0x00, 0x07, 0x03,
  0x8E, 0x00, 0x00, 0x78, 0x38, 0xE0, 0x00, 0x03, 0xC7, 0x0E, 0x00, 0x00,
  0x1E, 0x70, 0xE0, 0x00, 0x00, 0xEE, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x70,
  0x00, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x01, 0xE7, 0x00, 0xF0, 0x00,
  0x7C, 0x78, 0x07, 0xE0, 0x3F, 0x03, 0xC0, 0x3F, 0xFF, 0xE0, 0x1E, 0x00,
  0xFF, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x6D, 0xB6, 0xDF, 0xFF,
  0xFF, 0xF8, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x02, 0x40, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x05, 0xC0, 0x07, 0x00, 0x3B, 0xF0, 0x0E, 0x03, 0xF7, 0xFC, 0x1C, 0x1F,
  0xF1, 0xFF, 0x39, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x0E, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x9E, 0x73, 0xCE,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x77,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xEF, 0xC0, 0x00, 0x03, 0x9F, 0x80, 0x00, 0x1E, 0x3F, 0x00,
  0x00, 0x78, 0x7E, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x1E, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xE0, 0x01, 0xE0, 0x0F, 0xC0, 0x07,
  0x80, 0x1F, 0x80, 0x1E, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x7E, 0x01, 0xE0,
  0x00, 0xFC, 0x07, 0x80, 0x01, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x70, 0x00,
  0x07, 0xE1, 0xC0, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x1F, 0x9C, 0x00, 0x00,
  0x3F, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0x38, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x07,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC7, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x0F, 0xF8, 0x00, 0x73, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0xF8, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xF8, 0x10, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x3F,
  0xE0, 0x03, 0x81, 0xFF, 0xF8, 0x07, 0x0F, 0xFF, 0xF8, 0x0E, 0x7C, 0x00,
  0xF8, 0x1D, 0xE0, 0x00, 0x78, 0x37, 0x80, 0x00, 0x78, 0x6E, 0x00, 0x00,
  0x79, 0xF8, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3E, 0xE0,
  0x00, 0x00, 0x7C, 0xE0, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0x61, 0xE0,
  0x00, 0x1D, 0xC3, 0xE0, 0x00, 0x7B, 0x83, 0xE0, 0x03, 0xE7, 0x03, 0xF0,
  0x3F, 0x0E, 0x01, 0xFF, 0xFC, 0x1C, 0x01, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xDF, 0xFF, 0xFC, 0x1E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70,
  0xF0, 0x60, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x81, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x01, 0xFC, 0x01, 0xC1, 0xC0,
  0x0F, 0xFE, 0x01, 0x83, 0x80, 0x3C, 0x3E, 0x03, 0x8E, 0x00, 0xE0, 0x1C,
  0x07, 0x1C, 0x03, 0x80, 0x38, 0x06, 0x30, 0x07, 0x00, 0x70, 0x0C, 0x60,
  0x1C, 0x00, 0xC0, 0x19, 0xC0, 0x30, 0x01, 0x80, 0x33, 0x80, 0xE0, 0x03,
  0x00, 0x66, 0x01, 0xC0, 0x06, 0x00, 0xCC, 0x03, 0x00, 0x0C, 0x01, 0xF8,
  0x06, 0x00, 0x18, 0x03, 0xF0, 0x1C, 0x00, 0x30, 0x07, 0xE0, 0x38, 0x00,
  0xE0, 0x0F, 0xC0, 0x70, 0x01, 0xC0, 0x1B, 0x80, 0xC0, 0x03, 0x80, 0x36,
  0x01, 0x80, 0x06, 0x00, 0x6C, 0x03, 0x00, 0x0C, 0x00, 0xD8, 0x06, 0x00,
  0x18, 0x01, 0xB8, 0x0C, 0x00, 0x30, 0x03, 0x70, 0x18, 0x00, 0xE0, 0x0E,
  0xE0, 0x30, 0x01, 0xC0, 0x19, 0xC0, 0x70, 0x07, 0x80, 0x33, 0x80, 0xE0,
  0x0F, 0x00, 0xE3, 0x00, 0xC0, 0x37, 0x01, 0x86, 0x01, 0xC0, 0xEE, 0x07,
  0x0E, 0x03, 0x83, 0x8C, 0x1C, 0x1C, 0x03, 0xFE, 0x1E, 0xF8, 0x38, 0x03,
  0xF8, 0x1F, 0xE0, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0x80, 0x03, 0xFC, 0x07, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x3F, 0x80, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0xFF, 0x03, 0x80,
  0x00, 0x1F, 0x87, 0x00, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEE, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x0E, 0x0F, 0x80, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x00, 0xE3, 0xDC,
  0x00, 0x00, 0x39, 0xE7, 0x80, 0x00, 0x0E, 0xF0, 0xF0, 0x00, 0x03, 0xF8,
  0x1E, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFB, 0x80, 0x00, 0x3B, 0xF7, 0x00, 0x00, 0x77, 0xE6, 0x00,
  0x00, 0xEF, 0xCE, 0x00, 0x03, 0x9F, 0x9C, 0x00, 0x07, 0x3F, 0x1C, 0x00,
  0x1C, 0x7E, 0x38, 0x00, 0x38, 0xFC, 0x70, 0x00, 0x71, 0xF8, 0x70, 0x01,
  0xC3, 0xF0, 0xE0, 0x03, 0x87, 0xE0, 0xC0, 0x0E, 0x0F, 0xC1, 0xC0, 0x1C,
  0x1F, 0x83, 0x80, 0x38, 0x3F, 0x03, 0x80, 0xE0, 0x7E, 0x07, 0x01, 0xC0,
  0xFC, 0x0E, 0x07, 0x01, 0xF8, 0x0E, 0x0E, 0x03, 0xF0, 0x1C, 0x1C, 0x07,
  0xE0, 0x38, 0x70, 0x0F, 0xC0, 0x38, 0xE0, 0x1F, 0x80, 0x73, 0x80, 0x3F,
  0x00, 0x77, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0xC0,
  0x07, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x03, 0xF7, 0x00, 0x00, 0x07,
  0xE7, 0x00, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x3F,
  0x1E, 0x00, 0x00, 0x7E, 0x1C, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x01, 0xF8,
  0x38, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0xC0,
  0x70, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x7E, 0x01,
  0xE0, 0x00, 0xFC, 0x01, 0xC0, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xF0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x07,
  0x00, 0x3F, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x1E,
  0x01, 0xF8, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x38,
  0x0F, 0xC0, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x70, 0x3F, 0x00, 0x00, 0x70,
  0x7E, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x01, 0xE3,
  0xF0, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x03, 0x9F,
  0x80, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0x00, 0xFE, 0x07, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00,
  0x1F, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x1F, 0x83, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0xE0,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0xC0, 0xE0,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x01, 0xE0, 0x00, 0x66, 0x00, 0x07, 0x80, 0x01, 0x9C, 0x00,
  0x1E, 0x00, 0x0E, 0x70, 0x00, 0x78, 0x00, 0x39, 0xC0, 0x03, 0xF0, 0x00,
  0xE7, 0x00, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0x3F, 0x00, 0x0E, 0x70, 0x00,
  0xFC, 0x00, 0x30, 0xC0, 0x03, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0xC0, 0x07,
  0x0E, 0x00, 0x73, 0x80, 0x1C, 0x38, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x07,
  0x38, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x07, 0x06, 0x00, 0x61, 0x80, 0x18,
  0x1C, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x0E, 0x1C, 0x03, 0x81, 0xC0, 0x38,
  0x70, 0x0E, 0x07, 0x00, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x03, 0x00, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x0C, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x18, 0x06, 0x07, 0x00,
  0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01,
  0xC1, 0x80, 0x18, 0x38, 0x07, 0x06, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x03,
  0x38, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x0E,
  0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x00,
  0xE0, 0xF8, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x7E, 0x78,
  0x00, 0x01, 0xDC, 0x78, 0x00, 0x0F, 0x38, 0xF8, 0x00, 0x3C, 0x70, 0xFC,
  0x07, 0xF0, 0xE0, 0x7F, 0xFF, 0x81, 0xC0, 0x7F, 0xFC, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x07, 0xFC, 0x00, 0xE0, 0xFF, 0xFC, 0x03, 0x87, 0xFF, 0xF8, 0x0E, 0x3C,
  0x01, 0xF8, 0x39, 0xC0, 0x01, 0xE0, 0xEE, 0x00, 0x03, 0xC3, 0xF0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0E, 0x3F,
  0x00, 0x00, 0x70, 0xEE, 0x00, 0x03, 0xC3, 0x9E, 0x00, 0x3E, 0x0E, 0x3F,
  0x03, 0xF0, 0x38, 0x7F, 0xFF, 0x80, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0xFC, 0x07, 0x00, 0xFF, 0xF8, 0x38, 0x1F, 0xFF, 0xF1, 0xC1, 0xF0,
  0x03, 0xCE, 0x1F, 0x00, 0x0F, 0x71, 0xE0, 0x00, 0x1F, 0x8E, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xF8, 0x3C, 0x00, 0x3D, 0xC0, 0xFC, 0x0F, 0xCE, 0x03, 0xFF,
  0xF8, 0x70, 0x07, 0xFF, 0x83, 0x80, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x04, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x38, 0x07, 0xFF, 0xC1, 0xC0, 0xFF, 0xFF, 0x8E, 0x0F, 0x80, 0x1E, 0x70,
  0xF8, 0x00, 0x7B, 0x87, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0xC1, 0xE0, 0x01, 0xEE, 0x07, 0xE0, 0x7E, 0x70, 0x1F, 0xFF, 0xE3, 0x80,
  0x3F, 0xFC, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x08, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0xE0, 0x3F, 0xFE, 0x07,
  0x07, 0xFF, 0xFC, 0x38, 0x78, 0x01, 0xF1, 0xC7, 0x00, 0x07, 0xCE, 0x70,
  0x00, 0x0E, 0x77, 0x00, 0x00, 0x7B, 0xB0, 0x00, 0x01, 0xDF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE3, 0xF0, 0x00,
  0x03, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x3F, 0x07, 0x80, 0x00,
  0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0xFE, 0x00, 0xFF, 0x07, 0x1F, 0xFC, 0x1F, 0xFC, 0x39, 0xFF, 0xF1, 0xFF,
  0xF1, 0xDC, 0x07, 0x9E, 0x03, 0xCF, 0x80, 0x1F, 0xC0, 0x0F, 0x7C, 0x00,
  0x7C, 0x00, 0x3B, 0xC0, 0x03, 0xE0, 0x01, 0xDE, 0x00, 0x0E, 0x00, 0x0E,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03,
  0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01,
  0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x0F, 0xF8, 0x07, 0x01,
  0xFF, 0xF0, 0x38, 0x3F, 0xFF, 0xE1, 0xC3, 0xC0, 0x0F, 0x8E, 0x38, 0x00,
  0x3E, 0x73, 0x80, 0x00, 0xF3, 0xB8, 0x00, 0x03, 0xDD, 0x80, 0x00, 0x0E,
  0xF8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x3F, 0xF0, 0x03, 0x83, 0xFF,
  0xF0, 0x0E, 0x1F, 0xFF, 0xE0, 0x39, 0xF0, 0x07, 0xC0, 0xEF, 0x00, 0x07,
  0x83, 0xB8, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x0E, 0x3E, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x01, 0xC3, 0xB8, 0x00,
  0x1F, 0x0E, 0xF0, 0x00, 0xF8, 0x38, 0xF8, 0x0F, 0xC0, 0xE1, 0xFF, 0xFC,
  0x03, 0x81, 0xFF, 0xE0, 0x0E, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x38, 0x07, 0xFF, 0xC1, 0xC0, 0xFF, 0xFF, 0x8E, 0x0F, 0x80, 0x1E, 0x70,
  0xF8, 0x00, 0x3B, 0x8F, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0xC1, 0xE0, 0x01, 0xEE, 0x07, 0xE0, 0x7E, 0x70, 0x1F, 0xFF, 0xE3, 0x80,
  0x3F, 0xFC, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE1, 0xF8, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0x80, 0x00,
  0xEE, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x08, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x3F, 0x3C,
  0x00, 0x01, 0xB8, 0xE0, 0x00, 0x39, 0xC7, 0xC0, 0x03, 0xCE, 0x1F, 0x80,
  0xFC, 0x70, 0x7F, 0xFF, 0x83, 0x80, 0xFF, 0xF0, 0x1C, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0xC0, 0x01,
  0xC6, 0x00, 0x0D, 0x80, 0x03, 0x8E, 0x00, 0x1B, 0x00, 0x06, 0x1C, 0x00,
  0x37, 0x00, 0x1C, 0x38, 0x00, 0xEE, 0x00, 0x38, 0x70, 0x01, 0xDC, 0x00,
  0x70, 0x70, 0x03, 0x18, 0x00, 0xC0, 0xE0, 0x06, 0x38, 0x03, 0x81, 0xC0,
  0x1C, 0x70, 0x07, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x03, 0x00, 0x60, 0xC0,
  0x1C, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0x1C,
  0x07, 0x07, 0x01, 0xC0, 0x38, 0x0C, 0x06, 0x03, 0x80, 0x30, 0x18, 0x0E,
  0x06, 0x00, 0x70, 0x70, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x01,
  0xC1, 0x80, 0x30, 0x70, 0x01, 0x83, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00,
  0xE1, 0x80, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x01, 0x8E, 0x00,
  0x0C, 0x60, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x07, 0x30, 0x00, 0x3B, 0x80,
  0x0E, 0x60, 0x00, 0x76, 0x00, 0x0D, 0xC0, 0x00, 0xEC, 0x00, 0x1B, 0x80,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x31, 0xFF, 0xF8, 0x00, 0x00, 0xC7, 0x81,
  0xF8, 0x00, 0x07, 0x38, 0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x03, 0xE0, 0x00,
  0x67, 0x00, 0x03, 0xC0, 0x03, 0x98, 0x00, 0x07, 0xC0, 0x1E, 0xE0, 0x00,
  0x0F, 0x80, 0xF3, 0x80, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 5, 50, 43, 18, -50 },
  { 33, 12, 15, 43, 15, -53 },
  { 56, 39, 50, 43, 2, -50 },
  { 300, 31, 65, 43, 6, -58 },
  { 552, 39, 52, 43, 2, -51 },
  { 806, 36, 52, 43, 5, -51 },
  { 1040, 3, 15, 43, 18, -53 },
  { 1046, 16, 72, 43, 14, -56 },
  { 1190, 16, 72, 43, 12, -56 },
  { 1334, 31, 29, 43, 7, -50 },
  { 1447, 35, 37, 43, 4, -42 },
  { 1609, 6, 16, 43, 14, -6 },
  { 1621, 25, 3, 43, 9, -24 },
  { 1631, 5, 5, 43, 20, -5 },
  { 1635, 24, 54, 43, 10, -50 },
  { 1797, 31, 52, 43, 6, -51 },
  { 1999, 17, 50, 43, 8, -50 },
  { 2106, 32, 51, 43, 4, -51 },
  { 2310, 32, 52, 43, 3, -51 },
  { 2518, 36, 50, 43, 3, -50 },
  { 2743, 29, 51, 43, 8, -50 },
  { 2928, 31, 52, 43, 5, -51 },
  { 3130, 32, 50, 43, 5, -50 },
  { 3330, 32, 52, 43, 6, -51 },
  { 3538, 31, 52, 43, 6, -51 },
  { 3740, 5, 35, 43, 22, -35 },
  { 3762, 8, 45, 43, 19, -35 },
  { 3807, 30, 28, 43, 6, -37 },
  { 3912, 31, 17, 43, 6, -31 },
  { 3978, 31, 28, 43, 6, -37 },
  { 4087, 27, 51, 43, 8, -51 },
  { 4260, 39, 51, 43, 2, -51 },
  { 4509, 36, 50, 43, 4, -50 },
  { 4734, 31, 50, 43, 7, -50 },
  { 4928, 33, 52, 43, 5, -51 },
  { 5143, 32, 50, 43, 7, -50 },
  { 5343, 30, 50, 43, 7, -50 },
  { 5531, 29, 50, 43, 8, -50 },
  { 5713, 34, 52, 43, 4, -51 },
  { 5934, 31, 50, 43, 6, -50 },
  { 6128, 29, 50, 43, 7, -50 },
  { 6310, 31, 51, 43, 4, -50 },
  { 6508, 34, 50, 43, 7, -50 },
  { 6721, 29, 50, 43, 8, -50 },
  { 6903, 31, 50, 43, 6, -50 },
  { 7097, 31, 50, 43, 6, -50 },
  { 7291, 33, 52, 43, 5, -51 },
  { 7506, 31, 50, 43, 8, -50 },
  { 7700, 35, 60, 43, 4, -51 },
  { 7963, 32, 50, 43, 7, -50 },
  { 8163, 33, 52, 43, 5, -51 },
  { 8378, 35, 50, 43, 4, -50 },
  { 8597, 31, 51, 43, 6, -50 },
  { 8795, 36, 50, 43, 3, -50 },
  { 9020, 38, 50, 43, 3, -50 },
  { 9258, 36, 50, 43, 4, -50 },
  { 9483, 36, 50, 43, 3, -50 },
  { 9708, 31, 50, 43, 5, -50 },
  { 9902, 11, 69, 43, 16, -58 },
  { 9997, 24, 54, 43, 9, -50 },
  { 10159, 11, 69, 43, 15, -58 },
  { 10254, 25, 27, 43, 9, -50 },
  { 10339, 30, 3, 43, 6, 0 },
  { 10351, 10, 9, 43, 16, -52 },
  { 10363, 31, 39, 43, 6, -38 },
  { 10515, 30, 54, 43, 7, -53 },
  { 10718, 30, 39, 43, 6, -38 },
  { 10865, 29, 54, 43, 6, -53 },
  { 11061, 32, 39, 43, 5, -38 },
  { 11217, 32, 54, 43, 7, -54 },
  { 11433, 29, 53, 43, 6, -38 },
  { 11626, 29, 53, 43, 7, -53 },
  { 11819, 30, 51, 43, 8, -51 },
  { 12011, 23, 66, 43, 6, -51 },
  { 12201, 30, 53, 43, 8, -53 },
  { 12400, 30, 53, 43, 8, -53 },
  { 12599, 37, 38, 43, 3, -38 },
  { 12775, 29, 38, 43, 7, -38 },
  { 12913, 33, 39, 43, 5, -38 },
  { 13074, 30, 52, 43, 7, -38 },
  { 13269, 29, 52, 43, 6, -38 },
  { 13458, 24, 38, 43, 13, -38 },
  { 13572, 30, 39, 43, 7, -38 },
  { 13719, 30, 48, 43, 6, -47 },
  { 13899, 29, 39, 43, 7, -38 },
  { 14041, 35, 38, 43, 4, -38 },
  { 14208, 39, 38, 43, 2, -38 },
  { 14394, 34, 38, 43, 5, -38 },
  { 14556, 37, 53, 43, 3, -38 },
  { 14802, 33, 38, 43, 5, -38 },
  { 14959, 22, 70, 43, 12, -55 },
  { 15152, 3, 60, 43, 20, -50 },
  { 15175, 22, 70, 43, 12, -55 },
  { 15368, 38, 12, 43, 2, -27 },
};

const GFXfont RobotoMono_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight71pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_EXTRALIGHT71PT7B_H_
