#ifndef _ROBOTOMONO_EXTRALIGHT27PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x80, 0x3C, 0x99, 0x99, 0x90, 0x02, 0x10, 0x04,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x0F, 0xFF, 0xC1, 0x08, 0x04, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x01, 0x84, 0x1F, 0xFF, 0x84,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x82, 0x00, 0x02, 0x00, 0x20,
  0x02, 0x01, 0xFC, 0x30, 0x66, 0x02, 0x40, 0x14, 0x01, 0x40, 0x02, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x1C, 0x01,
  0x40, 0x16, 0x03, 0x30, 0x61, 0xFC, 0x02, 0x00, 0x20, 0x02, 0x00, 0x78,
  0x01, 0x08, 0x02, 0x10, 0x84, 0x21, 0x08, 0x44, 0x10, 0x88, 0x23, 0x20,
  0x3C, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x40, 0x33, 0x60, 0x4C, 0x41,
  0x10, 0x82, 0x20, 0x88, 0x41, 0x10, 0x84, 0x00, 0x88, 0x01, 0xE0, 0x1F,
  0x00, 0xC2, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x03, 0x30, 0x05,
  0x00, 0x08, 0x00, 0xD0, 0x02, 0x60, 0x10, 0xC2, 0xC1, 0x0A, 0x02, 0x48,
  0x05, 0x20, 0x1C, 0xC0, 0x71, 0x83, 0x43, 0xF0, 0xC0, 0xF8, 0x04, 0x21,
  0x0C, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x08, 0x20, 0xC3, 0x0C, 0x10, 0xC3, 0x08, 0x20, 0x82, 0x18, 0x41,
  0x08, 0x21, 0x08, 0x00, 0x04, 0x00, 0x80, 0x10, 0x42, 0x1E, 0x4E, 0x3E,
  0x03, 0x80, 0xD8, 0x11, 0x04, 0x11, 0x83, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x6D, 0xA5, 0x00, 0xFF, 0xC0,
  0x5C, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08,
  0x00, 0x1F, 0x82, 0x04, 0x60, 0x24, 0x02, 0x40, 0x18, 0x03, 0x80, 0x58,
  0x09, 0x83, 0x18, 0x61, 0x8C, 0x19, 0x81, 0xB0, 0x1E, 0x01, 0x40, 0x14,
  0x02, 0x60, 0x23, 0x04, 0x1F, 0x80, 0x06, 0x7F, 0x9C, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x1F,
  0x81, 0x03, 0x10, 0x08, 0x80, 0x4C, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x1F, 0xFE, 0x1F, 0xC2, 0x06, 0x60, 0x24, 0x01,
  0x40, 0x10, 0x01, 0x00, 0x30, 0x06, 0x01, 0xC0, 0xF8, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x33, 0x06, 0x1F, 0xC0, 0x00,
  0x40, 0x03, 0x00, 0x1C, 0x00, 0x50, 0x02, 0x40, 0x19, 0x00, 0x44, 0x02,
  0x10, 0x18, 0x40, 0x41, 0x02, 0x04, 0x18, 0x10, 0x40, 0x43, 0xFF, 0xF0,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x7F, 0xE8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0xF8, 0x61, 0xC0, 0x08, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x03, 0x40, 0x4E, 0x18, 0x7E, 0x00,
  0x07, 0x81, 0xC0, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC6, 0x09, 0xFC,
  0xA0, 0x6C, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x02,
  0x60, 0x23, 0x04, 0x1F, 0x80, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x00, 0x1F, 0xC1,
  0x83, 0x18, 0x0C, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC4, 0x04, 0x19,
  0xC0, 0xFC, 0x08, 0x18, 0x80, 0x24, 0x01, 0x60, 0x0F, 0x00, 0x68, 0x02,
  0x40, 0x11, 0x83, 0x07, 0xF0, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0xC0,
  0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x53, 0x99, 0x0E,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x38, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xDA, 0x50, 0x00, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x0E, 0x00, 0x80, 0x00, 0x3F, 0x18, 0x2C, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x07, 0xE0, 0x60, 0x63, 0x00, 0x98, 0x01, 0x43,
  0xC5, 0x11, 0x18, 0x84, 0x62, 0x11, 0x88, 0x46, 0x21, 0x19, 0x04, 0x64,
  0x11, 0x88, 0xC6, 0x25, 0x28, 0xF7, 0x90, 0x00, 0x60, 0x00, 0xC0, 0x80,
  0xFC, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x11,
  0x00, 0x44, 0x02, 0x10, 0x08, 0x20, 0x20, 0x81, 0x02, 0x04, 0x04, 0x1F,
  0xF0, 0x80, 0x42, 0x01, 0x88, 0x02, 0x40, 0x09, 0x00, 0x3C, 0x00, 0x40,
  0xFF, 0x08, 0x08, 0x80, 0x48, 0x06, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C,
  0x83, 0x8F, 0xF8, 0x80, 0x48, 0x02, 0x80, 0x28, 0x03, 0x80, 0x28, 0x02,
  0x80, 0x68, 0x0C, 0xFF, 0x00, 0x1F, 0xC2, 0x06, 0x40, 0x24, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0xC0, 0x14, 0x01, 0x60, 0x23, 0x04, 0x1F, 0x80, 0xFF, 0x06,
  0x06, 0x30, 0x19, 0x80, 0x4C, 0x01, 0x60, 0x0B, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0B, 0x00, 0x58, 0x04,
  0xC0, 0x66, 0x0E, 0x3F, 0xC0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F,
  0xC2, 0x06, 0x40, 0x24, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x83, 0xF8, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x01, 0x60,
  0x13, 0x03, 0x1F, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xE1, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xFF, 0x80,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x4C,
  0x18, 0xFC, 0x00, 0x80, 0x34, 0x02, 0x20, 0x31, 0x03, 0x08, 0x30, 0x43,
  0x02, 0x10, 0x11, 0x00, 0x90, 0x05, 0x40, 0x31, 0x01, 0x0C, 0x08, 0x30,
  0x40, 0x82, 0x02, 0x10, 0x18, 0x80, 0x64, 0x01, 0x20, 0x06, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF,
  0x80, 0xC0, 0x3E, 0x03, 0xA0, 0x3A, 0x05, 0xB0, 0x59, 0x0D, 0x90, 0x98,
  0x89, 0x89, 0x18, 0x91, 0x86, 0x18, 0x61, 0x86, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01,
  0x90, 0x19, 0x81, 0x88, 0x18, 0xC1, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11,
  0x81, 0x18, 0x09, 0x80, 0xD8, 0x05, 0x80, 0x78, 0x03, 0x80, 0x10, 0x1F,
  0x82, 0x04, 0x40, 0x24, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x02, 0x60,
  0x23, 0x04, 0x1F, 0x80, 0xFF, 0x88, 0x0C, 0x80, 0x28, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x0C, 0xFF, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x40,
  0xC2, 0x01, 0x18, 0x02, 0x40, 0x09, 0x00, 0x34, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0x88,
  0x02, 0x30, 0x10, 0x60, 0x80, 0xFC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0xFF, 0x08, 0x0C, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06,
  0x80, 0x48, 0x18, 0xFE, 0x08, 0x30, 0x81, 0x08, 0x08, 0x80, 0x88, 0x04,
  0x80, 0x68, 0x02, 0x80, 0x30, 0x1F, 0xC1, 0x03, 0x10, 0x0C, 0x80, 0x2C,
  0x01, 0x20, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x00, 0x0E, 0x00, 0x78, 0x02, 0x40, 0x11, 0x83, 0x07, 0xF0,
  0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x23,
  0x04, 0x1F, 0x80, 0xC0, 0x0D, 0x00, 0x24, 0x00, 0x98, 0x06, 0x20, 0x10,
  0x80, 0x43, 0x03, 0x04, 0x08, 0x10, 0x20, 0x60, 0x80, 0x84, 0x02, 0x10,
  0x0C, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x81, 0x07, 0x82, 0x09, 0x0C, 0x12, 0x14, 0x24, 0x28, 0x48, 0x50,
  0x90, 0xA2, 0x22, 0x44, 0x24, 0x48, 0x48, 0x90, 0x91, 0x21, 0x22, 0x42,
  0x84, 0x85, 0x0E, 0x0A, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0xC0, 0x1A, 0x01, 0x98, 0x08, 0x40, 0xC1, 0x04, 0x0C, 0x40, 0x26,
  0x00, 0xA0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x1A, 0x00, 0x88, 0x08, 0x60,
  0xC1, 0x04, 0x04, 0x40, 0x36, 0x00, 0xA0, 0x06, 0xC0, 0x0D, 0x00, 0x22,
  0x01, 0x08, 0x04, 0x10, 0x20, 0x41, 0x80, 0x84, 0x02, 0x30, 0x04, 0x80,
  0x16, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F,
  0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x0C, 0x03, 0x00, 0xA0, 0x48, 0x13, 0x08, 0x42, 0x11, 0x82, 0x40,
  0xB0, 0x30, 0xFF, 0xF0, 0xC6, 0x21, 0x02, 0x01, 0xFC, 0x60, 0x64, 0x02,
  0x40, 0x30, 0x03, 0x00, 0x31, 0xFF, 0x20, 0x34, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x76, 0x0F, 0x3F, 0x10, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x08, 0x2F, 0xE6, 0x06, 0xC0, 0x50, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x58, 0x0B, 0x82, 0x4F, 0x80, 0x02, 0x01, 0xFC,
  0x20, 0x66, 0x02, 0x40, 0x1C, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x01, 0x60, 0x23, 0x06, 0x1F, 0x80, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x08, 0x47, 0xE9, 0x03, 0x40, 0x28, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x40, 0x2C, 0x04, 0xC1, 0x8F, 0xD0,
  0x02, 0x01, 0xFC, 0x20, 0x66, 0x02, 0x40, 0x1C, 0x01, 0x80, 0x1F, 0xFF,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x13, 0x02, 0x0F, 0xC0, 0x00,
  0xE0, 0x7B, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x0F, 0xFC, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x04, 0x03, 0xF4, 0x81, 0xA0,
  0x14, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xA0, 0x16,
  0x02, 0x60, 0xC7, 0xE8, 0x01, 0x00, 0x20, 0x05, 0x81, 0x18, 0xC0, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x0C, 0x27, 0xE5, 0x06, 0xC0,
  0x50, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x0C, 0xF8, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x14, 0x0C, 0x83,
  0x10, 0xC2, 0x30, 0x4C, 0x0B, 0x81, 0x98, 0x21, 0x84, 0x18, 0x81, 0x10,
  0x12, 0x01, 0x40, 0x10, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0x08, 0x22, 0xFB, 0xEC,
  0x30, 0x70, 0xC1, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06,
  0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x40, 0x04,
  0x13, 0xF2, 0x83, 0x60, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x06, 0x01, 0xF8, 0x20,
  0x64, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x03, 0x40, 0x23, 0x04, 0x1F, 0x80, 0x04, 0x17, 0xE3, 0x02, 0x40,
  0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x28,
  0x05, 0xC1, 0x2F, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x04,
  0x03, 0xF4, 0x81, 0xA0, 0x14, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0xA0, 0x16, 0x02, 0x60, 0xC7, 0xE8, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x03, 0x4F, 0xE8, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x04, 0x07, 0xF1, 0x01,
  0x40, 0x18, 0x03, 0x80, 0x18, 0x00, 0xF0, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x18, 0x02, 0x81, 0x8F, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF,
  0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x3F, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x34, 0x1E, 0x7E, 0xC0, 0xC0, 0x0D, 0x00, 0x22, 0x01, 0x08, 0x04, 0x10,
  0x30, 0x40, 0x81, 0x82, 0x02, 0x10, 0x08, 0x40, 0x12, 0x00, 0x48, 0x01,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x81, 0x06, 0x0C, 0x14, 0x30, 0x50, 0xA1,
  0x42, 0x89, 0x12, 0x26, 0x48, 0x89, 0x12, 0x24, 0x58, 0xA1, 0x42, 0x85,
  0x06, 0x0C, 0x10, 0x30, 0x40, 0x80, 0xC0, 0x33, 0x01, 0x0C, 0x10, 0x21,
  0x00, 0x98, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x0D, 0x00, 0xC4, 0x04, 0x10,
  0x40, 0xC4, 0x03, 0x60, 0x0C, 0xC0, 0x0D, 0x00, 0x26, 0x00, 0x88, 0x04,
  0x30, 0x10, 0x40, 0xC1, 0x82, 0x02, 0x18, 0x08, 0x40, 0x13, 0x00, 0x48,
  0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x01, 0x80, 0x1C, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x7F, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x03, 0x07, 0x00, 0x40, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x80, 0x20, 0xFF, 0xFF,
  0xFE, 0xC0, 0x18, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x30, 0x0C, 0x18, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x10, 0x30, 0x20, 0x00, 0x7C, 0x07, 0x08, 0x18,
  0x18, 0xE0, 0x3E,
};

const GFXglyph RobotoMono_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 19, 16, 7, -19 },
  { 6, 4, 5, 16, 6, -20 },
  { 9, 15, 19, 16, 1, -19 },
  { 45, 12, 25, 16, 2, -22 },
  { 83, 15, 19, 16, 1, -19 },
  { 119, 14, 19, 16, 2, -19 },
  { 153, 1, 5, 16, 7, -20 },
  { 154, 6, 27, 16, 5, -21 },
  { 175, 6, 27, 16, 5, -21 },
  { 196, 11, 11, 16, 3, -19 },
  { 212, 13, 14, 16, 2, -16 },
  { 235, 3, 6, 16, 5, -2 },
  { 238, 10, 1, 16, 3, -9 },
  { 240, 3, 2, 16, 7, -2 },
  { 241, 9, 21, 16, 4, -19 },
  { 265, 12, 19, 16, 2, -19 },
  { 294, 7, 19, 16, 3, -19 },
  { 311, 13, 19, 16, 1, -19 },
  { 342, 12, 19, 16, 1, -19 },
  { 371, 14, 19, 16, 1, -19 },
  { 405, 11, 19, 16, 3, -19 },
  { 432, 12, 19, 16, 2, -19 },
  { 461, 12, 19, 16, 2, -19 },
  { 490, 13, 19, 16, 2, -19 },
  { 521, 12, 19, 16, 2, -19 },
  { 550, 2, 14, 16, 8, -14 },
  { 554, 3, 18, 16, 7, -14 },
  { 561, 12, 11, 16, 2, -14 },
  { 578, 12, 6, 16, 2, -12 },
  { 587, 12, 11, 16, 2, -14 },
  { 604, 10, 19, 16, 3, -19 },
  { 628, 14, 19, 16, 1, -19 },
  { 662, 14, 19, 16, 1, -19 },
  { 696, 12, 19, 16, 3, -19 },
  { 725, 12, 19, 16, 2, -19 },
  { 754, 13, 19, 16, 2, -19 },
  { 785, 11, 19, 16, 3, -19 },
  { 812, 11, 19, 16, 3, -19 },
  { 839, 12, 19, 16, 2, -19 },
  { 868, 12, 19, 16, 2, -19 },
  { 897, 11, 19, 16, 3, -19 },
  { 924, 11, 19, 16, 2, -19 },
  { 951, 13, 19, 16, 3, -19 },
  { 982, 11, 19, 16, 3, -19 },
  { 1009, 12, 19, 16, 2, -19 },
  { 1038, 12, 19, 16, 2, -19 },
  { 1067, 12, 19, 16, 2, -19 },
  { 1096, 12, 19, 16, 3, -19 },
  { 1125, 14, 22, 16, 1, -19 },
  { 1164, 12, 19, 16, 3, -19 },
  { 1193, 13, 19, 16, 2, -19 },
  { 1224, 14, 19, 16, 1, -19 },
  { 1258, 12, 19, 16, 2, -19 },
  { 1287, 14, 19, 16, 1, -19 },
  { 1321, 15, 19, 16, 1, -19 },
  { 1357, 13, 19, 16, 2, -19 },
  { 1388, 14, 19, 16, 1, -19 },
  { 1422, 12, 19, 16, 2, -19 },
  { 1451, 4, 26, 16, 6, -22 },
  { 1464, 9, 21, 16, 4, -19 },
  { 1488, 4, 26, 16, 6, -22 },
  { 1501, 10, 10, 16, 3, -19 },
  { 1514, 12, 1, 16, 2, 0 },
  { 1516, 4, 4, 16, 6, -20 },
  { 1518, 12, 15, 16, 2, -15 },
  { 1541, 11, 20, 16, 3, -20 },
  { 1569, 12, 15, 16, 2, -15 },
  { 1592, 11, 20, 16, 2, -20 },
  { 1620, 12, 15, 16, 2, -15 },
  { 1643, 12, 21, 16, 3, -21 },
  { 1675, 11, 21, 16, 2, -15 },
  { 1704, 11, 20, 16, 3, -20 },
  { 1732, 11, 19, 16, 3, -19 },
  { 1759, 9, 25, 16, 2, -19 },
  { 1788, 11, 20, 16, 3, -20 },
  { 1816, 11, 20, 16, 3, -20 },
  { 1844, 14, 15, 16, 1, -15 },
  { 1871, 11, 15, 16, 3, -15 },
  { 1892, 12, 15, 16, 2, -15 },
  { 1915, 11, 20, 16, 3, -15 },
  { 1943, 11, 20, 16, 2, -15 },
  { 1971, 9, 15, 16, 5, -15 },
  { 1988, 11, 15, 16, 3, -15 },
  { 2009, 12, 18, 16, 2, -18 },
  { 2036, 11, 14, 16, 3, -14 },
  { 2056, 14, 14, 16, 1, -14 },
  { 2081, 14, 14, 16, 1, -14 },
  { 2106, 13, 14, 16, 2, -14 },
  { 2129, 14, 20, 16, 1, -14 },
  { 2164, 13, 14, 16, 2, -14 },
  { 2187, 9, 27, 16, 4, -21 },
  { 2218, 1, 23, 16, 8, -19 },
  { 2221, 9, 27, 16, 4, -21 },
  { 2252, 14, 4, 16, 1, -10 },
};

const GFXfont RobotoMono_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight27pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_EXTRALIGHT27PT7B_H_
