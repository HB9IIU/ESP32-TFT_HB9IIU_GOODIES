#ifndef _ROBOTOMONO_EXTRALIGHT30PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA8, 0x03, 0xC0, 0xCF, 0x3C, 0xE3, 0x8A, 0x28,
  0x80, 0x03, 0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06,
  0x08, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C,
  0x30, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x08, 0x20, 0x18, 0x20, 0x10,
  0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x02, 0x00, 0x10, 0x01, 0xC0,
  0x3F, 0x82, 0x06, 0x20, 0x19, 0x00, 0x58, 0x03, 0xC0, 0x1A, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0x20, 0x18, 0xC1, 0x83, 0xF8, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x10, 0x00, 0x6C, 0x00, 0x84, 0x00, 0x82, 0x08, 0x82,
  0x10, 0x82, 0x10, 0x82, 0x20, 0x86, 0x20, 0xC4, 0x40, 0x78, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x08, 0x02, 0x3E, 0x02, 0x21, 0x04, 0x41, 0x04,
  0x41, 0x08, 0x41, 0x08, 0x41, 0x10, 0x41, 0x00, 0x23, 0x00, 0x1E, 0x02,
  0x00, 0x1F, 0x00, 0x41, 0x01, 0x82, 0x02, 0x06, 0x04, 0x08, 0x0C, 0x10,
  0x08, 0x40, 0x19, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x30, 0x0C,
  0x20, 0xD0, 0x21, 0x60, 0x62, 0x80, 0x65, 0x80, 0x73, 0x00, 0x62, 0x01,
  0xC3, 0x06, 0x43, 0xF0, 0xC0, 0xFE, 0x04, 0x30, 0x84, 0x30, 0x86, 0x10,
  0x43, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10,
  0x60, 0x83, 0x04, 0x08, 0x30, 0x40, 0x80, 0x80, 0x81, 0x81, 0x01, 0x02,
  0x06, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x02, 0x04, 0x18, 0x30,
  0x40, 0x81, 0x06, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x1E, 0x23, 0x9F, 0xF0, 0x08, 0x00, 0xA0, 0x09,
  0x80, 0xC6, 0x0C, 0x18, 0x40, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x6D, 0xA5,
  0xA0, 0xFF, 0xC0, 0xFC, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x7F,
  0x83, 0x03, 0x08, 0x04, 0x60, 0x19, 0x00, 0x24, 0x01, 0x90, 0x0F, 0xC0,
  0x6F, 0x03, 0x3C, 0x18, 0xF0, 0xC3, 0xC6, 0x0F, 0x30, 0x3D, 0x80, 0xDC,
  0x03, 0x60, 0x09, 0x00, 0x26, 0x01, 0x88, 0x04, 0x18, 0x20, 0x3F, 0x00,
  0x07, 0x1F, 0x73, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x01, 0xFE,
  0x18, 0x19, 0x80, 0x48, 0x03, 0x40, 0x0A, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xFC, 0x03, 0x80, 0x7F,
  0x83, 0x03, 0x08, 0x06, 0x40, 0x09, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x1E, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0xC0, 0x0D, 0x00, 0x34, 0x00, 0x98, 0x06, 0x38, 0x30, 0x3F, 0x80,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x13, 0x00, 0x66, 0x00,
  0x8C, 0x02, 0x18, 0x0C, 0x30, 0x10, 0x60, 0x40, 0xC1, 0x81, 0x82, 0x03,
  0x08, 0x06, 0x3F, 0xFF, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x40, 0x5F, 0xC3, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x78, 0x03, 0xC0, 0x1A, 0x00, 0x98, 0x0C, 0x70,
  0xC1, 0xFC, 0x00, 0x00, 0x20, 0x1F, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x47, 0xC6, 0xC3, 0x38, 0x0D, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x58, 0x06, 0x40, 0x21,
  0x86, 0x07, 0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x02, 0x01, 0xFE, 0x18, 0x18, 0x80, 0x6C, 0x01,
  0x40, 0x0E, 0x00, 0x78, 0x02, 0x40, 0x13, 0x01, 0x07, 0xF0, 0x3F, 0x86,
  0x02, 0x60, 0x0A, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x80,
  0x26, 0x06, 0x0F, 0xE0, 0x03, 0x00, 0xFE, 0x0C, 0x0C, 0xC0, 0x24, 0x01,
  0xA0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x50, 0x02, 0xC0, 0x32,
  0x03, 0x8C, 0x34, 0x3E, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00,
  0x06, 0xDB, 0x4A, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x30,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x0C, 0x00, 0x03, 0x01, 0xFC, 0x20, 0x64, 0x02,
  0x40, 0x3C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x07, 0xF8, 0x0C, 0x0C, 0x10, 0x06, 0x20, 0x02, 0x61,
  0xE3, 0x42, 0x31, 0x44, 0x11, 0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88,
  0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x61, 0x88, 0x62, 0x85, 0xB6, 0x43,
  0x18, 0x40, 0x00, 0x20, 0x00, 0x18, 0x10, 0x0F, 0xE0, 0x03, 0x00, 0x06,
  0x00, 0x0A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x98, 0x03, 0x10, 0x04, 0x20,
  0x08, 0x60, 0x30, 0x40, 0x40, 0x80, 0x81, 0x83, 0x01, 0x04, 0x02, 0x0F,
  0xFE, 0x30, 0x04, 0x40, 0x08, 0x80, 0x1B, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x60, 0xFF, 0x84, 0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x06, 0x80, 0x67, 0xFE, 0x3F, 0xF1, 0x00, 0x68, 0x01, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0D, 0x00, 0xCF, 0xF8, 0x00,
  0x03, 0x80, 0x7F, 0x83, 0x03, 0x08, 0x06, 0x40, 0x09, 0x00, 0x3C, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x01, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0x88, 0x06, 0x18,
  0x30, 0x3F, 0x00, 0xFF, 0x04, 0x06, 0x20, 0x19, 0x00, 0x68, 0x01, 0x40,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x14, 0x01, 0xA0, 0x19, 0x03, 0x8F,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFE, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x7F,
  0x83, 0x03, 0x08, 0x06, 0x40, 0x09, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFE, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x05, 0x00, 0x16, 0x00, 0x4C, 0x03, 0x18, 0x18, 0x3F, 0x80,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0C, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x03, 0x80,
  0x1E, 0x00, 0x90, 0x0C, 0x60, 0xC1, 0xF8, 0x00, 0x80, 0x1E, 0x00, 0xC8,
  0x06, 0x20, 0x10, 0x80, 0x82, 0x04, 0x08, 0x30, 0x21, 0x80, 0x8C, 0x02,
  0x60, 0x0B, 0x40, 0x39, 0x80, 0xC3, 0x02, 0x06, 0x08, 0x08, 0x20, 0x30,
  0x80, 0x62, 0x00, 0xC8, 0x01, 0x20, 0x02, 0x80, 0x0C, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0xC0, 0x1E, 0x01, 0xF0,
  0x0B, 0xC0, 0xDA, 0x04, 0xD0, 0x26, 0x43, 0x32, 0x11, 0x98, 0x8C, 0x48,
  0x62, 0x43, 0x1E, 0x38, 0x61, 0xC3, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xF4, 0x03, 0xD0, 0x0F, 0x20, 0x3C, 0xC0, 0xF1, 0x03, 0xC6, 0x0F, 0x08,
  0x3C, 0x30, 0xF0, 0x43, 0xC0, 0x8F, 0x02, 0x3C, 0x04, 0xF0, 0x1B, 0xC0,
  0x2F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0C, 0x03, 0x00, 0x7F, 0x83,
  0x03, 0x08, 0x04, 0x40, 0x09, 0x00, 0x2C, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x03,
  0xC0, 0x0D, 0x00, 0x26, 0x01, 0x88, 0x04, 0x18, 0x60, 0x3F, 0x00, 0xFF,
  0xC3, 0x00, 0xCC, 0x01, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xB0,
  0x02, 0xC0, 0x0B, 0x00, 0x4C, 0x07, 0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x05, 0x00, 0x34, 0x00, 0x88, 0x04, 0x18,
  0x30, 0x3F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0xFF, 0x84,
  0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80,
  0x14, 0x01, 0x20, 0x31, 0xFF, 0x08, 0x18, 0x40, 0x42, 0x01, 0x10, 0x0C,
  0x80, 0x24, 0x01, 0xA0, 0x05, 0x00, 0x38, 0x00, 0x80, 0x01, 0x00, 0x7F,
  0x83, 0x01, 0x18, 0x02, 0x40, 0x0D, 0x00, 0x14, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x58, 0x02, 0x30, 0x38, 0x3F, 0x80,
  0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x02, 0x40, 0x09, 0x80, 0x62,
  0x01, 0x06, 0x18, 0x0F, 0xC0, 0xC0, 0x02, 0x80, 0x05, 0x80, 0x19, 0x00,
  0x22, 0x00, 0x46, 0x01, 0x84, 0x02, 0x08, 0x04, 0x18, 0x18, 0x10, 0x20,
  0x20, 0x40, 0x61, 0x80, 0x42, 0x00, 0x84, 0x01, 0x18, 0x01, 0x20, 0x02,
  0x40, 0x05, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x81, 0x41,
  0x81, 0x41, 0x81, 0x41, 0xC3, 0x41, 0x43, 0x41, 0x42, 0x63, 0x42, 0x62,
  0x42, 0x22, 0x62, 0x22, 0x22, 0x22, 0x26, 0x26, 0x24, 0x24, 0x24, 0x34,
  0x34, 0x14, 0x14, 0x14, 0x14, 0x1C, 0x14, 0x18, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x08, 0xC0, 0x06, 0xC0, 0x10, 0x80, 0x61, 0x80, 0x81, 0x03,
  0x01, 0x0C, 0x03, 0x10, 0x02, 0x60, 0x06, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x4C, 0x01, 0x88, 0x02, 0x18, 0x0C, 0x10, 0x10, 0x10, 0x40,
  0x31, 0x80, 0x22, 0x00, 0x6C, 0x00, 0x60, 0xC0, 0x06, 0xC0, 0x08, 0x80,
  0x31, 0x80, 0x41, 0x01, 0x83, 0x02, 0x02, 0x0C, 0x06, 0x10, 0x04, 0x60,
  0x0C, 0x80, 0x0B, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xFF,
  0xF8, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0xFF, 0x80, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x43, 0xFF, 0x80, 0x0C, 0x03, 0x01, 0xE0, 0x48, 0x33, 0x08,
  0x42, 0x11, 0x86, 0x40, 0xB0, 0x38, 0x04, 0xFF, 0xF0, 0xC6, 0x21, 0x1F,
  0x83, 0x83, 0x10, 0x09, 0x00, 0x68, 0x01, 0x00, 0x08, 0x00, 0x43, 0xFE,
  0x70, 0x16, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x03, 0x40, 0x3B, 0x03, 0x47,
  0xE3, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x11, 0xF0, 0xB0, 0xC7, 0x01, 0x30, 0x0D, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x70, 0x03, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x80, 0x6C, 0x02, 0x58,
  0x32, 0x7E, 0x00, 0x0F, 0xC0, 0xC3, 0x8C, 0x04, 0xC0, 0x14, 0x00, 0xA0,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x16, 0x00,
  0x90, 0x0C, 0x60, 0xC1, 0xFC, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x21, 0xF1, 0x18, 0x69, 0x01, 0xD8, 0x06, 0x80,
  0x14, 0x00, 0xA0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02,
  0xC0, 0x32, 0x01, 0x88, 0x34, 0x3F, 0x20, 0x0F, 0xC0, 0x61, 0xC3, 0x01,
  0x18, 0x02, 0x40, 0x09, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x21, 0x81, 0x83, 0xF8, 0x00,
  0xF8, 0x1C, 0x41, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x1F, 0xFE,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x0F, 0x88, 0xC3, 0x48, 0x0E, 0xC0, 0x34, 0x00, 0xA0, 0x05, 0x00,
  0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x16, 0x01, 0x90, 0x0C,
  0x41, 0xA1, 0xF9, 0x00, 0x08, 0x00, 0xC0, 0x04, 0xC0, 0x63, 0x06, 0x07,
  0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0xFC, 0x98, 0x6A, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0F, 0xFF, 0x80, 0x01,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x81, 0x9F, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x06, 0xC0, 0x66, 0x06, 0x30,
  0x61, 0x86, 0x0C, 0x60, 0x64, 0x03, 0x70, 0x1C, 0xC0, 0xC2, 0x06, 0x08,
  0x30, 0x61, 0x81, 0x8C, 0x06, 0x60, 0x1B, 0x00, 0x60, 0xFE, 0x07, 0xF0,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x9E,
  0x3C, 0xA3, 0x42, 0xC1, 0x83, 0xC1, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x8F, 0xC9, 0x86, 0xA0, 0x3C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0x61, 0x82, 0x01,
  0x10, 0x06, 0x40, 0x0B, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0xD0, 0x02, 0x40, 0x08, 0x80, 0x43, 0x03, 0x03, 0xF0, 0x8F,
  0x85, 0x86, 0x38, 0x19, 0x80, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x1C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x03, 0x60, 0x12, 0x83, 0x13,
  0xF0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0F,
  0x88, 0xC3, 0x48, 0x0E, 0xC0, 0x34, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x01,
  0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x16, 0x01, 0x90, 0x0C, 0x41, 0xA1,
  0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0xC7,
  0xFB, 0x83, 0xC0, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x1F, 0xC1, 0x83,
  0x10, 0x0D, 0x80, 0x2C, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x04, 0x00, 0x38, 0x01, 0xE0, 0x09, 0x81, 0xC3, 0xF8, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x3F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x34, 0x03, 0x60, 0xD3, 0xF9, 0x80, 0x07, 0x00, 0x34, 0x00, 0x90, 0x02,
  0x60, 0x10, 0x80, 0x43, 0x03, 0x04, 0x08, 0x18, 0x60, 0x21, 0x00, 0x84,
  0x03, 0x20, 0x04, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x80, 0x81, 0xC1,
  0x81, 0x41, 0x83, 0x41, 0x82, 0x41, 0x42, 0x42, 0x42, 0x62, 0x42, 0x22,
  0x46, 0x22, 0x24, 0x24, 0x24, 0x34, 0x24, 0x14, 0x24, 0x14, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xC0, 0x0D, 0x80, 0x63, 0x01, 0x06, 0x08,
  0x08, 0x60, 0x13, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x1A, 0x00, 0xCC,
  0x02, 0x18, 0x10, 0x30, 0xC0, 0x46, 0x00, 0xB0, 0x03, 0xC0, 0x03, 0x40,
  0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x08,
  0x10, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x3F, 0xFF, 0x01, 0x80, 0x80,
  0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x0C, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x1C,
  0x08, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x80, 0xC0, 0x00, 0x7E, 0x01, 0x43, 0x01, 0x80, 0x82,
  0x80, 0x7E, 0x00, 0x18,
};

const GFXglyph RobotoMono_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 2, 21, 18, 8, -21 },
  { 7, 6, 7, 18, 6, -23 },
  { 13, 16, 21, 18, 1, -21 },
  { 55, 13, 27, 18, 3, -24 },
  { 99, 16, 22, 18, 1, -22 },
  { 143, 15, 22, 18, 2, -22 },
  { 185, 1, 7, 18, 8, -23 },
  { 186, 6, 31, 18, 6, -24 },
  { 210, 7, 31, 18, 5, -24 },
  { 238, 13, 12, 18, 3, -21 },
  { 258, 14, 16, 18, 2, -18 },
  { 286, 3, 7, 18, 6, -3 },
  { 289, 10, 1, 18, 4, -10 },
  { 291, 3, 2, 18, 8, -2 },
  { 292, 10, 23, 18, 4, -21 },
  { 321, 14, 22, 18, 2, -22 },
  { 360, 8, 21, 18, 3, -21 },
  { 381, 13, 22, 18, 2, -22 },
  { 417, 14, 22, 18, 1, -22 },
  { 456, 15, 21, 18, 1, -21 },
  { 496, 13, 21, 18, 3, -21 },
  { 531, 13, 22, 18, 2, -22 },
  { 567, 14, 21, 18, 2, -21 },
  { 604, 13, 22, 18, 3, -22 },
  { 640, 13, 22, 18, 2, -22 },
  { 676, 2, 15, 18, 9, -15 },
  { 680, 3, 19, 18, 8, -15 },
  { 688, 13, 12, 18, 2, -16 },
  { 708, 13, 7, 18, 3, -13 },
  { 720, 12, 12, 18, 3, -16 },
  { 738, 12, 22, 18, 3, -22 },
  { 771, 16, 21, 18, 1, -21 },
  { 813, 15, 21, 18, 2, -21 },
  { 853, 13, 21, 18, 3, -21 },
  { 888, 14, 22, 18, 2, -22 },
  { 927, 13, 21, 18, 3, -21 },
  { 962, 12, 21, 18, 3, -21 },
  { 994, 13, 21, 18, 3, -21 },
  { 1029, 14, 22, 18, 2, -22 },
  { 1068, 14, 21, 18, 2, -21 },
  { 1105, 12, 21, 18, 3, -21 },
  { 1137, 13, 21, 18, 2, -21 },
  { 1172, 14, 21, 18, 3, -21 },
  { 1209, 13, 21, 18, 3, -21 },
  { 1244, 13, 21, 18, 3, -21 },
  { 1279, 14, 21, 18, 2, -21 },
  { 1316, 14, 22, 18, 2, -22 },
  { 1355, 14, 21, 18, 3, -21 },
  { 1392, 14, 26, 18, 2, -22 },
  { 1438, 13, 21, 18, 3, -21 },
  { 1473, 14, 22, 18, 2, -22 },
  { 1512, 15, 21, 18, 2, -21 },
  { 1552, 14, 21, 18, 2, -21 },
  { 1589, 15, 21, 18, 1, -21 },
  { 1629, 16, 21, 18, 1, -21 },
  { 1671, 15, 21, 18, 2, -21 },
  { 1711, 15, 21, 18, 1, -21 },
  { 1751, 13, 21, 18, 2, -21 },
  { 1786, 5, 29, 18, 7, -24 },
  { 1805, 10, 23, 18, 4, -21 },
  { 1834, 5, 29, 18, 6, -24 },
  { 1853, 10, 11, 18, 4, -21 },
  { 1867, 12, 1, 18, 3, 0 },
  { 1869, 4, 4, 18, 7, -22 },
  { 1871, 13, 16, 18, 3, -16 },
  { 1897, 13, 23, 18, 3, -23 },
  { 1935, 13, 16, 18, 2, -16 },
  { 1961, 13, 23, 18, 2, -23 },
  { 1999, 14, 16, 18, 2, -16 },
  { 2027, 13, 23, 18, 3, -23 },
  { 2065, 13, 22, 18, 2, -16 },
  { 2101, 12, 23, 18, 3, -23 },
  { 2136, 13, 21, 18, 3, -21 },
  { 2171, 9, 28, 18, 3, -22 },
  { 2203, 13, 23, 18, 3, -23 },
  { 2241, 13, 23, 18, 3, -23 },
  { 2279, 16, 16, 18, 1, -16 },
  { 2311, 12, 16, 18, 3, -16 },
  { 2335, 14, 16, 18, 2, -16 },
  { 2363, 13, 22, 18, 3, -16 },
  { 2399, 13, 22, 18, 2, -16 },
  { 2435, 11, 16, 18, 5, -16 },
  { 2457, 13, 16, 18, 3, -16 },
  { 2483, 12, 20, 18, 3, -20 },
  { 2513, 12, 16, 18, 3, -16 },
  { 2537, 14, 16, 18, 2, -16 },
  { 2565, 16, 16, 18, 1, -16 },
  { 2597, 14, 16, 18, 2, -16 },
  { 2625, 16, 22, 18, 1, -16 },
  { 2669, 14, 16, 18, 2, -16 },
  { 2697, 10, 29, 18, 5, -23 },
  { 2734, 2, 25, 18, 8, -21 },
  { 2741, 10, 29, 18, 5, -23 },
  { 2778, 16, 5, 18, 1, -11 },
};

const GFXfont RobotoMono_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight30pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_EXTRALIGHT30PT7B_H_
