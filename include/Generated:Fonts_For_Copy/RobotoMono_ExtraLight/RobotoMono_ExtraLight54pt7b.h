#ifndef _ROBOTOMONO_EXTRALIGHT54PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x02, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xE0, 0xF0, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x70, 0xE0, 0x00,
  0x71, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCE, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xB8, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0x60, 0x08,
  0x0C, 0x01, 0x80, 0x70, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03,
  0x00, 0x60, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x06, 0x06, 0x00, 0x60,
  0x18, 0x30, 0x01, 0x80, 0xC0, 0xC0, 0x07, 0x03, 0x06, 0x00, 0x0E, 0x38,
  0x38, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x7C, 0x00, 0x03, 0x03, 0xFC, 0x00, 0x0C, 0x18, 0x38,
  0x00, 0x60, 0xC0, 0x60, 0x03, 0x83, 0x00, 0xC0, 0x0C, 0x18, 0x03, 0x00,
  0x70, 0x60, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x18, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x30, 0x03,
  0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x19,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x18, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x31, 0xC0, 0x70, 0x06, 0x70, 0x06, 0x01, 0xCC, 0x00, 0xE0, 0x3B,
  0x80, 0x0E, 0x06, 0x70, 0x00, 0xE0, 0xCC, 0x00, 0x0E, 0x39, 0x80, 0x00,
  0xC6, 0x30, 0x00, 0x1D, 0xC6, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x1E, 0x0C,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0xFC, 0x1C, 0x00, 0x3B, 0x81, 0xC0, 0x1E,
  0x38, 0x1F, 0xFF, 0x83, 0x80, 0xFF, 0xC0, 0x38, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x10, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x02, 0x70, 0x18, 0x0E,
  0xFC, 0x18, 0x7F, 0x1F, 0x99, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC3, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x04, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x33, 0x33, 0x33, 0x37, 0x66, 0xCC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x6F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x60,
  0x00, 0x1F, 0xE0, 0x00, 0x33, 0xE0, 0x00, 0x63, 0xE0, 0x00, 0xC3, 0xE0,
  0x01, 0x83, 0xE0, 0x03, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x38, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0xE0, 0x03, 0xE1, 0xC0, 0x03, 0xE3,
  0x80, 0x03, 0xE7, 0x00, 0x03, 0xEE, 0x00, 0x03, 0x7C, 0x00, 0x03, 0x78,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x07, 0xC0, 0xFE, 0x1F, 0x37, 0xE1, 0xF8, 0x0F, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x83, 0xE0, 0x1C, 0x00,
  0xF0, 0x38, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x60, 0x00,
  0x1C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00,
  0x70, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x07, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7E, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x80,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xF0, 0x03, 0xC0,
  0xF8, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0xFF, 0x80, 0x63, 0xFF, 0xC0,
  0xE7, 0x80, 0xF0, 0xEE, 0x00, 0x78, 0xD8, 0x00, 0x18, 0xF0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38,
  0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xC3, 0xE0, 0x1E, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1E,
  0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x83, 0xE0, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x30,
  0x00, 0x0B, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x77, 0x0F, 0x00, 0xE6, 0x07,
  0xFF, 0xC6, 0x01, 0xFF, 0x06, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x73, 0xFE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F,
  0xDC, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x87, 0x0C, 0x18, 0x61, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xF0, 0x78, 0x03,
  0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0xE0, 0x38, 0x60, 0x1F, 0xC0, 0x61, 0x80,
  0xE3, 0xC1, 0x8C, 0x06, 0x03, 0x06, 0x30, 0x38, 0x0C, 0x08, 0xC0, 0xC0,
  0x20, 0x36, 0x06, 0x00, 0x80, 0xD8, 0x18, 0x06, 0x03, 0x60, 0x60, 0x18,
  0x0D, 0x81, 0x00, 0x60, 0x36, 0x0C, 0x01, 0x80, 0xD0, 0x30, 0x06, 0x03,
  0x40, 0xC0, 0x18, 0x0D, 0x03, 0x00, 0x60, 0x34, 0x0C, 0x01, 0x80, 0x90,
  0x30, 0x0C, 0x02, 0x40, 0xC0, 0x30, 0x19, 0x83, 0x00, 0xC0, 0x66, 0x0C,
  0x07, 0x01, 0x18, 0x18, 0x36, 0x0C, 0x60, 0x61, 0xD8, 0x61, 0x81, 0xFE,
  0x3F, 0x83, 0x03, 0xF0, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x80,
  0x03, 0xC0, 0x0E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x07,
  0x00, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x06,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0E, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x7C,
  0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x38, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x30, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xC0, 0x03, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xC0, 0x01, 0xE0, 0xC0, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x0F, 0x60, 0x00, 0x0E,
  0x30, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x03, 0x00, 0x07, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x03, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x63,
  0xC0, 0x00, 0x33, 0xF0, 0x00, 0x1B, 0x9C, 0x00, 0x0F, 0x87, 0x00, 0x07,
  0x81, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x1C,
  0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0xFB, 0x00, 0x06, 0xF6, 0x00, 0x1D, 0xEE, 0x00,
  0x33, 0xCC, 0x00, 0x67, 0x98, 0x01, 0xCF, 0x18, 0x03, 0x1E, 0x30, 0x06,
  0x3C, 0x70, 0x18, 0x78, 0x60, 0x30, 0xF0, 0xC0, 0xE1, 0xE1, 0xC1, 0x83,
  0xC1, 0x83, 0x07, 0x83, 0x0C, 0x0F, 0x03, 0x18, 0x1E, 0x06, 0x70, 0x3C,
  0x0C, 0xC0, 0x78, 0x0D, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x60, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7B, 0x00, 0x00, 0xF7, 0x00, 0x01,
  0xE6, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x8C, 0x00, 0x0F, 0x1C, 0x00, 0x1E,
  0x18, 0x00, 0x3C, 0x18, 0x00, 0x78, 0x30, 0x00, 0xF0, 0x30, 0x01, 0xE0,
  0x70, 0x03, 0xC0, 0x60, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xC0, 0x1E, 0x01,
  0xC0, 0x3C, 0x01, 0x80, 0x78, 0x01, 0x80, 0xF0, 0x03, 0x01, 0xE0, 0x03,
  0x03, 0xC0, 0x07, 0x07, 0x80, 0x06, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0C,
  0x3C, 0x00, 0x1C, 0x78, 0x00, 0x18, 0xF0, 0x00, 0x19, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x37, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x78, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x21,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x03, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x07, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xF8,
  0x7C, 0x01, 0xC0, 0x07, 0x81, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0xF0, 0x03, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x1C,
  0x1E, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x07, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x38,
  0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x1B, 0x00, 0x38, 0x00, 0xD8, 0x01, 0xC0, 0x0E, 0xC0,
  0x0F, 0x00, 0x66, 0x00, 0x78, 0x03, 0x30, 0x03, 0xC0, 0x19, 0xC0, 0x36,
  0x00, 0xC6, 0x01, 0xB0, 0x06, 0x30, 0x0D, 0x80, 0x31, 0x80, 0x66, 0x03,
  0x8C, 0x03, 0x30, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x01, 0x8C, 0x06, 0x1C,
  0x0C, 0x60, 0x30, 0x60, 0x61, 0x81, 0x83, 0x03, 0x0C, 0x0C, 0x18, 0x38,
  0x60, 0xC0, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x38, 0x60, 0xE1,
  0x80, 0xC3, 0x03, 0x0C, 0x06, 0x38, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x01,
  0x8C, 0x06, 0x30, 0x0C, 0x60, 0x39, 0x80, 0x63, 0x00, 0xCC, 0x03, 0xB8,
  0x06, 0x60, 0x0D, 0x80, 0x33, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x60, 0x0F,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0xF0, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x18,
  0x00, 0x30, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x60, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x38, 0x00, 0x06, 0x03,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x70, 0x01, 0xC6, 0x00, 0x30,
  0xC0, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x38, 0x0E, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x1C, 0x70, 0x01, 0x8C, 0x00,
  0x3B, 0x80, 0x03, 0x60, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x7C, 0x07, 0x81, 0xE0, 0x03, 0x83, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x18, 0x00, 0x07, 0x70, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0x00, 0x06, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0x60, 0x00, 0x1E, 0xE0, 0x00, 0x7C, 0xE0, 0x01, 0xD9, 0xE0, 0x0F,
  0x30, 0xFF, 0xF8, 0x70, 0xFF, 0xC0, 0xE0, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0xFC, 0x03, 0x1F, 0xFC,
  0x0C, 0xF0, 0x7C, 0x37, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0x80, 0x01, 0xCE,
  0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB8, 0x00,
  0x0C, 0xF0, 0x00, 0x73, 0xE0, 0x03, 0x8D, 0xC0, 0x3C, 0x33, 0xFF, 0xE0,
  0xC3, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x07, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x78, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x0F,
  0xE0, 0x60, 0x7F, 0xF0, 0xC1, 0xE0, 0x79, 0x87, 0x00, 0x3B, 0x1C, 0x00,
  0x36, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x0C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xE1, 0xC0,
  0x06, 0xC3, 0xC0, 0x39, 0x83, 0xFF, 0xE3, 0x01, 0xFF, 0x06, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0xF0, 0x0F, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x3C, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFE,
  0x06, 0x07, 0xFF, 0x0C, 0x1E, 0x07, 0x98, 0x70, 0x03, 0xB1, 0xC0, 0x03,
  0x67, 0x00, 0x03, 0xCE, 0x00, 0x03, 0x98, 0x00, 0x07, 0x70, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x1C, 0x00,
  0x6C, 0x3C, 0x03, 0x98, 0x1F, 0xFE, 0x30, 0x1F, 0xF0, 0x60, 0x02, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x71, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xE0, 0x1C, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x7F, 0x83, 0x87, 0xFF, 0x8E, 0x3C, 0x1F, 0x39, 0x80,
  0x1E, 0xEC, 0x00, 0x3B, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0xF0, 0xFF, 0xF0, 0x7F,
  0xE0, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x3C, 0x70,
  0x00, 0xF0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x71, 0xE0,
  0x00, 0xE7, 0x80, 0x01, 0xDF, 0x00, 0x03, 0xF7, 0x00, 0x07, 0xC7, 0x00,
  0x0F, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC3, 0xF0, 0x1F, 0x8C, 0xFF, 0x87, 0xFC, 0xDC, 0x1C, 0xE0, 0xED, 0x00,
  0xF8, 0x06, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xE0, 0x06, 0x00,
  0x3E, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0xE0, 0x7F, 0x03, 0x87, 0xFF, 0x0E,
  0x3C, 0x1F, 0x39, 0x80, 0x1E, 0xEC, 0x00, 0x3B, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0C, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x7C, 0x01,
  0xC0, 0x0F, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03,
  0xC0, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0xFE, 0x01, 0xC7, 0xFF, 0x03, 0x9C, 0x0F, 0x87, 0x60, 0x07, 0x8F,
  0x80, 0x07, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x39,
  0xF0, 0x00, 0xE3, 0xB8, 0x07, 0x87, 0x3F, 0xFE, 0x0E, 0x1F, 0xF0, 0x1C,
  0x02, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x06, 0x07, 0xFF,
  0x0C, 0x1E, 0x07, 0x98, 0x70, 0x03, 0xB1, 0xC0, 0x03, 0x63, 0x00, 0x03,
  0xCE, 0x00, 0x03, 0x98, 0x00, 0x07, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x6C, 0x3C, 0x03,
  0x98, 0x3F, 0xFE, 0x30, 0x1F, 0xF0, 0x60, 0x02, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x7F, 0xFC, 0x3F, 0x07, 0x1C, 0x00, 0xCC,
  0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0xCE, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xB0, 0x00, 0x07, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x38, 0x78,
  0x01, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x30,
  0x00, 0x3C, 0xE0, 0x01, 0xB1, 0xC0, 0x1C, 0xC3, 0xFF, 0xE3, 0x07, 0xFE,
  0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x70, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x07, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF8, 0x01,
  0xC0, 0x0E, 0xC0, 0x0E, 0x00, 0x66, 0x00, 0x70, 0x03, 0x30, 0x06, 0xC0,
  0x19, 0x80, 0x36, 0x01, 0xCE, 0x01, 0xB0, 0x0C, 0x30, 0x09, 0x80, 0x61,
  0x80, 0xC6, 0x03, 0x0C, 0x06, 0x30, 0x18, 0x60, 0x31, 0x81, 0x81, 0x81,
  0x0C, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x0C,
  0x18, 0x1C, 0x20, 0x61, 0x80, 0x63, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x60,
  0x18, 0xC0, 0x63, 0x00, 0xC4, 0x03, 0x30, 0x03, 0x60, 0x0D, 0x80, 0x1B,
  0x00, 0x6C, 0x00, 0xD8, 0x03, 0x60, 0x06, 0x80, 0x1B, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x00,
  0x01, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x39, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x1C,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xCF, 0xFE, 0x00, 0x06,
  0xE0, 0x78, 0x00, 0x66, 0x00, 0xE0, 0x03, 0x60, 0x03, 0x80, 0x3B, 0x00,
  0x0F, 0x03, 0x98, 0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x20, 0x00,
};

const GFXglyph RobotoMono_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 4, 38, 32, 14, -38 },
  { 20, 10, 12, 32, 11, -41 },
  { 35, 29, 38, 32, 2, -38 },
  { 173, 23, 49, 32, 5, -44 },
  { 314, 30, 40, 32, 1, -39 },
  { 464, 27, 40, 32, 4, -39 },
  { 599, 2, 12, 32, 14, -41 },
  { 602, 12, 55, 32, 10, -43 },
  { 685, 12, 55, 32, 9, -43 },
  { 768, 24, 22, 32, 5, -38 },
  { 834, 26, 28, 32, 3, -32 },
  { 925, 4, 12, 32, 11, -5 },
  { 931, 19, 2, 32, 7, -18 },
  { 936, 4, 4, 32, 15, -4 },
  { 938, 18, 41, 32, 8, -38 },
  { 1031, 24, 40, 32, 4, -39 },
  { 1151, 13, 38, 32, 6, -38 },
  { 1213, 24, 39, 32, 3, -39 },
  { 1330, 24, 40, 32, 3, -39 },
  { 1450, 27, 38, 32, 2, -38 },
  { 1579, 23, 39, 32, 6, -38 },
  { 1692, 24, 40, 32, 4, -39 },
  { 1812, 25, 38, 32, 3, -38 },
  { 1931, 24, 40, 32, 5, -39 },
  { 2051, 24, 39, 32, 4, -39 },
  { 2168, 5, 27, 32, 16, -27 },
  { 2185, 7, 34, 32, 14, -27 },
  { 2215, 23, 22, 32, 4, -28 },
  { 2279, 23, 13, 32, 5, -24 },
  { 2317, 23, 21, 32, 5, -28 },
  { 2378, 21, 39, 32, 6, -39 },
  { 2481, 30, 39, 32, 1, -39 },
  { 2628, 27, 38, 32, 3, -38 },
  { 2757, 24, 38, 32, 5, -38 },
  { 2871, 25, 40, 32, 4, -39 },
  { 2996, 24, 38, 32, 5, -38 },
  { 3110, 22, 38, 32, 6, -38 },
  { 3215, 22, 38, 32, 6, -38 },
  { 3320, 26, 40, 32, 3, -39 },
  { 3450, 24, 38, 32, 4, -38 },
  { 3564, 22, 38, 32, 5, -38 },
  { 3669, 24, 39, 32, 3, -38 },
  { 3786, 25, 38, 32, 6, -38 },
  { 3905, 22, 38, 32, 6, -38 },
  { 4010, 23, 38, 32, 5, -38 },
  { 4120, 23, 38, 32, 5, -38 },
  { 4230, 26, 40, 32, 3, -39 },
  { 4360, 24, 38, 32, 6, -38 },
  { 4474, 27, 46, 32, 3, -39 },
  { 4630, 24, 38, 32, 6, -38 },
  { 4744, 25, 40, 32, 4, -39 },
  { 4869, 27, 38, 32, 3, -38 },
  { 4998, 24, 39, 32, 4, -38 },
  { 5115, 27, 38, 32, 3, -38 },
  { 5244, 29, 38, 32, 2, -38 },
  { 5382, 27, 38, 32, 3, -38 },
  { 5511, 27, 38, 32, 2, -38 },
  { 5640, 24, 38, 32, 4, -38 },
  { 5754, 9, 52, 32, 12, -44 },
  { 5813, 18, 41, 32, 7, -38 },
  { 5906, 8, 52, 32, 12, -44 },
  { 5958, 19, 20, 32, 7, -38 },
  { 6006, 23, 2, 32, 5, 0 },
  { 6012, 8, 7, 32, 12, -40 },
  { 6019, 23, 30, 32, 5, -29 },
  { 6106, 22, 42, 32, 6, -41 },
  { 6222, 24, 30, 32, 4, -29 },
  { 6312, 23, 42, 32, 4, -41 },
  { 6433, 24, 30, 32, 4, -29 },
  { 6523, 24, 41, 32, 5, -41 },
  { 6646, 23, 40, 32, 4, -29 },
  { 6761, 22, 41, 32, 5, -41 },
  { 6874, 23, 39, 32, 6, -39 },
  { 6987, 17, 51, 32, 5, -39 },
  { 7096, 23, 41, 32, 6, -41 },
  { 7214, 23, 41, 32, 6, -41 },
  { 7332, 28, 29, 32, 2, -29 },
  { 7434, 22, 29, 32, 5, -29 },
  { 7514, 25, 30, 32, 4, -29 },
  { 7608, 23, 40, 32, 5, -29 },
  { 7723, 23, 40, 32, 4, -29 },
  { 7838, 18, 29, 32, 10, -29 },
  { 7904, 23, 30, 32, 5, -29 },
  { 7991, 22, 37, 32, 5, -36 },
  { 8093, 22, 30, 32, 5, -29 },
  { 8176, 26, 29, 32, 3, -29 },
  { 8271, 29, 29, 32, 2, -29 },
  { 8377, 25, 29, 32, 4, -29 },
  { 8468, 28, 41, 32, 2, -29 },
  { 8612, 25, 29, 32, 4, -29 },
  { 8703, 17, 53, 32, 9, -42 },
  { 8816, 2, 46, 32, 15, -38 },
  { 8828, 17, 53, 32, 9, -42 },
  { 8941, 29, 10, 32, 2, -21 },
};

const GFXfont RobotoMono_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight54pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_EXTRALIGHT54PT7B_H_
