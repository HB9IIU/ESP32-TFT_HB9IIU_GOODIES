#ifndef _ROBOTOMONO_EXTRALIGHT64PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06,
  0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x60, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x78, 0x01, 0xF0, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38,
  0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x03,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x38, 0x06, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x06, 0x00, 0x70, 0x38, 0x00,
  0x60, 0x06, 0x03, 0x00, 0x07, 0x00, 0x60, 0x70, 0x00, 0x30, 0x0E, 0x06,
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x1F, 0xF8, 0x0C, 0x00, 0x00, 0xFF,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00,
  0x18, 0x0F, 0xF8, 0x00, 0x03, 0x81, 0xC3, 0xC0, 0x00, 0x30, 0x38, 0x0C,
  0x00, 0x07, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x60, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x70, 0x01, 0xC0, 0x60, 0x07, 0x00, 0x18, 0x06, 0x00, 0x70, 0x03,
  0x80, 0xE0, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x0C, 0x38, 0x03, 0x80, 0x0C, 0x38, 0x03, 0xC0,
  0x0C, 0x70, 0x01, 0xE0, 0x1C, 0x60, 0x00, 0xE0, 0x1C, 0xE0, 0x00, 0x70,
  0x1C, 0xE0, 0x00, 0x38, 0x18, 0xC0, 0x00, 0x1C, 0x38, 0xC0, 0x00, 0x1E,
  0x38, 0xC0, 0x00, 0x0E, 0x70, 0xE0, 0x00, 0x07, 0x70, 0xE0, 0x00, 0x03,
  0xE0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0xE0, 0x38, 0x00, 0x07, 0x70, 0x3C, 0x00, 0x1E, 0x38, 0x1F, 0x80, 0x7C,
  0x1C, 0x07, 0xFF, 0xF0, 0x1E, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xBE, 0x00, 0x04, 0x00, 0x18, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x08, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x06, 0xFC, 0x06, 0x03, 0xF7, 0xF8, 0x61, 0xFE,
  0x0F, 0xF6, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0xC0, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x70, 0x02, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x33, 0x9D, 0xCC, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x67, 0xBF, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xF6, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x77, 0xE0, 0x00, 0x0E, 0x7E, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x38, 0x3E,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0xE0, 0x3E, 0x00, 0x1C, 0x03, 0xE0, 0x03,
  0x80, 0x3E, 0x00, 0x70, 0x03, 0xE0, 0x0E, 0x00, 0x3E, 0x01, 0xC0, 0x03,
  0xE0, 0x38, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x7E, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x03, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xF7,
  0x0F, 0xC7, 0x7E, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0xC7,
  0xFF, 0xC0, 0x1B, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x78, 0x00, 0x7C,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x1F, 0xC0,
  0x06, 0x0F, 0xFF, 0x80, 0xE1, 0xFF, 0xFC, 0x0E, 0x7C, 0x01, 0xE0, 0xEF,
  0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x38, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00,
  0x37, 0x1E, 0x00, 0x0F, 0x70, 0xF8, 0x01, 0xE7, 0x07, 0xE0, 0xF8, 0x60,
  0x1F, 0xFF, 0x06, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x33,
  0xFE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x67, 0xFD, 0xEF, 0x0C, 0x3C, 0xF9, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x61, 0xC3, 0x8E, 0x1C, 0x70, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xF8, 0xFE, 0x03, 0xE0, 0x07, 0x81, 0xC0, 0x01, 0xE1,
  0xC0, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x70, 0x70, 0x03, 0xF8, 0x06, 0x0C, 0x01, 0xFF, 0x80,
  0xE3, 0x80, 0x78, 0x38, 0x1C, 0x60, 0x1C, 0x03, 0x01, 0x8C, 0x03, 0x00,
  0x60, 0x33, 0x80, 0xC0, 0x0C, 0x06, 0x60, 0x18, 0x03, 0x00, 0xCC, 0x06,
  0x00, 0x60, 0x19, 0x80, 0xC0, 0x0C, 0x03, 0x70, 0x18, 0x01, 0x80, 0x7C,
  0x07, 0x00, 0x30, 0x0F, 0x80, 0xC0, 0x06, 0x01, 0xF0, 0x18, 0x00, 0xC0,
  0x3E, 0x03, 0x00, 0x18, 0x06, 0xC0, 0x60, 0x03, 0x00, 0xD8, 0x0C, 0x00,
  0xE0, 0x1B, 0x01, 0x80, 0x1C, 0x03, 0x60, 0x30, 0x03, 0x00, 0x6C, 0x06,
  0x00, 0x60, 0x0D, 0x80, 0xC0, 0x1C, 0x03, 0x30, 0x18, 0x03, 0x80, 0x66,
  0x03, 0x00, 0xF8, 0x0C, 0xE0, 0x70, 0x3B, 0x03, 0x0C, 0x06, 0x0E, 0x60,
  0xE1, 0x80, 0xF7, 0x8E, 0x38, 0x38, 0x0F, 0xE0, 0xFE, 0x07, 0x00, 0xF8,
  0x0F, 0x80, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x1C, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x0E, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1F, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xC0, 0x03, 0xF0, 0x0E, 0x00, 0x07, 0xC0,
  0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x3E, 0x01, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x01, 0xE0, 0x0C,
  0x00, 0x0F, 0x00, 0x30, 0x00, 0x78, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x1C,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x30, 0x3C, 0x00,
  0x00, 0xC1, 0xE0, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x0C, 0x7F, 0x00, 0x00,
  0x33, 0xDE, 0x00, 0x00, 0xCE, 0x38, 0x00, 0x03, 0x70, 0x70, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x7B, 0x00,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xD8, 0x00, 0x07, 0x7D, 0xC0, 0x00, 0x77, 0xDC, 0x00, 0x06, 0x7C, 0xC0,
  0x00, 0xE7, 0xCE, 0x00, 0x0E, 0x7C, 0x60, 0x00, 0xC7, 0xC7, 0x00, 0x1C,
  0x7C, 0x70, 0x01, 0x87, 0xC3, 0x00, 0x38, 0x7C, 0x38, 0x03, 0x87, 0xC3,
  0x80, 0x30, 0x7C, 0x18, 0x07, 0x07, 0xC1, 0xC0, 0x60, 0x7C, 0x0C, 0x0E,
  0x07, 0xC0, 0xE0, 0xE0, 0x7C, 0x0E, 0x0C, 0x07, 0xC0, 0x61, 0xC0, 0x7C,
  0x07, 0x18, 0x07, 0xC0, 0x73, 0x80, 0x7C, 0x03, 0x38, 0x07, 0xC0, 0x3B,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x07,
  0xE6, 0x00, 0x00, 0x7E, 0x70, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x7E, 0x38,
  0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x1C, 0x00, 0x07, 0xE0, 0xE0, 0x00,
  0x7E, 0x0E, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x7E, 0x03, 0x00, 0x07, 0xE0,
  0x38, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0xE0, 0x1C, 0x00, 0x7E, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E,
  0x00, 0x38, 0x07, 0xE0, 0x01, 0x80, 0x7E, 0x00, 0x1C, 0x07, 0xE0, 0x00,
  0xE0, 0x7E, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x70, 0x7E, 0x00, 0x07, 0x07,
  0xE0, 0x00, 0x38, 0x7E, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x1C, 0x7E, 0x00,
  0x00, 0xC7, 0xE0, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x07,
  0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF0, 0xE0, 0x01,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x0F, 0xC0, 0xC0,
  0x00, 0x3E, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x8C, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x07, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x1C, 0x00, 0x1B, 0x80, 0x07, 0x80, 0x06, 0xE0, 0x01, 0xE0,
  0x01, 0x98, 0x00, 0x78, 0x00, 0x66, 0x00, 0x3E, 0x00, 0x39, 0x80, 0x0F,
  0x80, 0x0E, 0x70, 0x03, 0x70, 0x03, 0x9C, 0x00, 0xDC, 0x00, 0xC7, 0x00,
  0x33, 0x00, 0x31, 0xC0, 0x1C, 0xC0, 0x0C, 0x30, 0x07, 0x30, 0x07, 0x0C,
  0x01, 0xCE, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x70, 0xE0, 0x18, 0x60, 0x18,
  0x38, 0x06, 0x18, 0x06, 0x0E, 0x03, 0x86, 0x01, 0x81, 0x80, 0xE1, 0xC0,
  0x60, 0x60, 0x30, 0x70, 0x38, 0x18, 0x0C, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x03, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0x70, 0x70, 0x38, 0x30, 0x1C, 0x18,
  0x0E, 0x0C, 0x03, 0x06, 0x03, 0x83, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x30,
  0xE0, 0x18, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x03, 0x8C, 0x01, 0xC6, 0x00,
  0xE3, 0x00, 0x71, 0x80, 0x38, 0xC0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x18,
  0x01, 0x9C, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x0E,
  0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00,
  0x1B, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x18, 0x00, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x38, 0x00,
  0xC0, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x07, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFC,
  0x00, 0x38, 0xF8, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x7C, 0xE0, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0x71, 0xF0, 0x0F,
  0x87, 0x1F, 0xFF, 0xE0, 0xE0, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x0F, 0xFC,
  0x03, 0x0F, 0xFF, 0xC0, 0xC7, 0xC0, 0xF8, 0x33, 0x80, 0x0F, 0x0D, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x78, 0xDE,
  0x00, 0x3C, 0x33, 0xE0, 0x3E, 0x0C, 0x3F, 0xFF, 0x03, 0x03, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x06, 0x38,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x38, 0x0F, 0xFF,
  0x87, 0x07, 0xE0, 0x7C, 0xE1, 0xF0, 0x03, 0xDC, 0x38, 0x00, 0x1B, 0x8E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xF0,
  0xF0, 0x00, 0xEE, 0x0F, 0x80, 0x79, 0xC0, 0x7F, 0xFE, 0x38, 0x07, 0xFF,
  0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xE0, 0x3F, 0xFE, 0x1C, 0x0F, 0x81, 0xF3, 0x83, 0xC0, 0x0F, 0x70,
  0xE0, 0x00, 0x7E, 0x38, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3E,
  0x1C, 0x00, 0x0F, 0xC3, 0xC0, 0x03, 0xB8, 0x3E, 0x01, 0xE7, 0x01, 0xFF,
  0xF8, 0xE0, 0x1F, 0xFC, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x10, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x07,
  0x80, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x0F, 0xFC, 0x07, 0x07, 0xFF, 0xE0, 0xE1, 0xF0,
  0x3E, 0x1C, 0x70, 0x01, 0xE3, 0x9C, 0x00, 0x1E, 0x77, 0x00, 0x01, 0xCE,
  0xC0, 0x00, 0x1D, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x0E,
  0x00, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x78,
  0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x3B, 0xFC, 0x00,
  0x07, 0xF3, 0xC0, 0x00, 0xFC, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x1C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF8, 0x67, 0xFF, 0x0F, 0xFE,
  0x37, 0x83, 0xCF, 0x07, 0x9B, 0x00, 0xFE, 0x00, 0xEF, 0x00, 0x3E, 0x00,
  0x77, 0x00, 0x1E, 0x00, 0x1B, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C,
  0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x01,
  0x80, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x60, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0,
  0x00, 0xC0, 0x01, 0xF0, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x7C,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F,
  0x80, 0x03, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0xE0, 0x3F, 0xF0, 0x38, 0x3F, 0xFF, 0x0E, 0x1F, 0x03, 0xE3, 0x8E,
  0x00, 0x3C, 0xE7, 0x00, 0x07, 0xBB, 0x80, 0x00, 0xEE, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x7F, 0xE0, 0x1C, 0x3F, 0xFF, 0x03, 0x8F,
  0x03, 0xF0, 0x73, 0x80, 0x0F, 0x0E, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x0E,
  0x3E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0x78,
  0x00, 0x01, 0xCF, 0x80, 0x00, 0x71, 0xF8, 0x00, 0x1E, 0x3B, 0x80, 0x07,
  0x87, 0x3C, 0x03, 0xE0, 0xE3, 0xFF, 0xF8, 0x1C, 0x1F, 0xFC, 0x03, 0x80,
  0x18, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xE0, 0x3F,
  0xFE, 0x1C, 0x1F, 0x81, 0xF3, 0x87, 0xC0, 0x0F, 0x70, 0xE0, 0x00, 0x7E,
  0x38, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3E, 0x1C, 0x00, 0x0F,
  0xC3, 0xC0, 0x03, 0xB8, 0x3E, 0x01, 0xE7, 0x01, 0xFF, 0xF8, 0xE0, 0x1F,
  0xFC, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xEC, 0x1F, 0x80, 0xB0, 0xF0, 0x00, 0xE7, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x8F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xF1, 0xE0, 0x01, 0xDC, 0x3E,
  0x03, 0xE7, 0x07, 0xFF, 0xF1, 0xC0, 0x7F, 0xF0, 0x30, 0x01, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x19, 0x80, 0x03, 0x80, 0x03, 0x38, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x1F,
  0x00, 0x1C, 0xE0, 0x03, 0x60, 0x03, 0x8C, 0x00, 0x6C, 0x00, 0x61, 0x80,
  0x0D, 0x80, 0x0C, 0x38, 0x03, 0xB8, 0x03, 0x87, 0x00, 0x67, 0x00, 0x70,
  0x60, 0x0C, 0x60, 0x0C, 0x0C, 0x01, 0x8C, 0x01, 0x81, 0xC0, 0x71, 0xC0,
  0x70, 0x38, 0x0C, 0x38, 0x0E, 0x07, 0x01, 0x83, 0x01, 0x80, 0x60, 0x30,
  0x60, 0x30, 0x0C, 0x0E, 0x0E, 0x06, 0x01, 0xC1, 0x81, 0xC1, 0xC0, 0x38,
  0x30, 0x18, 0x38, 0x03, 0x06, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x70, 0xC0,
  0x0C, 0x30, 0x06, 0x38, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0x38, 0xC0, 0x18,
  0xC0, 0x03, 0x38, 0x03, 0x98, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x06, 0xE0, 0x01, 0xD8, 0x00, 0xDC, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x87,
  0xFF, 0x80, 0x00, 0x33, 0xE1, 0xF0, 0x00, 0x0C, 0xE0, 0x1E, 0x00, 0x07,
  0x70, 0x01, 0xE0, 0x01, 0xD8, 0x00, 0x3C, 0x00, 0xEE, 0x00, 0x07, 0x80,
  0x3B, 0x80, 0x00, 0xF8, 0x3C, 0xC0, 0x00, 0x0F, 0xFE, 0x30, 0x00, 0x01,
  0xFF, 0x00,
};

const GFXglyph RobotoMono_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 4, 46, 38, 17, -46 },
  { 24, 12, 13, 38, 13, -48 },
  { 44, 35, 46, 38, 2, -46 },
  { 246, 28, 59, 38, 6, -52 },
  { 453, 36, 47, 38, 1, -46 },
  { 665, 32, 47, 38, 5, -46 },
  { 853, 3, 13, 38, 16, -48 },
  { 858, 15, 66, 38, 12, -51 },
  { 982, 14, 66, 38, 11, -51 },
  { 1098, 28, 27, 38, 6, -46 },
  { 1193, 31, 33, 38, 4, -38 },
  { 1321, 5, 14, 38, 13, -5 },
  { 1330, 23, 3, 38, 8, -22 },
  { 1339, 5, 5, 38, 18, -5 },
  { 1343, 22, 50, 38, 9, -46 },
  { 1481, 28, 47, 38, 5, -46 },
  { 1646, 16, 46, 38, 7, -46 },
  { 1738, 29, 46, 38, 3, -46 },
  { 1905, 28, 47, 38, 3, -46 },
  { 2070, 32, 46, 38, 3, -46 },
  { 2254, 27, 47, 38, 7, -46 },
  { 2413, 28, 47, 38, 5, -46 },
  { 2578, 30, 46, 38, 4, -46 },
  { 2751, 29, 47, 38, 6, -46 },
  { 2922, 28, 46, 38, 5, -46 },
  { 3083, 5, 32, 38, 19, -32 },
  { 3103, 7, 41, 38, 17, -32 },
  { 3139, 27, 26, 38, 5, -34 },
  { 3227, 28, 15, 38, 5, -28 },
  { 3280, 27, 26, 38, 6, -34 },
  { 3368, 25, 46, 38, 7, -46 },
  { 3512, 35, 46, 38, 2, -46 },
  { 3714, 33, 46, 38, 3, -46 },
  { 3904, 28, 46, 38, 6, -46 },
  { 4065, 30, 47, 38, 4, -46 },
  { 4242, 29, 46, 38, 6, -46 },
  { 4409, 26, 46, 38, 7, -46 },
  { 4559, 26, 46, 38, 7, -46 },
  { 4709, 30, 47, 38, 4, -46 },
  { 4886, 28, 46, 38, 5, -46 },
  { 5047, 26, 46, 38, 6, -46 },
  { 5197, 28, 47, 38, 4, -46 },
  { 5362, 30, 46, 38, 7, -46 },
  { 5535, 27, 46, 38, 7, -46 },
  { 5691, 28, 46, 38, 6, -46 },
  { 5852, 28, 46, 38, 5, -46 },
  { 6013, 30, 47, 38, 4, -46 },
  { 6190, 28, 46, 38, 7, -46 },
  { 6351, 31, 54, 38, 4, -46 },
  { 6561, 28, 46, 38, 7, -46 },
  { 6722, 30, 47, 38, 5, -46 },
  { 6899, 32, 46, 38, 3, -46 },
  { 7083, 28, 47, 38, 5, -46 },
  { 7248, 32, 46, 38, 3, -46 },
  { 7432, 34, 46, 38, 3, -46 },
  { 7628, 32, 46, 38, 4, -46 },
  { 7812, 32, 46, 38, 3, -46 },
  { 7996, 29, 46, 38, 4, -46 },
  { 8163, 10, 62, 38, 15, -52 },
  { 8241, 22, 50, 38, 8, -46 },
  { 8379, 10, 62, 38, 14, -52 },
  { 8457, 23, 25, 38, 8, -46 },
  { 8529, 27, 2, 38, 6, 0 },
  { 8536, 9, 8, 38, 15, -47 },
  { 8545, 27, 35, 38, 6, -34 },
  { 8664, 26, 49, 38, 7, -48 },
  { 8824, 28, 35, 38, 5, -34 },
  { 8947, 27, 49, 38, 5, -48 },
  { 9113, 29, 35, 38, 5, -34 },
  { 9240, 29, 49, 38, 6, -49 },
  { 9418, 27, 48, 38, 5, -34 },
  { 9580, 27, 48, 38, 6, -48 },
  { 9742, 27, 46, 38, 7, -46 },
  { 9898, 20, 60, 38, 6, -46 },
  { 10048, 27, 48, 38, 7, -48 },
  { 10210, 27, 48, 38, 7, -48 },
  { 10372, 33, 34, 38, 3, -34 },
  { 10513, 26, 34, 38, 6, -34 },
  { 10624, 30, 35, 38, 4, -34 },
  { 10756, 27, 47, 38, 6, -34 },
  { 10915, 27, 47, 38, 5, -34 },
  { 11074, 22, 34, 38, 12, -34 },
  { 11168, 27, 35, 38, 6, -34 },
  { 11287, 26, 44, 38, 6, -43 },
  { 11430, 26, 35, 38, 6, -34 },
  { 11544, 32, 34, 38, 3, -34 },
  { 11680, 35, 34, 38, 2, -34 },
  { 11829, 31, 34, 38, 4, -34 },
  { 11961, 34, 48, 38, 2, -34 },
  { 12165, 31, 34, 38, 4, -34 },
  { 12297, 21, 63, 38, 10, -50 },
  { 12463, 2, 55, 38, 18, -46 },
  { 12477, 21, 63, 38, 10, -50 },
  { 12643, 34, 10, 38, 2, -24 },
};

const GFXfont RobotoMono_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight64pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_EXTRALIGHT64PT7B_H_
