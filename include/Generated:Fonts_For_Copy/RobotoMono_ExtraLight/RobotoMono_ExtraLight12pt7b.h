#ifndef _ROBOTOMONO_EXTRALIGHT12PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0x80, 0x14, 0x28, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x48, 0x23, 0xA3, 0x18, 0x38, 0x21, 0x8A, 0xC8, 0x41, 0x4A, 0xA5, 0x45,
  0x02, 0x8A, 0x95, 0x0E, 0x21, 0x49, 0x18, 0x42, 0x99, 0x62, 0x74, 0xE0,
  0x25, 0x29, 0x24, 0x91, 0x22, 0x89, 0x12, 0x49, 0x25, 0x28, 0x21, 0x3E,
  0x45, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x80, 0xE0, 0xF8, 0x80, 0x11, 0x22,
  0x44, 0x48, 0x88, 0x74, 0x63, 0x3A, 0xE6, 0x31, 0x70, 0x3C, 0x92, 0x49,
  0x20, 0x74, 0x62, 0x11, 0x11, 0x08, 0xF8, 0x74, 0x62, 0x17, 0x04, 0x31,
  0xF0, 0x10, 0x43, 0x14, 0x52, 0x4F, 0xC4, 0x10, 0x7A, 0x11, 0x6C, 0x84,
  0x31, 0x78, 0x32, 0x21, 0xE8, 0xC6, 0x31, 0x70, 0xF8, 0x42, 0x21, 0x10,
  0x84, 0x40, 0x74, 0x63, 0x17, 0x46, 0x31, 0x78, 0x74, 0x63, 0x18, 0xAC,
  0xA1, 0x70, 0x84, 0x40, 0x1A, 0x1B, 0x30, 0x60, 0x80, 0xF8, 0x3E, 0xE0,
  0x86, 0xC8, 0x00, 0x74, 0x42, 0x11, 0x10, 0x80, 0x20, 0x18, 0xC9, 0x6D,
  0x5A, 0xB5, 0x6E, 0xA2, 0x38, 0x20, 0x83, 0x14, 0x51, 0x2F, 0xA2, 0x84,
  0xF4, 0x63, 0x1F, 0x46, 0x31, 0xF0, 0x74, 0x63, 0x08, 0x42, 0x31, 0x70,
  0xE2, 0x68, 0xA1, 0x86, 0x18, 0x62, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10,
  0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x74, 0x63, 0x08, 0x4E, 0x31,
  0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0xF8, 0x08, 0x42, 0x10, 0x84, 0x31, 0xF0, 0x86, 0x29, 0x28, 0xC2, 0x89,
  0x22, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x8C, 0x63, 0xBD, 0xD6,
  0x31, 0x88, 0x8C, 0x73, 0x9A, 0xCE, 0x71, 0x88, 0x74, 0x63, 0x18, 0xC6,
  0x31, 0x70, 0xF2, 0x28, 0x61, 0x8B, 0xC8, 0x20, 0x80, 0x72, 0x28, 0x61,
  0x86, 0x18, 0x62, 0x70, 0x20, 0x40, 0xF2, 0x28, 0xA2, 0x8B, 0xC9, 0x22,
  0x84, 0x74, 0x63, 0x07, 0x04, 0x31, 0x78, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x86, 0x28, 0xA2, 0x49,
  0x45, 0x08, 0x20, 0xA6, 0x9A, 0x6D, 0xD7, 0x6D, 0x92, 0x48, 0x86, 0x24,
  0x94, 0x20, 0xC5, 0x22, 0x84, 0x82, 0x89, 0x11, 0x42, 0x82, 0x04, 0x08,
  0x10, 0xF8, 0x44, 0x22, 0x21, 0x10, 0xF8, 0xEA, 0xAA, 0xAB, 0x88, 0x88,
  0x44, 0x22, 0x21, 0xFF, 0xF0, 0x21, 0x14, 0xA8, 0x80, 0xF8, 0xC0, 0xF8,
  0x5F, 0x18, 0xFC, 0x84, 0x2D, 0x98, 0xC6, 0x31, 0xF0, 0x7C, 0x61, 0x08,
  0xB8, 0x08, 0x4B, 0xB8, 0xC6, 0x31, 0x78, 0x7C, 0x7F, 0x08, 0x3C, 0x3C,
  0x8F, 0x88, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x63, 0x18, 0xBC, 0x31, 0x70,
  0x84, 0x2D, 0x98, 0xC6, 0x31, 0x88, 0x20, 0x30, 0x42, 0x10, 0x84, 0xF8,
  0x10, 0x61, 0x11, 0x11, 0x11, 0x2C, 0x84, 0x23, 0x2A, 0x62, 0x92, 0x88,
  0xE1, 0x08, 0x42, 0x10, 0x84, 0xF8, 0xFE, 0x9A, 0x69, 0xA6, 0x90, 0xFC,
  0x63, 0x18, 0xC4, 0xFC, 0x63, 0x18, 0xB8, 0xFC, 0x63, 0x18, 0xFA, 0x10,
  0xFC, 0x63, 0x18, 0xBC, 0x21, 0xF8, 0x88, 0x88, 0xFC, 0x1C, 0x18, 0xBC,
  0x27, 0xC8, 0x42, 0x10, 0x87, 0x8C, 0x63, 0x18, 0xBC, 0x8E, 0x24, 0x94,
  0x50, 0x80, 0x92, 0xA5, 0xAB, 0x62, 0x44, 0x80, 0x89, 0x42, 0x0C, 0x4A,
  0x30, 0xC2, 0x88, 0x91, 0x41, 0x82, 0x04, 0x10, 0x40, 0xF8, 0x88, 0x84,
  0x7C, 0x34, 0x44, 0x48, 0x44, 0x44, 0x30, 0xFF, 0xE0, 0xC4, 0x44, 0x21,
  0x24, 0x44, 0xC0, 0x61, 0x3C,
};

const GFXglyph RobotoMono_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 3, 7, 2, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 7, 0, -9 },
  { 28, 6, 9, 7, 1, -9 },
  { 35, 1, 3, 7, 3, -9 },
  { 36, 3, 13, 7, 2, -10 },
  { 41, 3, 13, 7, 2, -10 },
  { 46, 5, 5, 7, 1, -9 },
  { 50, 6, 6, 7, 1, -7 },
  { 55, 1, 3, 7, 2, -1 },
  { 56, 5, 1, 7, 1, -4 },
  { 57, 1, 1, 7, 3, -1 },
  { 58, 4, 10, 7, 2, -9 },
  { 63, 5, 9, 7, 1, -9 },
  { 69, 3, 9, 7, 1, -9 },
  { 73, 5, 9, 7, 1, -9 },
  { 79, 5, 9, 7, 1, -9 },
  { 85, 6, 9, 7, 1, -9 },
  { 92, 5, 9, 7, 1, -9 },
  { 98, 5, 9, 7, 1, -9 },
  { 104, 5, 9, 7, 1, -9 },
  { 110, 5, 9, 7, 1, -9 },
  { 116, 5, 9, 7, 1, -9 },
  { 122, 1, 6, 7, 4, -6 },
  { 123, 2, 8, 7, 3, -6 },
  { 125, 5, 5, 7, 1, -6 },
  { 129, 5, 3, 7, 1, -5 },
  { 131, 5, 5, 7, 1, -6 },
  { 135, 5, 9, 7, 1, -9 },
  { 141, 7, 9, 7, 0, -9 },
  { 149, 6, 9, 7, 1, -9 },
  { 156, 5, 9, 7, 1, -9 },
  { 162, 5, 9, 7, 1, -9 },
  { 168, 6, 9, 7, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 5, 9, 7, 1, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 5, 9, 7, 1, -9 },
  { 199, 5, 9, 7, 1, -9 },
  { 205, 5, 9, 7, 1, -9 },
  { 211, 6, 9, 7, 1, -9 },
  { 218, 5, 9, 7, 1, -9 },
  { 224, 5, 9, 7, 1, -9 },
  { 230, 5, 9, 7, 1, -9 },
  { 236, 5, 9, 7, 1, -9 },
  { 242, 6, 9, 7, 1, -9 },
  { 249, 6, 11, 7, 1, -9 },
  { 258, 6, 9, 7, 1, -9 },
  { 265, 5, 9, 7, 1, -9 },
  { 271, 6, 9, 7, 1, -9 },
  { 278, 5, 9, 7, 1, -9 },
  { 284, 6, 9, 7, 1, -9 },
  { 291, 6, 9, 7, 1, -9 },
  { 298, 6, 9, 7, 1, -9 },
  { 305, 7, 9, 7, 0, -9 },
  { 313, 5, 9, 7, 1, -9 },
  { 319, 2, 12, 7, 3, -10 },
  { 322, 4, 10, 7, 2, -9 },
  { 327, 1, 12, 7, 3, -10 },
  { 329, 5, 5, 7, 1, -9 },
  { 333, 5, 1, 7, 1, 0 },
  { 334, 1, 2, 7, 3, -9 },
  { 335, 5, 6, 7, 1, -6 },
  { 339, 5, 9, 7, 1, -9 },
  { 345, 5, 6, 7, 1, -6 },
  { 349, 5, 9, 7, 1, -9 },
  { 355, 5, 6, 7, 1, -6 },
  { 359, 6, 9, 7, 1, -9 },
  { 366, 5, 9, 7, 1, -6 },
  { 372, 5, 9, 7, 1, -9 },
  { 378, 5, 9, 7, 1, -9 },
  { 384, 4, 12, 7, 1, -9 },
  { 390, 5, 9, 7, 1, -9 },
  { 396, 5, 9, 7, 1, -9 },
  { 402, 6, 6, 7, 1, -6 },
  { 407, 5, 6, 7, 1, -6 },
  { 411, 5, 6, 7, 1, -6 },
  { 415, 5, 8, 7, 1, -6 },
  { 420, 5, 8, 7, 1, -6 },
  { 425, 4, 6, 7, 2, -6 },
  { 428, 5, 6, 7, 1, -6 },
  { 432, 5, 8, 7, 1, -8 },
  { 437, 5, 6, 7, 1, -6 },
  { 441, 6, 6, 7, 1, -6 },
  { 446, 7, 6, 7, 0, -6 },
  { 452, 6, 6, 7, 1, -6 },
  { 457, 7, 9, 7, 0, -6 },
  { 465, 5, 6, 7, 1, -6 },
  { 469, 4, 11, 7, 2, -9 },
  { 475, 1, 11, 7, 3, -9 },
  { 477, 4, 11, 7, 2, -9 },
  { 483, 7, 2, 7, 0, -5 },
};

const GFXfont RobotoMono_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight12pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_EXTRALIGHT12PT7B_H_
