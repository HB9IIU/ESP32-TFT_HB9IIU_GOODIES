#ifndef _ROBOTOMONO_BOLDITALIC32PT7B_H_
#define _ROBOTOMONO_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0x0F,
  0x83, 0xC1, 0xE0, 0x78, 0xEE, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x98,
  0x77, 0x1C, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xC4,
  0x71, 0xC0, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x70, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0C,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xF8, 0x3F, 0x7E,
  0x3E, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x07, 0xDF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xF0, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3E,
  0x00, 0xFE, 0x01, 0xDE, 0x07, 0x1C, 0x7E, 0x39, 0xDC, 0x73, 0x39, 0xCE,
  0x7F, 0xB8, 0x7E, 0x60, 0x79, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE6, 0x03, 0xBF, 0x06, 0xFF, 0x1D, 0xCE, 0x73, 0x9D, 0xC7, 0x38, 0x8C,
  0x70, 0x1C, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0x78, 0x07, 0x8E, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C,
  0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0xE1,
  0xCF, 0xF8, 0xF7, 0xCF, 0x3D, 0xE3, 0xFF, 0x78, 0x7F, 0x9E, 0x1F, 0xC7,
  0x83, 0xF1, 0xF1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFC, 0xF8, 0x77,
  0x77, 0xFE, 0xEE, 0x00, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x04,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x41, 0xC1, 0x71, 0xC7, 0x7D, 0xDF, 0xFF, 0xFF, 0x0F,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1C, 0x70, 0x3C, 0x70, 0x78,
  0x78, 0x10, 0x20, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C, 0xF0, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xF3, 0xE1,
  0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0xFD, 0xE7, 0xFB,
  0xDE, 0xFF, 0xFB, 0xFF, 0xC7, 0xFF, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0xFB, 0xC1, 0xE7, 0xC7, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x20, 0x38, 0x3F, 0x3F, 0xEF, 0xFD, 0xFF, 0xB9, 0xF4, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x3C, 0xF8, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xF7, 0xE3, 0xE0, 0xF1, 0xF0, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x9F, 0x8F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xBC,
  0x03, 0xFE, 0x03, 0xDE, 0x03, 0xCF, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE3,
  0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1D, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xCF, 0xC0,
  0x83, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x1F,
  0x3E, 0x0F, 0x0F, 0x8F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3D, 0xF8, 0xF7, 0xF9, 0xFF, 0xF3, 0xF3, 0xF7, 0xC1, 0xEF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xE3,
  0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0xBF, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F,
  0x1E, 0x1F, 0x1F, 0x3E, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C,
  0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3E, 0xFC, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFB, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFB, 0xC3, 0xF7, 0xFF, 0xC7, 0xFF, 0x87, 0xEF, 0x03, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF1, 0xF8, 0x7C, 0x3C, 0x00, 0x07,
  0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x0F, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F,
  0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x78, 0x00,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x01,
  0xFE, 0x1F, 0xF9, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0x20, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xBF, 0xF8, 0x7F, 0xC0, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x7F,
  0xF0, 0x3C, 0x1C, 0x1C, 0x03, 0x86, 0x1C, 0x63, 0x9F, 0xD9, 0xCF, 0xE6,
  0x73, 0x99, 0x99, 0xC6, 0x6E, 0x63, 0x9B, 0xB8, 0xE6, 0xCE, 0x31, 0xB3,
  0x8C, 0xEC, 0xE7, 0x33, 0x39, 0xDC, 0xCF, 0xFE, 0x31, 0xEF, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x7C, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F,
  0x3C, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7C, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF0, 0x3C, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3,
  0xC1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x1F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x0F, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x1F, 0x7C, 0x0F, 0x1E,
  0x0F, 0x8F, 0x8F, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0x0F, 0x87, 0xC1, 0xE1,
  0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x7C, 0x0F,
  0x1F, 0x07, 0xC7, 0x83, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0xF9,
  0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x0F, 0xF7, 0x8F, 0xF7, 0xC7, 0xFB, 0xE3, 0xFD, 0xF0, 0x1E, 0xF8,
  0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0xC7, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xE1,
  0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x1F, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C,
  0x0F, 0x87, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x80, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0xF0, 0x1E,
  0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xF1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0x80, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F,
  0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x78, 0xFC, 0x03, 0xCF, 0xC0, 0x1E,
  0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0xC3,
  0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xC3, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x9F, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xFB, 0xC3, 0xBF, 0x78, 0xF7,
  0xCF, 0x1E, 0x7B, 0xC3, 0xCF, 0x78, 0x79, 0xCF, 0x0F, 0x39, 0xE1, 0xE6,
  0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xE0, 0x1E, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x07, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F, 0x87, 0x87, 0xF1, 0xF0, 0xFE,
  0x3E, 0x1F, 0xC7, 0x83, 0xFC, 0xF0, 0xFB, 0x9E, 0x1F, 0x73, 0xC3, 0xCE,
  0xF8, 0x79, 0xFF, 0x0F, 0x1F, 0xC1, 0xE3, 0xF8, 0x7C, 0x7F, 0x0F, 0x8F,
  0xE1, 0xE0, 0xFC, 0x3C, 0x1F, 0x87, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x07,
  0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xE0, 0xF1,
  0xF0, 0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF8,
  0x1F, 0x7C, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F, 0x83, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E,
  0x07, 0x87, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01,
  0xE3, 0xC1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFC, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3D, 0xE0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x02, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xE1, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xE0, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0x7E, 0x1E, 0x07, 0x8F, 0x81,
  0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0,
  0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x83, 0xE1, 0xF1, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFE, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDF, 0x03, 0xEF, 0x81,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0xF0, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8E,
  0xF1, 0xE7, 0xBC, 0xF9, 0xEF, 0x3E, 0x7B, 0xCF, 0xBC, 0xF7, 0xEF, 0x3D,
  0xFB, 0xCF, 0x7E, 0xE3, 0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x00, 0x0F, 0x80, 0xFC, 0x3E, 0x03,
  0xE0, 0x78, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x1F, 0x00,
  0x3E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xF0, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x80, 0x7C, 0x00, 0xF0,
  0x07, 0xFE, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x7C, 0x78, 0x1E, 0x1F, 0x0F,
  0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x07, 0xBC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xF0, 0xF0, 0xF0,
  0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x39, 0xC3, 0xCE, 0x1C, 0x71,
  0xC3, 0x9E, 0x1F, 0xE0, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x78, 0xF0, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF1, 0xF3, 0xC1,
  0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFF, 0x3F, 0xFE, 0xFC, 0x7F, 0xE0, 0xFF,
  0x81, 0xEF, 0x03, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0x3C, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0x3E, 0x3C, 0x1F, 0x3C,
  0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x3E, 0xFC, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xF7, 0xF0, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0x3E, 0x3C, 0x1F, 0x7C, 0x0F, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x1E, 0x78,
  0x3C, 0x7C, 0x7C, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x1F, 0xBE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xF3, 0xF0, 0xF0, 0x7C,
  0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E,
  0x07, 0x8F, 0x83, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7E, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0x3E, 0x3E,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x08, 0x7E, 0x3C, 0x3F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF3, 0xC1, 0xFE, 0xF0,
  0xFF, 0xFC, 0x7E, 0x7E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0,
  0x3E, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F,
  0x0F, 0x8F, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xDE, 0x00, 0x07, 0x82,
  0x03, 0xE0, 0xC1, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0xFC, 0x1E, 0xFF, 0x0F, 0xFF, 0x87, 0xE7,
  0xE3, 0xC1, 0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C,
  0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0xF9,
  0xE0, 0x79, 0xF0, 0x3C, 0x00, 0x20, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0x08,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x3F, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x3F, 0x3C,
  0x1F, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0x8F, 0x03,
  0xE3, 0xE0, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x1E, 0xF3, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0x3C, 0xF1, 0xE7, 0x9E, 0x78, 0xF3, 0xCF, 0x1C,
  0x71, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7, 0x9E, 0x78, 0xE3, 0xCF, 0x3C, 0x71,
  0xE7, 0x8E, 0x38, 0xF3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x3C, 0xF1, 0xE7,
  0x80, 0x1E, 0x7E, 0x0F, 0x7F, 0x87, 0xFF, 0xC3, 0xF3, 0xF1, 0xE0, 0xF9,
  0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x03,
  0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0xF8,
  0x1E, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0x3E, 0x3C, 0x1F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E,
  0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x7C, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xE0,
  0x0F, 0x3E, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x3E, 0x0F, 0x07, 0xC3,
  0xC1, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0,
  0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0xC7, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3D, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xE7, 0x87, 0xFF, 0x87, 0xFF,
  0xC7, 0xE7, 0xE3, 0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78,
  0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE3, 0xE3, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xBC, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x7E, 0x7B,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xF0, 0x47, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E,
  0x1F, 0x3C, 0x0F, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x41, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0x3C, 0x0F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0x78, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83,
  0xC3, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x07,
  0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0xF1, 0xC7, 0xF0, 0xE3, 0xF8, 0xF1, 0xDC, 0x79, 0xEE,
  0x7C, 0xF7, 0x3E, 0x73, 0x9F, 0x79, 0xDF, 0xBC, 0xEF, 0xDC, 0x76, 0xEE,
  0x3F, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x00, 0x1E, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x03,
  0xCF, 0x80, 0x79, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xF3, 0xC0, 0x3E,
  0x7C, 0x0F, 0x87, 0x83, 0xE0, 0xF8, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xF1,
  0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0x7B, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x00,
  0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xE0, 0x02, 0x00, 0x0E,
  0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E,
  0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C,
  0x00, 0x06, 0x00, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x03, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x77, 0xFC, 0x39, 0xFF, 0xDE, 0xF1, 0xFF, 0xB8,
  0x1F, 0xC0, 0x03, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 23, 19, 5, -23 },
  { 27, 11, 8, 19, 5, -24 },
  { 38, 19, 23, 19, 0, -23 },
  { 93, 17, 29, 19, 1, -26 },
  { 155, 15, 23, 19, 2, -23 },
  { 199, 18, 23, 19, 0, -23 },
  { 251, 4, 8, 19, 8, -24 },
  { 255, 11, 32, 19, 5, -25 },
  { 299, 11, 32, 19, 3, -25 },
  { 343, 16, 16, 19, 2, -23 },
  { 375, 16, 17, 19, 1, -19 },
  { 409, 7, 10, 19, 3, -4 },
  { 418, 13, 4, 19, 4, -12 },
  { 425, 6, 5, 19, 5, -5 },
  { 429, 17, 25, 19, 1, -23 },
  { 483, 15, 23, 19, 2, -23 },
  { 527, 11, 23, 19, 4, -23 },
  { 559, 17, 23, 19, 0, -23 },
  { 608, 17, 23, 19, 1, -23 },
  { 657, 17, 23, 19, 0, -23 },
  { 706, 17, 23, 19, 1, -23 },
  { 755, 15, 23, 19, 1, -23 },
  { 799, 17, 23, 19, 2, -23 },
  { 848, 16, 23, 19, 1, -23 },
  { 894, 15, 23, 19, 2, -23 },
  { 938, 9, 18, 19, 5, -18 },
  { 959, 10, 24, 19, 4, -18 },
  { 989, 15, 15, 19, 2, -17 },
  { 1018, 16, 11, 19, 2, -15 },
  { 1040, 15, 15, 19, 1, -17 },
  { 1069, 14, 23, 19, 4, -23 },
  { 1110, 18, 23, 19, 1, -23 },
  { 1162, 18, 23, 19, -1, -23 },
  { 1214, 19, 23, 19, 0, -23 },
  { 1269, 17, 23, 19, 1, -23 },
  { 1318, 18, 23, 19, 0, -23 },
  { 1370, 18, 23, 19, 1, -23 },
  { 1422, 19, 23, 19, 1, -23 },
  { 1477, 17, 23, 19, 1, -23 },
  { 1526, 19, 23, 19, 0, -23 },
  { 1581, 17, 23, 19, 1, -23 },
  { 1630, 18, 23, 19, 1, -23 },
  { 1682, 21, 23, 19, 0, -23 },
  { 1743, 15, 23, 19, 1, -23 },
  { 1787, 19, 23, 19, 0, -23 },
  { 1842, 19, 23, 19, 0, -23 },
  { 1897, 17, 23, 19, 1, -23 },
  { 1946, 18, 23, 19, 1, -23 },
  { 1998, 17, 27, 19, 1, -23 },
  { 2056, 19, 23, 19, 0, -23 },
  { 2111, 18, 23, 19, 1, -23 },
  { 2163, 19, 23, 19, 2, -23 },
  { 2218, 18, 23, 19, 1, -23 },
  { 2270, 17, 23, 19, 3, -23 },
  { 2319, 18, 23, 19, 2, -23 },
  { 2371, 22, 23, 19, -1, -23 },
  { 2435, 18, 23, 19, 3, -23 },
  { 2487, 19, 23, 19, 0, -23 },
  { 2542, 12, 31, 19, 4, -26 },
  { 2589, 8, 25, 19, 6, -23 },
  { 2614, 12, 31, 19, 4, -26 },
  { 2661, 13, 12, 19, 3, -23 },
  { 2681, 14, 3, 19, 0, 0 },
  { 2687, 7, 4, 19, 8, -23 },
  { 2691, 15, 17, 19, 1, -17 },
  { 2723, 16, 24, 19, 1, -24 },
  { 2771, 16, 17, 19, 1, -17 },
  { 2805, 18, 24, 19, 1, -24 },
  { 2859, 16, 17, 19, 1, -17 },
  { 2893, 17, 25, 19, 3, -25 },
  { 2947, 18, 24, 19, 0, -17 },
  { 3001, 17, 24, 19, 0, -24 },
  { 3052, 14, 24, 19, 2, -24 },
  { 3094, 14, 31, 19, 1, -24 },
  { 3149, 18, 24, 19, 1, -24 },
  { 3203, 15, 24, 19, 1, -24 },
  { 3248, 19, 17, 19, -1, -17 },
  { 3289, 17, 17, 19, 0, -17 },
  { 3326, 16, 17, 19, 1, -17 },
  { 3360, 18, 24, 19, -1, -17 },
  { 3414, 17, 24, 19, 1, -17 },
  { 3465, 15, 17, 19, 3, -17 },
  { 3497, 16, 17, 19, 1, -17 },
  { 3531, 14, 21, 19, 3, -21 },
  { 3568, 16, 17, 19, 2, -17 },
  { 3602, 17, 17, 19, 2, -17 },
  { 3639, 17, 17, 19, 2, -17 },
  { 3676, 19, 17, 19, 0, -17 },
  { 3717, 20, 24, 19, 0, -17 },
  { 3777, 18, 17, 19, 0, -17 },
  { 3816, 12, 31, 19, 5, -25 },
  { 3863, 7, 29, 19, 6, -23 },
  { 3889, 12, 31, 19, 3, -25 },
  { 3936, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic32pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_BOLDITALIC32PT7B_H_
