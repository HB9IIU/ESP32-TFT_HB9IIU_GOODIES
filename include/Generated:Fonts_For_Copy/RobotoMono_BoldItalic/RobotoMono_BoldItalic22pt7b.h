#ifndef _ROBOTOMONO_BOLDITALIC22PT7B_H_
#define _ROBOTOMONO_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x99, 0xCE, 0x73, 0x9C, 0x00, 0x73, 0x9C, 0xE7,
  0x8F, 0x3E, 0x6C, 0xD9, 0x80, 0x03, 0x30, 0x19, 0x80, 0x88, 0x0C, 0xC0,
  0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98, 0x19, 0x80, 0xCC, 0x3F, 0xF9, 0xFF,
  0xC3, 0x30, 0x19, 0x81, 0x98, 0x0C, 0xC0, 0x01, 0x80, 0x10, 0x07, 0x81,
  0xFE, 0x3F, 0xE3, 0x8E, 0x38, 0x73, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xCE, 0x0E, 0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x0C, 0x00,
  0x80, 0x38, 0x0F, 0x81, 0xB1, 0x66, 0x6C, 0xD8, 0xFB, 0x1E, 0xC0, 0x30,
  0x04, 0x01, 0xB0, 0x6F, 0x9B, 0x33, 0x66, 0xCC, 0xC1, 0xF0, 0x1E, 0x03,
  0x80, 0x7E, 0x07, 0xF8, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x7E, 0x01, 0xE0,
  0x1E, 0x3B, 0xF9, 0x9D, 0xDD, 0xC7, 0xEE, 0x1E, 0x39, 0xE1, 0xFF, 0x87,
  0xDE, 0x76, 0x66, 0x6E, 0x03, 0x07, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30,
  0x38, 0x10, 0x18, 0x30, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x70, 0xE1, 0xC3, 0x0E, 0x18, 0x70, 0xC3, 0x0C, 0x10, 0x00, 0x06, 0x01,
  0x80, 0x62, 0x11, 0xED, 0xFF, 0xF0, 0xC0, 0x78, 0x36, 0x38, 0xC6, 0x30,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x00, 0x39, 0xCC, 0xE7, 0x33, 0x00, 0xFF, 0xFF, 0xC0,
  0x6E, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x1C, 0x77, 0x0E, 0xE1, 0xDC, 0x7B,
  0xBF, 0x7E, 0xEF, 0x3B, 0xC7, 0x70, 0xEE, 0x1C, 0xE7, 0x1F, 0xC1, 0xF0,
  0x01, 0x07, 0x3F, 0x7F, 0x66, 0x8E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x87, 0x38, 0x74,
  0x06, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xEF, 0xFC, 0x0F, 0x83, 0xF8, 0xFF, 0xB8, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x7C, 0x0F, 0x82, 0x78, 0x07, 0x00, 0xEE, 0x1D, 0xC7, 0x3F,
  0xE1, 0xF0, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0xEE, 0x0C,
  0xC1, 0xDC, 0x39, 0xC7, 0x1C, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x38, 0x03,
  0x80, 0x38, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0x80, 0x38, 0x03, 0x00, 0x7F,
  0x87, 0xFC, 0x31, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0xE1, 0xCF, 0x38, 0x7F,
  0x83, 0xE0, 0x01, 0xC1, 0xE1, 0xF8, 0xF0, 0x38, 0x1C, 0x07, 0xFB, 0xFF,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xE7, 0xF8, 0xF8, 0x7F, 0xF7,
  0xFF, 0x7F, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0x03,
  0xF8, 0xFF, 0x9C, 0x77, 0x0E, 0xE1, 0xCE, 0x71, 0xFC, 0x3F, 0x8E, 0x7B,
  0x87, 0x70, 0xEE, 0x1D, 0xC7, 0x3F, 0xE1, 0xF0, 0x1E, 0x0F, 0xC7, 0xFB,
  0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xF7, 0xBF, 0xE3, 0xB8, 0x1C, 0x0F,
  0x0F, 0x8F, 0xC3, 0xC0, 0x33, 0xDE, 0x70, 0x00, 0x00, 0x03, 0x3D, 0xEE,
  0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0x87,
  0x0E, 0x1C, 0x70, 0xC0, 0x00, 0x20, 0x3C, 0x1F, 0x1F, 0xC7, 0xC0, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0x80, 0x30, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x0F,
  0xFD, 0xFF, 0xBF, 0xF0, 0x40, 0x1C, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x71,
  0xFF, 0xFC, 0xF8, 0x30, 0x08, 0x00, 0x1E, 0x3F, 0xFF, 0xFC, 0x70, 0x38,
  0x1C, 0x1C, 0x1E, 0x1C, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0,
  0x00, 0x00, 0x3F, 0x03, 0x0C, 0x30, 0x23, 0x3D, 0x93, 0x6D, 0xB3, 0x6D,
  0x93, 0x48, 0x96, 0xCC, 0xB2, 0x6D, 0x9F, 0xC4, 0x4C, 0x30, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xB0,
  0x1D, 0x81, 0xCC, 0x0E, 0x70, 0xE3, 0x87, 0xFC, 0x7F, 0xE3, 0xFF, 0x38,
  0x39, 0xC1, 0xDE, 0x07, 0x1F, 0x80, 0xFF, 0x87, 0xFC, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xE1, 0xC7, 0xFC, 0x3F, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0xF3, 0xFF, 0x1F, 0xF0, 0x07, 0x81, 0xFC, 0x3F, 0xE7, 0x8E,
  0x70, 0x77, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E,
  0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x1F, 0x01, 0xFC, 0x1F, 0xE3, 0x8F,
  0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0E,
  0x71, 0xE7, 0x7C, 0xFF, 0x8F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE1, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x9F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE1, 0xFF,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x81,
  0xFC, 0x3F, 0xE3, 0x8E, 0x70, 0x77, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xEE,
  0x7E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCF, 0x1C, 0x7F, 0xC3, 0xF0, 0x1C, 0x38,
  0xE1, 0xC6, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0xFE, 0x7F,
  0xF3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x38,
  0x1F, 0xE7, 0xFC, 0xFF, 0x83, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x3F, 0xE7, 0xFC, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x83, 0xE0, 0x1C, 0x1E,
  0x38, 0x78, 0x71, 0xE1, 0xC7, 0x83, 0x9E, 0x07, 0x78, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0xFF, 0x01, 0xEF, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0x78, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0x1E, 0x38, 0xF3, 0xC7, 0x9E, 0x7D, 0xF3, 0xEF, 0x9F, 0xD8,
  0xDE, 0xC6, 0xFE, 0x77, 0x73, 0xBB, 0x9D, 0x9C, 0xE0, 0xC7, 0x0E, 0x30,
  0x73, 0x83, 0x9C, 0x1C, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x7C, 0xE3, 0xE7,
  0x1F, 0x38, 0xF9, 0xC7, 0xEE, 0x73, 0x73, 0x9F, 0x1C, 0xF8, 0xE7, 0xC7,
  0x1E, 0x38, 0xF3, 0x87, 0x9C, 0x38, 0x07, 0x83, 0xF8, 0xFF, 0xBC, 0x77,
  0x0E, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEE, 0x1D,
  0xE7, 0x1F, 0xE1, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x38, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x1E, 0x3F, 0xE1, 0xFE, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x81, 0xFC, 0x3F, 0xE7, 0x8E,
  0x70, 0xE7, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0x1F,
  0x80, 0xFF, 0x07, 0xFC, 0x70, 0xF3, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x1E,
  0x3F, 0xE3, 0xFC, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0x73, 0x83, 0x9C,
  0x1C, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x87, 0x70, 0x77, 0x00, 0x3C, 0x03,
  0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xEE, 0x0E, 0xE0, 0xEF, 0x1C, 0x7F, 0xC3,
  0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x38,
  0x7F, 0x83, 0xE0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xC6, 0x1C,
  0x73, 0x87, 0x38, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x63, 0x3B, 0x39, 0xD9, 0xCC, 0xCE, 0xE6, 0x77, 0x37,
  0xB9, 0xBD, 0x8D, 0xFC, 0x7B, 0xE3, 0xDE, 0x3E, 0xF1, 0xE7, 0x8F, 0x3C,
  0x79, 0xC3, 0x8E, 0x1C, 0x70, 0x1C, 0x1E, 0x3C, 0x38, 0x38, 0xF0, 0x71,
  0xC0, 0x77, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x3B, 0x00, 0xF7, 0x01, 0xCE, 0x07, 0x0E, 0x1E, 0x1C, 0x78, 0x3C, 0xE0,
  0x7E, 0x0F, 0x70, 0xE7, 0x1C, 0x71, 0xC3, 0x38, 0x3F, 0x03, 0xF0, 0x3E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xFF, 0x9F,
  0xFC, 0x1F, 0x1E, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xF8, 0xF0, 0xF0, 0xE3,
  0x8E, 0x18, 0x61, 0xC7, 0x1C, 0x70, 0xC3, 0x0E, 0x38, 0xE3, 0x86, 0x1C,
  0x1F, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xF0, 0x06, 0x07,
  0x03, 0xC3, 0xE1, 0xB1, 0x98, 0xCE, 0xC3, 0xE1, 0x80, 0xFF, 0xFF, 0xF0,
  0xE7, 0x30, 0x0F, 0x0F, 0xE7, 0xBD, 0xC7, 0x01, 0xCF, 0xF7, 0xFF, 0x87,
  0xE1, 0xF8, 0xEF, 0xF9, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0xB8, 0x3F, 0xE3, 0xFE, 0x38, 0xE3, 0x87, 0x30, 0x77, 0x06, 0x70,
  0xE7, 0x0E, 0x79, 0xE7, 0xFC, 0xEF, 0x80, 0x0F, 0x07, 0xF0, 0xFF, 0x38,
  0x6E, 0x0D, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xDE, 0x71, 0xFE, 0x1F, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE1, 0xEE, 0x3F, 0xE7, 0xFE,
  0x71, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xF3, 0xC7, 0xF8,
  0x3D, 0x80, 0x0F, 0x03, 0xF8, 0xFF, 0x38, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x9E, 0x31, 0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x0F, 0x20,
  0xE0, 0x1C, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x00, 0x07, 0x31, 0xFF,
  0x3F, 0xF3, 0x87, 0x70, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x9E,
  0x3F, 0xE1, 0xEC, 0x01, 0xC4, 0x1C, 0xFF, 0x87, 0xF0, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x9C, 0x3F, 0xE3, 0xFE, 0x38,
  0x73, 0x87, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xE0,
  0xE0, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFE, 0x01, 0x80, 0xF0,
  0x18, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x8F, 0xC3, 0xE0, 0xE0, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x3C, 0xE3, 0xC7,
  0x3C, 0x3B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xB8, 0x39, 0xC1, 0xC7,
  0x0E, 0x38, 0xE0, 0xE0, 0x1F, 0x87, 0xE3, 0xF8, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF,
  0xFF, 0xC0, 0x36, 0x67, 0xFF, 0x7F, 0xF7, 0x73, 0x77, 0x76, 0x77, 0x66,
  0x7E, 0x67, 0xE6, 0x6E, 0xE6, 0xEE, 0xEC, 0xEE, 0x39, 0xC3, 0xFE, 0x3F,
  0xE3, 0x87, 0x38, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xEE, 0x0E, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0E, 0xE1, 0xDE, 0x71, 0xFE, 0x1F, 0x00, 0x3B, 0x83, 0xFE, 0x3F, 0xE3,
  0x8E, 0x38, 0x73, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x9C, 0x7F, 0xCE,
  0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x67, 0xFD, 0xFF, 0xB8,
  0x7E, 0x0D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDE, 0x79, 0xFE, 0x1F, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x39, 0xE6, 0xF8, 0xFF, 0x3E, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x07,
  0xF9, 0xE7, 0xB8, 0x77, 0x00, 0xFC, 0x07, 0xE0, 0x1E, 0xE1, 0xDC, 0x39,
  0xFE, 0x1F, 0x80, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xCE, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x07, 0x00, 0xE2, 0x3F, 0x07, 0xE0, 0x70, 0xEE, 0x1D,
  0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xB8, 0x77, 0x0E, 0xE1, 0xDE, 0x79, 0xFF,
  0x3E, 0xC0, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x38, 0xCE, 0x19, 0xC3,
  0xB0, 0x7E, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE6, 0x7E, 0x67, 0xEE, 0x7E,
  0xE6, 0xEE, 0xEF, 0xEC, 0xFA, 0xCD, 0x3C, 0xF3, 0x8F, 0x38, 0xE3, 0x8E,
  0x30, 0x38, 0x38, 0xE3, 0x87, 0x38, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x3C,
  0x01, 0xF0, 0x1F, 0xC1, 0xCE, 0x1C, 0x39, 0xE1, 0xC0, 0x78, 0x3C, 0xE0,
  0xE3, 0x87, 0x8E, 0x1C, 0x18, 0xE0, 0x73, 0x81, 0xDC, 0x07, 0x70, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0x03, 0xC3,
  0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x7C, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x80, 0x80, 0x18, 0xC4, 0x63,
  0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x80, 0x18, 0x0E,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0E, 0x03, 0xC1, 0xC1, 0xE1,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x0C, 0x00, 0x38, 0x07,
  0xE3, 0xFF, 0xFC, 0x7E, 0x01, 0xC0,
};

const GFXglyph RobotoMono_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 6, 13, 4, -17 },
  { 17, 13, 16, 13, 0, -16 },
  { 43, 12, 20, 13, 1, -18 },
  { 73, 11, 16, 13, 1, -16 },
  { 95, 13, 16, 13, 0, -16 },
  { 121, 4, 6, 13, 5, -17 },
  { 124, 8, 22, 13, 3, -17 },
  { 146, 7, 22, 13, 2, -17 },
  { 166, 10, 11, 13, 2, -16 },
  { 180, 11, 11, 13, 1, -13 },
  { 196, 5, 7, 13, 2, -3 },
  { 201, 9, 2, 13, 3, -8 },
  { 204, 4, 4, 13, 4, -4 },
  { 206, 11, 17, 13, 1, -16 },
  { 230, 11, 16, 13, 1, -16 },
  { 252, 8, 16, 13, 2, -16 },
  { 268, 12, 16, 13, 0, -16 },
  { 292, 11, 16, 13, 1, -16 },
  { 314, 12, 16, 13, 0, -16 },
  { 338, 12, 16, 13, 1, -16 },
  { 362, 10, 16, 13, 1, -16 },
  { 382, 12, 16, 13, 1, -16 },
  { 406, 11, 16, 13, 1, -16 },
  { 428, 10, 16, 13, 2, -16 },
  { 448, 5, 13, 13, 4, -13 },
  { 457, 7, 17, 13, 3, -13 },
  { 472, 11, 10, 13, 1, -12 },
  { 486, 11, 7, 13, 1, -10 },
  { 496, 10, 11, 13, 1, -12 },
  { 510, 9, 16, 13, 3, -16 },
  { 528, 13, 16, 13, 0, -16 },
  { 554, 13, 16, 13, -1, -16 },
  { 580, 13, 16, 13, 0, -16 },
  { 606, 12, 16, 13, 1, -16 },
  { 630, 12, 16, 13, 0, -16 },
  { 654, 13, 16, 13, 0, -16 },
  { 680, 13, 16, 13, 0, -16 },
  { 706, 12, 16, 13, 1, -16 },
  { 730, 13, 16, 13, 0, -16 },
  { 756, 11, 16, 13, 1, -16 },
  { 778, 12, 16, 13, 1, -16 },
  { 802, 15, 16, 13, 0, -16 },
  { 832, 11, 16, 13, 0, -16 },
  { 854, 13, 16, 13, 0, -16 },
  { 880, 13, 16, 13, 0, -16 },
  { 906, 11, 16, 13, 1, -16 },
  { 928, 13, 16, 13, 0, -16 },
  { 954, 12, 19, 13, 1, -16 },
  { 983, 13, 16, 13, 0, -16 },
  { 1009, 12, 16, 13, 1, -16 },
  { 1033, 13, 16, 13, 1, -16 },
  { 1059, 12, 16, 13, 1, -16 },
  { 1083, 12, 16, 13, 2, -16 },
  { 1107, 13, 16, 13, 1, -16 },
  { 1133, 15, 16, 13, -1, -16 },
  { 1163, 12, 16, 13, 2, -16 },
  { 1187, 13, 16, 13, 0, -16 },
  { 1213, 8, 22, 13, 3, -18 },
  { 1235, 6, 17, 13, 4, -16 },
  { 1248, 8, 22, 13, 3, -18 },
  { 1270, 9, 9, 13, 2, -16 },
  { 1281, 10, 2, 13, 0, 0 },
  { 1284, 4, 3, 13, 6, -16 },
  { 1286, 10, 12, 13, 1, -12 },
  { 1301, 12, 17, 13, 0, -17 },
  { 1327, 11, 12, 13, 1, -12 },
  { 1344, 12, 17, 13, 1, -17 },
  { 1370, 11, 12, 13, 1, -12 },
  { 1387, 12, 17, 13, 2, -17 },
  { 1413, 12, 17, 13, 0, -12 },
  { 1439, 12, 17, 13, 0, -17 },
  { 1465, 10, 16, 13, 1, -16 },
  { 1485, 10, 21, 13, 1, -16 },
  { 1512, 13, 17, 13, 0, -17 },
  { 1540, 10, 17, 13, 1, -17 },
  { 1562, 12, 12, 13, 0, -12 },
  { 1580, 12, 12, 13, 0, -12 },
  { 1598, 11, 12, 13, 1, -12 },
  { 1615, 12, 16, 13, 0, -12 },
  { 1639, 11, 16, 13, 1, -12 },
  { 1661, 11, 12, 13, 2, -12 },
  { 1678, 11, 12, 13, 1, -12 },
  { 1695, 10, 14, 13, 2, -14 },
  { 1713, 11, 12, 13, 1, -12 },
  { 1730, 11, 12, 13, 2, -12 },
  { 1747, 12, 12, 13, 1, -12 },
  { 1765, 13, 12, 13, 0, -12 },
  { 1785, 14, 17, 13, 0, -12 },
  { 1815, 12, 12, 13, 0, -12 },
  { 1833, 9, 21, 13, 3, -17 },
  { 1857, 5, 20, 13, 4, -16 },
  { 1870, 9, 21, 13, 2, -17 },
  { 1894, 12, 5, 13, 0, -9 },
};

const GFXfont RobotoMono_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic22pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_BOLDITALIC22PT7B_H_
