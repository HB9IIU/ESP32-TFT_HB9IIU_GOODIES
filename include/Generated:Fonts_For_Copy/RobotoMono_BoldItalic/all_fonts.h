#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoMono_BoldItalic
// Headers: 67

#include "RobotoMono_BoldItalic6pt7b.h"
#include "RobotoMono_BoldItalic7pt7b.h"
#include "RobotoMono_BoldItalic8pt7b.h"
#include "RobotoMono_BoldItalic9pt7b.h"
#include "RobotoMono_BoldItalic10pt7b.h"
#include "RobotoMono_BoldItalic11pt7b.h"
#include "RobotoMono_BoldItalic12pt7b.h"
#include "RobotoMono_BoldItalic13pt7b.h"
#include "RobotoMono_BoldItalic14pt7b.h"
#include "RobotoMono_BoldItalic15pt7b.h"
#include "RobotoMono_BoldItalic16pt7b.h"
#include "RobotoMono_BoldItalic17pt7b.h"
#include "RobotoMono_BoldItalic18pt7b.h"
#include "RobotoMono_BoldItalic19pt7b.h"
#include "RobotoMono_BoldItalic20pt7b.h"
#include "RobotoMono_BoldItalic21pt7b.h"
#include "RobotoMono_BoldItalic22pt7b.h"
#include "RobotoMono_BoldItalic23pt7b.h"
#include "RobotoMono_BoldItalic24pt7b.h"
#include "RobotoMono_BoldItalic25pt7b.h"
#include "RobotoMono_BoldItalic26pt7b.h"
#include "RobotoMono_BoldItalic27pt7b.h"
#include "RobotoMono_BoldItalic28pt7b.h"
#include "RobotoMono_BoldItalic29pt7b.h"
#include "RobotoMono_BoldItalic30pt7b.h"
#include "RobotoMono_BoldItalic31pt7b.h"
#include "RobotoMono_BoldItalic32pt7b.h"
#include "RobotoMono_BoldItalic33pt7b.h"
#include "RobotoMono_BoldItalic34pt7b.h"
#include "RobotoMono_BoldItalic35pt7b.h"
#include "RobotoMono_BoldItalic36pt7b.h"
#include "RobotoMono_BoldItalic37pt7b.h"
#include "RobotoMono_BoldItalic38pt7b.h"
#include "RobotoMono_BoldItalic39pt7b.h"
#include "RobotoMono_BoldItalic40pt7b.h"
#include "RobotoMono_BoldItalic41pt7b.h"
#include "RobotoMono_BoldItalic42pt7b.h"
#include "RobotoMono_BoldItalic43pt7b.h"
#include "RobotoMono_BoldItalic44pt7b.h"
#include "RobotoMono_BoldItalic45pt7b.h"
#include "RobotoMono_BoldItalic46pt7b.h"
#include "RobotoMono_BoldItalic47pt7b.h"
#include "RobotoMono_BoldItalic48pt7b.h"
#include "RobotoMono_BoldItalic49pt7b.h"
#include "RobotoMono_BoldItalic50pt7b.h"
#include "RobotoMono_BoldItalic51pt7b.h"
#include "RobotoMono_BoldItalic52pt7b.h"
#include "RobotoMono_BoldItalic53pt7b.h"
#include "RobotoMono_BoldItalic54pt7b.h"
#include "RobotoMono_BoldItalic55pt7b.h"
#include "RobotoMono_BoldItalic56pt7b.h"
#include "RobotoMono_BoldItalic57pt7b.h"
#include "RobotoMono_BoldItalic58pt7b.h"
#include "RobotoMono_BoldItalic59pt7b.h"
#include "RobotoMono_BoldItalic60pt7b.h"
#include "RobotoMono_BoldItalic61pt7b.h"
#include "RobotoMono_BoldItalic62pt7b.h"
#include "RobotoMono_BoldItalic63pt7b.h"
#include "RobotoMono_BoldItalic64pt7b.h"
#include "RobotoMono_BoldItalic65pt7b.h"
#include "RobotoMono_BoldItalic66pt7b.h"
#include "RobotoMono_BoldItalic67pt7b.h"
#include "RobotoMono_BoldItalic68pt7b.h"
#include "RobotoMono_BoldItalic69pt7b.h"
#include "RobotoMono_BoldItalic70pt7b.h"
#include "RobotoMono_BoldItalic71pt7b.h"
#include "RobotoMono_BoldItalic72pt7b.h"
