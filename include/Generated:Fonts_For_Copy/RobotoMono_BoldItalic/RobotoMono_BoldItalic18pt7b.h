#ifndef _ROBOTOMONO_BOLDITALIC18PT7B_H_
#define _ROBOTOMONO_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x39, 0xCC, 0x60, 0x11, 0xCE, 0x00, 0x4D, 0x3C,
  0xF2, 0xD8, 0x06, 0xC0, 0x98, 0x32, 0x06, 0xD3, 0xFC, 0xB2, 0x06, 0xC0,
  0x90, 0xFF, 0x86, 0xC0, 0x90, 0x36, 0x04, 0xC0, 0x06, 0x03, 0x07, 0xC7,
  0xF7, 0x1B, 0x8D, 0xC0, 0x70, 0x3E, 0x07, 0x80, 0xD8, 0x6E, 0x37, 0xF9,
  0xF8, 0x20, 0x10, 0x00, 0x70, 0x6C, 0x36, 0x5B, 0x4F, 0xE1, 0x60, 0x20,
  0x30, 0x3F, 0x16, 0xD2, 0x61, 0xB0, 0xF0, 0x0F, 0x07, 0xC1, 0x98, 0xE6,
  0x1B, 0x07, 0x81, 0xC1, 0xF3, 0x6E, 0xF9, 0xFE, 0x39, 0xFE, 0x7D, 0xC0,
  0x6D, 0xAC, 0x0C, 0x63, 0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x10, 0x60, 0x80, 0x10, 0x30, 0x30, 0x60, 0xC0, 0xC1, 0x87, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x0E, 0x18, 0xE0, 0x80, 0x0C, 0x06, 0x03, 0x0D,
  0xBF, 0xF8, 0xE0, 0xD0, 0xCC, 0x62, 0x00, 0x0C, 0x06, 0x03, 0x03, 0x8F,
  0xFF, 0xF8, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x76, 0x6E, 0xC8, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x76, 0x3B,
  0x3F, 0xFF, 0xE6, 0xE3, 0x61, 0xB9, 0xCF, 0xC7, 0xC0, 0x04, 0xFF, 0xFF,
  0x1C, 0x61, 0x86, 0x38, 0xE3, 0x8C, 0x30, 0x0F, 0x0F, 0xE3, 0x19, 0xC7,
  0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x01, 0xC0, 0xE0, 0xF0, 0x0E, 0x01, 0xA0,
  0x66, 0x39, 0xFC, 0x3E, 0x00, 0x01, 0x81, 0xC1, 0xE1, 0xF0, 0xF8, 0xDC,
  0xCC, 0xC6, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0x60, 0x3F, 0x9F, 0xCC, 0x0E,
  0x06, 0x03, 0xF3, 0xFC, 0x06, 0x03, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x07,
  0x1E, 0x38, 0x70, 0x64, 0xFE, 0xF7, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C,
  0x7F, 0xDF, 0xE8, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x76, 0x33, 0xF8,
  0xF8, 0xEE, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x1E, 0x1F, 0x9C, 0xCC,
  0x6E, 0x3F, 0x1B, 0x9C, 0xFE, 0x3B, 0x03, 0x03, 0x8F, 0x87, 0x00, 0x33,
  0xCC, 0x00, 0x00, 0x1C, 0xE7, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0xC7, 0x18, 0xE1, 0x00, 0x00, 0x81, 0x87, 0xCF, 0x8E, 0x07, 0xC0,
  0xFC, 0x0C, 0x01, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x40, 0x70,
  0x7C, 0x1F, 0x03, 0x1F, 0xFC, 0xE0, 0x80, 0x3E, 0x7F, 0xE3, 0xE3, 0x07,
  0x0E, 0x1C, 0x38, 0x30, 0x00, 0x20, 0x70, 0x70, 0x07, 0x03, 0xF0, 0xC1,
  0x13, 0xA6, 0xD4, 0xB2, 0x96, 0xD6, 0x92, 0xD2, 0xDB, 0xF1, 0x00, 0x31,
  0x03, 0xE0, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x07, 0x70,
  0xC6, 0x3F, 0xC7, 0xF8, 0xC3, 0x38, 0x6E, 0x0E, 0x3F, 0x07, 0xF8, 0xC7,
  0x18, 0x63, 0x0C, 0xE7, 0x9F, 0xC3, 0x8C, 0x61, 0xCC, 0x39, 0x86, 0x7F,
  0xCF, 0xE0, 0x1E, 0x1F, 0xDC, 0xEC, 0x3E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x3E, 0x0F, 0xE3, 0x38, 0xC7, 0x30, 0xDC,
  0x37, 0x1D, 0xC7, 0x61, 0xD8, 0x66, 0x3B, 0xFC, 0xFC, 0x00, 0x1F, 0xE7,
  0xFC, 0xE0, 0x18, 0x03, 0x00, 0x7F, 0x1F, 0xE3, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1F, 0xE3, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x1E, 0x1F,
  0xDC, 0x6C, 0x3E, 0x07, 0x03, 0x3F, 0x9F, 0xC3, 0xE1, 0xB8, 0xDF, 0xE7,
  0xE0, 0x38, 0xE7, 0x18, 0xC3, 0x18, 0x63, 0x1C, 0xFF, 0x9F, 0xF3, 0x0C,
  0x61, 0x8C, 0x31, 0x8E, 0x71, 0xCE, 0x30, 0x3F, 0x9F, 0xC3, 0x01, 0x80,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x1F, 0xCF, 0xE0, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x30, 0xCC, 0x73,
  0xF8, 0x7C, 0x00, 0x38, 0x73, 0x8E, 0x31, 0xC3, 0x38, 0x37, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x06, 0x30, 0x63, 0x8E, 0x38, 0xE1, 0xC0, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0F,
  0xFF, 0xF8, 0x38, 0xE7, 0x3C, 0xF7, 0x1F, 0xE3, 0xFC, 0xFD, 0x9B, 0xB3,
  0x6E, 0x6D, 0x8C, 0x31, 0x86, 0x70, 0xCC, 0x38, 0x38, 0xE7, 0x18, 0xE3,
  0x1E, 0x63, 0xDC, 0xFB, 0x9F, 0x73, 0xAC, 0x67, 0x8C, 0xF1, 0x9E, 0x71,
  0xCE, 0x30, 0x1E, 0x1F, 0x9C, 0xEC, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3,
  0xE1, 0xB1, 0xDF, 0xC7, 0xC0, 0x1F, 0x07, 0xF8, 0xE3, 0x18, 0x73, 0x0E,
  0x61, 0x9F, 0xF3, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x1E,
  0x1F, 0x9C, 0xEC, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xB1, 0xDF,
  0xC7, 0xE0, 0x38, 0x0C, 0x3F, 0x07, 0xF8, 0xC7, 0x18, 0x63, 0x0C, 0xE3,
  0x9F, 0xE3, 0xF8, 0x67, 0x0C, 0x61, 0x8E, 0x71, 0xCE, 0x18, 0x0F, 0x83,
  0xF8, 0xE3, 0x18, 0x73, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xCC, 0x39,
  0x86, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x71, 0xDC,
  0x66, 0x19, 0x86, 0x61, 0xB8, 0xEE, 0x3B, 0x8C, 0xC3, 0x30, 0xCE, 0x73,
  0xF8, 0x7C, 0x00, 0xE0, 0xD8, 0x76, 0x19, 0x8E, 0x63, 0x9C, 0xC7, 0x71,
  0xD8, 0x3E, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0xEC, 0xFB, 0x3C, 0xCF,
  0x37, 0xDD, 0xB7, 0x6D, 0x5B, 0xDC, 0xF7, 0x39, 0xCE, 0x63, 0x98, 0xC6,
  0x00, 0x18, 0x78, 0xE3, 0x87, 0x38, 0x19, 0x80, 0xFC, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x80, 0xEC, 0x0E, 0x70, 0xE3, 0x8F, 0x0E, 0x00, 0xC1,
  0xF0, 0xEE, 0x31, 0x9C, 0x66, 0x1B, 0x07, 0xC0, 0xE0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x70, 0x00, 0x3F, 0xE7, 0xFC, 0x07, 0x00, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x7F, 0xCF, 0xF8, 0x1E, 0x3C,
  0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x30,
  0xF1, 0xE0, 0xE3, 0x18, 0xC6, 0x31, 0xC6, 0x31, 0x8C, 0x63, 0x8C, 0x1E,
  0x3C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C,
  0x18, 0xF1, 0xE0, 0x0C, 0x38, 0xF1, 0xA6, 0x4C, 0xF1, 0x80, 0xFF, 0xFF,
  0xCC, 0x1C, 0x7F, 0x67, 0x83, 0x3F, 0xFF, 0xC7, 0xC7, 0xFE, 0xFF, 0x18,
  0x0E, 0x03, 0x80, 0xC0, 0x37, 0x0F, 0xE3, 0xB9, 0xC6, 0x71, 0x9C, 0x66,
  0x19, 0x8E, 0x7F, 0x3F, 0x80, 0x1C, 0x3F, 0x77, 0xE3, 0xC0, 0xC0, 0xC0,
  0xC7, 0xFE, 0x7C, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x19, 0x9F, 0xE7, 0x7B,
  0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x1C, 0xFF, 0x1F, 0x80, 0x0C, 0x1F, 0x9C,
  0xDC, 0x7F, 0xFF, 0xFB, 0x01, 0xC4, 0x7F, 0x1F, 0x00, 0x03, 0xC3, 0xF0,
  0xE0, 0x70, 0x7F, 0x9F, 0xE9, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x00, 0x0C, 0xCF, 0xF3, 0x9D, 0xC7, 0x61, 0x98, 0x66, 0x19,
  0xCE, 0x7F, 0x8F, 0xE0, 0x31, 0x1C, 0xFE, 0x0E, 0x00, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x33, 0x0F, 0xE3, 0x99, 0xC7, 0x71, 0x98, 0x66, 0x19, 0x86,
  0x63, 0xB8, 0xE0, 0x06, 0x0E, 0x00, 0x3E, 0x7C, 0x0C, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0x03, 0xE1, 0xF0, 0x38, 0x1C,
  0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0xF0, 0xF0, 0x00,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x1E, 0x67, 0x0D, 0xC3, 0xF0, 0x7C,
  0x0F, 0xC1, 0xD8, 0x33, 0x86, 0x31, 0xC7, 0x00, 0x3E, 0x3E, 0x3E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0xFF, 0xFF, 0x6D, 0x9F,
  0xF6, 0xED, 0xB3, 0x6C, 0xDB, 0x7C, 0xDB, 0x36, 0xDD, 0xB6, 0x60, 0x33,
  0x0F, 0xE3, 0x99, 0xC7, 0x71, 0x98, 0x66, 0x19, 0x86, 0x63, 0xB8, 0xE0,
  0x1C, 0x1F, 0x9D, 0xDC, 0x6C, 0x3E, 0x1B, 0x0D, 0x8E, 0xFE, 0x3E, 0x00,
  0x37, 0x1F, 0xCE, 0xEE, 0x37, 0x1B, 0x0D, 0x86, 0xC7, 0x7F, 0x7F, 0x38,
  0x18, 0x0C, 0x06, 0x00, 0x19, 0xBF, 0xDD, 0xFC, 0x6C, 0x36, 0x1B, 0x0D,
  0x8E, 0xFF, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x67, 0x6F, 0x7F, 0x70,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x1C, 0x3F, 0x98, 0xEC, 0x07, 0x81,
  0xF0, 0x1D, 0x86, 0xFF, 0x3F, 0x00, 0x1C, 0x0C, 0x1F, 0xEF, 0xF9, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0F, 0xC3, 0xE0, 0x61, 0xB0, 0xD8, 0xEC,
  0x7E, 0x37, 0x1B, 0x0D, 0x8E, 0xFF, 0x3F, 0x80, 0xE1, 0xD8, 0x66, 0x39,
  0x8C, 0x66, 0x19, 0x83, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0xCC, 0xF3, 0x6D,
  0xDB, 0x76, 0xDF, 0x3F, 0xCE, 0xF3, 0xB8, 0xEE, 0x33, 0x80, 0x30, 0xE7,
  0x38, 0x6E, 0x0F, 0x80, 0xE0, 0x1C, 0x07, 0x81, 0xF8, 0x73, 0x1C, 0x30,
  0x70, 0x6E, 0x1C, 0xC7, 0x18, 0xC3, 0xB8, 0x36, 0x07, 0xC0, 0xF0, 0x1C,
  0x01, 0x80, 0x60, 0x1C, 0x0F, 0x01, 0xC0, 0x00, 0x3F, 0xCF, 0xF4, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xBF, 0xE0, 0x0C, 0x3C, 0x60,
  0xC3, 0x86, 0x0C, 0x38, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x30,
  0x11, 0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0xCC, 0xC0, 0x30, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0E, 0x0E, 0x38, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0xC0,
  0x78, 0xFF, 0x3C, 0xF8, 0x0C,
};

const GFXglyph RobotoMono_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 5, 11, 3, -14 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 9, 17, 11, 1, -15 },
  { 52, 9, 13, 11, 1, -13 },
  { 67, 10, 13, 11, 0, -13 },
  { 84, 3, 5, 11, 4, -14 },
  { 86, 6, 18, 11, 3, -14 },
  { 100, 7, 18, 11, 1, -14 },
  { 116, 9, 9, 11, 1, -13 },
  { 127, 9, 10, 11, 1, -11 },
  { 139, 4, 6, 11, 2, -2 },
  { 142, 8, 2, 11, 2, -7 },
  { 144, 3, 3, 11, 3, -3 },
  { 146, 9, 14, 11, 1, -13 },
  { 162, 9, 13, 11, 1, -13 },
  { 177, 6, 13, 11, 2, -13 },
  { 187, 10, 13, 11, 0, -13 },
  { 204, 10, 13, 11, 0, -13 },
  { 221, 9, 13, 11, 0, -13 },
  { 236, 9, 13, 11, 1, -13 },
  { 251, 8, 13, 11, 1, -13 },
  { 264, 10, 13, 11, 1, -13 },
  { 281, 9, 13, 11, 1, -13 },
  { 296, 9, 13, 11, 1, -13 },
  { 311, 5, 10, 11, 3, -10 },
  { 318, 6, 14, 11, 2, -10 },
  { 329, 9, 9, 11, 1, -10 },
  { 340, 9, 5, 11, 1, -8 },
  { 346, 8, 9, 11, 1, -10 },
  { 355, 8, 13, 11, 2, -13 },
  { 368, 11, 13, 11, 0, -13 },
  { 386, 11, 13, 11, -1, -13 },
  { 404, 11, 13, 11, 0, -13 },
  { 422, 9, 13, 11, 1, -13 },
  { 437, 10, 13, 11, 0, -13 },
  { 454, 11, 13, 11, 0, -13 },
  { 472, 11, 13, 11, 0, -13 },
  { 490, 9, 13, 11, 1, -13 },
  { 505, 11, 13, 11, 0, -13 },
  { 523, 9, 13, 11, 1, -13 },
  { 538, 10, 13, 11, 1, -13 },
  { 555, 12, 13, 11, 0, -13 },
  { 575, 9, 13, 11, 0, -13 },
  { 590, 11, 13, 11, 0, -13 },
  { 608, 11, 13, 11, 0, -13 },
  { 626, 9, 13, 11, 1, -13 },
  { 641, 11, 13, 11, 0, -13 },
  { 659, 9, 15, 11, 1, -13 },
  { 676, 11, 13, 11, 0, -13 },
  { 694, 11, 13, 11, 0, -13 },
  { 712, 11, 13, 11, 1, -13 },
  { 730, 10, 13, 11, 1, -13 },
  { 747, 10, 13, 11, 1, -13 },
  { 764, 10, 13, 11, 1, -13 },
  { 781, 13, 13, 11, -1, -13 },
  { 803, 10, 13, 11, 2, -13 },
  { 820, 11, 13, 11, 0, -13 },
  { 838, 7, 18, 11, 2, -15 },
  { 854, 5, 14, 11, 3, -13 },
  { 863, 7, 18, 11, 2, -15 },
  { 879, 7, 7, 11, 2, -13 },
  { 886, 8, 2, 11, 0, 0 },
  { 888, 3, 2, 11, 5, -13 },
  { 889, 8, 10, 11, 1, -10 },
  { 899, 10, 14, 11, 0, -14 },
  { 917, 8, 10, 11, 1, -10 },
  { 927, 10, 14, 11, 1, -14 },
  { 945, 9, 10, 11, 1, -10 },
  { 957, 10, 14, 11, 1, -14 },
  { 975, 10, 14, 11, 0, -10 },
  { 993, 10, 14, 11, 0, -14 },
  { 1011, 8, 13, 11, 1, -13 },
  { 1024, 9, 17, 11, 0, -13 },
  { 1044, 11, 14, 11, 0, -14 },
  { 1064, 8, 14, 11, 1, -14 },
  { 1078, 10, 10, 11, 0, -10 },
  { 1091, 10, 10, 11, 0, -10 },
  { 1104, 9, 10, 11, 1, -10 },
  { 1116, 9, 14, 11, 0, -10 },
  { 1132, 9, 14, 11, 1, -10 },
  { 1148, 8, 10, 11, 2, -10 },
  { 1158, 9, 10, 11, 1, -10 },
  { 1170, 9, 12, 11, 1, -12 },
  { 1184, 9, 10, 11, 1, -10 },
  { 1196, 10, 10, 11, 1, -10 },
  { 1209, 10, 10, 11, 1, -10 },
  { 1222, 11, 10, 11, 0, -10 },
  { 1236, 11, 14, 11, 0, -10 },
  { 1256, 10, 10, 11, 0, -10 },
  { 1269, 7, 17, 11, 3, -14 },
  { 1284, 4, 17, 11, 3, -13 },
  { 1293, 7, 17, 11, 2, -14 },
  { 1308, 10, 4, 11, 0, -7 },
};

const GFXfont RobotoMono_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic18pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_BOLDITALIC18PT7B_H_
