#ifndef _ROBOTOMONO_BOLDITALIC40PT7B_H_
#define _ROBOTOMONO_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0,
  0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE,
  0x1C, 0xE0, 0xE7, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x70, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x70, 0x00, 0xF1, 0xE0,
  0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x80, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x0F,
  0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xC3,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFE, 0x0F, 0x87, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01,
  0xF9, 0xF8, 0x0F, 0xC7, 0xE1, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xDE, 0x00, 0x78, 0xE0, 0xC7, 0x0E, 0x1E, 0x70, 0xE3, 0xCF, 0x0E, 0x38,
  0xF1, 0xE7, 0x07, 0xFE, 0xF0, 0x7F, 0xDE, 0x03, 0xF9, 0xC0, 0x06, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0xF8, 0x03, 0x9F, 0xE0, 0x7B, 0xFE, 0x0F, 0x78, 0xF0, 0xE7, 0x8F, 0x1C,
  0x70, 0xF3, 0xC7, 0x0F, 0x18, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7C, 0x7C, 0x00, 0xF0,
  0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0x1F, 0xFC, 0x3E, 0x7F, 0xFC, 0x7C, 0xFC, 0xF9, 0xF3,
  0xF1, 0xFB, 0xE7, 0xC1, 0xFF, 0xCF, 0x83, 0xFF, 0x1F, 0x03, 0xFC, 0x3E,
  0x07, 0xF8, 0x7E, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0x9F, 0x80, 0x7D, 0xE7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3,
  0xCE, 0x00, 0x00, 0x08, 0x00, 0x60, 0x07, 0x80, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0,
  0x02, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x1C, 0x00,
  0x40, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x40, 0xE0, 0xDE, 0x1C, 0x7B, 0xF3, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0x70, 0x07,
  0xCF, 0x01, 0xF1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x60, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x20, 0x7F, 0xFF, 0xBF, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x39, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xF1, 0xF0,
  0x3F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0xFF, 0x7E,
  0x1F, 0xE7, 0xE7, 0xFE, 0x7C, 0xFB, 0xE7, 0xFF, 0x3E, 0x7F, 0xC7, 0xE7,
  0xF8, 0x7E, 0x7E, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x0F, 0xC3, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xDE, 0x3E, 0x81, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x13, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xFC,
  0x7E, 0x1F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E,
  0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x70, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x60, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0xFC,
  0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x87, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF9, 0xF0, 0x3E,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xE7, 0xF7, 0xF0, 0x7E, 0xFC,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0x7C, 0x7E, 0x3F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xF8,
  0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0,
  0xFC, 0x1F, 0x07, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xF8, 0xF8, 0x07,
  0xCF, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E,
  0x1F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0x83, 0xE7, 0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFD, 0xFD,
  0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFE, 0xF8, 0x1E, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x07, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0x87, 0xC0,
  0x00, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0x80, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x1E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0x71,
  0xE3, 0xF1, 0xC7, 0x1F, 0xE7, 0x38, 0xFF, 0x9C, 0xE7, 0x8E, 0x77, 0x1C,
  0x39, 0xDC, 0xF1, 0xC7, 0x73, 0x87, 0x1F, 0xCE, 0x1C, 0x7E, 0x38, 0x71,
  0xB9, 0xE3, 0xCE, 0xE7, 0x8E, 0x3B, 0x9E, 0x38, 0xCE, 0x79, 0xE7, 0x38,
  0xFF, 0xF8, 0xE3, 0xFF, 0xE3, 0x87, 0x9E, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x08, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0,
  0x7C, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x83, 0xFC, 0x3F, 0x00, 0xF8, 0x7E, 0x01,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x1F, 0x80, 0x7E, 0x3F, 0x07, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x0F, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x81, 0xF8,
  0x7F, 0x0F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x03, 0xF1,
  0xF8, 0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0x9F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x3E, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0xFF, 0xDF, 0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xC3, 0xFF,
  0x3E, 0x1F, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0,
  0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F,
  0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0xF8, 0x07, 0xF0,
  0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF3, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x0F,
  0xF1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF3, 0xFE, 0x0F, 0xF3, 0xFE, 0x0F,
  0x7F, 0xBE, 0x0F, 0x7F, 0xBC, 0x1F, 0x7F, 0x7C, 0x1F, 0x7F, 0x7C, 0x1F,
  0x7F, 0x7C, 0x1F, 0x7E, 0x7C, 0x1F, 0x3E, 0x7C, 0x1E, 0x3C, 0x78, 0x3E,
  0x3C, 0xF8, 0x3E, 0x38, 0xF8, 0x3E, 0x38, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F,
  0xF8, 0x7C, 0x0F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F,
  0x3C, 0xF8, 0x1F, 0x3C, 0xF8, 0x1F, 0x3C, 0xF8, 0x3F, 0x3D, 0xF8, 0x3F,
  0x1F, 0xF8, 0x3F, 0x1F, 0xF0, 0x3E, 0x1F, 0xF0, 0x3E, 0x1F, 0xF0, 0x3E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xE0, 0x7C,
  0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xFC,
  0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0x1F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F,
  0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87,
  0xC0, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0x1F,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7C, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xE1, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x8F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80,
  0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x3F,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03,
  0xE3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x7C, 0x3C, 0x3F, 0x7C, 0x3C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0x7C, 0xFC, 0x7C, 0x7C,
  0xFC, 0xF8, 0x7C, 0xFC, 0xF8, 0x7D, 0xFC, 0xF8, 0x7D, 0xFC, 0xF0, 0x79,
  0xFD, 0xF0, 0x7B, 0xFD, 0xF0, 0x7B, 0xFD, 0xE0, 0x7B, 0xBF, 0xE0, 0x7B,
  0xBF, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x80, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0xFE,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xE1, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0xFC,
  0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x80, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0,
  0xF8, 0x7C, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xBC, 0x0F, 0x9E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E,
  0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F, 0x00, 0x30, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x7E,
  0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0x87, 0xE7, 0xE0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0x7C, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFC, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x8C, 0x01, 0xF3, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xF0, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFB, 0xFF, 0x0F, 0x9F, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0xC0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F, 0x9F, 0x81, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0xFC, 0x0F, 0x8F,
  0xC3, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x41,
  0xF0, 0x1F, 0xE7, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF8, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xEF, 0x80, 0x7F, 0x3E, 0x00, 0x00,
  0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x03, 0x0F, 0xC1, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xE7, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xC1, 0xFC, 0xFC, 0x07,
  0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8,
  0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7E, 0x07, 0xE3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xF3, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x60, 0x1F, 0x83,
  0x81, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x86, 0x01,
  0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xF8, 0x3F,
  0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x17, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF1, 0xF0, 0x3F, 0x87, 0xC1,
  0xFC, 0x1F, 0x0F, 0xE0, 0x7C, 0x7F, 0x03, 0xF3, 0xF8, 0x0F, 0x9F, 0x80,
  0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00,
  0x08, 0x10, 0x1F, 0x7C, 0xF8, 0x3D, 0xFB, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xE3, 0xE3, 0xE7,
  0xC7, 0xC7, 0x8F, 0x8F, 0x9F, 0x1F, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C,
  0xF8, 0xF8, 0xF1, 0xF1, 0xE3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x9F,
  0x1F, 0x1F, 0x00, 0x00, 0x02, 0x01, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF3, 0xF8, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x20,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0x81, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E,
  0xFC, 0x0F, 0xDF, 0x83, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x1F, 0x3F, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F,
  0x01, 0xF8, 0xFE, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0xFF,
  0xC0, 0xF9, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x9F, 0x0F, 0xFD, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07,
  0xEF, 0xC0, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x0F, 0x8F, 0xE3, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0x81, 0xFD, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0xF8, 0xFF, 0x0F, 0xBF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xEF,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x82, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F,
  0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07,
  0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0xFC, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFE, 0xF8, 0x1F,
  0xCF, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x07, 0x83, 0xF0, 0x3E,
  0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x01, 0xE7, 0xC0,
  0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x78,
  0x7F, 0xE1, 0xE1, 0xFF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0xF8, 0xF8, 0xFB,
  0xE7, 0xE7, 0xCF, 0x9F, 0x9F, 0x3E, 0x7E, 0x78, 0xF3, 0xB9, 0xE3, 0xCE,
  0xEF, 0x8F, 0x3B, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3F, 0xC3, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0x0F,
  0xC0, 0xFE, 0x07, 0xC0, 0xFC, 0x07, 0xE1, 0xF8, 0x03, 0xE3, 0xF0, 0x03,
  0xF7, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0x87, 0xC0, 0x1F,
  0x87, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0x83, 0xE0,
  0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78,
  0x3C, 0x1C, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0xF3, 0xFF, 0x03, 0xDF,
  0xFE, 0x1F, 0x7C, 0xFF, 0xFB, 0xC1, 0xFF, 0xEF, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0x80,
};

const GFXglyph RobotoMono_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 13, 10, 23, 7, -30 },
  { 53, 23, 28, 23, 0, -28 },
  { 134, 21, 37, 23, 2, -33 },
  { 232, 20, 29, 23, 2, -29 },
  { 305, 23, 29, 23, 0, -29 },
  { 389, 6, 11, 23, 10, -30 },
  { 398, 14, 41, 23, 6, -32 },
  { 470, 14, 41, 23, 3, -32 },
  { 542, 19, 20, 23, 3, -28 },
  { 590, 20, 21, 23, 2, -24 },
  { 643, 8, 13, 23, 4, -5 },
  { 656, 17, 5, 23, 5, -15 },
  { 667, 7, 7, 23, 7, -7 },
  { 674, 20, 30, 23, 2, -28 },
  { 749, 20, 29, 23, 2, -29 },
  { 822, 13, 28, 23, 5, -28 },
  { 868, 21, 29, 23, 0, -29 },
  { 945, 21, 29, 23, 1, -29 },
  { 1022, 21, 28, 23, 0, -28 },
  { 1096, 22, 28, 23, 1, -28 },
  { 1173, 19, 29, 23, 2, -29 },
  { 1242, 21, 28, 23, 2, -28 },
  { 1316, 21, 29, 23, 1, -29 },
  { 1393, 18, 29, 23, 3, -29 },
  { 1459, 10, 23, 23, 7, -23 },
  { 1488, 13, 31, 23, 5, -23 },
  { 1539, 18, 19, 23, 3, -22 },
  { 1582, 20, 12, 23, 2, -18 },
  { 1612, 20, 18, 23, 1, -21 },
  { 1657, 18, 29, 23, 5, -29 },
  { 1723, 22, 28, 23, 1, -28 },
  { 1800, 23, 28, 23, -2, -28 },
  { 1881, 23, 28, 23, 0, -28 },
  { 1962, 22, 29, 23, 1, -29 },
  { 2042, 22, 28, 23, 0, -28 },
  { 2119, 23, 28, 23, 1, -28 },
  { 2200, 23, 28, 23, 1, -28 },
  { 2281, 21, 29, 23, 2, -29 },
  { 2358, 24, 28, 23, 0, -28 },
  { 2442, 21, 28, 23, 2, -28 },
  { 2516, 23, 28, 23, 1, -28 },
  { 2597, 27, 28, 23, 0, -28 },
  { 2692, 19, 28, 23, 1, -28 },
  { 2759, 24, 28, 23, 0, -28 },
  { 2843, 24, 28, 23, 0, -28 },
  { 2927, 22, 29, 23, 1, -29 },
  { 3007, 23, 28, 23, 1, -28 },
  { 3088, 22, 34, 23, 1, -29 },
  { 3182, 23, 28, 23, 0, -28 },
  { 3263, 22, 29, 23, 1, -29 },
  { 3343, 23, 28, 23, 3, -28 },
  { 3424, 22, 28, 23, 2, -28 },
  { 3501, 22, 28, 23, 3, -28 },
  { 3578, 24, 28, 23, 2, -28 },
  { 3662, 27, 28, 23, -1, -28 },
  { 3757, 22, 28, 23, 4, -28 },
  { 3834, 24, 28, 23, 0, -28 },
  { 3918, 14, 40, 23, 5, -33 },
  { 3988, 9, 30, 23, 8, -28 },
  { 4022, 14, 40, 23, 5, -33 },
  { 4092, 16, 15, 23, 4, -28 },
  { 4122, 18, 4, 23, 0, 0 },
  { 4131, 8, 6, 23, 11, -29 },
  { 4137, 20, 22, 23, 1, -22 },
  { 4192, 20, 30, 23, 1, -30 },
  { 4267, 19, 22, 23, 2, -22 },
  { 4320, 22, 30, 23, 2, -30 },
  { 4403, 19, 22, 23, 2, -22 },
  { 4456, 22, 31, 23, 3, -31 },
  { 4542, 21, 30, 23, 1, -22 },
  { 4621, 20, 30, 23, 1, -30 },
  { 4696, 18, 30, 23, 2, -30 },
  { 4764, 18, 39, 23, 1, -30 },
  { 4852, 22, 30, 23, 1, -30 },
  { 4935, 18, 30, 23, 2, -30 },
  { 5003, 23, 22, 23, -1, -22 },
  { 5067, 20, 22, 23, 1, -22 },
  { 5122, 19, 22, 23, 2, -22 },
  { 5175, 22, 30, 23, -1, -22 },
  { 5258, 20, 30, 23, 2, -22 },
  { 5333, 20, 22, 23, 3, -22 },
  { 5388, 20, 22, 23, 1, -22 },
  { 5443, 19, 26, 23, 3, -26 },
  { 5505, 20, 21, 23, 2, -21 },
  { 5558, 21, 21, 23, 3, -21 },
  { 5614, 22, 21, 23, 2, -21 },
  { 5672, 24, 21, 23, 0, -21 },
  { 5735, 25, 30, 23, 0, -21 },
  { 5829, 23, 21, 23, 0, -21 },
  { 5890, 15, 38, 23, 6, -31 },
  { 5962, 9, 36, 23, 7, -28 },
  { 6003, 15, 38, 23, 4, -31 },
  { 6075, 22, 9, 23, 0, -16 },
};

const GFXfont RobotoMono_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic40pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_BOLDITALIC40PT7B_H_
