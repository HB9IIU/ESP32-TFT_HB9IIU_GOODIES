#ifndef _ROBOTOMONO_BOLDITALIC28PT7B_H_
#define _ROBOTOMONO_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7,
  0x80, 0x00, 0x00, 0x61, 0xE3, 0xC7, 0x80, 0x63, 0xF1, 0xF8, 0xDC, 0x6E,
  0x76, 0x3B, 0x1C, 0x00, 0xC7, 0x00, 0xC6, 0x01, 0xCE, 0x01, 0x8C, 0x03,
  0x8C, 0x03, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0x38, 0x06, 0x30, 0x0E,
  0x70, 0x0E, 0x70, 0xFF, 0xFC, 0xFF, 0xFC, 0x1C, 0xE0, 0x18, 0xC0, 0x39,
  0xC0, 0x31, 0xC0, 0x31, 0x80, 0x73, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x1F, 0x80, 0xFF, 0xC3, 0xFF, 0x87, 0x87, 0x8E, 0x0F, 0x3C, 0x1E,
  0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x3D, 0xE0, 0x7B, 0xC0, 0xF3, 0xC3, 0xC7, 0xFF, 0x87, 0xFE,
  0x07, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x03, 0xF0, 0x39,
  0x89, 0x8C, 0x6C, 0x67, 0x63, 0x73, 0xFB, 0x0F, 0xB8, 0x13, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xDF, 0x0D, 0xFC, 0xEC, 0x6E, 0x63, 0x67, 0x18,
  0x39, 0xC0, 0xFC, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0x80, 0x1F, 0x87, 0x3F, 0xC7, 0x79, 0xEF, 0x79, 0xEE, 0x70, 0xFE, 0xF0,
  0xFC, 0x78, 0x78, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x9E, 0x77, 0x6E, 0xEE,
  0xE0, 0x00, 0x80, 0x70, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x20,
  0x04, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x01, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x63, 0x09, 0xED, 0xFF, 0xFF, 0xC3,
  0xF8, 0x0F, 0x80, 0x76, 0x03, 0xDC, 0x1E, 0x30, 0x70, 0xE0, 0x83, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x3C, 0xE3, 0x9E, 0x79, 0xCE, 0x38, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x67, 0xBF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE0, 0xFF, 0x8F, 0xFC, 0x78, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0xEE, 0x1F,
  0xF1, 0xFF, 0xBF, 0xFF, 0xDF, 0xF8, 0xFF, 0x87, 0x70, 0x7B, 0x83, 0xDC,
  0x1E, 0xF1, 0xE7, 0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0x00, 0xC0, 0xF1, 0xF9,
  0xFE, 0x7F, 0xB9, 0xE8, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xC0, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x3C, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xEF, 0x03,
  0x9C, 0x0F, 0x38, 0x3C, 0xF0, 0x71, 0xE1, 0xC3, 0xC7, 0x07, 0x9F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1D, 0xF0, 0x3F, 0xF0, 0xFF, 0xF0, 0x61, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x7C, 0x7F, 0xF3, 0xFF, 0xDE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC1, 0xFE, 0x0F, 0x78, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E,
  0x1F, 0xF8, 0x3F, 0x83, 0xFF, 0x1F, 0x3C, 0x78, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0xF3, 0xFF, 0xC7, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFF,
  0x0F, 0xFC, 0xF1, 0xE7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xFF, 0x7C, 0xFF, 0xE3, 0xFF, 0x02, 0x70, 0x07, 0x80, 0x78, 0x07,
  0xC3, 0xFC, 0x1F, 0x80, 0xF0, 0x00, 0x18, 0x7C, 0xF9, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x0F, 0x9F, 0x3E, 0x78, 0x06, 0x0F, 0x1F, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x38,
  0x78, 0x78, 0x70, 0xE0, 0xE0, 0x40, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F,
  0xE7, 0xFC, 0x7F, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xF8,
  0x01, 0xC0, 0x02, 0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x20, 0x01, 0xE0, 0x0F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xE0, 0x7F, 0x1F, 0xF3, 0xFC,
  0x3F, 0x81, 0xE0, 0x0C, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF0,
  0xFF, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0x73, 0x8C,
  0x66, 0x7E, 0xD9, 0xFD, 0xB3, 0x33, 0xEE, 0x67, 0x98, 0xCF, 0x31, 0x9E,
  0xE7, 0x2D, 0xCC, 0xD9, 0xB9, 0xB3, 0xFE, 0x63, 0x38, 0xE0, 0x00, 0xE1,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xDC, 0x03, 0xDC, 0x03, 0xDC, 0x03, 0x9C, 0x07,
  0x9C, 0x07, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0x0F, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x38, 0x1E, 0x78,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x0F, 0x78, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1E, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x7C, 0x78,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x04, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF0, 0xF3, 0xC1,
  0xE7, 0x03, 0xDE, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC7, 0xF7,
  0x8F, 0xEF, 0x1F, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1C, 0x78, 0x78, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0E, 0x07, 0x8F, 0x03, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x38, 0x78, 0x1C, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x07, 0xE3, 0xC0, 0xF0, 0x78,
  0x3C, 0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0x3E, 0x01, 0xEF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF,
  0x00, 0xF9, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x0E, 0x07,
  0x81, 0xC0, 0xF8, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xF3, 0xE1,
  0xFB, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xEE, 0x1C, 0xF7,
  0x0E, 0x73, 0x87, 0x39, 0xC3, 0x99, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xE0,
  0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x80, 0x0E, 0x07,
  0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xFC, 0x78, 0x7E,
  0x38, 0x7F, 0x3C, 0x3D, 0x9E, 0x1E, 0xEF, 0x0F, 0x77, 0x87, 0x3B, 0xC7,
  0x8D, 0xC3, 0xC7, 0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0x78, 0x7C, 0x38, 0x3E,
  0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1,
  0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1F, 0xE0, 0x3F,
  0xC0, 0x77, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0x78,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38,
  0x1E, 0x78, 0x7C, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x10, 0x0F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xFE, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x78, 0x70,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x3E,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF3, 0xC1, 0xE7, 0x01, 0xCF,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7C, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x78,
  0xF0, 0x78, 0x78, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xF0, 0x1F,
  0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x38, 0xF0, 0x39, 0xE0, 0x39, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0xF3, 0x8F, 0xF3, 0x8E, 0xE3, 0x8E, 0xE3, 0x9E, 0xE7, 0x9E,
  0xE7, 0x9C, 0xE7, 0x9C, 0xEF, 0xBC, 0xEF, 0xB8, 0xED, 0xB8, 0xED, 0xB8,
  0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x3C,
  0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x3C, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x3E, 0x3C, 0x07, 0x83,
  0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF3,
  0x83, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x78, 0x1C, 0xF0, 0x3F, 0xC0, 0x7F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x02, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x80, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0,
  0xE1, 0xC0, 0x07, 0xE1, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xDC,
  0x3B, 0x8E, 0x71, 0xC6, 0x70, 0xEE, 0x1F, 0x83, 0x80, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0xF8, 0xE3, 0xC7, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0xF8, 0xF7,
  0x83, 0x80, 0x3C, 0x7F, 0xE7, 0xFF, 0x7C, 0x7F, 0x83, 0xFC, 0x1D, 0xE1,
  0xEF, 0xFF, 0x3F, 0xF8, 0xFB, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xDE, 0x0F, 0xFC, 0x3F, 0xF8, 0xF1, 0xE7,
  0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0E, 0xF0, 0x7B,
  0xE3, 0xEF, 0xFF, 0x3F, 0xF8, 0xEF, 0xC0, 0x07, 0xE0, 0x7F, 0xC1, 0xFF,
  0x8F, 0x1E, 0x78, 0x3D, 0xE0, 0xF7, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x07, 0x9E, 0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x9C,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3C, 0x7C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x38,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0xF8, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0x70, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x78,
  0x3D, 0xE0, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x1E,
  0x0C, 0x7F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x3D, 0x00, 0xFE, 0x03,
  0xFE, 0x03, 0xF6, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x03, 0xEF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x3E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x3C, 0x3C, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xB8, 0x00, 0x78, 0x20,
  0x78, 0x71, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xBE, 0x0E, 0xFE,
  0x1F, 0xFC, 0x7C, 0x7C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xCE,
  0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xEF, 0x03,
  0x80, 0x00, 0x40, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x1F, 0xC1, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x1F, 0xFE, 0xFF, 0xEF, 0xFF, 0x00,
  0x00, 0x20, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0xFF, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x1F, 0x1E, 0x3E,
  0x1C, 0x7C, 0x3C, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7D, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x70, 0x7C,
  0xF0, 0x3C, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3B, 0xDE, 0x3F, 0xFE, 0x3F, 0xFE, 0x39, 0xCF, 0x79, 0xCE, 0x79,
  0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0x9E, 0x73, 0x9E, 0xF3, 0x9E, 0xF3,
  0x9C, 0xE7, 0x9C, 0xE7, 0x9C, 0xE7, 0x3C, 0x1C, 0xF8, 0x3B, 0xF8, 0x7F,
  0xF1, 0xF1, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x1C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0E, 0x00,
  0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x1E, 0x78, 0x3D, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0x9E, 0x3E, 0x7F, 0xF0, 0xFF,
  0x81, 0xF8, 0x00, 0x0E, 0x78, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3B, 0xF0, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F, 0x9C, 0x7F,
  0x73, 0xFF, 0xCF, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xBC, 0x1E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0x9E, 0x3E, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x1C, 0x7C,
  0x77, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x78, 0x3C, 0xE0, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xEF, 0x07, 0xBC, 0x1E, 0x7D, 0xF9,
  0xFF, 0xC1, 0xFC, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x78, 0x3D,
  0xE0, 0xF7, 0x03, 0x9C, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1C,
  0xE0, 0x73, 0x83, 0xCE, 0x0F, 0x3C, 0x7C, 0xFF, 0xF3, 0xFF, 0x87, 0xCE,
  0x00, 0xF0, 0x3F, 0xC0, 0xF7, 0x07, 0x9C, 0x1E, 0x70, 0xF1, 0xE3, 0xC7,
  0x8E, 0x0E, 0x78, 0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0xE3, 0x1F, 0xCE, 0x3B, 0x9C, 0x77, 0x39, 0xEE,
  0xF3, 0x9D, 0xE7, 0x3B, 0xCE, 0x6F, 0xB8, 0xDB, 0x71, 0xB6, 0xE3, 0xCF,
  0x87, 0x9F, 0x0F, 0x3E, 0x1C, 0x78, 0x38, 0xF0, 0x00, 0x3C, 0x0F, 0x8F,
  0x0F, 0x83, 0x87, 0x81, 0xE7, 0x80, 0x77, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xCF, 0x03, 0xC7,
  0x83, 0xC1, 0xE3, 0xC0, 0xF0, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF0,
  0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x39, 0xE0, 0x0F,
  0x78, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x00,
  0x60, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x0F, 0xC1, 0xE0, 0x3E, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x18,
  0x00, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3,
  0x1C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x38, 0xC3, 0x00, 0x08, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0xC0, 0x70, 0x7C, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x0C, 0x00, 0x3E, 0x04, 0xFF, 0x0D, 0xFF,
  0x3F, 0x1F, 0xFE, 0x0F, 0xC0, 0x0F, 0x00,
};

const GFXglyph RobotoMono_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 20, 16, 5, -20 },
  { 19, 9, 7, 16, 5, -21 },
  { 27, 16, 20, 16, 0, -20 },
  { 67, 15, 26, 16, 1, -23 },
  { 116, 13, 20, 16, 2, -20 },
  { 149, 16, 20, 16, 0, -20 },
  { 189, 4, 7, 16, 7, -21 },
  { 193, 10, 28, 16, 4, -22 },
  { 228, 10, 28, 16, 2, -22 },
  { 263, 14, 14, 16, 2, -20 },
  { 288, 14, 14, 16, 1, -16 },
  { 313, 6, 9, 16, 3, -3 },
  { 320, 11, 3, 16, 4, -10 },
  { 325, 5, 5, 16, 5, -5 },
  { 329, 15, 22, 16, 1, -20 },
  { 371, 13, 20, 16, 2, -20 },
  { 404, 10, 20, 16, 3, -20 },
  { 429, 15, 20, 16, 0, -20 },
  { 467, 14, 20, 16, 1, -20 },
  { 502, 15, 20, 16, 0, -20 },
  { 540, 15, 20, 16, 1, -20 },
  { 578, 13, 20, 16, 1, -20 },
  { 611, 14, 20, 16, 2, -20 },
  { 646, 14, 20, 16, 1, -20 },
  { 681, 13, 20, 16, 2, -20 },
  { 714, 7, 16, 16, 5, -16 },
  { 728, 8, 22, 16, 4, -16 },
  { 750, 13, 13, 16, 2, -15 },
  { 772, 14, 9, 16, 1, -13 },
  { 788, 13, 13, 16, 1, -15 },
  { 810, 13, 20, 16, 3, -20 },
  { 843, 15, 20, 16, 1, -20 },
  { 881, 16, 20, 16, -1, -20 },
  { 921, 16, 20, 16, 0, -20 },
  { 961, 15, 20, 16, 1, -20 },
  { 999, 16, 20, 16, 0, -20 },
  { 1039, 16, 20, 16, 1, -20 },
  { 1079, 16, 20, 16, 1, -20 },
  { 1119, 15, 20, 16, 1, -20 },
  { 1157, 17, 20, 16, 0, -20 },
  { 1200, 15, 20, 16, 1, -20 },
  { 1238, 16, 20, 16, 1, -20 },
  { 1278, 19, 20, 16, 0, -20 },
  { 1326, 13, 20, 16, 1, -20 },
  { 1359, 17, 20, 16, 0, -20 },
  { 1402, 17, 20, 16, 0, -20 },
  { 1445, 15, 20, 16, 1, -20 },
  { 1483, 16, 20, 16, 1, -20 },
  { 1523, 15, 24, 16, 1, -20 },
  { 1568, 16, 20, 16, 0, -20 },
  { 1608, 15, 20, 16, 1, -20 },
  { 1646, 16, 20, 16, 2, -20 },
  { 1686, 16, 20, 16, 1, -20 },
  { 1726, 16, 20, 16, 2, -20 },
  { 1766, 16, 20, 16, 2, -20 },
  { 1806, 19, 20, 16, -1, -20 },
  { 1854, 15, 20, 16, 3, -20 },
  { 1892, 17, 20, 16, 0, -20 },
  { 1935, 11, 28, 16, 3, -23 },
  { 1974, 7, 22, 16, 5, -20 },
  { 1994, 11, 28, 16, 3, -23 },
  { 2033, 11, 11, 16, 3, -20 },
  { 2049, 13, 3, 16, 0, 0 },
  { 2054, 6, 4, 16, 7, -20 },
  { 2057, 13, 15, 16, 1, -15 },
  { 2082, 14, 21, 16, 1, -21 },
  { 2119, 14, 15, 16, 1, -15 },
  { 2146, 16, 21, 16, 1, -21 },
  { 2188, 14, 15, 16, 1, -15 },
  { 2215, 16, 22, 16, 2, -22 },
  { 2259, 16, 21, 16, 0, -15 },
  { 2301, 15, 21, 16, 0, -21 },
  { 2341, 13, 21, 16, 1, -21 },
  { 2376, 13, 27, 16, 1, -21 },
  { 2420, 16, 21, 16, 0, -21 },
  { 2462, 13, 21, 16, 1, -21 },
  { 2497, 16, 15, 16, 0, -15 },
  { 2527, 15, 15, 16, 0, -15 },
  { 2556, 14, 15, 16, 1, -15 },
  { 2583, 16, 21, 16, -1, -15 },
  { 2625, 14, 21, 16, 1, -15 },
  { 2662, 14, 15, 16, 2, -15 },
  { 2689, 14, 15, 16, 1, -15 },
  { 2716, 13, 18, 16, 2, -18 },
  { 2746, 14, 15, 16, 2, -15 },
  { 2773, 14, 15, 16, 2, -15 },
  { 2800, 15, 15, 16, 2, -15 },
  { 2829, 17, 15, 16, 0, -15 },
  { 2861, 18, 21, 16, 0, -15 },
  { 2909, 16, 15, 16, 0, -15 },
  { 2939, 11, 27, 16, 4, -22 },
  { 2977, 6, 26, 16, 5, -20 },
  { 2997, 10, 27, 16, 3, -22 },
  { 3031, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic28pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_BOLDITALIC28PT7B_H_
