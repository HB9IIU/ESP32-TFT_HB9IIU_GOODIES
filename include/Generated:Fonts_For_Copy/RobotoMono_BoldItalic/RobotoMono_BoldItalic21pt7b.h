#ifndef _ROBOTOMONO_BOLDITALIC21PT7B_H_
#define _ROBOTOMONO_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x67, 0x39, 0xCE, 0x63, 0x00, 0x0C, 0x73, 0x80, 0x66,
  0xCD, 0x9B, 0x34, 0x78, 0x80, 0x03, 0x30, 0x26, 0x06, 0x60, 0x64, 0x3F,
  0xF3, 0xFF, 0x0C, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xC3, 0x30, 0x36,
  0x06, 0x60, 0x66, 0x00, 0x03, 0x00, 0x60, 0x3E, 0x0F, 0xE3, 0x8E, 0x61,
  0xCC, 0x39, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xEE, 0x1D, 0xC3, 0xB8,
  0xF3, 0xFC, 0x3F, 0x01, 0x00, 0x60, 0x00, 0x38, 0x1F, 0x0C, 0xCF, 0x36,
  0xCD, 0x1E, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0xF3, 0x6C, 0x9B, 0x66, 0xC1,
  0xB0, 0x78, 0x07, 0x80, 0xFC, 0x1C, 0xC1, 0x8C, 0x19, 0xC1, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x37, 0x77, 0x63, 0xEE, 0x3E, 0xF3, 0xC7, 0xFC, 0x3E,
  0xE0, 0x6D, 0xBD, 0x80, 0x02, 0x0C, 0x38, 0xE1, 0x86, 0x0C, 0x38, 0x60,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x81, 0x83, 0x02, 0x00,
  0x10, 0x30, 0x60, 0x60, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC1,
  0x87, 0x0E, 0x18, 0x71, 0xC7, 0x0C, 0x10, 0x00, 0x0E, 0x03, 0x00, 0xC3,
  0x33, 0xFF, 0xCF, 0xC1, 0xC0, 0xD8, 0x66, 0x31, 0xC0, 0x40, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x37, 0x77, 0xEC, 0xFF, 0xFF, 0xFF, 0x27, 0xF7, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x0F, 0x87, 0xF3, 0x9D, 0xC3, 0x70,
  0xDC, 0x77, 0x3D, 0xBF, 0xF9, 0xFC, 0x7E, 0x1F, 0x8E, 0x63, 0x9F, 0xC3,
  0xE0, 0x03, 0x1E, 0x7E, 0x7E, 0xCE, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x0F, 0x83, 0xF8, 0xF3, 0x9C, 0x77, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xBF,
  0xF0, 0x1F, 0x87, 0xF9, 0xE7, 0x38, 0x70, 0x0C, 0x03, 0x83, 0xE0, 0xF8,
  0x1F, 0x80, 0x30, 0x07, 0x60, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x00, 0xE0,
  0x3C, 0x0F, 0x83, 0xE0, 0x6C, 0x1B, 0x87, 0x71, 0xCE, 0x71, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xE7, 0xFC, 0xE0, 0x18,
  0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x9C, 0x01, 0xC0, 0x38, 0x07, 0x71, 0xCE,
  0x38, 0xFE, 0x0F, 0x80, 0x03, 0x83, 0xE1, 0xE0, 0xE0, 0x70, 0x1F, 0xCF,
  0xFB, 0xCE, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE3, 0x9F, 0xC3, 0xE0, 0x7F,
  0xEF, 0xFC, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x00, 0x0F, 0x8F, 0xF3, 0x9D,
  0xC3, 0x71, 0xDC, 0x73, 0xF8, 0xFC, 0x7F, 0xB8, 0x6E, 0x1B, 0x8E, 0xE3,
  0xBF, 0xC7, 0xE0, 0x1F, 0x0F, 0xE7, 0x9D, 0xC7, 0x61, 0xD8, 0x76, 0x1D,
  0xCF, 0x7F, 0xCF, 0x60, 0x38, 0x1C, 0x0F, 0x1F, 0x87, 0x80, 0x23, 0xDE,
  0xE0, 0x00, 0x00, 0x47, 0x39, 0xC0, 0x08, 0x73, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x1C, 0x71, 0x8E, 0x30, 0x00, 0xC0, 0xF1, 0xFD, 0xF8, 0x70,
  0x3E, 0x03, 0xF0, 0x3E, 0x03, 0x80, 0x7F, 0xEF, 0xF9, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x60, 0x1E, 0x07, 0xF0, 0x3F, 0x01, 0xC3, 0xE7,
  0xF3, 0xE0, 0xE0, 0x20, 0x00, 0x1F, 0x1F, 0xE7, 0x1F, 0x87, 0x01, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80,
  0x03, 0xC0, 0xFE, 0x18, 0x33, 0x3B, 0x37, 0xD6, 0xC9, 0x6C, 0x94, 0x9B,
  0xD9, 0xBD, 0x92, 0xDF, 0xE4, 0xDC, 0x60, 0x07, 0xF0, 0x1F, 0x00, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xE6, 0x1C,
  0x61, 0xFE, 0x3F, 0xE3, 0xFF, 0x70, 0x77, 0x07, 0xE0, 0x70, 0x1F, 0xC1,
  0xFE, 0x38, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x3F, 0xE3, 0xFC, 0x71, 0xE7,
  0x06, 0x70, 0x67, 0x0E, 0x61, 0xEF, 0xFC, 0xFF, 0x80, 0x0F, 0x87, 0xF8,
  0xE7, 0xB8, 0x76, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87,
  0x70, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x1F, 0x01, 0xFC, 0x39, 0xE3, 0x8E,
  0x38, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x1C,
  0x63, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x86, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xFF, 0x87, 0xF8, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x02, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0F, 0x83, 0xF8, 0xE7, 0xB8,
  0x77, 0x0F, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xDC, 0xFB, 0x87, 0x70, 0xEF,
  0x3C, 0xFF, 0x0F, 0xC0, 0x1C, 0x33, 0x87, 0x38, 0x73, 0x87, 0x38, 0x73,
  0x86, 0x3F, 0xE7, 0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x61, 0xCE,
  0x1C, 0xE1, 0xC0, 0x3F, 0xE7, 0xFC, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC1, 0xFF, 0x3F, 0xC0,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x70, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x1C, 0x3C, 0x61,
  0xE3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xEE, 0x03, 0x70, 0x0F, 0xC0, 0x7F,
  0x81, 0xEE, 0x07, 0x38, 0x1C, 0x70, 0x61, 0xC3, 0x83, 0x8E, 0x0E, 0x00,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFC, 0x1C, 0x78, 0xE7, 0x8F, 0x3C,
  0x79, 0xE3, 0x7F, 0x1B, 0xF8, 0xDD, 0xCE, 0xEC, 0x76, 0x63, 0xB7, 0x1C,
  0x38, 0xC1, 0xC6, 0x0E, 0x70, 0x63, 0x87, 0x00, 0x1C, 0x73, 0xC7, 0x3C,
  0x73, 0xC7, 0x3E, 0x73, 0xE6, 0x36, 0xE7, 0x6E, 0x77, 0xE7, 0x3E, 0x73,
  0xE7, 0x3C, 0x63, 0xCE, 0x1C, 0xE1, 0xC0, 0x0F, 0x87, 0xF8, 0xE7, 0x38,
  0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xDC, 0x3B, 0x87, 0x70, 0xEE,
  0x38, 0xFE, 0x0F, 0x80, 0x1F, 0xC1, 0xFE, 0x18, 0xF3, 0x87, 0x38, 0x73,
  0x87, 0x38, 0x73, 0xFE, 0x3F, 0xC7, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x00, 0x0F, 0x87, 0xF8, 0xE7, 0x38, 0x77, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0x87, 0x70, 0xEE, 0x38, 0xFE, 0x0F, 0xC0,
  0x1C, 0x01, 0xC0, 0x20, 0x1F, 0xC1, 0xFE, 0x38, 0xF3, 0x87, 0x38, 0x73,
  0x87, 0x38, 0xF3, 0xFE, 0x7F, 0x87, 0x38, 0x71, 0x87, 0x1C, 0x61, 0xCE,
  0x1C, 0xE0, 0xE0, 0x0F, 0x87, 0xF9, 0xE3, 0xB8, 0x77, 0x00, 0xE0, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x3B, 0x07, 0x70, 0xEE, 0x3C, 0xFF, 0x0F, 0xC0,
  0x7F, 0xF7, 0xFF, 0x87, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x66, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x33, 0x0E, 0xE1, 0xDC,
  0x3B, 0x87, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0xE0, 0xFC, 0x1F, 0x87,
  0x70, 0xEE, 0x39, 0xC7, 0x18, 0xC3, 0x38, 0x77, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0x70, 0x0E, 0x00, 0x66, 0x36, 0x67, 0x66, 0x76, 0xE6, 0x6E,
  0x66, 0xEE, 0xEA, 0xEF, 0xAC, 0xFB, 0xCF, 0xBC, 0xF3, 0x8F, 0x38, 0xF3,
  0x8E, 0x30, 0xE3, 0x00, 0x1C, 0x1E, 0x38, 0x70, 0x38, 0xE0, 0x73, 0x80,
  0x6E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xE7, 0x03, 0x8E, 0x0F, 0x1E, 0x3C, 0x1C, 0x00, 0xE0, 0xFE, 0x0E,
  0x61, 0xC7, 0x1C, 0x73, 0x87, 0x70, 0x37, 0x03, 0xE0, 0x3C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0x1F, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70,
  0x70, 0x70, 0x70, 0x78, 0xF8, 0xE7, 0x38, 0xC6, 0x31, 0x8E, 0x73, 0x8C,
  0x63, 0x1C, 0xE7, 0x0F, 0x1F, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x78, 0xF8, 0x0E,
  0x07, 0x07, 0x83, 0x63, 0x31, 0x99, 0x8D, 0xC7, 0xFF, 0xFF, 0xE0, 0xE6,
  0x30, 0x3F, 0x1F, 0xE7, 0x1C, 0x07, 0x1F, 0xDF, 0xEE, 0x3B, 0x8E, 0xE7,
  0xBF, 0xE7, 0xB8, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x7F, 0x8F,
  0xF9, 0xC7, 0x30, 0xE6, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0x9F, 0xF7,
  0x78, 0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x86, 0xE3,
  0x9F, 0xC3, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x7D, 0xDF,
  0xF3, 0x8E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xCE, 0x39, 0xC7, 0x1F, 0xE3,
  0xFC, 0x1F, 0x8F, 0xE7, 0x1D, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xF1,
  0x9F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x38, 0x0E, 0x01, 0xC1, 0xFF, 0xBF,
  0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x0F, 0x71, 0xFE, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7,
  0x0C, 0x71, 0xC3, 0xFC, 0x1F, 0xC0, 0x1C, 0x43, 0x8F, 0xF8, 0x7F, 0x00,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x77, 0x8F, 0xF9, 0xC7, 0x30,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0x98, 0x77, 0x0E, 0x07, 0x03,
  0xC0, 0xC0, 0x03, 0xF1, 0xF8, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xC7, 0xFF, 0xFE, 0x01, 0xC0, 0x70, 0x08, 0x00, 0x0F, 0x83, 0xE1, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x1F, 0x87, 0xC2, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x8F, 0x39, 0xE3, 0xBC, 0x37, 0x87, 0xE0, 0x7F, 0x07, 0xF0, 0x73, 0x87,
  0x38, 0x61, 0xCE, 0x1E, 0x1F, 0x9F, 0x8F, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x63, 0xFF, 0xFF, 0x7E, 0xE7,
  0xFF, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0xE6, 0x6E, 0xEE, 0xEE, 0xEC,
  0xCE, 0xCC, 0xC0, 0x3B, 0xC7, 0xFC, 0xE3, 0x98, 0x77, 0x0E, 0xE1, 0xDC,
  0x3B, 0x87, 0x70, 0xCC, 0x3B, 0x87, 0x00, 0x1F, 0x0F, 0xE7, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0x9F, 0xC3, 0xE0, 0x3F, 0xC7, 0xF8,
  0xE3, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x71, 0xCF, 0xF3, 0xBC,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3E, 0xEF, 0xF9, 0xC7, 0x70, 0xEE,
  0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x8F, 0xF1, 0xFE, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x37, 0xDF, 0xF7, 0xF9, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0x9F, 0xF7, 0x1D, 0xC0, 0x7C, 0x0F,
  0xC0, 0x7B, 0x07, 0xE1, 0xBF, 0xE3, 0xF0, 0x1C, 0x0E, 0x06, 0x1F, 0xFF,
  0xF9, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0F, 0x03, 0xF0, 0xF8, 0x70,
  0xEE, 0x1D, 0xC3, 0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x8F,
  0xF1, 0xEE, 0x00, 0xC1, 0xF8, 0x6E, 0x3B, 0x8C, 0x67, 0x19, 0x86, 0xE1,
  0xB0, 0x7C, 0x0E, 0x03, 0x80, 0xE6, 0x7E, 0xE6, 0xEE, 0xEC, 0xEC, 0xDE,
  0xCD, 0xFC, 0xD7, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x00, 0x38, 0x78,
  0xE7, 0x07, 0x70, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xF0, 0x39,
  0xC3, 0x8E, 0x38, 0x38, 0x70, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xC1, 0x9C,
  0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x7C, 0x03, 0xC0, 0x08, 0x00, 0x3F, 0xF3, 0xFF, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFE, 0xFF, 0xC0, 0x07,
  0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x78, 0xE0, 0xF0, 0x30, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x08, 0x13, 0x33, 0x33, 0x22, 0x66,
  0x66, 0x44, 0xCC, 0xCC, 0xC0, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0E, 0x07, 0x0F, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0,
  0x80, 0x7C, 0x37, 0xE6, 0xC7, 0xE4, 0x3C,
};

const GFXglyph RobotoMono_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 15, 12, 4, -15 },
  { 11, 7, 6, 12, 3, -16 },
  { 17, 12, 15, 12, 0, -15 },
  { 40, 11, 19, 12, 1, -17 },
  { 67, 10, 15, 12, 1, -15 },
  { 86, 12, 15, 12, 0, -15 },
  { 109, 3, 6, 12, 5, -16 },
  { 112, 7, 22, 12, 3, -17 },
  { 132, 7, 22, 12, 2, -17 },
  { 152, 10, 11, 12, 2, -15 },
  { 166, 10, 11, 12, 1, -12 },
  { 180, 4, 6, 12, 2, -2 },
  { 183, 8, 3, 12, 3, -8 },
  { 186, 4, 4, 12, 3, -4 },
  { 188, 11, 16, 12, 1, -15 },
  { 210, 10, 15, 12, 1, -15 },
  { 229, 8, 15, 12, 2, -15 },
  { 244, 11, 15, 12, 0, -15 },
  { 265, 11, 15, 12, 1, -15 },
  { 286, 11, 15, 12, 0, -15 },
  { 307, 11, 15, 12, 1, -15 },
  { 328, 10, 15, 12, 1, -15 },
  { 347, 11, 15, 12, 1, -15 },
  { 368, 10, 15, 12, 1, -15 },
  { 387, 10, 15, 12, 1, -15 },
  { 406, 5, 12, 12, 4, -12 },
  { 414, 6, 16, 12, 3, -12 },
  { 426, 10, 9, 12, 1, -11 },
  { 438, 11, 7, 12, 1, -10 },
  { 448, 10, 10, 12, 1, -11 },
  { 461, 10, 15, 12, 2, -15 },
  { 480, 12, 15, 12, 0, -15 },
  { 503, 12, 15, 12, -1, -15 },
  { 526, 12, 15, 12, 0, -15 },
  { 549, 11, 15, 12, 1, -15 },
  { 570, 12, 15, 12, 0, -15 },
  { 593, 13, 15, 12, 0, -15 },
  { 618, 13, 15, 12, 0, -15 },
  { 643, 11, 15, 12, 1, -15 },
  { 664, 12, 15, 12, 0, -15 },
  { 687, 11, 15, 12, 1, -15 },
  { 708, 11, 15, 12, 1, -15 },
  { 729, 14, 15, 12, 0, -15 },
  { 756, 10, 15, 12, 0, -15 },
  { 775, 13, 15, 12, 0, -15 },
  { 800, 12, 15, 12, 0, -15 },
  { 823, 11, 15, 12, 1, -15 },
  { 844, 12, 15, 12, 0, -15 },
  { 867, 11, 18, 12, 1, -15 },
  { 892, 12, 15, 12, 0, -15 },
  { 915, 11, 15, 12, 1, -15 },
  { 936, 12, 15, 12, 1, -15 },
  { 959, 11, 15, 12, 1, -15 },
  { 980, 11, 15, 12, 2, -15 },
  { 1001, 12, 15, 12, 1, -15 },
  { 1024, 15, 15, 12, -1, -15 },
  { 1053, 12, 15, 12, 2, -15 },
  { 1076, 13, 15, 12, 0, -15 },
  { 1101, 8, 20, 12, 2, -17 },
  { 1121, 5, 16, 12, 4, -15 },
  { 1131, 8, 20, 12, 2, -17 },
  { 1151, 9, 8, 12, 2, -15 },
  { 1160, 10, 2, 12, 0, 0 },
  { 1163, 4, 3, 12, 6, -15 },
  { 1165, 10, 11, 12, 1, -11 },
  { 1179, 11, 16, 12, 0, -16 },
  { 1201, 10, 11, 12, 1, -11 },
  { 1215, 11, 16, 12, 1, -16 },
  { 1237, 10, 11, 12, 1, -11 },
  { 1251, 11, 16, 12, 2, -16 },
  { 1273, 12, 15, 12, 0, -11 },
  { 1296, 11, 16, 12, 0, -16 },
  { 1318, 9, 15, 12, 1, -15 },
  { 1335, 10, 20, 12, 0, -15 },
  { 1360, 12, 16, 12, 0, -16 },
  { 1384, 9, 16, 12, 1, -16 },
  { 1402, 12, 11, 12, 0, -11 },
  { 1419, 11, 11, 12, 0, -11 },
  { 1435, 10, 11, 12, 1, -11 },
  { 1449, 11, 15, 12, 0, -11 },
  { 1470, 11, 15, 12, 1, -11 },
  { 1491, 10, 11, 12, 2, -11 },
  { 1505, 10, 11, 12, 1, -11 },
  { 1519, 9, 14, 12, 2, -14 },
  { 1535, 11, 11, 12, 1, -11 },
  { 1551, 10, 11, 12, 2, -11 },
  { 1565, 12, 11, 12, 1, -11 },
  { 1582, 13, 11, 12, 0, -11 },
  { 1600, 13, 16, 12, 0, -11 },
  { 1626, 12, 11, 12, 0, -11 },
  { 1643, 8, 20, 12, 3, -16 },
  { 1663, 4, 19, 12, 4, -15 },
  { 1673, 8, 20, 12, 2, -16 },
  { 1693, 12, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic21pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_BOLDITALIC21PT7B_H_
