#ifndef _ROBOTOMONO_BOLDITALIC8PT7B_H_
#define _ROBOTOMONO_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0xB4, 0x29, 0x9E, 0xCF, 0x50, 0x11, 0x96, 0x83, 0x49,
  0xC4, 0x4B, 0x62, 0x73, 0x22, 0x98, 0xDB, 0x78, 0xC0, 0x29, 0x49, 0x22,
  0x55, 0x5A, 0x5D, 0x50, 0x22, 0xF6, 0xE0, 0xE0, 0xC0, 0x11, 0x22, 0x4C,
  0x35, 0x57, 0xD6, 0x39, 0x24, 0x80, 0x35, 0x12, 0x4F, 0x35, 0x13, 0x96,
  0x13, 0x55, 0xF2, 0x7A, 0x18, 0x29, 0x30, 0x34, 0x7D, 0x96, 0x78, 0x84,
  0x46, 0x60, 0x35, 0x57, 0x96, 0x76, 0xF3, 0x80, 0x43, 0x60, 0x29, 0x00,
  0x71, 0x80, 0x70, 0xF0, 0x61, 0xE0, 0x6B, 0x24, 0x0C, 0x33, 0x77, 0xDF,
  0x30, 0x23, 0x55, 0xF9, 0x72, 0xD4, 0xE9, 0x78, 0x32, 0xF1, 0x09, 0x38,
  0x65, 0x5D, 0x9E, 0x7A, 0x10, 0xE8, 0x78, 0x7A, 0x10, 0xE8, 0x40, 0x32,
  0xD1, 0x69, 0x38, 0x4A, 0xD5, 0xE9, 0x48, 0x79, 0x08, 0x42, 0x78, 0x08,
  0xC4, 0x29, 0x30, 0x4A, 0x98, 0xC9, 0x48, 0x44, 0x44, 0x8F, 0x5A, 0xDD,
  0x69, 0x48, 0x4A, 0xDD, 0xEB, 0x48, 0x32, 0xB7, 0x29, 0x30, 0x72, 0x56,
  0xE8, 0x40, 0x32, 0x97, 0x29, 0x30, 0x40, 0x72, 0xD6, 0xE9, 0x48, 0x32,
  0x50, 0x69, 0x38, 0xF4, 0x44, 0x4C, 0x4A, 0xD4, 0xA9, 0x30, 0x9B, 0xAA,
  0xCC, 0x6B, 0x5D, 0x67, 0x78, 0x4A, 0x8C, 0xC5, 0x48, 0x9A, 0xA4, 0x4C,
  0x78, 0x8C, 0x44, 0x78, 0x69, 0x25, 0x26, 0xD5, 0x50, 0x64, 0xA4, 0x96,
  0x4E, 0x80, 0xF0, 0xC0, 0x77, 0x9F, 0x44, 0x75, 0x9F, 0x7C, 0x87, 0x08,
  0x9D, 0xA9, 0x38, 0x7F, 0x87, 0x74, 0xE4, 0x88, 0x7D, 0x97, 0xB6, 0x44,
  0x75, 0x99, 0x30, 0x62, 0x2F, 0x10, 0x72, 0x22, 0x2C, 0x42, 0x54, 0xCE,
  0x48, 0x72, 0x22, 0x2F, 0xFB, 0xBD, 0x75, 0x99, 0x79, 0x96, 0x75, 0x9F,
  0x88, 0x7D, 0x97, 0x12, 0xF8, 0x88, 0x76, 0x1F, 0x5F, 0x4E, 0x5A, 0xB4,
  0xE0, 0xBA, 0xCC, 0xAD, 0xBD, 0xE0, 0x59, 0x19, 0xA0, 0x5A, 0x98, 0xC4,
  0x40, 0x79, 0x11, 0xE0, 0x29, 0x44, 0x90, 0x55, 0x5A, 0x49, 0x14, 0xA0,
  0xF1,
};

const GFXglyph RobotoMono_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 3, 2, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -6 },
  { 21, 3, 8, 5, 1, -6 },
  { 24, 2, 8, 5, 1, -6 },
  { 26, 3, 4, 5, 1, -6 },
  { 28, 4, 4, 5, 0, -5 },
  { 30, 1, 3, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 2, 1, 5, 1, -1 },
  { 33, 4, 6, 5, 0, -6 },
  { 36, 4, 6, 5, 0, -6 },
  { 39, 3, 6, 5, 1, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 4, 6, 5, 0, -6 },
  { 65, 3, 6, 5, 1, -6 },
  { 68, 2, 4, 5, 1, -4 },
  { 69, 3, 6, 5, 1, -4 },
  { 72, 3, 3, 5, 1, -4 },
  { 74, 4, 3, 5, 0, -4 },
  { 76, 4, 3, 5, 0, -4 },
  { 78, 4, 6, 5, 1, -6 },
  { 81, 5, 6, 5, 0, -6 },
  { 85, 4, 6, 5, 0, -6 },
  { 88, 5, 6, 5, 0, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 5, 7, 5, 0, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 4, 6, 5, 1, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 4, 6, 5, 1, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 4, 6, 5, 1, -6 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 3, 8, 5, 1, -7 },
  { 187, 2, 6, 5, 1, -6 },
  { 189, 3, 8, 5, 1, -7 },
  { 192, 3, 3, 5, 1, -6 },
  { 194, 4, 1, 5, 0, 0 },
  { 195, 2, 1, 5, 2, -6 },
  { 196, 4, 4, 5, 0, -4 },
  { 198, 4, 6, 5, 0, -6 },
  { 201, 4, 4, 5, 0, -4 },
  { 203, 5, 6, 5, 0, -6 },
  { 207, 4, 4, 5, 0, -4 },
  { 209, 4, 6, 5, 1, -6 },
  { 212, 4, 6, 5, 0, -4 },
  { 215, 4, 6, 5, 0, -6 },
  { 218, 4, 6, 5, 0, -6 },
  { 221, 4, 8, 5, 0, -6 },
  { 225, 5, 6, 5, 0, -6 },
  { 229, 4, 6, 5, 0, -6 },
  { 232, 4, 4, 5, 0, -4 },
  { 234, 4, 4, 5, 0, -4 },
  { 236, 4, 4, 5, 0, -4 },
  { 238, 4, 6, 5, 0, -4 },
  { 241, 4, 6, 5, 0, -4 },
  { 244, 4, 4, 5, 1, -4 },
  { 246, 4, 4, 5, 0, -4 },
  { 248, 3, 5, 5, 1, -5 },
  { 250, 5, 4, 5, 0, -4 },
  { 253, 4, 4, 5, 1, -4 },
  { 255, 5, 4, 5, 0, -4 },
  { 258, 5, 4, 5, 0, -4 },
  { 261, 5, 6, 5, 0, -4 },
  { 265, 5, 4, 5, 0, -4 },
  { 268, 3, 7, 5, 1, -6 },
  { 271, 2, 8, 5, 1, -6 },
  { 273, 3, 7, 5, 1, -6 },
  { 276, 4, 2, 5, 0, -3 },
};

const GFXfont RobotoMono_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic8pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_BOLDITALIC8PT7B_H_
