#ifndef _ROBOTOMONO_BOLDITALIC54PT7B_H_
#define _ROBOTOMONO_BOLDITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xCF, 0x83,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1E, 0x3E, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0xC1,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x10,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x0F, 0x81,
  0x07, 0xC3, 0xE0, 0xFB, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E, 0x1F, 0x3E, 0x0F,
  0x8F, 0x8F, 0x83, 0xE3, 0xC3, 0xF1, 0xF1, 0xF0, 0x7E, 0xFC, 0xF8, 0x1F,
  0xFF, 0x3C, 0x03, 0xFF, 0x9E, 0x00, 0x7F, 0xCF, 0x80, 0x07, 0x87, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE3, 0xF8, 0x00,
  0xF3, 0xFF, 0x00, 0x7D, 0xFF, 0xE0, 0x3E, 0x7F, 0xFC, 0x0F, 0x3F, 0x1F,
  0x07, 0xCF, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF0, 0x7C, 0x7C, 0x7C,
  0x1F, 0x0E, 0x1F, 0x07, 0xC1, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xBF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0xFC, 0x3F, 0xFE,
  0x03, 0xF1, 0xFF, 0xFC, 0x1F, 0xCF, 0xFF, 0xF8, 0x7E, 0x3F, 0xCF, 0xE1,
  0xF9, 0xFE, 0x3F, 0xCF, 0xE7, 0xF0, 0x7F, 0x3F, 0x3F, 0xC1, 0xFF, 0xFC,
  0xFE, 0x03, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFC, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0x7F, 0x80, 0x7F, 0xF0, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x3F, 0x3F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x3C, 0x03,
  0x3C, 0x0F, 0x07, 0xDF, 0xC3, 0xC7, 0xF7, 0xFC, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xFC, 0x07, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x01, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x03,
  0x80, 0x10, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x3E, 0x1F, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x03,
  0xFF, 0x3F, 0x81, 0xFF, 0xCF, 0xE1, 0xFF, 0xF7, 0xF8, 0xFF, 0xFD, 0xFC,
  0xFF, 0xFF, 0x7F, 0x7F, 0x3F, 0x9F, 0xFF, 0x8F, 0xE7, 0xFF, 0x83, 0xF9,
  0xFF, 0xC0, 0xFE, 0xFF, 0xC0, 0x3F, 0xBF, 0xE0, 0x1F, 0xEF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xE7, 0xF3, 0xE0, 0xFE, 0x60, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83,
  0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE7, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F,
  0x80, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F,
  0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE7,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x20, 0x01, 0xFC, 0xFF,
  0x80, 0xFE, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7,
  0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0x3F, 0x81, 0xFF, 0x0F,
  0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F,
  0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0x01, 0xFF, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8,
  0x7F, 0x81, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F,
  0xDF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x3F, 0xE7, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x7E, 0x00,
  0x38, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x02, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xC1, 0xF8, 0x3C, 0x3E, 0x1F, 0xF8,
  0xF0, 0xF0, 0xFF, 0xF3, 0xC7, 0xC7, 0xFF, 0xCF, 0x1E, 0x1F, 0x1E, 0x3C,
  0xF8, 0xF8, 0x78, 0xF3, 0xC3, 0xC1, 0xE3, 0xCF, 0x1F, 0x07, 0x8F, 0x7C,
  0x78, 0x3C, 0x3D, 0xE3, 0xE0, 0xF0, 0xF7, 0x8F, 0x83, 0xC3, 0xDE, 0x3C,
  0x0F, 0x0E, 0xF8, 0xF0, 0x78, 0x7B, 0xE3, 0xC1, 0xE1, 0xEF, 0x0F, 0x07,
  0x87, 0x3C, 0x3C, 0x3E, 0x3C, 0xF0, 0xF0, 0xF8, 0xF3, 0xC3, 0xE7, 0xE7,
  0x8F, 0x0F, 0xFF, 0xFE, 0x3E, 0x3F, 0xFF, 0xF0, 0xF8, 0x7F, 0x7F, 0x81,
  0xE0, 0xF0, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03,
  0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0xE7, 0xF0,
  0x3F, 0xFE, 0x3F, 0x81, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0x9F, 0xE0, 0x7F,
  0xFC, 0xFF, 0x07, 0xFF, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE7, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x07, 0xF0,
  0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xCF, 0xF8, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xE1, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03,
  0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xCF, 0xBF, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0xFD, 0xF7, 0xFF, 0xC0, 0x7E, 0xFB, 0xEF, 0xC0, 0x3F, 0x7F, 0xF7, 0xE0,
  0x1F, 0xBF, 0xF3, 0xF0, 0x1F, 0xDF, 0xFB, 0xF8, 0x0F, 0xE7, 0xF9, 0xFC,
  0x07, 0xF3, 0xFC, 0xFC, 0x03, 0xF1, 0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x3F,
  0x00, 0xFC, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0x0F,
  0xE0, 0x3F, 0x8F, 0x87, 0xE0, 0x1F, 0x87, 0x83, 0xF0, 0x0F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x03,
  0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x03,
  0xFF, 0x01, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x07,
  0xFF, 0x81, 0xFC, 0x07, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xC3, 0xF8, 0x0F,
  0xFF, 0xC3, 0xF8, 0x0F, 0xF7, 0xC3, 0xF8, 0x0F, 0xE7, 0xC3, 0xF8, 0x0F,
  0xE7, 0xE7, 0xF8, 0x0F, 0xE7, 0xE7, 0xF8, 0x0F, 0xE3, 0xE7, 0xF0, 0x1F,
  0xE3, 0xE7, 0xF0, 0x1F, 0xE3, 0xF7, 0xF0, 0x1F, 0xC3, 0xF7, 0xF0, 0x1F,
  0xC1, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xE0, 0x3F,
  0xC1, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xE0, 0x3F,
  0x80, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF,
  0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01,
  0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0x80, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0xFE, 0xFE, 0x0F, 0xC1, 0xFD, 0xFC, 0x1F, 0x83, 0xFB,
  0xF8, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0x9F,
  0x87, 0xF8, 0x7E, 0x3F, 0x0F, 0xF0, 0xFC, 0x7E, 0x1F, 0xE3, 0xF8, 0xFC,
  0x3F, 0xC7, 0xF1, 0xF8, 0xFF, 0x8F, 0xC3, 0xF1, 0xFF, 0x3F, 0x87, 0xE3,
  0xFE, 0x7F, 0x0F, 0xCF, 0xFC, 0xFC, 0x1F, 0x9F, 0xF9, 0xF8, 0x3F, 0x3F,
  0xF7, 0xF0, 0x7E, 0x7B, 0xEF, 0xE0, 0xFD, 0xF7, 0x9F, 0x81, 0xFB, 0xEF,
  0x3F, 0x03, 0xF7, 0xDE, 0xFE, 0x07, 0xFF, 0x3D, 0xF8, 0x0F, 0xFE, 0x7B,
  0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x9F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x03,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xF9, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x0F,
  0xC1, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0x3F, 0xE0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x1F,
  0xE3, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFB, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xEF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xF9,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0x07,
  0xF3, 0xFF, 0xC0, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFE, 0x7F, 0x80, 0x7F, 0x7F,
  0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x8F,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x0F, 0xF0, 0x03, 0xFF, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xE0, 0x03, 0xFF,
  0x9F, 0x80, 0x07, 0xFC, 0x7E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0xFF, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xC7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF,
  0xC0, 0x07, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x40, 0xFF, 0x00, 0x18,
  0x1F, 0xF0, 0x0F, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x03, 0xFF,
  0x9F, 0xC0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x18, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x02, 0x00,
  0x1F, 0xE0, 0x38, 0x01, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x3F, 0xF0, 0x0F, 0xE7, 0xFF, 0x80,
  0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF,
  0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xDF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0xFE, 0x01, 0xFF, 0x81, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x0F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x7F,
  0x1F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x07, 0xF7,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0xFE, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE3, 0xE1,
  0xF0, 0x0F, 0xDF, 0xE7, 0xF0, 0x1F, 0xBF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0xFF, 0x3F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFE, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F,
  0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8,
  0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x3F, 0xF0, 0x0F, 0xE7, 0xFF,
  0xC0, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00,
  0xFF, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F,
  0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xCF, 0xFC, 0x00, 0x7E, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xC0,
  0x7F, 0x83, 0xFF, 0x9F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0x1F,
  0xC0, 0x60, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xFE, 0x7F, 0x03, 0xFF,
  0xF7, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFF,
  0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0x07,
  0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xEF, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x06, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x7F, 0x83, 0xF8, 0x7F, 0xF0, 0xFE, 0x7F, 0xF8, 0x3F, 0xBF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0C, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xF8, 0x0F, 0xFE, 0x7F, 0x00, 0xFF,
  0x0F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x3F, 0x00,
  0xFF, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x0F, 0x81, 0xFF, 0xF0, 0x3E, 0x07, 0xEF, 0xC1, 0xF8, 0x3F, 0xBF,
  0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0xFE, 0x1F, 0xCF, 0xC3,
  0xF8, 0x7E, 0x3F, 0x0F, 0xE1, 0xF8, 0xFC, 0x7F, 0x8F, 0xE3, 0xF1, 0xFE,
  0x3F, 0x0F, 0xC7, 0xF8, 0xFC, 0x3F, 0x3F, 0xE3, 0xF0, 0xFC, 0xF7, 0x9F,
  0x83, 0xF3, 0xDE, 0x7E, 0x0F, 0xDF, 0x79, 0xF8, 0x3F, 0x79, 0xEF, 0xC0,
  0xFD, 0xE7, 0xBF, 0x03, 0xEF, 0x1E, 0xFC, 0x0F, 0xBC, 0x7F, 0xE0, 0x3E,
  0xF1, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x04, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0x40, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xCF, 0xFF,
  0xC0, 0x3F, 0x3F, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0x87, 0xE7, 0xF3, 0xFF,
  0xFF, 0x9F, 0x03, 0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0xF3, 0xE0, 0x07, 0xFF,
  0x80, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoMono_BoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 14, 38, 32, 9, -38 },
  { 68, 18, 14, 32, 9, -41 },
  { 100, 32, 38, 32, 0, -38 },
  { 252, 29, 51, 32, 2, -45 },
  { 437, 26, 40, 32, 3, -39 },
  { 567, 30, 40, 32, 1, -39 },
  { 717, 8, 15, 32, 13, -41 },
  { 732, 19, 55, 32, 8, -43 },
  { 863, 19, 55, 32, 4, -43 },
  { 994, 26, 27, 32, 4, -38 },
  { 1082, 27, 28, 32, 2, -32 },
  { 1177, 12, 17, 32, 5, -6 },
  { 1203, 22, 6, 32, 7, -20 },
  { 1220, 10, 10, 32, 9, -9 },
  { 1233, 28, 41, 32, 2, -38 },
  { 1377, 26, 40, 32, 3, -39 },
  { 1507, 19, 38, 32, 6, -38 },
  { 1598, 29, 39, 32, 0, -39 },
  { 1740, 29, 40, 32, 1, -39 },
  { 1885, 28, 38, 32, 0, -38 },
  { 2018, 29, 39, 32, 2, -38 },
  { 2160, 26, 40, 32, 2, -39 },
  { 2290, 28, 38, 32, 3, -38 },
  { 2423, 27, 40, 32, 2, -39 },
  { 2558, 25, 39, 32, 4, -39 },
  { 2680, 14, 32, 32, 9, -31 },
  { 2736, 17, 42, 32, 7, -31 },
  { 2826, 25, 25, 32, 4, -29 },
  { 2905, 27, 17, 32, 3, -25 },
  { 2963, 26, 25, 32, 2, -29 },
  { 3045, 25, 39, 32, 6, -39 },
  { 3167, 30, 38, 32, 1, -38 },
  { 3310, 31, 38, 32, -2, -38 },
  { 3458, 31, 38, 32, 1, -38 },
  { 3606, 29, 40, 32, 2, -39 },
  { 3751, 30, 38, 32, 0, -38 },
  { 3894, 32, 38, 32, 1, -38 },
  { 4046, 32, 38, 32, 1, -38 },
  { 4198, 29, 40, 32, 2, -39 },
  { 4343, 32, 38, 32, 0, -38 },
  { 4495, 28, 38, 32, 2, -38 },
  { 4628, 30, 39, 32, 2, -38 },
  { 4775, 35, 38, 32, 1, -38 },
  { 4942, 26, 38, 32, 1, -38 },
  { 5066, 33, 38, 32, 0, -38 },
  { 5223, 32, 38, 32, 0, -38 },
  { 5375, 29, 40, 32, 2, -39 },
  { 5520, 31, 38, 32, 1, -38 },
  { 5668, 29, 46, 32, 2, -39 },
  { 5835, 31, 38, 32, 1, -38 },
  { 5983, 31, 40, 32, 1, -39 },
  { 6138, 31, 38, 32, 4, -38 },
  { 6286, 30, 39, 32, 2, -38 },
  { 6433, 30, 38, 32, 4, -38 },
  { 6576, 31, 38, 32, 3, -38 },
  { 6724, 37, 38, 32, -2, -38 },
  { 6900, 30, 38, 32, 5, -38 },
  { 7043, 33, 38, 32, 0, -38 },
  { 7200, 20, 54, 32, 6, -45 },
  { 7335, 13, 41, 32, 10, -38 },
  { 7402, 20, 54, 32, 6, -45 },
  { 7537, 21, 20, 32, 6, -38 },
  { 7590, 24, 6, 32, 0, 0 },
  { 7608, 11, 7, 32, 14, -39 },
  { 7618, 26, 30, 32, 2, -29 },
  { 7716, 27, 42, 32, 1, -41 },
  { 7858, 25, 30, 32, 3, -29 },
  { 7952, 30, 42, 32, 2, -41 },
  { 8110, 27, 30, 32, 2, -29 },
  { 8212, 30, 42, 32, 4, -42 },
  { 8370, 29, 40, 32, 1, -29 },
  { 8515, 28, 41, 32, 1, -41 },
  { 8659, 23, 40, 32, 3, -40 },
  { 8774, 25, 52, 32, 1, -40 },
  { 8937, 31, 41, 32, 1, -41 },
  { 9096, 25, 41, 32, 2, -41 },
  { 9225, 31, 29, 32, -1, -29 },
  { 9338, 28, 29, 32, 1, -29 },
  { 9440, 27, 30, 32, 2, -29 },
  { 9542, 29, 40, 32, -1, -29 },
  { 9687, 28, 40, 32, 2, -29 },
  { 9827, 26, 29, 32, 5, -29 },
  { 9922, 27, 30, 32, 2, -29 },
  { 10024, 25, 37, 32, 4, -36 },
  { 10140, 27, 30, 32, 3, -29 },
  { 10242, 28, 29, 32, 4, -29 },
  { 10344, 30, 29, 32, 3, -29 },
  { 10453, 32, 29, 32, 0, -29 },
  { 10569, 34, 41, 32, 0, -29 },
  { 10744, 29, 29, 32, 1, -29 },
  { 10850, 20, 51, 32, 8, -42 },
  { 10978, 13, 49, 32, 9, -38 },
  { 11058, 21, 52, 32, 5, -42 },
  { 11195, 30, 12, 32, 0, -22 },
};

const GFXfont RobotoMono_BoldItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic54pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_BOLDITALIC54PT7B_H_
