#ifndef _ROBOTOMONO_BOLDITALIC42PT7B_H_
#define _ROBOTOMONO_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F,
  0x83, 0xF8, 0x7F, 0x0F, 0xC0, 0xF8, 0x00, 0x3C, 0x3D, 0xF0, 0xF7, 0x87,
  0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0xBC, 0x1C, 0xF0, 0x73, 0xC3,
  0xCF, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x70, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xCF, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xC7,
  0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x0E, 0x3C, 0x78, 0x79, 0xC3, 0xC7, 0x8E, 0x1E, 0x78, 0x78, 0xF3,
  0x83, 0xFF, 0x3C, 0x1F, 0xFB, 0xC0, 0x7F, 0xBC, 0x00, 0xF1, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x1C,
  0x00, 0x73, 0xF8, 0x07, 0x3F, 0xE0, 0x7B, 0xFF, 0x07, 0x9E, 0x3C, 0x39,
  0xE1, 0xE3, 0xCF, 0x0F, 0x3C, 0x78, 0x78, 0x43, 0xC3, 0x80, 0x1E, 0x3C,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x3E, 0x00, 0xFC,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0x1F, 0xF8, 0x3E, 0x7F, 0xF8, 0x7D,
  0xF9, 0xF8, 0xFB, 0xF3, 0xF3, 0xEF, 0xC3, 0xFF, 0xDF, 0x87, 0xFF, 0x3E,
  0x07, 0xFE, 0x7C, 0x07, 0xF8, 0xFC, 0x0F, 0xE1, 0xFC, 0x7F, 0xC3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x83, 0xFE, 0x3F, 0x80, 0x3C,
  0xF3, 0xCF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x3C, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0xC1, 0xE0, 0xCF, 0x8E, 0x1E, 0x7F, 0x77, 0xF7, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1E,
  0xF0, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xE0,
  0x38, 0x1E, 0x00, 0x80, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x07, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFE, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xF3,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0xFF,
  0x7C, 0x1F, 0xF7, 0xC7, 0xFE, 0xFC, 0xFB, 0xEF, 0xFF, 0x7E, 0xFF, 0xC7,
  0xEF, 0xF8, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x04, 0x00,
  0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xBE, 0xF1,
  0xFA, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFB, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F,
  0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xF3, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xFC, 0x7F,
  0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xF3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF1, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x17, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x3E, 0x07, 0xEF, 0xF8, 0x7D, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF,
  0xF0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7C, 0x0F,
  0xC7, 0xE1, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x3E, 0x03, 0xE0,
  0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xE0, 0x3E,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0x7E, 0x07, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF9, 0xFC, 0x7E, 0x0F, 0xDF, 0x81, 0xFB,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFB, 0xF0, 0xFF, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF8, 0x7F, 0xDF, 0x07, 0xF7, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0x83, 0xE0, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE7, 0xF9, 0xFC, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3E, 0x03, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x03, 0x8F,
  0x0F, 0xC7, 0x1C, 0x7F, 0xCE, 0x79, 0xFF, 0x9C, 0xE3, 0xC7, 0x3B, 0xCF,
  0x1E, 0x77, 0x1C, 0x38, 0xEE, 0x78, 0x71, 0xFC, 0xF0, 0xE3, 0xF9, 0xC3,
  0xC7, 0xE3, 0x87, 0x1D, 0xC7, 0x0E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x79,
  0xCE, 0x3D, 0xF7, 0x9C, 0x7F, 0xFE, 0x38, 0x7D, 0xF8, 0x78, 0x70, 0xC0,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x30, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3E, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0,
  0x0F, 0xC1, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xE7, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0x7D, 0xF8,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xCF, 0x80,
  0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x7F, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x07, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xF7, 0xF8,
  0x7F, 0x03, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0x7D, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xFE, 0xFC, 0x3F, 0xFB, 0xE0, 0xFF, 0xEF,
  0x83, 0xFF, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x7F, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7E,
  0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xE0, 0x0F, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xF0, 0x03, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3,
  0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFD, 0xEF, 0x83, 0xFE, 0xF7, 0xC1, 0xF7,
  0xF7, 0xC1, 0xF3, 0xFB, 0xE0, 0xF9, 0xF9, 0xF0, 0x7C, 0xFC, 0xF8, 0x3E,
  0x7C, 0x7C, 0x1F, 0x3E, 0x7E, 0x0F, 0x9F, 0x3E, 0x0F, 0x8F, 0x1F, 0x07,
  0xC7, 0x8F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0x7F,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0xE0, 0xFC, 0x1F, 0xF0, 0x7E, 0x0F,
  0xF8, 0x3E, 0x07, 0xFC, 0x3F, 0x03, 0xFF, 0x1F, 0x81, 0xF7, 0x8F, 0xC1,
  0xFB, 0xC7, 0xE0, 0xFD, 0xE3, 0xE0, 0x7E, 0xF9, 0xF0, 0x3F, 0x3D, 0xF8,
  0x1F, 0x1E, 0xFC, 0x1F, 0x8F, 0x7E, 0x0F, 0xC7, 0xFF, 0x07, 0xE1, 0xFF,
  0x03, 0xF0, 0xFF, 0x81, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0xFC, 0x0F,
  0xF0, 0x7E, 0x07, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0x80,
  0xFE, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF8,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F,
  0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x7F, 0x3F, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F,
  0x00, 0x7E, 0x1F, 0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC1, 0xF8, 0x1F, 0x83, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3F,
  0x01, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x0F,
  0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF9, 0xFE, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F,
  0x87, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFE, 0x7F, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3E,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x3C, 0x3F, 0xF8, 0x7C, 0x3E, 0xF8,
  0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x7E, 0xF8, 0xFC, 0x7C, 0xF8,
  0xFC, 0x7C, 0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0xF8, 0xF9, 0xFC, 0xF8, 0xF9,
  0xFC, 0xF8, 0xF9, 0xFD, 0xF8, 0xFB, 0xFD, 0xF0, 0xFB, 0xFD, 0xF0, 0xFB,
  0xBD, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0x8F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7D,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F,
  0xBC, 0x07, 0x9E, 0x07, 0xC7, 0x83, 0xC3, 0xC3, 0xE1, 0xE3, 0xE0, 0xF1,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF0, 0x0F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xC1, 0xF8, 0x7C, 0x07, 0xC4, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8,
  0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x87, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFB, 0xF0, 0x7F, 0x9F, 0x80, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x30, 0x07, 0xEF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFE, 0x1F,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xEF, 0xFE, 0x1F, 0x1F, 0xC0, 0x00,
  0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xF8, 0x7E, 0x3F, 0x03, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0xFC, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x01,
  0xC1, 0xF0, 0x0F, 0xF7, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C,
  0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xF1, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFD, 0xF0, 0x07, 0xF7, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0xFC, 0x07, 0xCF,
  0xC0, 0x3E, 0x7E, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x83, 0xF0, 0x0C, 0x1F, 0xE3, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x40, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x30, 0x02, 0x03, 0xFC, 0xF8, 0x1F, 0xFD, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x87, 0xE0, 0x7F, 0x1F, 0x80,
  0x7C, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0x7C, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x40, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x38,
  0x07, 0xE7, 0xF8, 0x3F, 0x7F, 0xE1, 0xF7, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF0, 0x3F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x01, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x1F,
  0x83, 0xF8, 0x1F, 0x07, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0x3F, 0xC0, 0x3F,
  0x7F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xBF, 0x00, 0x7F,
  0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xF8, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x10,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x00, 0x0C, 0x18, 0x0F, 0xBF, 0x7E, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x9F, 0x9F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0x7C,
  0x00, 0x83, 0x00, 0xF8, 0xFF, 0x07, 0xDF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xE1, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F,
  0x80, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x7E, 0x1F,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x0F, 0xDF, 0xE0, 0x1F, 0x7F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xC3,
  0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x1F, 0x87, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xBE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC1,
  0xF9, 0xFF, 0x1F, 0x3F, 0xE1, 0xF7, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xE0, 0x23, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3F, 0x01, 0xF9, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x18, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xF7, 0xC0, 0x7F, 0x1F, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xE7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x07, 0x8F, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x3F, 0xF0,
  0xF8, 0x7F, 0xE1, 0xF1, 0xF7, 0xC3, 0xE3, 0xEF, 0x8F, 0xC7, 0xDF, 0x1F,
  0x9F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFE, 0x7C, 0xF9, 0xFC, 0xF1, 0xF7, 0xFB,
  0xE3, 0xEE, 0xF7, 0xC7, 0xDD, 0xEF, 0x0F, 0xFB, 0xFE, 0x1F, 0xE7, 0xFC,
  0x3F, 0xCF, 0xF0, 0x7F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x83, 0xE0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0x7C, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x10, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xC0, 0x3C, 0xFF, 0xC0, 0x7B, 0xFF, 0xE1, 0xF7,
  0xFF, 0xF7, 0xCF, 0x0F, 0xFF, 0xBC, 0x0F, 0xFE, 0x78, 0x07, 0xFC, 0x00,
  0x07, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 30, 25, 7, -30 },
  { 43, 14, 11, 25, 7, -32 },
  { 63, 25, 30, 25, 0, -30 },
  { 157, 22, 39, 25, 2, -35 },
  { 265, 21, 30, 25, 2, -30 },
  { 344, 23, 30, 25, 1, -30 },
  { 431, 6, 12, 25, 10, -32 },
  { 440, 15, 42, 25, 6, -33 },
  { 519, 15, 42, 25, 3, -33 },
  { 598, 21, 21, 25, 3, -30 },
  { 654, 21, 22, 25, 2, -25 },
  { 712, 9, 13, 25, 4, -5 },
  { 727, 18, 4, 25, 5, -15 },
  { 736, 8, 7, 25, 7, -7 },
  { 743, 22, 33, 25, 2, -30 },
  { 834, 20, 30, 25, 3, -30 },
  { 909, 14, 30, 25, 5, -30 },
  { 962, 22, 30, 25, 0, -30 },
  { 1045, 22, 30, 25, 1, -30 },
  { 1128, 22, 30, 25, 0, -30 },
  { 1211, 22, 30, 25, 2, -30 },
  { 1294, 20, 30, 25, 2, -30 },
  { 1369, 21, 30, 25, 3, -30 },
  { 1448, 22, 30, 25, 1, -30 },
  { 1531, 19, 30, 25, 3, -30 },
  { 1603, 11, 24, 25, 7, -24 },
  { 1636, 14, 32, 25, 5, -24 },
  { 1692, 20, 20, 25, 3, -23 },
  { 1742, 21, 13, 25, 2, -19 },
  { 1777, 20, 20, 25, 2, -23 },
  { 1827, 19, 30, 25, 5, -30 },
  { 1899, 23, 30, 25, 1, -30 },
  { 1986, 24, 30, 25, -2, -30 },
  { 2076, 25, 30, 25, 0, -30 },
  { 2170, 22, 31, 25, 2, -30 },
  { 2256, 24, 30, 25, 0, -30 },
  { 2346, 24, 30, 25, 1, -30 },
  { 2436, 25, 30, 25, 1, -30 },
  { 2530, 22, 30, 25, 2, -30 },
  { 2613, 25, 30, 25, 0, -30 },
  { 2707, 22, 30, 25, 2, -30 },
  { 2790, 24, 30, 25, 1, -30 },
  { 2880, 28, 30, 25, 0, -30 },
  { 2985, 20, 30, 25, 1, -30 },
  { 3060, 25, 30, 25, 0, -30 },
  { 3154, 25, 30, 25, 0, -30 },
  { 3248, 23, 30, 25, 1, -30 },
  { 3335, 24, 30, 25, 1, -30 },
  { 3425, 23, 35, 25, 1, -30 },
  { 3526, 25, 30, 25, 0, -30 },
  { 3620, 24, 30, 25, 1, -30 },
  { 3710, 24, 30, 25, 3, -30 },
  { 3800, 23, 30, 25, 2, -30 },
  { 3887, 24, 30, 25, 3, -30 },
  { 3977, 24, 30, 25, 3, -30 },
  { 4067, 28, 30, 25, -1, -30 },
  { 4172, 24, 30, 25, 4, -30 },
  { 4262, 25, 30, 25, 0, -30 },
  { 4356, 15, 42, 25, 5, -35 },
  { 4435, 10, 33, 25, 8, -30 },
  { 4477, 15, 42, 25, 5, -35 },
  { 4556, 17, 16, 25, 4, -30 },
  { 4590, 19, 4, 25, 0, 0 },
  { 4600, 9, 5, 25, 11, -30 },
  { 4606, 21, 23, 25, 1, -23 },
  { 4667, 21, 32, 25, 1, -32 },
  { 4751, 20, 23, 25, 2, -23 },
  { 4809, 23, 32, 25, 2, -32 },
  { 4901, 21, 23, 25, 2, -23 },
  { 4962, 23, 32, 25, 3, -32 },
  { 5054, 23, 32, 25, 1, -23 },
  { 5146, 21, 32, 25, 1, -32 },
  { 5230, 19, 31, 25, 2, -31 },
  { 5304, 19, 40, 25, 1, -31 },
  { 5399, 24, 32, 25, 1, -32 },
  { 5495, 19, 32, 25, 2, -32 },
  { 5571, 24, 23, 25, -1, -23 },
  { 5640, 21, 23, 25, 1, -23 },
  { 5701, 20, 24, 25, 2, -23 },
  { 5761, 23, 32, 25, -1, -23 },
  { 5853, 21, 32, 25, 2, -23 },
  { 5937, 20, 23, 25, 4, -23 },
  { 5995, 21, 23, 25, 2, -23 },
  { 6056, 20, 28, 25, 3, -28 },
  { 6126, 22, 22, 25, 2, -22 },
  { 6187, 22, 22, 25, 3, -22 },
  { 6248, 23, 22, 25, 2, -22 },
  { 6312, 25, 22, 25, 0, -22 },
  { 6381, 26, 31, 25, 0, -22 },
  { 6482, 24, 22, 25, 0, -22 },
  { 6548, 16, 40, 25, 6, -33 },
  { 6628, 10, 38, 25, 7, -30 },
  { 6676, 16, 40, 25, 4, -33 },
  { 6756, 23, 9, 25, 0, -17 },
};

const GFXfont RobotoMono_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic42pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_BOLDITALIC42PT7B_H_
