#ifndef _ROBOTOMONO_BOLDITALIC43PT7B_H_
#define _ROBOTOMONO_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x82, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x00, 0x3C, 0x3C, 0xF0, 0xF7,
  0xC3, 0xDE, 0x0F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x1E, 0xF0, 0x7B,
  0xC1, 0xCF, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x78, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x07, 0x87, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC0, 0x1C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x00, 0xF1, 0xE0, 0xCF, 0x0E,
  0x1E, 0xF0, 0xE1, 0xCF, 0x1E, 0x3C, 0xF1, 0xE7, 0x8F, 0x1E, 0x70, 0xFF,
  0xCF, 0x07, 0xFD, 0xE0, 0x3F, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xCF, 0x80, 0x39, 0xFE,
  0x07, 0xBF, 0xF0, 0xF7, 0xFF, 0x1E, 0x78, 0xF1, 0xC7, 0x8F, 0x3C, 0x78,
  0xF7, 0x8F, 0x0F, 0x10, 0xF0, 0xF0, 0x07, 0x9F, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0x1F, 0xFC, 0x1E, 0x3F, 0x7E,
  0x3E, 0x7E, 0x7E, 0x3E, 0xFE, 0x3F, 0x7E, 0xFC, 0x3F, 0x7C, 0xFC, 0x1F,
  0xFC, 0xFC, 0x1F, 0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xF0, 0xFE, 0x3F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8,
  0xFC, 0x7D, 0xE7, 0x9E, 0x7B, 0xEF, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x08,
  0x00, 0x70, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0x80, 0x02,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x80, 0xE0, 0x27, 0x07, 0x0F, 0x7E,
  0x39, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0xF8,
  0xF8, 0x1F, 0x83, 0xE0, 0x78, 0x1F, 0x01, 0xC0, 0x70, 0x04, 0x02, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x87,
  0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x07,
  0x01, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0,
  0x7F, 0x7E, 0x0F, 0xF7, 0xC1, 0xFF, 0x7C, 0x7F, 0xFF, 0xCF, 0xBF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x3E, 0xFF, 0x83, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8,
  0xFE, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x02, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFE, 0xFC, 0xF9, 0xC1, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F, 0x83,
  0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xE1, 0xFC, 0x7F, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x83,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xDF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xF7, 0xF8, 0x0E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x3E, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE7, 0xF0, 0x7E, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8, 0xFE,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7, 0xE0,
  0xFE, 0x7F, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFA, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xE3, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF1, 0xF8, 0x1F, 0xC7, 0xF9, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8, 0x7E, 0x7F, 0x03, 0xE7,
  0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0xBF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0x7C, 0x07, 0xEF, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF0, 0x01, 0xF0, 0x1F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x0E,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x08, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x3C,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x0E, 0x0F, 0x0F, 0x8E, 0x1E, 0x3F, 0xE7,
  0x1C, 0x7F, 0xE7, 0x3C, 0xF9, 0xC7, 0x38, 0xF1, 0xC7, 0x79, 0xE1, 0xC7,
  0x71, 0xE3, 0xC7, 0x71, 0xC3, 0x8E, 0xF3, 0xC3, 0x8E, 0xF3, 0xC3, 0x8E,
  0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x1C, 0xE3, 0xCF, 0x1C,
  0xE3, 0xFF, 0xF8, 0xE3, 0xFF, 0xF0, 0xF1, 0xF3, 0xE0, 0xF0, 0x41, 0x80,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01,
  0xF3, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0x03, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x3E,
  0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xFC,
  0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xE3, 0xFC, 0x07, 0xC0,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x0F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F,
  0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xFE, 0xFC, 0x1F, 0xF9, 0xF8, 0x3F, 0xF3, 0xF0, 0xFF, 0xE7, 0xE1, 0xFF,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xFE, 0x7F, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x0F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xE7, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0x81, 0xF8, 0x07, 0xF8,
  0x0F, 0xC0, 0x7F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0x03, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xF9, 0xFC, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xDF,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00,
  0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x3F,
  0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xEE, 0x7F, 0xC0, 0xFB, 0xBD, 0xF0,
  0x3E, 0xFF, 0x7C, 0x0F, 0xBF, 0xDF, 0x07, 0xEF, 0xE7, 0xC1, 0xF3, 0xFB,
  0xF0, 0x7C, 0xFC, 0xF8, 0x1F, 0x3F, 0x3E, 0x07, 0xCF, 0x8F, 0x81, 0xF3,
  0xE3, 0xE0, 0xFC, 0x71, 0xF8, 0x3E, 0x1C, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x83, 0xF8, 0x0F, 0xC1,
  0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0xC0, 0xF8,
  0x1F, 0xE0, 0x7C, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0x3F, 0x07, 0xFE, 0x1F,
  0x83, 0xFF, 0x0F, 0xC1, 0xFF, 0x87, 0xC0, 0xFB, 0xC7, 0xE0, 0xFD, 0xE3,
  0xF0, 0x7E, 0xF9, 0xF8, 0x3F, 0x3C, 0xFC, 0x1F, 0x9E, 0x7E, 0x0F, 0x8F,
  0x3E, 0x0F, 0xC7, 0xFF, 0x07, 0xE1, 0xFF, 0x83, 0xF0, 0xFF, 0xC1, 0xF8,
  0x7F, 0xE0, 0xFC, 0x3F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7E, 0x07, 0xF8, 0x3F,
  0x03, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x03,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x07,
  0xDF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x7E, 0x1F, 0x01, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F,
  0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x07, 0xF8,
  0x1F, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x03,
  0xF8, 0x7E, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC3,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x7F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00,
  0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x3F,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01,
  0xF8, 0x3E, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0xBE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x3C,
  0x1F, 0xFC, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C,
  0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC, 0x7E, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC,
  0x7C, 0xF9, 0xFC, 0x7C, 0xF9, 0xFC, 0xFC, 0xF9, 0xFC, 0xF8, 0xF9, 0xFC,
  0xF8, 0xFB, 0xFD, 0xF8, 0xFB, 0xFD, 0xF0, 0xFB, 0xFD, 0xF0, 0xFF, 0xBD,
  0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x0F,
  0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xEF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x3E, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x9F, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x7C, 0x0F, 0x9E,
  0x07, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F, 0x0F, 0xC3, 0xE0, 0xF0,
  0x3C, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFC, 0x7F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F,
  0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F,
  0x3F, 0x87, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0x8F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0xFB, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0xE3, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0x9F, 0xF8, 0x3E, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xC1, 0xF8, 0xFC, 0x07,
  0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF1, 0xF8,
  0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xE0, 0xFE, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F,
  0x83, 0xF9, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFD, 0xF0,
  0x07, 0xF3, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xC1, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x1F,
  0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x83,
  0xF0, 0x0E, 0x1F, 0xE3, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x3E, 0x07, 0xFE, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x40, 0x1F, 0x81, 0xC0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x3F, 0x01, 0xFB, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xC0,
  0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3E, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7F, 0x1F, 0x80, 0xFE, 0x1F,
  0x81, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0x8F, 0xF0, 0x1F, 0x1F, 0xE0, 0x1F,
  0x3F, 0xC0, 0x3F, 0x7F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xBF, 0x00, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x9F, 0x3E, 0x07, 0xDF, 0xBF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0xFC,
  0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F,
  0x8F, 0x8F, 0xC7, 0xC7, 0xC7, 0xE3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x3E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xC7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0xFF, 0xC1,
  0xF7, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x07, 0xF1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F,
  0xC1, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x1F, 0xC7, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0xE0, 0x07, 0xEF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0x3F, 0x80, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x7C, 0x1F, 0xFB, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF8, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xDF, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x87, 0xF1, 0xF9, 0xFF, 0x1F, 0xBF,
  0xF1, 0xF7, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0x80, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0xF8, 0x03, 0xF7,
  0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x18, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF8, 0x3F,
  0x87, 0xF1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xDF, 0x01,
  0xFE, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x9F,
  0x00, 0x7E, 0x7C, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x0F,
  0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C,
  0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x7C, 0xF8, 0xFC,
  0x7C, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8, 0xF9, 0xFC, 0xF8, 0xF9, 0xDC,
  0xF8, 0xF9, 0xDC, 0xF0, 0xFB, 0xDD, 0xF0, 0xFB, 0x9D, 0xF0, 0xFF, 0x9D,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x03,
  0xF9, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xF0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x3E, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x10, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0x02, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0x3F, 0xF8, 0x1E, 0x7F, 0xFC,
  0x1E, 0x7F, 0xFF, 0xFE, 0xF8, 0x3F, 0xFC, 0xF0, 0x1F, 0xFC, 0x70, 0x0F,
  0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 31, 25, 7, -31 },
  { 44, 14, 11, 25, 7, -32 },
  { 64, 25, 31, 25, 0, -31 },
  { 161, 23, 39, 25, 2, -35 },
  { 274, 20, 31, 25, 3, -31 },
  { 352, 24, 31, 25, 1, -31 },
  { 445, 6, 11, 25, 11, -32 },
  { 454, 14, 44, 25, 7, -34 },
  { 531, 15, 44, 25, 3, -34 },
  { 614, 21, 22, 25, 3, -31 },
  { 672, 21, 22, 25, 2, -25 },
  { 730, 9, 14, 25, 4, -5 },
  { 746, 18, 5, 25, 5, -16 },
  { 758, 8, 7, 25, 7, -7 },
  { 765, 22, 34, 25, 2, -31 },
  { 859, 20, 31, 25, 3, -31 },
  { 937, 15, 31, 25, 5, -31 },
  { 996, 23, 31, 25, 0, -31 },
  { 1086, 23, 31, 25, 1, -31 },
  { 1176, 23, 31, 25, 0, -31 },
  { 1266, 22, 31, 25, 2, -31 },
  { 1352, 20, 31, 25, 2, -31 },
  { 1430, 22, 31, 25, 3, -31 },
  { 1516, 22, 31, 25, 1, -31 },
  { 1602, 20, 31, 25, 3, -31 },
  { 1680, 11, 24, 25, 7, -24 },
  { 1713, 13, 33, 25, 6, -24 },
  { 1767, 20, 20, 25, 3, -23 },
  { 1817, 22, 14, 25, 2, -20 },
  { 1856, 20, 20, 25, 2, -23 },
  { 1906, 19, 31, 25, 5, -31 },
  { 1980, 24, 30, 25, 1, -30 },
  { 2070, 25, 31, 25, -2, -31 },
  { 2167, 25, 31, 25, 0, -31 },
  { 2264, 23, 32, 25, 2, -31 },
  { 2356, 24, 31, 25, 0, -31 },
  { 2449, 25, 31, 25, 1, -31 },
  { 2546, 25, 31, 25, 1, -31 },
  { 2643, 23, 31, 25, 2, -31 },
  { 2733, 25, 31, 25, 0, -31 },
  { 2830, 22, 31, 25, 2, -31 },
  { 2916, 25, 31, 25, 1, -31 },
  { 3013, 29, 31, 25, 0, -31 },
  { 3126, 20, 31, 25, 1, -31 },
  { 3204, 26, 31, 25, 0, -31 },
  { 3305, 25, 31, 25, 0, -31 },
  { 3402, 22, 31, 25, 2, -31 },
  { 3488, 24, 31, 25, 1, -31 },
  { 3581, 24, 36, 25, 1, -31 },
  { 3689, 25, 31, 25, 0, -31 },
  { 3786, 24, 31, 25, 1, -31 },
  { 3879, 25, 31, 25, 3, -31 },
  { 3976, 24, 31, 25, 2, -31 },
  { 4069, 24, 31, 25, 3, -31 },
  { 4162, 24, 31, 25, 3, -31 },
  { 4255, 30, 31, 25, -2, -31 },
  { 4372, 24, 31, 25, 4, -31 },
  { 4465, 26, 31, 25, 0, -31 },
  { 4566, 16, 42, 25, 5, -35 },
  { 4650, 11, 34, 25, 8, -31 },
  { 4697, 16, 42, 25, 5, -35 },
  { 4781, 17, 17, 25, 5, -31 },
  { 4818, 19, 5, 25, 0, 0 },
  { 4830, 9, 6, 25, 11, -31 },
  { 4837, 21, 23, 25, 1, -23 },
  { 4898, 22, 32, 25, 1, -32 },
  { 4986, 21, 23, 25, 2, -23 },
  { 5047, 23, 32, 25, 2, -32 },
  { 5139, 21, 23, 25, 2, -23 },
  { 5200, 23, 33, 25, 4, -33 },
  { 5295, 23, 32, 25, 1, -23 },
  { 5387, 22, 32, 25, 1, -32 },
  { 5475, 19, 32, 25, 2, -32 },
  { 5551, 20, 41, 25, 1, -32 },
  { 5654, 24, 32, 25, 1, -32 },
  { 5750, 19, 32, 25, 2, -32 },
  { 5826, 25, 23, 25, -1, -23 },
  { 5898, 22, 23, 25, 1, -23 },
  { 5962, 21, 24, 25, 2, -23 },
  { 6025, 24, 32, 25, -1, -23 },
  { 6121, 22, 32, 25, 2, -23 },
  { 6209, 20, 23, 25, 4, -23 },
  { 6267, 21, 23, 25, 2, -23 },
  { 6328, 19, 28, 25, 4, -28 },
  { 6395, 22, 23, 25, 2, -23 },
  { 6459, 22, 23, 25, 3, -23 },
  { 6523, 24, 23, 25, 2, -23 },
  { 6592, 26, 23, 25, 0, -23 },
  { 6667, 27, 32, 25, 0, -23 },
  { 6775, 24, 23, 25, 0, -23 },
  { 6844, 17, 42, 25, 6, -34 },
  { 6934, 9, 40, 25, 8, -31 },
  { 6979, 17, 42, 25, 4, -34 },
  { 7069, 24, 9, 25, 0, -17 },
};

const GFXfont RobotoMono_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic43pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_BOLDITALIC43PT7B_H_
