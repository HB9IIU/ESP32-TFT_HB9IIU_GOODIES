#ifndef _ROBOTOMONO_BOLDITALIC23PT7B_H_
#define _ROBOTOMONO_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x9C, 0x71, 0xC0, 0x00, 0x03, 0x8E,
  0x38, 0x67, 0xCF, 0x1E, 0x3C, 0xD9, 0x80, 0x03, 0xB8, 0x19, 0x80, 0xCC,
  0x0C, 0xC3, 0xFF, 0x9F, 0xFC, 0x33, 0x01, 0x98, 0x0C, 0xC7, 0xFF, 0xBF,
  0xFC, 0x73, 0x03, 0x30, 0x19, 0x81, 0x8C, 0x0C, 0xC0, 0x01, 0x80, 0x18,
  0x01, 0x80, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0xE0, 0xEE, 0x0E, 0x71, 0xE7, 0xFC,
  0x3F, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x07, 0xC0, 0x6E, 0x06, 0x66, 0xE6,
  0xCE, 0xD8, 0x7D, 0x81, 0x30, 0x06, 0x00, 0x60, 0x0D, 0xC1, 0xBE, 0x37,
  0x67, 0x66, 0x26, 0x60, 0x7E, 0x03, 0xC0, 0x01, 0x80, 0x3E, 0x03, 0xF8,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x01, 0xF0, 0x0E, 0x01, 0xF8, 0xDF,
  0xCE, 0xE7, 0x7F, 0x3F, 0x78, 0xF9, 0xCF, 0x8F, 0xFC, 0x3F, 0x70, 0xFF,
  0x6D, 0x80, 0x02, 0x1C, 0x70, 0xC3, 0x8E, 0x1C, 0x30, 0xE1, 0xC3, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x06, 0x06, 0x04, 0x00, 0x18,
  0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xC0, 0x06, 0x00,
  0xC0, 0x18, 0x73, 0x3F, 0xFE, 0x7F, 0x07, 0x81, 0xF0, 0x73, 0x1C, 0x71,
  0x8C, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x61, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x39, 0xCE, 0x67, 0x3B, 0x88,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3,
  0x8E, 0x38, 0xE7, 0x07, 0x70, 0xE7, 0x3E, 0x77, 0xE7, 0xEE, 0x78, 0xEF,
  0x0E, 0xE1, 0xC6, 0x1C, 0x73, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0x3E, 0xFE,
  0xFE, 0x8E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x01, 0x80, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x00, 0x70,
  0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x7F, 0xEF,
  0xFE, 0xFF, 0xE0, 0x03, 0x01, 0xFC, 0x3F, 0xE3, 0x8F, 0x70, 0x70, 0x0F,
  0x00, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xEE, 0x1C,
  0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x39, 0xE7, 0x1C, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x1F, 0xF1, 0xFF, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x70, 0x7F, 0xC7, 0xFC, 0x11, 0xE0, 0x0E, 0x00, 0xEE, 0x1E, 0xE1,
  0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x00, 0x40, 0xF8, 0x3F, 0x0F, 0x03, 0xC0,
  0xF0, 0x1D, 0xE3, 0xFE, 0xFF, 0xDE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0x9C, 0xF3, 0xFC, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0x03, 0x03, 0xF8, 0xFF, 0x9C, 0x73, 0x8E,
  0xE1, 0xCE, 0x39, 0xFE, 0x1F, 0x8F, 0xF9, 0xC7, 0x70, 0xEE, 0x1D, 0xC3,
  0xBC, 0xF3, 0xFC, 0x3F, 0x00, 0x04, 0x0F, 0xE7, 0xF9, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE3, 0xFF, 0xF7, 0xFC, 0xEE, 0x03, 0x81, 0xC3, 0xE1,
  0xF0, 0xF0, 0x00, 0x38, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x01, 0x8F, 0x3C,
  0xF0, 0x0C, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3,
  0x8E, 0x1C, 0x30, 0xE0, 0x80, 0x00, 0xC1, 0xF1, 0xFF, 0xF8, 0xF0, 0x3C,
  0x0F, 0xE0, 0xFE, 0x07, 0x80, 0x60, 0x7F, 0xF7, 0xFF, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xEF, 0xFC, 0x30, 0x0F, 0x81, 0xFC, 0x07, 0xE0,
  0x1E, 0x07, 0xC7, 0xF7, 0xF0, 0xF8, 0x18, 0x00, 0x0C, 0x0F, 0xE7, 0xFF,
  0xC7, 0xE1, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x07, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x06, 0x33,
  0xB3, 0x7E, 0xB3, 0x25, 0xB3, 0x2D, 0x9B, 0x4C, 0xDE, 0x64, 0xF3, 0x6C,
  0x9F, 0xC6, 0x44, 0x30, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3,
  0x87, 0xFC, 0x7F, 0xF3, 0xFF, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0x1F, 0xF0,
  0xFF, 0xC7, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE3, 0xC7, 0xFC, 0x3F,
  0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x3F, 0xFB, 0xFF, 0x9F, 0xF0,
  0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x8F, 0x70, 0x77, 0x07, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x1E, 0xF3, 0xC7, 0xF8,
  0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0x3C, 0x70, 0xE3, 0x83, 0x9C, 0x1C,
  0xE0, 0xE7, 0x07, 0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0x1E, 0x3F,
  0xE3, 0xFE, 0x1F, 0xC0, 0x1F, 0xFC, 0x7F, 0xF1, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFC, 0x3F, 0xF0,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0xFE, 0x1F, 0xE3, 0x87, 0x78, 0x77, 0x07, 0x70, 0x0E, 0x00,
  0xE0, 0x1E, 0x3E, 0xE3, 0xEE, 0x4E, 0xE0, 0xEE, 0x0E, 0x71, 0xE7, 0xFC,
  0x3F, 0x80, 0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE0,
  0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x70,
  0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0x1F, 0xF3, 0xFF, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x0F, 0xFC, 0xFF, 0x8F, 0xF8, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x39,
  0xC1, 0xCE, 0x1C, 0x79, 0xE1, 0xFE, 0x07, 0xE0, 0x1C, 0x1E, 0x38, 0x78,
  0x71, 0xE1, 0xC7, 0x83, 0x9E, 0x07, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x81, 0xE7, 0x03, 0x8F, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x3C,
  0x70, 0x38, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFF, 0xFF,
  0x1E, 0x3C, 0x79, 0xF1, 0xE7, 0x8F, 0xBE, 0x3E, 0xF8, 0xFF, 0xE3, 0xFB,
  0x8D, 0xEE, 0x33, 0x31, 0xCD, 0xC7, 0x27, 0x1C, 0x1C, 0x70, 0x71, 0x81,
  0x8E, 0x0E, 0x38, 0x38, 0x1C, 0x3C, 0x70, 0xE1, 0xE3, 0x8F, 0x8E, 0x3E,
  0x38, 0xF9, 0xE3, 0xF7, 0x0E, 0xDC, 0x7B, 0x71, 0xCD, 0xC7, 0x3F, 0x1C,
  0x7C, 0x71, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x38, 0x03, 0x00, 0xFC, 0x3F,
  0xE3, 0x8F, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xE0,
  0x7F, 0xE1, 0xC7, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xE3, 0x83, 0x8F, 0xFE,
  0x3F, 0xF0, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x8F, 0x70, 0x77, 0x07, 0x70,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xF3,
  0xC7, 0xF8, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x08, 0x1F, 0xE0, 0xFF, 0xC7,
  0x1E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE,
  0x1C, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0x71, 0xC3, 0xDC, 0x0E, 0x03, 0x01,
  0xFE, 0x3F, 0xF3, 0x87, 0x70, 0x77, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x01, 0xE0, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0x80,
  0x7F, 0xFD, 0xFF, 0xE8, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07,
  0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE,
  0x1C, 0x39, 0xE1, 0xFE, 0x07, 0xE0, 0xE0, 0x7F, 0x07, 0xB8, 0x39, 0xE1,
  0xC7, 0x1C, 0x38, 0xE1, 0xCF, 0x0E, 0x70, 0x77, 0x83, 0xB8, 0x1D, 0xC0,
  0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x73, 0x1D, 0x9C, 0xE6,
  0x73, 0x99, 0xCE, 0x67, 0x71, 0xBD, 0xC6, 0xF7, 0x1B, 0xD8, 0x7F, 0xE1,
  0xEF, 0x87, 0xBE, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x38, 0x38, 0xE0,
  0x1E, 0x1F, 0x0E, 0x1C, 0x0E, 0x3C, 0x07, 0x38, 0x07, 0x70, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0,
  0x1C, 0x70, 0x3C, 0x70, 0x78, 0x78, 0xF0, 0x38, 0xF0, 0x7B, 0x87, 0x9C,
  0x38, 0xE3, 0xC3, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xF8, 0xF8,
  0xF8, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0x61,
  0x87, 0x1C, 0x1F, 0x1F, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xF8, 0xF8,
  0xF8, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1B, 0x8E, 0x67, 0x1B, 0x87, 0xFF,
  0xFF, 0xF0, 0xE3, 0x8C, 0x70, 0x1F, 0x87, 0xF9, 0xC7, 0x80, 0x70, 0x0E,
  0x7F, 0xBE, 0x77, 0x0E, 0xE1, 0xDC, 0x7B, 0xFF, 0x3E, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xBE, 0x3F, 0xE3, 0xCF, 0x38, 0x73,
  0x87, 0x38, 0x77, 0x07, 0x70, 0x77, 0x0E, 0x79, 0xE7, 0xFC, 0xEF, 0x80,
  0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x7F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1,
  0xCE, 0x79, 0xFE, 0x1F, 0x80, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x0F, 0xF8, 0xFF, 0x8F, 0x3C, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x1C, 0x70, 0xE3, 0xCF, 0x0F, 0xF8, 0x3D, 0xC0, 0x1F, 0x87, 0xF9,
  0xE3, 0xB8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x8F, 0x39, 0xFF,
  0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xE0, 0x0E, 0x01, 0xC0, 0xFF,
  0xEF, 0xFC, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x0F, 0xB8, 0xFF, 0xCF, 0x1C, 0x70, 0xE7,
  0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0xCF, 0x0F, 0xF8, 0x3D,
  0xC0, 0x0E, 0x20, 0xE3, 0xFF, 0x0F, 0xF0, 0x1E, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xBE, 0x3F, 0xF3, 0xC7, 0x38, 0x73, 0x87,
  0x78, 0x77, 0x07, 0x70, 0x77, 0x0F, 0x70, 0xE7, 0x0E, 0xE0, 0xE0, 0x01,
  0x80, 0xE0, 0x38, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE3, 0xF0, 0xFC, 0x3C,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x3C, 0xE3,
  0xC7, 0x3C, 0x3B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFF, 0x07, 0xB8, 0x38, 0xE1,
  0xC7, 0x0E, 0x3C, 0xF0, 0xF0, 0x1F, 0xC7, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x37, 0x73, 0xFF, 0xDC, 0xEE, 0xE6, 0x77, 0x73, 0xBB,
  0x99, 0x9D, 0xDC, 0xEE, 0xE6, 0x77, 0x33, 0xBB, 0x9D, 0xDC, 0xC0, 0x3B,
  0xE3, 0xFF, 0x3C, 0x73, 0x87, 0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0x70,
  0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xDE, 0x79, 0xFE, 0x1F, 0x80, 0x3B, 0xE3,
  0xFE, 0x3C, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0xE7,
  0x9E, 0x7F, 0xCF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x1F, 0x73, 0xFE, 0x79, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCF, 0x3C, 0x7F, 0xC3, 0xDC, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3B, 0xE7, 0xFC, 0xFF, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x1F, 0xC7, 0xFD, 0xC3, 0xB8,
  0x77, 0x80, 0x7F, 0x07, 0xF0, 0x0E, 0xE0, 0xFC, 0x39, 0xFF, 0x1F, 0x80,
  0x1E, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xC7, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x8F, 0xE1, 0xF8, 0x78, 0x77, 0x07, 0x70, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0xF0, 0xEE, 0x0E, 0xE1, 0xCF, 0x3C, 0x7F, 0xC3,
  0xDC, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE, 0x1C, 0x63, 0x87, 0x38, 0x77, 0x07,
  0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0xE7, 0x3F, 0x39, 0xB9, 0xDD,
  0xDE, 0xEE, 0xF6, 0x7D, 0xF3, 0xEF, 0x9F, 0x78, 0xF3, 0xC7, 0x9E, 0x38,
  0xE1, 0xC7, 0x00, 0x38, 0x3C, 0x71, 0xC1, 0xEF, 0x03, 0xF8, 0x0F, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1D, 0xC0, 0xE7, 0x87, 0x8E, 0x3C, 0x3C,
  0x38, 0x1C, 0xE0, 0xE3, 0x87, 0x8F, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDC,
  0x03, 0x70, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xBF, 0xFD,
  0xFF, 0xC0, 0x01, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x1E, 0x3C, 0x1E, 0x03, 0x81, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x31,
  0x8C, 0x62, 0x31, 0x8C, 0x00, 0x08, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0xE0, 0xE0, 0x70, 0x30, 0x18,
  0x1C, 0x0E, 0x06, 0x0F, 0x06, 0x00, 0x3C, 0x13, 0xF1, 0xF9, 0xFD, 0x87,
  0xE0, 0x0C, 0x00,
};

const GFXglyph RobotoMono_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 16, 14, 4, -16 },
  { 13, 7, 6, 14, 4, -17 },
  { 19, 13, 16, 14, 0, -16 },
  { 45, 12, 21, 14, 1, -19 },
  { 77, 12, 17, 14, 1, -17 },
  { 103, 13, 17, 14, 0, -17 },
  { 131, 3, 6, 14, 6, -17 },
  { 134, 7, 23, 14, 4, -18 },
  { 155, 8, 23, 14, 2, -18 },
  { 178, 11, 11, 14, 2, -16 },
  { 194, 11, 12, 14, 1, -14 },
  { 211, 5, 8, 14, 2, -3 },
  { 216, 9, 2, 14, 3, -8 },
  { 219, 4, 4, 14, 4, -4 },
  { 221, 12, 17, 14, 1, -16 },
  { 247, 12, 17, 14, 1, -17 },
  { 273, 8, 16, 14, 3, -16 },
  { 289, 12, 17, 14, 0, -17 },
  { 315, 12, 17, 14, 1, -17 },
  { 341, 12, 16, 14, 0, -16 },
  { 365, 12, 16, 14, 1, -16 },
  { 389, 11, 17, 14, 1, -17 },
  { 413, 12, 16, 14, 1, -16 },
  { 437, 11, 17, 14, 1, -17 },
  { 461, 10, 17, 14, 2, -17 },
  { 483, 6, 13, 14, 4, -13 },
  { 493, 7, 18, 14, 3, -13 },
  { 509, 10, 10, 14, 2, -12 },
  { 522, 12, 8, 14, 1, -11 },
  { 534, 11, 10, 14, 1, -12 },
  { 548, 10, 17, 14, 3, -17 },
  { 570, 13, 16, 14, 0, -16 },
  { 596, 13, 16, 14, -1, -16 },
  { 622, 13, 16, 14, 0, -16 },
  { 648, 12, 17, 14, 1, -17 },
  { 674, 13, 16, 14, 0, -16 },
  { 700, 14, 16, 14, 0, -16 },
  { 728, 14, 16, 14, 0, -16 },
  { 756, 12, 17, 14, 1, -17 },
  { 782, 14, 16, 14, 0, -16 },
  { 810, 12, 16, 14, 1, -16 },
  { 834, 13, 16, 14, 1, -16 },
  { 860, 15, 16, 14, 0, -16 },
  { 890, 11, 16, 14, 0, -16 },
  { 912, 14, 16, 14, 0, -16 },
  { 940, 14, 16, 14, 0, -16 },
  { 968, 12, 17, 14, 1, -17 },
  { 994, 14, 16, 14, 0, -16 },
  { 1022, 12, 20, 14, 1, -17 },
  { 1052, 13, 16, 14, 0, -16 },
  { 1078, 12, 17, 14, 1, -17 },
  { 1104, 14, 16, 14, 1, -16 },
  { 1132, 13, 16, 14, 1, -16 },
  { 1158, 13, 16, 14, 2, -16 },
  { 1184, 14, 16, 14, 1, -16 },
  { 1212, 16, 16, 14, -1, -16 },
  { 1244, 13, 16, 14, 2, -16 },
  { 1270, 14, 16, 14, 0, -16 },
  { 1298, 8, 23, 14, 3, -19 },
  { 1321, 6, 17, 14, 4, -16 },
  { 1334, 8, 23, 14, 3, -19 },
  { 1357, 10, 8, 14, 2, -16 },
  { 1367, 10, 2, 14, 0, 0 },
  { 1370, 5, 4, 14, 6, -17 },
  { 1373, 11, 12, 14, 1, -12 },
  { 1390, 12, 17, 14, 0, -17 },
  { 1416, 11, 12, 14, 1, -12 },
  { 1433, 13, 17, 14, 1, -17 },
  { 1461, 11, 12, 14, 1, -12 },
  { 1478, 12, 18, 14, 2, -18 },
  { 1505, 13, 17, 14, 0, -12 },
  { 1533, 12, 17, 14, 0, -17 },
  { 1559, 10, 17, 14, 1, -17 },
  { 1581, 10, 22, 14, 1, -17 },
  { 1609, 13, 17, 14, 0, -17 },
  { 1637, 10, 17, 14, 1, -17 },
  { 1659, 13, 12, 14, 0, -12 },
  { 1679, 12, 12, 14, 0, -12 },
  { 1697, 11, 12, 14, 1, -12 },
  { 1714, 12, 17, 14, 0, -12 },
  { 1740, 12, 17, 14, 1, -12 },
  { 1766, 11, 12, 14, 2, -12 },
  { 1783, 11, 12, 14, 1, -12 },
  { 1800, 10, 15, 14, 2, -15 },
  { 1819, 12, 12, 14, 1, -12 },
  { 1837, 12, 12, 14, 2, -12 },
  { 1855, 13, 12, 14, 1, -12 },
  { 1875, 14, 12, 14, 0, -12 },
  { 1896, 14, 17, 14, 0, -12 },
  { 1926, 13, 12, 14, 0, -12 },
  { 1946, 9, 22, 14, 3, -18 },
  { 1971, 5, 21, 14, 4, -16 },
  { 1985, 9, 22, 14, 2, -18 },
  { 2010, 13, 5, 14, 0, -9 },
};

const GFXfont RobotoMono_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic23pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_BOLDITALIC23PT7B_H_
