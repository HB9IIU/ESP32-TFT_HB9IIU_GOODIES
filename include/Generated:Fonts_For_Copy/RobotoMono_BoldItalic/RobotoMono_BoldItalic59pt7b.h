#ifndef _ROBOTOMONO_BOLDITALIC59PT7B_H_
#define _ROBOTOMONO_BOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x83,
  0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0xCF, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x03, 0x0F, 0x83,
  0xF0, 0x3C, 0xF8, 0x1F, 0x07, 0xCF, 0x83, 0xF0, 0xF8, 0xF8, 0x3F, 0x0F,
  0x8F, 0x83, 0xF1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0xC7, 0xE7, 0xC0, 0xFF,
  0xFC, 0x7C, 0x07, 0xFF, 0xCF, 0x80, 0x7F, 0xF9, 0xF0, 0x03, 0xFF, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFF, 0x80, 0x0F, 0x9F, 0xFC,
  0x01, 0xF3, 0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x07, 0xE7, 0xE3, 0xF0, 0x7C,
  0xFC, 0x3F, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x81,
  0xF3, 0xE0, 0xF8, 0x3F, 0x0C, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0x0F,
  0xFF, 0xE0, 0x3F, 0x8F, 0xFF, 0xF8, 0x1F, 0x8F, 0xFB, 0xFE, 0x1F, 0xC7,
  0xF8, 0xFF, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF3, 0xFC, 0x1F, 0xE7, 0xF3,
  0xFC, 0x07, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFC,
  0x7F, 0x80, 0x7F, 0xFC, 0x3F, 0xC0, 0x1F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF3,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x30, 0x0F, 0x80, 0x27, 0xC0, 0xF8, 0x1E,
  0x7F, 0x0F, 0x87, 0xFF, 0xFC, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x1F,
  0x80, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01,
  0xE0, 0x0F, 0x80, 0x04, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x02, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x1E, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xF7, 0xF8, 0x07, 0xFF, 0x7F,
  0x81, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0x7F, 0x8F, 0xFF, 0xE7, 0xF9, 0xFF,
  0xFE, 0x7F, 0x7F, 0x9F, 0xEF, 0xFF, 0xF1, 0xFE, 0xFF, 0xFC, 0x1F, 0xEF,
  0xFF, 0x81, 0xFE, 0xFF, 0xE0, 0x1F, 0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0x9F, 0xCF, 0xC3, 0xFC,
  0xE0, 0x3F, 0xC8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x40, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x01, 0xFE, 0x7F, 0xE0,
  0x1F, 0xDF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x1F,
  0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0xFF,
  0xDF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xC0, 0x3F, 0xE7, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x7F, 0xE3, 0xE1,
  0xF8, 0x7F, 0xF8, 0xF0, 0xF8, 0x7F, 0xFC, 0x78, 0xF8, 0x7F, 0xFE, 0x3C,
  0x7C, 0x7F, 0x1E, 0x1E, 0x7C, 0x3E, 0x0F, 0x0F, 0x3E, 0x3F, 0x07, 0x87,
  0x9F, 0x1F, 0x07, 0xC3, 0xDF, 0x0F, 0x83, 0xE3, 0xEF, 0x8F, 0x81, 0xE1,
  0xF7, 0xC7, 0xC0, 0xF0, 0xF3, 0xE3, 0xE0, 0xF8, 0x79, 0xE1, 0xF0, 0x7C,
  0x3D, 0xF1, 0xF0, 0x3C, 0x1E, 0xF8, 0xF8, 0x1E, 0x1E, 0x7C, 0x7C, 0x1F,
  0x0F, 0x3E, 0x3E, 0x0F, 0x87, 0x9F, 0x1F, 0x8F, 0xC7, 0x8F, 0x87, 0xCF,
  0xE7, 0xC7, 0xC3, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF, 0xFF, 0xC0, 0xF0, 0x7F,
  0x3F, 0xC0, 0x7C, 0x1F, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x00, 0x00, 0xFF,
  0x07, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x7F, 0x81, 0xFF, 0xFC, 0x7F,
  0x81, 0xFF, 0xFC, 0x7F, 0x81, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x00, 0xFF,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xF0, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xC7, 0xDF, 0xC0, 0x7F, 0xF9, 0xFF, 0xF0,
  0x1F, 0xDF, 0x3E, 0xFE, 0x03, 0xFB, 0xFF, 0xDF, 0xC0, 0x7F, 0x7F, 0xFB,
  0xF8, 0x0F, 0xE7, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0xCF, 0xE0, 0x3F, 0x9F,
  0xF3, 0xF8, 0x0F, 0xF3, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x8F, 0xE0, 0x3F,
  0x8F, 0xF1, 0xFC, 0x07, 0xF1, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x8F, 0xF0,
  0x1F, 0xC7, 0xE1, 0xFC, 0x07, 0xF8, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0x07,
  0xF0, 0x1F, 0xC1, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xC0,
  0x3F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x3F,
  0xC0, 0x3F, 0xFF, 0x07, 0xF8, 0x07, 0xFB, 0xF0, 0xFF, 0x00, 0xFF, 0x7E,
  0x1F, 0xE0, 0x3F, 0xCF, 0xC3, 0xFC, 0x07, 0xF9, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0x1F, 0xE0, 0x1F, 0xE3, 0xF3, 0xFC, 0x03, 0xFC, 0x7E, 0x7F, 0x80,
  0x7F, 0x8F, 0xCF, 0xF0, 0x1F, 0xE0, 0xF9, 0xFE, 0x03, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0x83, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0xFE, 0x01, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0x01, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFC,
  0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x3F,
  0xDF, 0xC0, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xC1,
  0xFE, 0x7F, 0x07, 0xF0, 0x7F, 0x3F, 0xC3, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF,
  0x07, 0xF3, 0xF8, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x3F, 0x87,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0xC7, 0xF0, 0xFE,
  0x3F, 0xF1, 0xFC, 0x3F, 0x8F, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0x3F, 0x83,
  0xF9, 0xFF, 0xCF, 0xE0, 0xFE, 0x7F, 0xF3, 0xF8, 0x3F, 0x9F, 0xFC, 0xFE,
  0x0F, 0xE7, 0xFF, 0x7F, 0x03, 0xFB, 0xFF, 0x9F, 0xC0, 0xFE, 0xFB, 0xE7,
  0xF0, 0x3F, 0xBE, 0xFB, 0xF8, 0x0F, 0xFF, 0xBE, 0xFE, 0x03, 0xFF, 0xCF,
  0xBF, 0x80, 0xFF, 0xF3, 0xEF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07,
  0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7C, 0x1F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xE0, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x1F,
  0xEF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0x3F, 0xC0,
  0x7F, 0xC3, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x1F, 0xE7, 0xFE, 0x00,
  0x7F, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF1, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0xE0,
  0x3F, 0x87, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87,
  0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0xFF, 0xE7, 0xFC,
  0x01, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xBF, 0x80, 0x0F, 0xFF, 0x7F, 0x00, 0x07, 0xFC, 0x7F, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xE3, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x3F, 0xE0,
  0x07, 0x80, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x02, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x7F, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xE0,
  0x03, 0xFF, 0xDF, 0xE0, 0x01, 0xFF, 0x9F, 0xE0, 0x00, 0x3C, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x10, 0x00, 0x3F, 0xC0, 0x18, 0x00, 0x7F, 0xC0,
  0x3C, 0x00, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x1F, 0xE3, 0xFF,
  0x00, 0x7F, 0x9F, 0xFE, 0x01, 0xFC, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x41, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x80, 0x03, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xBF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xF0, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xF0, 0x3C, 0x01, 0xFC, 0xFE, 0x3F, 0xC0, 0x7F, 0x7F, 0xDF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xEF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x7F,
  0x1F, 0xFE, 0x01, 0xFD, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x07,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x01,
  0xFC, 0xFF, 0xF0, 0x01, 0xFD, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0x80, 0x3F, 0xC7, 0xFE, 0x00, 0x3F,
  0xC0, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0x3F, 0x81, 0xFF,
  0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xF0, 0x01, 0xFF, 0x1F, 0xC0, 0x00,
  0x60, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0xC3, 0xFF, 0xC1, 0xFC, 0x7F, 0xFC, 0x0F, 0xE7, 0xFF, 0xE0, 0x7F,
  0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xE0, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x06, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xBF, 0x80,
  0x7F, 0xF8, 0xFE, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0x03, 0xF0, 0x3F, 0xBF, 0x81, 0xF8, 0x3F,
  0xDF, 0xC1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x07,
  0xF3, 0xF8, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE1,
  0xFC, 0x7F, 0x1F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF8, 0xFE, 0x1F, 0xC7, 0xFC,
  0x7E, 0x0F, 0xE7, 0xFE, 0x7F, 0x07, 0xF3, 0xFF, 0x3F, 0x83, 0xF3, 0xEF,
  0x9F, 0x81, 0xF9, 0xF7, 0xCF, 0xC0, 0xFC, 0xF3, 0xEF, 0xE0, 0x7E, 0xF9,
  0xF7, 0xE0, 0x3F, 0x7C, 0x7B, 0xF0, 0x1F, 0xBC, 0x3F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC3,
  0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE8, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xE3, 0xFF, 0xF0, 0x03, 0xE3, 0xFF,
  0xFE, 0x03, 0xF1, 0xFF, 0xFF, 0x83, 0xF9, 0xFF, 0xFF, 0xF7, 0xFC, 0xFE,
  0x1F, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFE, 0x3E,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph RobotoMono_BoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 15, 42, 35, 10, -42 },
  { 80, 19, 15, 35, 10, -44 },
  { 116, 35, 42, 35, 0, -42 },
  { 300, 31, 55, 35, 3, -49 },
  { 514, 28, 44, 35, 4, -43 },
  { 668, 33, 44, 35, 1, -43 },
  { 850, 8, 15, 35, 15, -44 },
  { 865, 20, 60, 35, 9, -47 },
  { 1015, 20, 60, 35, 5, -47 },
  { 1165, 28, 30, 35, 5, -42 },
  { 1270, 29, 31, 35, 3, -35 },
  { 1383, 13, 19, 35, 5, -7 },
  { 1414, 24, 7, 35, 8, -22 },
  { 1435, 10, 11, 35, 10, -10 },
  { 1449, 31, 46, 35, 2, -42 },
  { 1628, 28, 44, 35, 4, -43 },
  { 1782, 20, 42, 35, 7, -42 },
  { 1887, 31, 43, 35, 0, -43 },
  { 2054, 32, 44, 35, 1, -43 },
  { 2230, 30, 42, 35, 1, -42 },
  { 2388, 32, 43, 35, 2, -42 },
  { 2560, 28, 43, 35, 2, -42 },
  { 2711, 30, 42, 35, 4, -42 },
  { 2869, 30, 44, 35, 2, -43 },
  { 3034, 27, 43, 35, 4, -43 },
  { 3180, 15, 35, 35, 10, -34 },
  { 3246, 18, 46, 35, 8, -34 },
  { 3350, 28, 28, 35, 4, -32 },
  { 3448, 30, 19, 35, 3, -27 },
  { 3520, 28, 28, 35, 2, -32 },
  { 3618, 26, 43, 35, 7, -43 },
  { 3758, 33, 42, 35, 1, -42 },
  { 3932, 33, 42, 35, -2, -42 },
  { 4106, 34, 42, 35, 1, -42 },
  { 4285, 32, 44, 35, 2, -43 },
  { 4461, 33, 42, 35, 0, -42 },
  { 4635, 35, 42, 35, 1, -42 },
  { 4819, 35, 42, 35, 1, -42 },
  { 5003, 32, 44, 35, 2, -43 },
  { 5179, 35, 42, 35, 0, -42 },
  { 5363, 31, 42, 35, 2, -42 },
  { 5526, 33, 43, 35, 2, -42 },
  { 5704, 38, 42, 35, 1, -42 },
  { 5904, 28, 42, 35, 1, -42 },
  { 6051, 35, 42, 35, 1, -42 },
  { 6235, 35, 42, 35, 0, -42 },
  { 6419, 31, 44, 35, 2, -43 },
  { 6590, 34, 42, 35, 1, -42 },
  { 6769, 32, 50, 35, 2, -43 },
  { 6969, 33, 42, 35, 1, -42 },
  { 7143, 33, 44, 35, 2, -43 },
  { 7325, 34, 42, 35, 4, -42 },
  { 7504, 32, 43, 35, 3, -42 },
  { 7676, 32, 42, 35, 5, -42 },
  { 7844, 34, 42, 35, 4, -42 },
  { 8023, 40, 42, 35, -2, -42 },
  { 8233, 34, 42, 35, 5, -42 },
  { 8412, 36, 42, 35, 0, -42 },
  { 8601, 22, 59, 35, 7, -49 },
  { 8764, 14, 46, 35, 11, -42 },
  { 8845, 22, 59, 35, 7, -49 },
  { 9008, 24, 22, 35, 6, -42 },
  { 9074, 27, 6, 35, 0, 0 },
  { 9095, 12, 8, 35, 16, -43 },
  { 9107, 28, 33, 35, 2, -32 },
  { 9223, 30, 45, 35, 1, -44 },
  { 9392, 28, 33, 35, 3, -32 },
  { 9508, 32, 45, 35, 3, -44 },
  { 9688, 30, 33, 35, 2, -32 },
  { 9812, 32, 46, 35, 5, -46 },
  { 9996, 32, 44, 35, 1, -32 },
  { 10172, 30, 44, 35, 1, -44 },
  { 10337, 26, 44, 35, 3, -44 },
  { 10480, 27, 57, 35, 1, -44 },
  { 10673, 34, 44, 35, 1, -44 },
  { 10860, 26, 44, 35, 3, -44 },
  { 11003, 34, 32, 35, -1, -32 },
  { 11139, 30, 32, 35, 1, -32 },
  { 11259, 29, 33, 35, 2, -32 },
  { 11379, 32, 44, 35, -1, -32 },
  { 11555, 30, 44, 35, 3, -32 },
  { 11720, 29, 32, 35, 5, -32 },
  { 11836, 30, 33, 35, 2, -32 },
  { 11960, 27, 40, 35, 5, -39 },
  { 12095, 30, 32, 35, 3, -31 },
  { 12215, 31, 31, 35, 4, -31 },
  { 12336, 33, 31, 35, 3, -31 },
  { 12464, 35, 31, 35, 0, -31 },
  { 12600, 37, 44, 35, 0, -31 },
  { 12804, 32, 31, 35, 1, -31 },
  { 12928, 23, 56, 35, 8, -46 },
  { 13089, 14, 54, 35, 10, -42 },
  { 13184, 22, 56, 35, 6, -46 },
  { 13338, 33, 13, 35, 0, -24 },
};

const GFXfont RobotoMono_BoldItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic59pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_BOLDITALIC59PT7B_H_
