#ifndef _ROBOTOMONO_BOLDITALIC64PT7B_H_
#define _ROBOTOMONO_BOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x08, 0x00, 0x1F,
  0x81, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8,
  0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x38, 0x7E, 0x07, 0xE0, 0x78, 0xFC,
  0x0F, 0xC1, 0xF9, 0xF8, 0x1F, 0x07, 0xE3, 0xF0, 0x3E, 0x0F, 0x87, 0xE0,
  0xFC, 0x3E, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x9F,
  0xC7, 0xC0, 0x3F, 0xFF, 0x9F, 0x80, 0x7F, 0xFE, 0x7E, 0x00, 0x7F, 0xF8,
  0xF8, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0xFF, 0x00, 0x07, 0xE7, 0xFF, 0x00, 0x1F, 0x9F, 0xFF,
  0x00, 0x3E, 0x7F, 0xFF, 0x00, 0xF8, 0xFF, 0xFE, 0x03, 0xF3, 0xF0, 0xFC,
  0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x1F, 0x81, 0xF8, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0xFC, 0x0F, 0xC3, 0x81, 0xF8, 0x1F, 0x01,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE,
  0x0F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xF0,
  0x7F, 0xFF, 0x80, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0xC0,
  0xFE, 0x3F, 0xF3, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x7F, 0xC1,
  0xFF, 0x3F, 0xC7, 0xFC, 0x0F, 0xFB, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x8F,
  0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xF8, 0x03, 0xFF,
  0xF0, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF9, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x20, 0x07, 0xC0, 0x08, 0xF0, 0x0F, 0x80, 0xF1, 0xF8, 0x1F, 0x07, 0xE7,
  0xFC, 0x3C, 0x3F, 0xCF, 0xFE, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x0F, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x07, 0x01, 0xFC, 0x3F, 0xE7, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0x80, 0x1F,
  0xFC, 0xFF, 0x00, 0xFF, 0xF1, 0xFE, 0x03, 0xFF, 0xE7, 0xFC, 0x1F, 0xFF,
  0xCF, 0xF8, 0x7F, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0x3F, 0xCF, 0xF3, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFC, 0xFF, 0xFE, 0x0F, 0xF3, 0xFF, 0xF8, 0x1F, 0xE7,
  0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x3F,
  0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x7F, 0x8F, 0xF1, 0xF0, 0x3F, 0xCE, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x01,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x9F, 0xFE, 0x03, 0xFD, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0xC7,
  0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xE3,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01,
  0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x04, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0xE0, 0x3E, 0x03, 0xF0, 0x7F, 0xE1, 0xE0, 0x7E, 0x0F, 0xFF,
  0x1F, 0x07, 0xC1, 0xFF, 0xF1, 0xF0, 0xF8, 0x3F, 0xFF, 0x1F, 0x0F, 0x87,
  0xF1, 0xF1, 0xF1, 0xF0, 0xFE, 0x1F, 0x1F, 0x1F, 0x0F, 0xC1, 0xE1, 0xF3,
  0xF1, 0xF8, 0x3E, 0x1F, 0x3E, 0x1F, 0x03, 0xE1, 0xF3, 0xE3, 0xF0, 0x3E,
  0x1F, 0x7E, 0x3F, 0x03, 0xC1, 0xE7, 0xC3, 0xE0, 0x7C, 0x1E, 0x7C, 0x3E,
  0x07, 0xC1, 0xE7, 0xC7, 0xE0, 0x7C, 0x3E, 0x7C, 0x7E, 0x07, 0xC3, 0xEF,
  0xC7, 0xE0, 0xF8, 0x3C, 0xF8, 0x7C, 0x0F, 0x83, 0xCF, 0x87, 0xC0, 0xF8,
  0x7C, 0xF8, 0x7E, 0x0F, 0x87, 0x8F, 0x87, 0xE1, 0xF0, 0xF8, 0xF8, 0x7F,
  0x7F, 0x9F, 0x0F, 0x83, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0xFE, 0x07,
  0xC1, 0xFE, 0x7F, 0xC0, 0x7C, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0x00, 0x08,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x08, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xE7, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x7F,
  0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xE0,
  0x3F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0xF8, 0xFF,
  0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF7,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x00,
  0x1F, 0xF1, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF,
  0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0xFF, 0xFC, 0x07, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xFF, 0x9F, 0xBF,
  0x80, 0x7F, 0xFE, 0x7E, 0xFE, 0x01, 0xFD, 0xFB, 0xF7, 0xF8, 0x07, 0xF7,
  0xEF, 0xDF, 0xE0, 0x1F, 0xCF, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xF9, 0xFE,
  0x03, 0xFC, 0xFF, 0xE7, 0xF0, 0x0F, 0xF3, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF,
  0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F,
  0x87, 0xF8, 0x07, 0xF8, 0x7E, 0x1F, 0xE0, 0x1F, 0xC1, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xC1, 0xFE, 0x03, 0xFC, 0x1E, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xF8, 0x03, 0xFF, 0xF8, 0x3F, 0xE0, 0x1F, 0xF7, 0xE0, 0xFF, 0x80, 0x7F,
  0xDF, 0x83, 0xFE, 0x01, 0xFF, 0x7E, 0x0F, 0xF0, 0x07, 0xFD, 0xFC, 0x3F,
  0xC0, 0x1F, 0xE7, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xC7, 0xFC, 0x03, 0xFE,
  0x3F, 0x1F, 0xF0, 0x0F, 0xF8, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xF9, 0xFE,
  0x00, 0xFF, 0x07, 0xE7, 0xF8, 0x03, 0xFC, 0x1F, 0xBF, 0xE0, 0x1F, 0xF0,
  0x7F, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0x87, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x07, 0xFB, 0xFC, 0x0F, 0xE0, 0x3F,
  0xDF, 0xE0, 0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0x7F, 0x8F,
  0xE0, 0x7F, 0x83, 0xFC, 0x7F, 0x07, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xE1,
  0xFE, 0x1F, 0xC1, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7F, 0x87, 0xF0,
  0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0xF1, 0xFE,
  0x0F, 0xE3, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xFC, 0xFF, 0x03, 0xF8, 0xFF,
  0xE7, 0xF8, 0x1F, 0xCF, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0xF9, 0xFC, 0x07,
  0xF3, 0xFF, 0x9F, 0xE0, 0x3F, 0xBF, 0x7C, 0xFF, 0x01, 0xFD, 0xFB, 0xE7,
  0xF0, 0x1F, 0xEF, 0xDF, 0x3F, 0x80, 0xFF, 0x7C, 0xFB, 0xFC, 0x07, 0xFF,
  0xE7, 0xDF, 0xE0, 0x3F, 0xFF, 0x3E, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x0F,
  0xF1, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xFC, 0x01,
  0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x7F,
  0xC7, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xEF, 0xF0,
  0x1F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFC, 0x3F, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x07, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xFE, 0x03, 0xFC, 0x7F,
  0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xC0, 0x07, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xE7, 0xF8, 0x00, 0x1F, 0xF8, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xF8, 0xFF, 0xC0, 0x07,
  0xF9, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x01, 0x01, 0xFF,
  0x00, 0x0F, 0x03, 0xFF, 0x00, 0x3F, 0x03, 0xFF, 0xC7, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x7F,
  0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x07,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x06,
  0x00, 0x07, 0xFC, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0xFF,
  0xF0, 0x07, 0xFD, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0x01, 0xFE, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xE7, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x9F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFE, 0x03,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0x83,
  0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x0F,
  0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xF7, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0x1F, 0xDF,
  0xF9, 0xFF, 0x01, 0xFE, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F,
  0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xFC,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x01,
  0xFC, 0x3F, 0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03,
  0xFE, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE7, 0xFF, 0x80, 0x03, 0xFB, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xE0,
  0x07, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0x81, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0x00, 0xFF,
  0xF8, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xDF, 0xE0, 0x0F, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x70,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0,
  0xFF, 0xF8, 0x1F, 0xE3, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x70, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xF8,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x01, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFE,
  0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC,
  0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0xE0,
  0x3F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xFE, 0xFF, 0x03,
  0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0x81, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x87,
  0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x87, 0xF0, 0xFF, 0x1F,
  0xF8, 0x7F, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0xFE, 0x1F, 0xF8, 0xFE, 0x0F,
  0xE3, 0xEF, 0x8F, 0xE0, 0xFE, 0x3E, 0xF9, 0xFE, 0x0F, 0xE3, 0xEF, 0x9F,
  0xC0, 0xFE, 0x7C, 0xF9, 0xFC, 0x0F, 0xE7, 0xCF, 0xBF, 0xC0, 0xFE, 0x7C,
  0xFB, 0xF8, 0x0F, 0xEF, 0x8F, 0xBF, 0x80, 0xFE, 0xF8, 0xFB, 0xF8, 0x0F,
  0xEF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xF0,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x27, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x8F,
  0xFF, 0xF0, 0x03, 0xF1, 0xFF, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0xF0, 0x1F,
  0xCF, 0xFF, 0xFF, 0x07, 0xF3, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0x03, 0xFF,
  0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xFC, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph RobotoMono_BoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 16, 47, 38, 11, -46 },
  { 95, 22, 17, 38, 10, -48 },
  { 142, 38, 46, 38, 0, -46 },
  { 361, 34, 60, 38, 3, -53 },
  { 616, 31, 47, 38, 4, -46 },
  { 799, 36, 47, 38, 1, -46 },
  { 1011, 9, 17, 38, 16, -48 },
  { 1031, 21, 65, 38, 10, -51 },
  { 1202, 22, 65, 38, 5, -51 },
  { 1381, 31, 33, 38, 5, -46 },
  { 1509, 31, 33, 38, 3, -38 },
  { 1637, 14, 21, 38, 6, -8 },
  { 1674, 27, 7, 38, 8, -24 },
  { 1698, 12, 12, 38, 10, -11 },
  { 1716, 33, 50, 38, 3, -46 },
  { 1923, 31, 47, 38, 4, -46 },
  { 2106, 22, 46, 38, 7, -46 },
  { 2233, 34, 46, 38, 0, -46 },
  { 2429, 33, 47, 38, 2, -46 },
  { 2623, 33, 46, 38, 1, -46 },
  { 2813, 34, 47, 38, 2, -46 },
  { 3013, 30, 47, 38, 3, -46 },
  { 3190, 33, 46, 38, 4, -46 },
  { 3380, 33, 47, 38, 2, -46 },
  { 3574, 30, 46, 38, 4, -46 },
  { 3747, 16, 38, 38, 11, -37 },
  { 3823, 20, 50, 38, 8, -37 },
  { 3948, 30, 30, 38, 4, -35 },
  { 4061, 32, 21, 38, 3, -30 },
  { 4145, 31, 30, 38, 2, -34 },
  { 4262, 28, 46, 38, 8, -46 },
  { 4423, 36, 45, 38, 1, -45 },
  { 4626, 37, 46, 38, -3, -46 },
  { 4839, 36, 46, 38, 1, -46 },
  { 5046, 35, 47, 38, 2, -46 },
  { 5252, 35, 46, 38, 1, -46 },
  { 5454, 38, 46, 38, 1, -46 },
  { 5673, 38, 46, 38, 1, -46 },
  { 5892, 34, 47, 38, 3, -46 },
  { 6092, 38, 46, 38, 0, -46 },
  { 6311, 33, 46, 38, 3, -46 },
  { 6501, 36, 47, 38, 2, -46 },
  { 6713, 42, 46, 38, 1, -46 },
  { 6955, 31, 46, 38, 1, -46 },
  { 7134, 38, 46, 38, 1, -46 },
  { 7353, 38, 46, 38, 0, -46 },
  { 7572, 34, 47, 38, 2, -46 },
  { 7772, 37, 46, 38, 1, -46 },
  { 7985, 35, 54, 38, 2, -46 },
  { 8222, 36, 46, 38, 1, -46 },
  { 8429, 36, 47, 38, 2, -46 },
  { 8641, 37, 46, 38, 4, -46 },
  { 8854, 35, 47, 38, 3, -46 },
  { 9060, 36, 46, 38, 5, -46 },
  { 9267, 37, 46, 38, 4, -46 },
  { 9480, 43, 46, 38, -2, -46 },
  { 9728, 36, 46, 38, 6, -46 },
  { 9935, 39, 46, 38, 0, -46 },
  { 10160, 23, 63, 38, 8, -53 },
  { 10342, 16, 50, 38, 12, -46 },
  { 10442, 23, 63, 38, 8, -53 },
  { 10624, 25, 25, 38, 7, -46 },
  { 10703, 29, 7, 38, 0, 0 },
  { 10729, 13, 9, 38, 17, -46 },
  { 10744, 31, 36, 38, 2, -35 },
  { 10884, 33, 49, 38, 1, -48 },
  { 11087, 31, 36, 38, 3, -35 },
  { 11227, 35, 49, 38, 3, -48 },
  { 11442, 31, 36, 38, 3, -35 },
  { 11582, 35, 49, 38, 5, -49 },
  { 11797, 35, 48, 38, 1, -35 },
  { 12007, 33, 48, 38, 1, -48 },
  { 12205, 28, 47, 38, 3, -47 },
  { 12370, 30, 61, 38, 1, -47 },
  { 12599, 36, 48, 38, 1, -48 },
  { 12815, 29, 48, 38, 3, -48 },
  { 12989, 37, 34, 38, -1, -34 },
  { 13147, 33, 34, 38, 1, -34 },
  { 13288, 31, 36, 38, 3, -35 },
  { 13428, 35, 47, 38, -1, -34 },
  { 13634, 32, 48, 38, 3, -35 },
  { 13826, 31, 35, 38, 5, -35 },
  { 13962, 32, 35, 38, 2, -34 },
  { 14102, 30, 43, 38, 5, -42 },
  { 14264, 32, 35, 38, 4, -34 },
  { 14404, 33, 34, 38, 5, -34 },
  { 14545, 36, 34, 38, 3, -34 },
  { 14698, 38, 34, 38, 0, -34 },
  { 14860, 40, 48, 38, 0, -34 },
  { 15100, 35, 34, 38, 1, -34 },
  { 15249, 25, 61, 38, 9, -50 },
  { 15440, 15, 59, 38, 11, -46 },
  { 15551, 25, 61, 38, 6, -50 },
  { 15742, 35, 14, 38, 0, -26 },
};

const GFXfont RobotoMono_BoldItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic64pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_BOLDITALIC64PT7B_H_
