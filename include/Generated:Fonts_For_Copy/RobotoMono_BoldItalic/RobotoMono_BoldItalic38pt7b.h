#ifndef _ROBOTOMONO_BOLDITALIC38PT7B_H_
#define _ROBOTOMONO_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x00, 0x3C, 0x79, 0xC3, 0xDE,
  0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0x70, 0xE7, 0x87,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x78, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x70, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x70, 0xE0, 0x01, 0xC7,
  0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78,
  0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0,
  0x03, 0x8F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0x83, 0xE1, 0xF0, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xFC, 0x1F, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x38, 0xF0, 0x87, 0x1E, 0x3D, 0xE3, 0xC7, 0x3C, 0x79,
  0xC7, 0x8E, 0x70, 0x7F, 0xDE, 0x0F, 0xF3, 0x80, 0xFC, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x9F,
  0x80, 0xE7, 0xF8, 0x3D, 0xFF, 0x07, 0x38, 0xF1, 0xCF, 0x1E, 0x79, 0xE3,
  0xC6, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x07,
  0xCF, 0xC0, 0x1F, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x3F, 0x7C, 0x79,
  0xF9, 0xFB, 0xE7, 0xC3, 0xEF, 0x9F, 0x0F, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0,
  0x3F, 0x87, 0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0x1F, 0x00, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x9C, 0x71, 0xCF,
  0x00, 0x00, 0x10, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00,
  0xE0, 0x03, 0x00, 0x02, 0x00, 0x18, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x18, 0x38, 0x17, 0x8E, 0x3F, 0xFB,
  0xBF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x70,
  0x03, 0xDE, 0x01, 0xE3, 0x80, 0xF0, 0xF0, 0x7C, 0x3E, 0x0E, 0x07, 0x01,
  0x01, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0xF8, 0xF0, 0xE0, 0x20, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFD, 0xF0, 0x7F, 0xBE,
  0x1F, 0xE7, 0xC7, 0xFC, 0xFB, 0xEF, 0x9F, 0xF9, 0xF3, 0xFC, 0x3E, 0xFF,
  0x07, 0xDF, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x3E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x08, 0x03, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF, 0xBF, 0xF9,
  0xFF, 0xCE, 0x3E, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xFC, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBE, 0x00, 0xFB,
  0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0x87, 0xC0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF9, 0xC0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0, 0x08,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x3F, 0x07, 0xDF, 0xE1, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0xC3,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xF1,
  0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xF1, 0xF8, 0x7E, 0x0F,
  0x87, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0,
  0xFC, 0x7C, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1,
  0xF3, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xEF, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x00,
  0x0F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x1F, 0x8F, 0xE1,
  0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1E, 0x00,
  0x02, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x18, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xC3, 0xC0, 0xF8,
  0x07, 0x07, 0x00, 0x38, 0x70, 0xF8, 0xE7, 0x9F, 0xE7, 0x38, 0xFF, 0x3B,
  0xCF, 0x39, 0xDC, 0xF1, 0xCE, 0xE7, 0x0E, 0x7F, 0x38, 0xE3, 0xF3, 0xC7,
  0x1B, 0x9C, 0x38, 0xDC, 0xE1, 0xCE, 0xE7, 0x1C, 0x77, 0x38, 0xE3, 0x39,
  0xFF, 0x79, 0xC7, 0xFF, 0x8E, 0x3C, 0xF8, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0x81, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x3E, 0x01,
  0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x7E, 0x01, 0xF1,
  0xF0, 0x0F, 0xC7, 0xC0, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xF8, 0xFF, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x3E,
  0x07, 0xE1, 0xF0, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xF0, 0x3E,
  0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xFE, 0xF8, 0x7F, 0xEF, 0x87,
  0xFC, 0xF8, 0x7F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xF0,
  0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x3F, 0x81, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07,
  0xDF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xDF, 0x00, 0x1F, 0xCF, 0x80,
  0x0F, 0xC7, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x1F, 0x87, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83,
  0xFC, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xF7, 0xF8, 0x3E, 0xFE, 0xF0, 0x7D,
  0xFD, 0xE0, 0xFB, 0xF7, 0xC1, 0xE7, 0xEF, 0x83, 0xCF, 0x9F, 0x07, 0x9F,
  0x3C, 0x1F, 0x3C, 0x78, 0x3E, 0x79, 0xF0, 0x7C, 0xE3, 0xE0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x00,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x07, 0xC3, 0xF8, 0x1F, 0x0F,
  0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x1F, 0xF0,
  0xF8, 0x7F, 0xC3, 0xE1, 0xF7, 0x9F, 0x87, 0xDE, 0x7C, 0x1F, 0x79, 0xF0,
  0x7D, 0xE7, 0xC3, 0xF3, 0xDF, 0x0F, 0x8F, 0x7C, 0x3E, 0x3F, 0xF0, 0xF8,
  0xFF, 0x83, 0xE1, 0xFE, 0x0F, 0x87, 0xF8, 0x7E, 0x1F, 0xE1, 0xF0, 0x7F,
  0x87, 0xC0, 0xFE, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x03, 0xF7,
  0xC0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07,
  0xE1, 0xF8, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xF8, 0x3F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x7F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8,
  0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0x81, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F, 0x07,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x8F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFC, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7E,
  0x01, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00,
  0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F,
  0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x78, 0x7D, 0xF1, 0xE1, 0xF7, 0x87, 0x87,
  0xDE, 0x1E, 0x1E, 0x78, 0xF8, 0xF9, 0xE3, 0xE3, 0xE7, 0x8F, 0x8F, 0x1E,
  0x7E, 0x7C, 0x79, 0xF9, 0xF1, 0xE7, 0xE7, 0x87, 0x9F, 0x9E, 0x1E, 0xFE,
  0xF8, 0x7B, 0xBB, 0xE1, 0xEE, 0xEF, 0x07, 0xFB, 0xBC, 0x1F, 0xCF, 0xF0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E,
  0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x7F, 0x01,
  0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFD, 0xF0,
  0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00,
  0xF3, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xF8, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03,
  0xCE, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE0, 0xE7, 0x81,
  0xFF, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x3C, 0x3E, 0x1E, 0x0F, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xCF, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x03, 0xEF, 0xC0, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xBE, 0x0F, 0xE7, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xEF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x7E, 0xFE, 0x1F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7D, 0xFF, 0x0F,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x8F, 0x83, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFB,
  0xE0, 0x7C, 0xFC, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x7F, 0x3E, 0x0F, 0xFB, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE0,
  0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0x9F, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0x0F, 0xDF, 0x81, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x23, 0xF8, 0x3C, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x3F, 0x8F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7,
  0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0xC0, 0x7E, 0x0F, 0x87, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE7, 0xF0, 0x7D, 0xFF, 0x0F, 0x7F, 0xE3,
  0xFF, 0xFE, 0x7E, 0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xF8, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0xC7,
  0xC1, 0xFC, 0x3E, 0x1F, 0xC1, 0xF1, 0xFC, 0x1F, 0x1F, 0x80, 0xF9, 0xF8,
  0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xBE, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xE0,
  0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0x80,
  0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x0F, 0x7C, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xE3, 0xE7, 0xC7,
  0x8F, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F, 0x1F,
  0x1E, 0x3C, 0x7C, 0xF8, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1E, 0x3C,
  0x7C, 0xF8, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x9F, 0x3E, 0x3C, 0x7C, 0x1F,
  0x3F, 0x83, 0xDF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x7E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E,
  0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0,
  0x7E, 0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xDF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7C, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xF3, 0xE1, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F,
  0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xCF, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x1F,
  0xE3, 0xE7, 0xF8, 0x7D, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x80,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xE3, 0xF1, 0xF0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x3E,
  0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xE1, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFD, 0xE0, 0xFF, 0x3C, 0x0F, 0xCF, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1F, 0x3C, 0x03,
  0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xF0, 0xFF, 0xC7, 0x87,
  0xBC, 0x3C, 0x7D, 0xE3, 0xE3, 0xEF, 0x1F, 0x1E, 0x78, 0xF8, 0xF3, 0xCF,
  0xCF, 0x9E, 0x7E, 0x78, 0xF3, 0xF3, 0xC7, 0xBB, 0xBE, 0x3D, 0xDD, 0xE1,
  0xEE, 0xEF, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x80, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80,
  0x3E, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC7,
  0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x03, 0xDF,
  0x00, 0x03, 0xDF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x08,
  0x00, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x04, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x7F, 0x03,
  0xF8, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x03, 0xDF, 0xFC,
  0x1E, 0xFF, 0xF9, 0xE7, 0x8F, 0xFF, 0x78, 0x3F, 0xF3, 0x80, 0x7F, 0x80,
  0x01, 0xF0,
};

const GFXglyph RobotoMono_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 13, 10, 22, 6, -29 },
  { 49, 22, 27, 22, 0, -27 },
  { 124, 20, 35, 22, 2, -31 },
  { 212, 19, 27, 22, 2, -27 },
  { 277, 22, 27, 22, 0, -27 },
  { 352, 6, 11, 22, 9, -29 },
  { 361, 13, 38, 22, 6, -30 },
  { 423, 13, 39, 22, 3, -30 },
  { 487, 18, 19, 22, 3, -27 },
  { 530, 18, 19, 22, 2, -22 },
  { 573, 8, 13, 22, 4, -5 },
  { 586, 16, 4, 22, 5, -14 },
  { 594, 7, 6, 22, 6, -6 },
  { 600, 19, 29, 22, 2, -27 },
  { 669, 19, 27, 22, 2, -27 },
  { 734, 13, 27, 22, 4, -27 },
  { 778, 20, 27, 22, 0, -27 },
  { 846, 20, 27, 22, 1, -27 },
  { 914, 20, 27, 22, 0, -27 },
  { 982, 21, 27, 22, 1, -27 },
  { 1053, 18, 27, 22, 2, -27 },
  { 1114, 20, 27, 22, 2, -27 },
  { 1182, 20, 27, 22, 1, -27 },
  { 1250, 17, 27, 22, 3, -27 },
  { 1308, 10, 21, 22, 6, -21 },
  { 1335, 12, 29, 22, 5, -21 },
  { 1379, 17, 18, 22, 3, -21 },
  { 1418, 19, 13, 22, 2, -18 },
  { 1449, 19, 17, 22, 1, -20 },
  { 1490, 17, 27, 22, 5, -27 },
  { 1548, 21, 27, 22, 1, -27 },
  { 1619, 22, 27, 22, -2, -27 },
  { 1694, 22, 27, 22, 0, -27 },
  { 1769, 21, 27, 22, 1, -27 },
  { 1840, 21, 27, 22, 0, -27 },
  { 1911, 22, 27, 22, 1, -27 },
  { 1986, 22, 27, 22, 1, -27 },
  { 2061, 20, 27, 22, 2, -27 },
  { 2129, 22, 27, 22, 0, -27 },
  { 2204, 19, 27, 22, 2, -27 },
  { 2269, 22, 27, 22, 1, -27 },
  { 2344, 25, 27, 22, 0, -27 },
  { 2429, 18, 27, 22, 1, -27 },
  { 2490, 23, 27, 22, 0, -27 },
  { 2568, 22, 27, 22, 0, -27 },
  { 2643, 21, 27, 22, 1, -27 },
  { 2714, 21, 27, 22, 1, -27 },
  { 2785, 21, 32, 22, 1, -27 },
  { 2869, 22, 27, 22, 0, -27 },
  { 2944, 21, 27, 22, 1, -27 },
  { 3015, 22, 27, 22, 2, -27 },
  { 3090, 21, 27, 22, 2, -27 },
  { 3161, 21, 27, 22, 3, -27 },
  { 3232, 22, 27, 22, 2, -27 },
  { 3307, 25, 27, 22, -1, -27 },
  { 3392, 22, 27, 22, 3, -27 },
  { 3467, 23, 27, 22, 0, -27 },
  { 3545, 14, 37, 22, 4, -31 },
  { 3610, 9, 29, 22, 7, -27 },
  { 3643, 14, 37, 22, 4, -31 },
  { 3708, 15, 14, 22, 4, -27 },
  { 3735, 17, 4, 22, 0, 0 },
  { 3744, 8, 5, 22, 10, -27 },
  { 3749, 19, 20, 22, 1, -20 },
  { 3797, 19, 29, 22, 1, -29 },
  { 3866, 18, 21, 22, 2, -21 },
  { 3914, 20, 29, 22, 2, -29 },
  { 3987, 18, 20, 22, 2, -20 },
  { 4032, 21, 29, 22, 3, -29 },
  { 4109, 21, 28, 22, 0, -20 },
  { 4183, 19, 29, 22, 1, -29 },
  { 4252, 17, 28, 22, 2, -28 },
  { 4312, 17, 36, 22, 1, -28 },
  { 4389, 21, 29, 22, 1, -29 },
  { 4466, 17, 29, 22, 2, -29 },
  { 4528, 22, 20, 22, -1, -20 },
  { 4583, 19, 20, 22, 1, -20 },
  { 4631, 19, 21, 22, 1, -21 },
  { 4681, 21, 28, 22, -1, -20 },
  { 4755, 19, 28, 22, 2, -20 },
  { 4822, 19, 20, 22, 3, -20 },
  { 4870, 19, 20, 22, 1, -20 },
  { 4918, 18, 25, 22, 3, -25 },
  { 4975, 19, 20, 22, 2, -20 },
  { 5023, 19, 20, 22, 3, -20 },
  { 5071, 21, 20, 22, 2, -20 },
  { 5124, 23, 20, 22, 0, -20 },
  { 5182, 24, 28, 22, 0, -20 },
  { 5266, 21, 20, 22, 0, -20 },
  { 5319, 15, 37, 22, 5, -30 },
  { 5389, 8, 35, 22, 7, -27 },
  { 5424, 14, 37, 22, 4, -30 },
  { 5489, 21, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic38pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_BOLDITALIC38PT7B_H_
