#ifndef _ROBOTOMONO_BOLDITALIC55PT7B_H_
#define _ROBOTOMONO_BOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F,
  0x7E, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x7C, 0x04, 0x1F, 0x0F, 0x81, 0xC3, 0xE0,
  0xF8, 0x7C, 0x7C, 0x3E, 0x0F, 0x1F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8,
  0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0xE7, 0xC0, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF,
  0x3C, 0x01, 0xFF, 0xCF, 0x80, 0x1F, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0xF8, 0xFF, 0x00,
  0x1F, 0x7F, 0xF0, 0x07, 0xCF, 0xFF, 0x01, 0xF3, 0xFF, 0xE0, 0x3C, 0xFC,
  0x7E, 0x0F, 0x9F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0x1F,
  0x0F, 0x83, 0xE1, 0xC1, 0xF0, 0x7C, 0x10, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xC3, 0xFF, 0xF0, 0x3F, 0x0F,
  0xFF, 0xF0, 0x7E, 0x3F, 0xDF, 0xE1, 0xFC, 0xFF, 0x1F, 0xE3, 0xF9, 0xFE,
  0x1F, 0xCF, 0xE3, 0xF8, 0x3F, 0xDF, 0xCF, 0xF0, 0x3F, 0xFF, 0x1F, 0xE0,
  0x7F, 0xFE, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0xFF, 0x00,
  0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF3,
  0xFC, 0x03, 0xFF, 0x87, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x7D, 0xFB,
  0xF7, 0xEF, 0x9F, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x7C,
  0x02, 0x3C, 0x0F, 0x81, 0xC7, 0xE1, 0xE0, 0xF9, 0xFF, 0x3C, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x87, 0xE0,
  0x07, 0xE0, 0x7E, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xC0,
  0x1E, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0x78,
  0x01, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x3F, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xFF,
  0x3F, 0x80, 0xFF, 0xE7, 0xF0, 0x7F, 0xF8, 0xFE, 0x1F, 0xFF, 0x3F, 0xC7,
  0xFF, 0xE7, 0xFB, 0xF9, 0xFC, 0xFE, 0xFE, 0x3F, 0x9F, 0xFF, 0x0F, 0xF3,
  0xFF, 0xC1, 0xFE, 0x7F, 0xE0, 0x3F, 0x9F, 0xF8, 0x07, 0xF3, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xF7,
  0xF9, 0xF8, 0xFE, 0x78, 0x1F, 0xC8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC3,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x07, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF1, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0x38, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0xBF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x01, 0xFD, 0xFF, 0xC0, 0xFE,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xC1, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xFD, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE7, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xEF, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8, 0x1F, 0xF3,
  0xFF, 0x3F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFE, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFC, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x70, 0x3C, 0x0F, 0x87, 0xFC,
  0x78, 0x3E, 0x1F, 0xFC, 0x70, 0x78, 0x7F, 0xF8, 0xF1, 0xF1, 0xFE, 0xF1,
  0xE3, 0xC3, 0xE1, 0xE3, 0xCF, 0x8F, 0x87, 0x87, 0x9E, 0x3E, 0x0F, 0x0F,
  0x7C, 0x7C, 0x1E, 0x1E, 0xF8, 0xF0, 0x3C, 0x79, 0xE3, 0xE0, 0xF0, 0xF3,
  0xC7, 0xC1, 0xE1, 0xE7, 0x8F, 0x83, 0xC3, 0xDF, 0x1E, 0x07, 0x87, 0xBE,
  0x3C, 0x1F, 0x1E, 0x7C, 0x78, 0x3C, 0x3C, 0xF0, 0xF0, 0x78, 0x79, 0xE1,
  0xF1, 0xF1, 0xE3, 0xC3, 0xE7, 0xE7, 0xC7, 0xC7, 0xFF, 0xFF, 0x0F, 0x87,
  0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xF0, 0x1E, 0x07, 0x07, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0,
  0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE1,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFE,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x01,
  0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0,
  0x3F, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x10, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x03, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0x3F,
  0xC0, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0x8F, 0xF0,
  0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F,
  0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x81, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x00,
  0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF,
  0x81, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF3, 0xEF, 0xC0, 0x7F, 0xFB, 0xF7,
  0xE0, 0x3F, 0x7D, 0xF7, 0xF0, 0x1F, 0x9F, 0xFB, 0xF8, 0x0F, 0xCF, 0xF9,
  0xF8, 0x0F, 0xE7, 0xFC, 0xFC, 0x07, 0xF3, 0xFC, 0x7E, 0x03, 0xF9, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x8F, 0xC0, 0x7F, 0x1F, 0x87, 0xE0, 0x3F, 0x8F, 0xC7, 0xF0, 0x1F, 0xC3,
  0xC3, 0xF8, 0x0F, 0xE1, 0xE1, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFE,
  0x03, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x81, 0xFC,
  0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC3, 0xFC,
  0x0F, 0xF7, 0xC3, 0xFC, 0x0F, 0xF7, 0xC3, 0xFC, 0x0F, 0xF7, 0xE3, 0xF8,
  0x0F, 0xE7, 0xE3, 0xF8, 0x0F, 0xE3, 0xE3, 0xF8, 0x0F, 0xE3, 0xE7, 0xF8,
  0x1F, 0xE3, 0xF7, 0xF8, 0x1F, 0xE3, 0xF7, 0xF8, 0x1F, 0xE1, 0xF7, 0xF0,
  0x1F, 0xC1, 0xF7, 0xF0, 0x1F, 0xC1, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xE0,
  0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xE0, 0x3F, 0x80, 0x7F, 0xE0,
  0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x80,
  0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F,
  0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x83,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x1F,
  0xC0, 0x1F, 0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x10, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x7F,
  0x7F, 0x07, 0xE0, 0x7F, 0x7F, 0x07, 0xE0, 0x7E, 0x7F, 0x07, 0xE0, 0xFE,
  0x7F, 0x0F, 0xE0, 0xFE, 0x7F, 0x0F, 0xE0, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x1F, 0xE1, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF8, 0x7E, 0x3F, 0xE3, 0xF8, 0x7E, 0x3F, 0xE3, 0xF0,
  0x7E, 0x3F, 0xE3, 0xF0, 0x7E, 0x3F, 0xE7, 0xF0, 0x7E, 0x7F, 0xE7, 0xF0,
  0x7E, 0x7F, 0xE7, 0xE0, 0x7E, 0x7F, 0xEF, 0xE0, 0x7E, 0xFB, 0xEF, 0xE0,
  0x7E, 0xFB, 0xEF, 0xC0, 0x7E, 0xFB, 0xEF, 0xC0, 0x7F, 0xF3, 0xFF, 0xC0,
  0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x80,
  0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3E, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC1, 0xF8,
  0x1F, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x0F,
  0xBF, 0x80, 0x3E, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x7F,
  0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xEF, 0xF8,
  0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC, 0x3F, 0xFE, 0x7F, 0x03, 0xFE,
  0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0x00, 0x07,
  0xF3, 0xFE, 0x00, 0x7F, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFF, 0xBF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF,
  0xC0, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0,
  0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFC,
  0x07, 0xF8, 0x7F, 0xE7, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x60, 0x3F, 0x80,
  0x07, 0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0x80,
  0x07, 0xFC, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x40, 0x7F, 0x80, 0x0E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xFD, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x01, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x00, 0xFF,
  0x00, 0xE0, 0x03, 0xFC, 0x03, 0xC0, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x03, 0x80, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x3F, 0xF8,
  0x0F, 0xF7, 0xFF, 0xC0, 0xFE, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x06, 0x1F, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0xFE, 0x01,
  0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x7F, 0x1F, 0xF0,
  0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xF7, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x07,
  0xE7, 0xF1, 0xFC, 0x07, 0xEF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF, 0x0F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F,
  0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x7E,
  0x1F, 0xF0, 0x07, 0xE3, 0xFF, 0xC0, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF3,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xC0, 0x1F, 0xE7, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF,
  0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x1F, 0x9F, 0xFC,
  0x00, 0x7E, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xFE, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xF8, 0x0C, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x01, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF,
  0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xE1,
  0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F,
  0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x7F, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x60, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0E, 0x01, 0xF8, 0x3F, 0xF0, 0xFE, 0x3F, 0xFC, 0x3F, 0x9F, 0xFF,
  0x0F, 0xEF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFE, 0x00, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03,
  0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xF8,
  0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0x7E, 0x01, 0xFF, 0xCF, 0xE0,
  0x0F, 0xF8, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x0F, 0x81, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0xC0, 0xF8, 0x1F,
  0xBF, 0x07, 0xE0, 0xFE, 0xFC, 0x1F, 0x83, 0xFB, 0xF0, 0x7E, 0x0F, 0xCF,
  0xC3, 0xF8, 0x7F, 0x3F, 0x0F, 0xE1, 0xFC, 0xFC, 0x7F, 0x87, 0xE3, 0xF1,
  0xFE, 0x3F, 0x8F, 0xC7, 0xF8, 0xFC, 0x3F, 0x3F, 0xE3, 0xF0, 0xFC, 0xF7,
  0x8F, 0xC3, 0xF3, 0xDE, 0x7E, 0x0F, 0xDF, 0x79, 0xF8, 0x3F, 0x79, 0xE7,
  0xE0, 0xFD, 0xE7, 0xBF, 0x03, 0xFF, 0x9E, 0xFC, 0x0F, 0xFC, 0x7B, 0xF0,
  0x3F, 0xF1, 0xEF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0x81, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xC0, 0xFD,
  0xFF, 0xFF, 0xCF, 0xE7, 0xE1, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0xFE, 0xF8,
  0x03, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xC0,
};

const GFXglyph RobotoMono_BoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 15, 39, 32, 9, -39 },
  { 75, 18, 14, 32, 9, -41 },
  { 107, 32, 39, 32, 0, -39 },
  { 263, 30, 51, 32, 2, -45 },
  { 455, 27, 41, 32, 3, -40 },
  { 594, 31, 41, 32, 1, -40 },
  { 753, 7, 14, 32, 14, -41 },
  { 766, 19, 56, 32, 8, -44 },
  { 899, 19, 55, 32, 4, -43 },
  { 1030, 27, 28, 32, 4, -39 },
  { 1125, 28, 28, 32, 2, -32 },
  { 1223, 12, 18, 32, 5, -7 },
  { 1250, 23, 6, 32, 7, -20 },
  { 1268, 10, 10, 32, 9, -9 },
  { 1281, 29, 42, 32, 2, -39 },
  { 1434, 27, 41, 32, 3, -40 },
  { 1573, 19, 39, 32, 6, -39 },
  { 1666, 29, 40, 32, 0, -40 },
  { 1811, 29, 41, 32, 1, -40 },
  { 1960, 28, 39, 32, 1, -39 },
  { 2097, 29, 40, 32, 2, -39 },
  { 2242, 26, 40, 32, 2, -39 },
  { 2372, 29, 39, 32, 3, -39 },
  { 2514, 28, 41, 32, 2, -40 },
  { 2658, 25, 40, 32, 4, -40 },
  { 2783, 14, 32, 32, 9, -31 },
  { 2839, 17, 42, 32, 7, -31 },
  { 2929, 26, 26, 32, 4, -30 },
  { 3014, 27, 17, 32, 3, -25 },
  { 3072, 26, 25, 32, 2, -29 },
  { 3154, 24, 40, 32, 7, -40 },
  { 3274, 31, 39, 32, 1, -39 },
  { 3426, 31, 39, 32, -2, -39 },
  { 3578, 31, 39, 32, 1, -39 },
  { 3730, 30, 41, 32, 2, -40 },
  { 3884, 31, 39, 32, 0, -39 },
  { 4036, 32, 39, 32, 1, -39 },
  { 4192, 33, 39, 32, 1, -39 },
  { 4353, 30, 41, 32, 2, -40 },
  { 4507, 32, 39, 32, 0, -39 },
  { 4663, 29, 39, 32, 2, -39 },
  { 4805, 31, 40, 32, 2, -39 },
  { 4960, 36, 39, 32, 1, -39 },
  { 5136, 26, 39, 32, 1, -39 },
  { 5263, 33, 39, 32, 0, -39 },
  { 5424, 32, 39, 32, 0, -39 },
  { 5580, 29, 41, 32, 2, -40 },
  { 5729, 31, 39, 32, 1, -39 },
  { 5881, 29, 47, 32, 2, -40 },
  { 6052, 31, 39, 32, 1, -39 },
  { 6204, 30, 41, 32, 2, -40 },
  { 6358, 31, 39, 32, 4, -39 },
  { 6510, 30, 40, 32, 3, -39 },
  { 6660, 31, 39, 32, 4, -39 },
  { 6812, 32, 39, 32, 3, -39 },
  { 6968, 37, 39, 32, -2, -39 },
  { 7149, 31, 39, 32, 5, -39 },
  { 7301, 33, 39, 32, 0, -39 },
  { 7462, 21, 54, 32, 6, -45 },
  { 7604, 14, 42, 32, 10, -39 },
  { 7678, 21, 54, 32, 6, -45 },
  { 7820, 22, 21, 32, 6, -39 },
  { 7878, 25, 6, 32, 0, 0 },
  { 7897, 11, 8, 32, 15, -40 },
  { 7908, 26, 31, 32, 2, -30 },
  { 8009, 28, 42, 32, 1, -41 },
  { 8156, 26, 31, 32, 3, -30 },
  { 8257, 31, 42, 32, 2, -41 },
  { 8420, 28, 31, 32, 2, -30 },
  { 8529, 29, 43, 32, 5, -43 },
  { 8685, 30, 42, 32, 1, -30 },
  { 8843, 28, 41, 32, 1, -41 },
  { 8987, 24, 41, 32, 3, -41 },
  { 9110, 26, 53, 32, 1, -41 },
  { 9283, 31, 41, 32, 1, -41 },
  { 9442, 25, 41, 32, 2, -41 },
  { 9571, 32, 30, 32, -1, -30 },
  { 9691, 28, 30, 32, 1, -30 },
  { 9796, 27, 31, 32, 2, -30 },
  { 9901, 30, 41, 32, -1, -30 },
  { 10055, 28, 41, 32, 2, -30 },
  { 10199, 26, 30, 32, 5, -30 },
  { 10297, 28, 31, 32, 2, -30 },
  { 10406, 25, 37, 32, 5, -36 },
  { 10522, 28, 30, 32, 3, -29 },
  { 10627, 28, 29, 32, 4, -29 },
  { 10729, 30, 29, 32, 3, -29 },
  { 10838, 33, 29, 32, 0, -29 },
  { 10958, 34, 41, 32, 0, -29 },
  { 11133, 30, 29, 32, 1, -29 },
  { 11242, 21, 53, 32, 8, -43 },
  { 11382, 12, 50, 32, 10, -39 },
  { 11457, 21, 53, 32, 5, -43 },
  { 11597, 30, 12, 32, 0, -22 },
};

const GFXfont RobotoMono_BoldItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic55pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_BOLDITALIC55PT7B_H_
