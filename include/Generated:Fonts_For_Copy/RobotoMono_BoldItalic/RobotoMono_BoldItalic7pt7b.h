#ifndef _ROBOTOMONO_BOLDITALIC7PT7B_H_
#define _ROBOTOMONO_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xF0, 0x37, 0x6F, 0xA0, 0x27, 0x56, 0x96, 0x40, 0x5E,
  0x27, 0x30, 0x66, 0x4B, 0xF0, 0xC0, 0x5A, 0xA9, 0x95, 0x5A, 0x5F, 0x20,
  0x2F, 0x44, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0xC0, 0x75, 0x79, 0x60, 0x75,
  0x80, 0x69, 0x24, 0xE0, 0x71, 0x61, 0xE0, 0x36, 0x6F, 0x20, 0x74, 0x61,
  0xE0, 0x24, 0xE9, 0x60, 0x71, 0x24, 0xC0, 0x75, 0x69, 0xE0, 0x65, 0x72,
  0x60, 0x42, 0x42, 0x80, 0x16, 0xE0, 0x7F, 0x43, 0x68, 0xE5, 0x48, 0x7B,
  0xFF, 0xE0, 0x26, 0x6E, 0x90, 0x75, 0x69, 0xE0, 0x75, 0x89, 0x60, 0x65,
  0x99, 0xE0, 0x74, 0x78, 0xF0, 0x74, 0x78, 0x80, 0x75, 0xB9, 0x60, 0x55,
  0xF9, 0xA0, 0x72, 0x24, 0xE0, 0x11, 0x11, 0xE0, 0x5B, 0x19, 0x49, 0x00,
  0x49, 0x4E, 0x57, 0xB9, 0xB0, 0x55, 0xBB, 0xA0, 0x75, 0x99, 0x60, 0x75,
  0x78, 0x80, 0x75, 0x99, 0x61, 0x75, 0x7A, 0xB0, 0x74, 0x69, 0x60, 0xF9,
  0x08, 0x84, 0x00, 0x55, 0x99, 0x60, 0xB7, 0x68, 0xBB, 0xFE, 0xA0, 0x5B,
  0x08, 0xC9, 0x00, 0xBA, 0xC8, 0x80, 0x72, 0x24, 0xF0, 0x56, 0xA8, 0xA5,
  0x40, 0x55, 0x58, 0x5A, 0x80, 0xE0, 0x80, 0x61, 0xEE, 0x46, 0x59, 0xE0,
  0x69, 0x86, 0x17, 0x99, 0x60, 0x69, 0xE6, 0x7E, 0x48, 0x79, 0x96, 0xE0,
  0x46, 0x99, 0xA0, 0x2C, 0x9E, 0x2C, 0x92, 0xA0, 0x45, 0x6E, 0xB0, 0x64,
  0x9E, 0xDB, 0xDD, 0x65, 0x9A, 0x69, 0x96, 0x65, 0x9E, 0x80, 0x79, 0x96,
  0x20, 0xF2, 0x40, 0x65, 0x3E, 0x5E, 0x4C, 0x55, 0x96, 0xB7, 0x40, 0xBB,
  0xEA, 0x56, 0x6B, 0xD5, 0x64, 0x48, 0x72, 0x4F, 0x6B, 0x24, 0x80, 0x56,
  0xA0, 0x55, 0xA0, 0xDA,
};

const GFXglyph RobotoMono_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 2, 8, 4, 1, -6 },
  { 22, 3, 4, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 3, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 2, 5, 4, 1, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 2, 5, 4, 1, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 2, 4, 0, -3 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 5, 5, 4, 0, -5 },
  { 108, 3, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 6, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 5, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 3, 5, 4, 1, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 5, 5, 4, 0, -5 },
  { 147, 4, 5, 4, 1, -5 },
  { 150, 4, 5, 4, 0, -5 },
  { 153, 2, 7, 4, 1, -6 },
  { 155, 2, 5, 4, 1, -5 },
  { 157, 2, 7, 4, 1, -6 },
  { 159, 3, 3, 4, 1, -5 },
  { 161, 3, 1, 4, 0, 0 },
  { 162, 1, 1, 4, 2, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 4, 4, 4, 0, -4 },
  { 170, 4, 5, 4, 0, -5 },
  { 173, 4, 4, 4, 0, -4 },
  { 175, 3, 5, 4, 1, -5 },
  { 177, 4, 5, 4, 0, -4 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 3, 5, 4, 0, -5 },
  { 185, 3, 7, 4, 0, -5 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 3, 5, 4, 0, -5 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 5, 4, 0, -4 },
  { 202, 4, 5, 4, 0, -4 },
  { 205, 3, 4, 4, 1, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 3, 5, 4, 1, -5 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 3, 4, 4, 1, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 6, 4, 0, -4 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 3, 6, 4, 1, -5 },
  { 227, 2, 6, 4, 1, -5 },
  { 229, 2, 6, 4, 1, -5 },
  { 231, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic7pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_BOLDITALIC7PT7B_H_
