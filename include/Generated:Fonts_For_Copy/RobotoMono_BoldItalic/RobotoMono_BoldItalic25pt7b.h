#ifndef _ROBOTOMONO_BOLDITALIC25PT7B_H_
#define _ROBOTOMONO_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC0,
  0x00, 0x08, 0x38, 0xF0, 0xE0, 0x73, 0x63, 0x63, 0x67, 0xE7, 0xC6, 0xC6,
  0x01, 0x8C, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x07, 0xFF, 0xCF,
  0xFF, 0x03, 0x30, 0x0E, 0x60, 0x19, 0xC0, 0x33, 0x07, 0xFF, 0xCF, 0xFF,
  0x83, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x33, 0x00, 0xCE, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0x38,
  0x39, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xDE, 0x0E,
  0xF0, 0x77, 0x87, 0x9F, 0xF8, 0xFF, 0xC1, 0xF8, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x3C, 0x03, 0xF0, 0x19, 0x88, 0xCC, 0xE6, 0x66, 0x37, 0x61, 0xF7,
  0x07, 0x30, 0x03, 0x00, 0x30, 0x01, 0x90, 0x1B, 0xE1, 0xBB, 0x1D, 0x9C,
  0xCC, 0xE2, 0x66, 0x03, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0xFF,
  0x03, 0x9C, 0x1C, 0x70, 0x71, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x73, 0xF9, 0xDE, 0xE7, 0x71, 0xFF, 0xC7, 0xEF, 0x0F, 0x1E, 0xFC, 0x7F,
  0xF8, 0xFC, 0xE0, 0x77, 0x66, 0x6E, 0xC0, 0x01, 0x03, 0x07, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x08, 0x08, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xE0,
  0xC0, 0x40, 0x00, 0x03, 0x00, 0x30, 0x03, 0x04, 0x60, 0x66, 0x7F, 0xFF,
  0x3F, 0xE0, 0xE0, 0x1F, 0x03, 0xB8, 0x71, 0x8E, 0x1C, 0x21, 0x00, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xCF,
  0x18, 0x7F, 0xFF, 0xFB, 0xFF, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E,
  0x70, 0xF7, 0x0F, 0xF0, 0xFF, 0x3E, 0xE7, 0xEF, 0xEE, 0xF8, 0xEF, 0x1E,
  0xE1, 0xEE, 0x1C, 0xE1, 0xCF, 0x78, 0x7F, 0x83, 0xE0, 0x01, 0x0F, 0x3F,
  0xFF, 0xFF, 0x8F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0x9C,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xC0, 0xFF,
  0x8F, 0xFC, 0x70, 0xF7, 0x87, 0x80, 0x3C, 0x01, 0xC0, 0x3E, 0x0F, 0xC0,
  0x7E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x70, 0x73, 0x83, 0x9F, 0xFC, 0x7F,
  0xC1, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xF8, 0x1D, 0xC1, 0xCE, 0x1C, 0xF1, 0xC7, 0x8E, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xEC, 0x07, 0xF8, 0x7F, 0xE1,
  0x87, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x70, 0x73, 0xC3, 0x9F, 0x7C, 0x7F,
  0xC1, 0xF8, 0x00, 0x01, 0xE0, 0x7E, 0x0F, 0xE1, 0xF0, 0x3C, 0x03, 0x80,
  0x7B, 0x87, 0xFE, 0x7F, 0xEF, 0x8F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xE7, 0xBE, 0x7F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x78, 0xE3, 0x87, 0x9C, 0x38, 0xE1, 0xC7,
  0xFC, 0x1F, 0xC1, 0xFE, 0x1E, 0x79, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x87,
  0x9F, 0x7C, 0x7F, 0xC1, 0xF8, 0x00, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0xFF,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFF, 0x7D, 0xFF, 0x9F, 0xE0, 0x1C,
  0x07, 0x01, 0xE3, 0xF8, 0x7E, 0x0F, 0x00, 0x1C, 0x7C, 0xF1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x8E, 0x00, 0x0E, 0x0F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x70, 0xE0, 0x40, 0x00, 0x20, 0x0C, 0x0F, 0x87, 0xF7, 0xF9, 0xF8, 0x38,
  0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x0F, 0x00, 0x60, 0x3F, 0xFB, 0xFF, 0xDF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0xFF, 0xE0, 0x30,
  0x03, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0x07, 0xE3, 0xFC, 0xFE,
  0x0F, 0x80, 0xC0, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0xF8, 0xFE, 0x0E, 0x03,
  0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x04,
  0x01, 0xC0, 0x78, 0x07, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x3C, 0x60, 0xE0,
  0x61, 0x9E, 0xC6, 0x7E, 0x8D, 0xD9, 0x33, 0x32, 0x6C, 0x6C, 0xD8, 0x99,
  0xB3, 0x36, 0x66, 0x46, 0xFD, 0x8C, 0xFE, 0x18, 0x00, 0x38, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0xFE,
  0x1F, 0xF8, 0xFF, 0xF3, 0x83, 0xDE, 0x07, 0x70, 0x1F, 0xC0, 0x70, 0x1F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE1, 0xE1, 0xC1, 0xE7, 0x83, 0x8F, 0x07,
  0x1C, 0x3C, 0x3F, 0xF0, 0x7F, 0xE0, 0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xCE,
  0x07, 0x1C, 0x1E, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0x80, 0x07, 0xC0, 0x7F,
  0x87, 0xFE, 0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x70, 0x7B, 0xC3, 0xCF, 0xFC, 0x7F,
  0xC1, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x07, 0x1E, 0x1C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCE, 0x07, 0x38, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0E,
  0x78, 0x79, 0xC1, 0xC7, 0x0F, 0x1F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFE,
  0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x9F, 0xF8,
  0xFD, 0xC0, 0xEE, 0x07, 0x78, 0x3B, 0xC3, 0xCF, 0xFE, 0x7F, 0xE0, 0xFC,
  0x00, 0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x83,
  0x8F, 0x0F, 0x1C, 0x1E, 0x3F, 0xF8, 0x7F, 0xF1, 0xE0, 0xE3, 0xC3, 0xC7,
  0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x71, 0xE1, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF3, 0x83, 0xCF, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC,
  0x00, 0x1E, 0x0F, 0x8E, 0x0F, 0x07, 0x0F, 0x83, 0x8F, 0x81, 0xC7, 0x81,
  0xE7, 0x80, 0xF7, 0x80, 0x77, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xBC, 0x07, 0x9E, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE0, 0xE0, 0x70,
  0x78, 0x78, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0x1E, 0x1E, 0x3E, 0x7C, 0x7C,
  0xF8, 0xFB, 0xF1, 0xF7, 0xC7, 0x7F, 0x8E, 0xFF, 0x1D, 0xEE, 0x3B, 0xDC,
  0x77, 0x70, 0xEE, 0xE3, 0x99, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x38, 0xF0, 0x71, 0xC0, 0xE0, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x70, 0xF0,
  0xE1, 0xF1, 0xC7, 0xE7, 0x8F, 0xCF, 0x1D, 0x9C, 0x3B, 0xB8, 0x77, 0x71,
  0xE6, 0xE3, 0xCF, 0xC7, 0x9F, 0x8E, 0x3E, 0x1C, 0x3C, 0x38, 0x78, 0xF0,
  0xF1, 0xE1, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x83, 0xB8,
  0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xEE, 0x07,
  0x70, 0x7B, 0xC3, 0x8F, 0xFC, 0x7F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E,
  0x38, 0x7C, 0x7F, 0xF0, 0xFF, 0xC1, 0xC8, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC,
  0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x7B, 0xC3, 0x8F, 0xFC, 0x7F, 0xC0, 0xFE,
  0x00, 0x78, 0x01, 0xE0, 0x04, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0xE1, 0xE1, 0xC1, 0xC7, 0x83, 0xCF, 0x07, 0x1C, 0x1E, 0x38, 0xF8, 0x7F,
  0xE0, 0xFF, 0x83, 0xCF, 0x07, 0x8E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38,
  0x70, 0x79, 0xE0, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x0E, 0x38,
  0x3D, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x3C, 0xE0, 0x73, 0x81, 0xCF, 0x07, 0x3F, 0xFC, 0x7F, 0xE0, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x3C, 0xE0, 0xF3,
  0x83, 0x8E, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x87, 0x9C, 0x1E, 0x70, 0x71,
  0xC1, 0xC7, 0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFC, 0x00, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0x70,
  0xF1, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xEF, 0x07, 0xB8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00,
  0xE3, 0x1F, 0x9C, 0xFE, 0x73, 0xB9, 0xCE, 0xEF, 0x3B, 0xBD, 0xCE, 0xF7,
  0x3B, 0xDC, 0xFB, 0x73, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x00, 0x1E, 0x07, 0x87, 0x07,
  0x83, 0xC3, 0x81, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x00,
  0xF3, 0x80, 0x71, 0xE0, 0x78, 0x70, 0x78, 0x3C, 0x7C, 0x1E, 0x00, 0xF0,
  0x3D, 0xC0, 0xF7, 0x07, 0x9E, 0x1C, 0x78, 0xF0, 0xE7, 0x83, 0x9C, 0x0F,
  0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0x87, 0xC7, 0xE3, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xF1, 0xF8, 0xF8, 0x00, 0xE3, 0x8E,
  0x38, 0xE1, 0xC7, 0x1C, 0x71, 0xC7, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE1,
  0xC7, 0x0F, 0x87, 0xC7, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1B,
  0x0E, 0xE7, 0x39, 0xC6, 0xE1, 0xB8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE3, 0x8E, 0x1F, 0xC3, 0xFE, 0x78, 0xF7, 0x0F, 0x00, 0xF1, 0xFF, 0x7F,
  0xEF, 0x0E, 0xE0, 0xEE, 0x1E, 0xF3, 0xEF, 0xFE, 0x7F, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xC7, 0xFE, 0x3E,
  0x79, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0xBC, 0x1D, 0xE1, 0xEF, 0x0E,
  0x7D, 0xF3, 0xFF, 0x3D, 0xF0, 0x0F, 0xC3, 0xFE, 0x3C, 0xF7, 0x87, 0x70,
  0x7F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0xEF, 0x0E, 0x7B, 0xE7, 0xFC, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE1,
  0xFF, 0x8F, 0xFE, 0x7C, 0xF1, 0xE1, 0xC7, 0x07, 0x3C, 0x1C, 0xF0, 0xF3,
  0x83, 0x8E, 0x0E, 0x3C, 0x38, 0x7F, 0xE1, 0xFF, 0x83, 0xEE, 0x00, 0x0F,
  0xC1, 0xFE, 0x3C, 0xF7, 0x87, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x04, 0x7D, 0xE3, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x7C,
  0x83, 0xC0, 0x0E, 0x00, 0x38, 0x0F, 0xFF, 0x3F, 0xFC, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xDC, 0x7F, 0xF3, 0xE7, 0xCF, 0x0E,
  0x38, 0x39, 0xE0, 0xE7, 0x83, 0x9C, 0x1E, 0x78, 0x79, 0xE1, 0xC3, 0xFF,
  0x0F, 0xFC, 0x1F, 0x70, 0x03, 0xC2, 0x0E, 0x1E, 0xF8, 0xFF, 0xC0, 0xFC,
  0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x77,
  0xC7, 0xFF, 0x3E, 0x79, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0xBC, 0x3D,
  0xE1, 0xEE, 0x0E, 0x70, 0x73, 0x83, 0xBC, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x00, 0x04, 0x7F, 0x0F, 0xE1, 0xFC, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC3, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0xE0, 0x3C,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0xFE, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x89, 0xE1, 0xFC, 0x3E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x47, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0, 0x73, 0xC0,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x1E, 0x70, 0x38, 0xF0, 0x70,
  0xE0, 0xE1, 0xE3, 0xC1, 0xE0, 0x1F, 0xE3, 0xF8, 0x7F, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF7,
  0xBD, 0xDC, 0xE7, 0x73, 0x9D, 0xCE, 0x77, 0x3B, 0x9D, 0xCE, 0xE7, 0x3B,
  0x9C, 0xEE, 0x73, 0xB9, 0xCE, 0xEF, 0x70, 0x1D, 0xF1, 0xDF, 0xCF, 0x9E,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x0F, 0x78, 0x7B, 0x83, 0x9C,
  0x1C, 0xE0, 0xEF, 0x07, 0x00, 0x0F, 0xC3, 0xFE, 0x7C, 0xF7, 0x07, 0x70,
  0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0E, 0x7B, 0xE7, 0xFC, 0x3F,
  0x00, 0x1F, 0xF1, 0xFF, 0x8F, 0x9E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE0,
  0xEF, 0x07, 0x78, 0x7B, 0xC3, 0x9F, 0x7C, 0xFF, 0xC7, 0x7C, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1F, 0xB9, 0xFF, 0xDF, 0x3C,
  0xF0, 0xE7, 0x07, 0x78, 0x3B, 0xC3, 0xDC, 0x1C, 0xF0, 0xE7, 0x87, 0x1F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0x3D, 0xF3, 0xBF, 0x3F, 0xF3, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xE3, 0xFF,
  0x78, 0x77, 0x07, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x0F,
  0xF1, 0xE7, 0xFE, 0x3F, 0x80, 0x0E, 0x00, 0xE0, 0x1E, 0x1F, 0xFE, 0xFF,
  0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x38, 0x39, 0xC3, 0xDE, 0x1E, 0xE0, 0xE7,
  0x07, 0x38, 0x39, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0x1E, 0xF8, 0xFF,
  0xC3, 0xEE, 0x00, 0xE0, 0x7F, 0x07, 0xBC, 0x38, 0xE3, 0xC7, 0x1C, 0x38,
  0xE1, 0xCE, 0x0E, 0x70, 0x37, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xC0,
  0x00, 0xE3, 0x1F, 0x9C, 0xEE, 0x73, 0xB9, 0xCE, 0xEF, 0x33, 0xBD, 0xCE,
  0xF7, 0x3E, 0xD8, 0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x3C, 0x70, 0xE1, 0xC0,
  0x3C, 0x1E, 0x3C, 0x78, 0x39, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x3D, 0xC0, 0xF3, 0xC3, 0xC3, 0x8F, 0x07,
  0x80, 0x38, 0x1F, 0x3C, 0x1E, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x78, 0x1C,
  0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFE, 0xFF, 0xF0,
  0x00, 0x81, 0xC1, 0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0F,
  0x1F, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x0C,
  0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x8E, 0x00, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x0F,
  0x07, 0xC3, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x3C,
  0x0E, 0x00, 0x3C, 0x01, 0xFC, 0x77, 0xFB, 0xB8, 0xFE, 0x41, 0xF0,
};

const GFXglyph RobotoMono_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 8, 7, 15, 4, -19 },
  { 24, 15, 18, 15, 0, -18 },
  { 58, 13, 24, 15, 1, -21 },
  { 97, 13, 18, 15, 1, -18 },
  { 127, 14, 18, 15, 0, -18 },
  { 159, 4, 7, 15, 6, -19 },
  { 163, 8, 26, 15, 4, -20 },
  { 189, 9, 26, 15, 2, -20 },
  { 219, 12, 13, 15, 2, -18 },
  { 239, 12, 13, 15, 1, -15 },
  { 259, 6, 8, 15, 2, -3 },
  { 265, 11, 3, 15, 3, -9 },
  { 270, 5, 4, 15, 4, -4 },
  { 273, 13, 20, 15, 1, -18 },
  { 306, 12, 18, 15, 2, -18 },
  { 333, 8, 18, 15, 3, -18 },
  { 351, 13, 18, 15, 0, -18 },
  { 381, 13, 18, 15, 1, -18 },
  { 411, 13, 18, 15, 0, -18 },
  { 441, 13, 18, 15, 1, -18 },
  { 471, 12, 18, 15, 1, -18 },
  { 498, 13, 18, 15, 2, -18 },
  { 528, 13, 18, 15, 1, -18 },
  { 558, 11, 18, 15, 2, -18 },
  { 583, 7, 14, 15, 4, -14 },
  { 596, 8, 19, 15, 3, -14 },
  { 615, 11, 12, 15, 2, -14 },
  { 632, 13, 9, 15, 1, -12 },
  { 647, 12, 11, 15, 1, -13 },
  { 664, 11, 18, 15, 3, -18 },
  { 689, 15, 18, 15, 0, -18 },
  { 723, 14, 18, 15, -1, -18 },
  { 755, 15, 18, 15, 0, -18 },
  { 789, 13, 18, 15, 1, -18 },
  { 819, 14, 18, 15, 0, -18 },
  { 851, 15, 18, 15, 0, -18 },
  { 885, 15, 18, 15, 0, -18 },
  { 919, 13, 18, 15, 1, -18 },
  { 949, 15, 18, 15, 0, -18 },
  { 983, 13, 18, 15, 1, -18 },
  { 1013, 14, 18, 15, 1, -18 },
  { 1045, 17, 18, 15, 0, -18 },
  { 1084, 12, 18, 15, 0, -18 },
  { 1111, 15, 18, 15, 0, -18 },
  { 1145, 15, 18, 15, 0, -18 },
  { 1179, 13, 18, 15, 1, -18 },
  { 1209, 15, 18, 15, 0, -18 },
  { 1243, 13, 21, 15, 1, -18 },
  { 1278, 15, 18, 15, 0, -18 },
  { 1312, 14, 18, 15, 1, -18 },
  { 1344, 14, 18, 15, 2, -18 },
  { 1376, 14, 18, 15, 1, -18 },
  { 1408, 14, 18, 15, 2, -18 },
  { 1440, 14, 18, 15, 2, -18 },
  { 1472, 17, 18, 15, -1, -18 },
  { 1511, 14, 18, 15, 2, -18 },
  { 1543, 15, 18, 15, 0, -18 },
  { 1577, 9, 25, 15, 3, -21 },
  { 1606, 6, 20, 15, 5, -18 },
  { 1621, 9, 25, 15, 3, -21 },
  { 1650, 10, 10, 15, 3, -18 },
  { 1663, 11, 3, 15, 0, 0 },
  { 1668, 5, 3, 15, 7, -18 },
  { 1670, 12, 13, 15, 1, -13 },
  { 1690, 13, 19, 15, 0, -19 },
  { 1721, 12, 13, 15, 1, -13 },
  { 1741, 14, 19, 15, 1, -19 },
  { 1775, 12, 13, 15, 1, -13 },
  { 1795, 14, 19, 15, 2, -19 },
  { 1829, 14, 18, 15, 0, -13 },
  { 1861, 13, 19, 15, 0, -19 },
  { 1892, 11, 18, 15, 1, -18 },
  { 1917, 11, 23, 15, 1, -18 },
  { 1949, 15, 19, 15, 0, -19 },
  { 1985, 11, 19, 15, 1, -19 },
  { 2012, 14, 13, 15, 0, -13 },
  { 2035, 13, 13, 15, 0, -13 },
  { 2057, 12, 13, 15, 1, -13 },
  { 2077, 13, 18, 15, 0, -13 },
  { 2107, 13, 18, 15, 1, -13 },
  { 2137, 12, 13, 15, 2, -13 },
  { 2157, 12, 13, 15, 1, -13 },
  { 2177, 12, 16, 15, 2, -16 },
  { 2201, 13, 13, 15, 1, -13 },
  { 2223, 13, 13, 15, 2, -13 },
  { 2245, 14, 13, 15, 1, -13 },
  { 2268, 15, 13, 15, 0, -13 },
  { 2293, 16, 18, 15, 0, -13 },
  { 2329, 14, 13, 15, 0, -13 },
  { 2352, 9, 24, 15, 4, -20 },
  { 2379, 6, 23, 15, 4, -18 },
  { 2397, 10, 23, 15, 2, -19 },
  { 2426, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic25pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_BOLDITALIC25PT7B_H_
