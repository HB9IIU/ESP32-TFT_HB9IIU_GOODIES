#ifndef _ROBOTOMONO_BOLDITALIC51PT7B_H_
#define _ROBOTOMONO_BOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00,
  0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xCF, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xC1, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07,
  0xC3, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xFC, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE7,
  0xC0, 0x03, 0xE3, 0xE0, 0x43, 0xE0, 0xF0, 0x79, 0xF0, 0x78, 0x7C, 0xF8,
  0x7C, 0x3C, 0x7C, 0x3E, 0x3C, 0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0x3E, 0x07,
  0xFF, 0x9E, 0x03, 0xFF, 0x9E, 0x00, 0xFF, 0x9F, 0x00, 0x3F, 0x8F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC7, 0xF0, 0x03, 0xCF,
  0xFC, 0x03, 0xEF, 0xFF, 0x01, 0xE7, 0xFF, 0x81, 0xE7, 0xC3, 0xE1, 0xF3,
  0xE1, 0xF0, 0xF1, 0xE0, 0xF8, 0xF0, 0xF0, 0x7C, 0xF8, 0x78, 0x3C, 0x18,
  0x3C, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x83,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0x0F, 0xFF, 0x03, 0xF1, 0xFF,
  0xF8, 0x3F, 0x3F, 0xDF, 0xC3, 0xF7, 0xF9, 0xFC, 0x7E, 0x7F, 0x0F, 0xE7,
  0xEF, 0xE0, 0xFE, 0xFE, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0xFE,
  0x03, 0xFF, 0x8F, 0xE0, 0x3F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFB, 0xF8, 0x07, 0xFE, 0x1F, 0xC0, 0x04, 0x00, 0x00, 0x3E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x00, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x80, 0x78, 0x00, 0x70, 0x3C, 0x0E, 0x7E, 0x1E, 0x1F, 0x3F, 0xCF,
  0x3F, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x03,
  0xF7, 0xC0, 0x03, 0xF1, 0xE0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7E, 0x03,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x38, 0x03, 0x80, 0x04, 0x01, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x01, 0x80, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0x0C, 0x0F, 0xC7, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE,
  0x3F, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC7, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFC,
  0x03, 0xFE, 0xFE, 0x07, 0xFE, 0x7F, 0x07, 0xFF, 0x3F, 0x8F, 0xFF, 0x9F,
  0xCF, 0xDF, 0xCF, 0xFF, 0xCF, 0xE7, 0xFF, 0x87, 0xF3, 0xFF, 0x83, 0xF3,
  0xFF, 0x81, 0xF9, 0xFF, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x7E, 0x3F, 0xB8,
  0x1F, 0xD0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x3E, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x03, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x14, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x3F, 0xBF,
  0xF8, 0x3F, 0x7F, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xF3,
  0xFE, 0x7F, 0xC0, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01,
  0xFC, 0x3F, 0x87, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0xE7, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0x07,
  0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F,
  0x3F, 0xC0, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xFC,
  0x3F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFE,
  0xFC, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x2F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x3F, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0,
  0xFF, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x0F, 0x83, 0xF8,
  0xF0, 0x78, 0x7F, 0xE3, 0x87, 0xC7, 0xFF, 0x1C, 0x3C, 0x7F, 0x78, 0xE3,
  0xE3, 0xE3, 0xC7, 0x1E, 0x3E, 0x1E, 0x38, 0xF1, 0xE0, 0xE1, 0xCF, 0x1F,
  0x0F, 0x1E, 0x78, 0xF0, 0x78, 0xF3, 0xC7, 0x83, 0xC7, 0xBE, 0x7C, 0x1C,
  0x3D, 0xE3, 0xE1, 0xE1, 0xCF, 0x1E, 0x0F, 0x0E, 0x78, 0xF0, 0x78, 0xF3,
  0xC7, 0x87, 0x87, 0x1E, 0x3E, 0x3C, 0x78, 0xF1, 0xFF, 0xF7, 0x87, 0x87,
  0xFF, 0xFC, 0x3C, 0x3F, 0xBF, 0xC1, 0xF0, 0xF8, 0xFC, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x10, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F,
  0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0xFF,
  0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFE, 0x1F, 0xC0,
  0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0xE0,
  0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0x3F,
  0x03, 0xFF, 0xEF, 0xE0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFF, 0x3F, 0x81, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xE3,
  0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x07,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFD, 0xF7, 0xE0, 0x3F,
  0xFB, 0xEF, 0xC0, 0x7E, 0xFF, 0xDF, 0x81, 0xF9, 0xFF, 0x7E, 0x03, 0xF3,
  0xFE, 0xFC, 0x07, 0xE7, 0xF9, 0xF8, 0x0F, 0xCF, 0xF3, 0xF0, 0x1F, 0x9F,
  0xC7, 0xE0, 0x7F, 0x3F, 0x9F, 0xC0, 0xFC, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x7E, 0x03, 0xF1, 0xF0, 0xFC, 0x07, 0xE1, 0xE1, 0xF8, 0x0F, 0xC3, 0x87,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x00, 0x7E, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F,
  0xE0, 0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x1F, 0xFC,
  0x0F, 0xC0, 0x7F, 0xF0, 0x7F, 0x01, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x07,
  0xF0, 0x3F, 0xBE, 0x1F, 0xC0, 0xFE, 0xF8, 0x7F, 0x03, 0xFB, 0xE3, 0xF8,
  0x0F, 0xEF, 0x8F, 0xE0, 0x3F, 0x1F, 0x3F, 0x81, 0xFC, 0x7C, 0xFE, 0x07,
  0xF1, 0xF3, 0xF8, 0x1F, 0xC7, 0xCF, 0xC0, 0x7F, 0x0F, 0xFF, 0x01, 0xFC,
  0x3F, 0xFC, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0, 0xFE, 0x07,
  0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0x81, 0xFF,
  0x81, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0,
  0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83,
  0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFE, 0x1F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F,
  0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07,
  0xF1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x0F, 0xC1, 0xFD, 0xF8, 0x3E, 0x07, 0xE7, 0xE0, 0xF8, 0x3F,
  0x9F, 0x87, 0xE0, 0xFC, 0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7F, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE1, 0xF8,
  0xFE, 0x1F, 0x87, 0xE7, 0xF8, 0xFC, 0x1F, 0x9F, 0xE3, 0xF0, 0x7E, 0x7F,
  0x8F, 0xC1, 0xF9, 0xFE, 0x7F, 0x07, 0xEF, 0xF9, 0xF8, 0x1F, 0x3F, 0xE7,
  0xE0, 0x7C, 0xF7, 0x9F, 0x81, 0xF7, 0xDE, 0xFC, 0x07, 0xDF, 0x7B, 0xF0,
  0x1F, 0x79, 0xEF, 0xC0, 0x7F, 0xE7, 0xBF, 0x03, 0xFF, 0x9F, 0xF8, 0x0F,
  0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x03, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x87,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E,
  0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7E, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F,
  0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xE7, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x81, 0xFF, 0x1F, 0xC0, 0x0C,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x9F, 0xE0, 0x0F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xF8, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xC1,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFE,
  0xFF, 0xF0, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0x3F, 0x1F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x03, 0xFF,
  0xDF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x01, 0x03, 0xFC, 0x01, 0xC0, 0xFF, 0x03, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0x06, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x7F, 0x00, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0x7E, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7E, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x20, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x10, 0x01, 0xFC, 0x03, 0x00, 0x3F,
  0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x0F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFD, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC7, 0xF8, 0x0F,
  0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x07,
  0xF3, 0xFE, 0x00, 0x3F, 0xBF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xEF, 0xE3, 0xE0, 0x3E, 0xFF, 0x7F, 0x83, 0xF7, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xF3, 0xFC, 0xFC,
  0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF3, 0xFF, 0xC0, 0xFD,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF1,
  0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xE0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xBF, 0xF8, 0x03, 0xF7,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xC0, 0x3F, 0x9F,
  0xF0, 0x03, 0xF8, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F,
  0x87, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE7, 0xF0, 0x00, 0xC1, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x03, 0xF0, 0xFF, 0xC1,
  0xF8, 0xFF, 0xE0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0x3C, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0xFF, 0x03, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF,
  0xE0, 0x07, 0xE7, 0xF8, 0x07, 0xF1, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x30, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x1F, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFE, 0x7E, 0x00, 0xFF,
  0x1F, 0x80, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x3F,
  0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0,
  0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x07,
  0xFF, 0xC1, 0xF0, 0x7E, 0xFC, 0x3F, 0x07, 0xEF, 0xC3, 0xF0, 0xFE, 0xFC,
  0x3F, 0x0F, 0xCF, 0xC7, 0xF0, 0xFC, 0xFC, 0x7F, 0x0F, 0x8F, 0x87, 0xF1,
  0xF8, 0xF8, 0xFF, 0x1F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x3F, 0x0F,
  0x9E, 0xF3, 0xF0, 0xF9, 0xEF, 0x3E, 0x0F, 0x9E, 0xF7, 0xE0, 0xFB, 0xCF,
  0x7E, 0x0F, 0xBC, 0xF7, 0xC0, 0xFB, 0xCF, 0x7C, 0x0F, 0xF8, 0xFF, 0xC0,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x30, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xF3, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0x03, 0xF7, 0xFF, 0xFC,
  0x7E, 0x7E, 0x3F, 0xFF, 0xE7, 0xC0, 0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xCF,
  0x80, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x80,
};

const GFXglyph RobotoMono_BoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 13, 36, 30, 9, -36 },
  { 60, 17, 13, 30, 8, -38 },
  { 88, 30, 36, 30, 0, -36 },
  { 223, 27, 47, 30, 2, -42 },
  { 382, 25, 38, 30, 3, -37 },
  { 501, 28, 38, 30, 1, -37 },
  { 634, 7, 13, 30, 13, -38 },
  { 646, 17, 51, 30, 8, -40 },
  { 755, 18, 51, 30, 4, -40 },
  { 870, 25, 25, 30, 4, -36 },
  { 949, 25, 26, 30, 2, -30 },
  { 1031, 11, 16, 30, 5, -6 },
  { 1053, 22, 6, 30, 6, -19 },
  { 1070, 10, 10, 30, 8, -9 },
  { 1083, 27, 39, 30, 2, -36 },
  { 1215, 25, 38, 30, 3, -37 },
  { 1334, 17, 36, 30, 6, -36 },
  { 1411, 27, 37, 30, 0, -37 },
  { 1536, 27, 38, 30, 1, -37 },
  { 1665, 27, 36, 30, 0, -36 },
  { 1787, 27, 37, 30, 2, -36 },
  { 1912, 24, 38, 30, 2, -37 },
  { 2026, 27, 36, 30, 3, -36 },
  { 2148, 26, 38, 30, 2, -37 },
  { 2272, 23, 37, 30, 4, -37 },
  { 2379, 13, 31, 30, 9, -30 },
  { 2430, 15, 40, 30, 7, -30 },
  { 2505, 24, 24, 30, 3, -28 },
  { 2577, 26, 17, 30, 2, -24 },
  { 2633, 24, 24, 30, 2, -27 },
  { 2705, 23, 37, 30, 6, -37 },
  { 2812, 29, 36, 30, 1, -36 },
  { 2943, 29, 36, 30, -2, -36 },
  { 3074, 30, 36, 30, 0, -36 },
  { 3209, 27, 38, 30, 2, -37 },
  { 3338, 29, 36, 30, 0, -36 },
  { 3469, 30, 36, 30, 1, -36 },
  { 3604, 30, 36, 30, 1, -36 },
  { 3739, 27, 38, 30, 2, -37 },
  { 3868, 30, 36, 30, 0, -36 },
  { 4003, 27, 36, 30, 2, -36 },
  { 4125, 28, 37, 30, 2, -36 },
  { 4255, 34, 36, 30, 0, -36 },
  { 4408, 24, 36, 30, 1, -36 },
  { 4516, 31, 36, 30, 0, -36 },
  { 4656, 30, 36, 30, 0, -36 },
  { 4791, 27, 38, 30, 2, -37 },
  { 4920, 29, 36, 30, 1, -36 },
  { 5051, 27, 43, 30, 2, -37 },
  { 5197, 29, 36, 30, 1, -36 },
  { 5328, 29, 38, 30, 1, -37 },
  { 5466, 30, 36, 30, 3, -36 },
  { 5601, 28, 37, 30, 2, -36 },
  { 5731, 28, 36, 30, 4, -36 },
  { 5857, 30, 36, 30, 3, -36 },
  { 5992, 35, 36, 30, -2, -36 },
  { 6150, 28, 36, 30, 5, -36 },
  { 6276, 31, 36, 30, 0, -36 },
  { 6416, 19, 50, 30, 6, -42 },
  { 6535, 12, 39, 30, 10, -36 },
  { 6594, 19, 50, 30, 6, -42 },
  { 6713, 21, 19, 30, 5, -36 },
  { 6763, 23, 5, 30, 0, 0 },
  { 6778, 10, 7, 30, 14, -37 },
  { 6787, 25, 29, 30, 1, -28 },
  { 6878, 26, 39, 30, 1, -38 },
  { 7005, 25, 29, 30, 2, -28 },
  { 7096, 28, 39, 30, 2, -38 },
  { 7233, 25, 29, 30, 2, -28 },
  { 7324, 28, 39, 30, 4, -39 },
  { 7461, 28, 39, 30, 1, -28 },
  { 7598, 26, 38, 30, 1, -38 },
  { 7722, 22, 38, 30, 3, -38 },
  { 7827, 24, 49, 30, 1, -38 },
  { 7974, 29, 38, 30, 1, -38 },
  { 8112, 23, 38, 30, 2, -38 },
  { 8222, 29, 27, 30, -1, -27 },
  { 8320, 26, 27, 30, 1, -27 },
  { 8408, 25, 29, 30, 2, -28 },
  { 8499, 28, 37, 30, -1, -27 },
  { 8629, 26, 38, 30, 2, -28 },
  { 8753, 25, 28, 30, 4, -28 },
  { 8841, 25, 28, 30, 2, -27 },
  { 8929, 24, 35, 30, 4, -34 },
  { 9034, 26, 28, 30, 3, -27 },
  { 9125, 26, 27, 30, 4, -27 },
  { 9213, 28, 27, 30, 3, -27 },
  { 9308, 30, 27, 30, 0, -27 },
  { 9410, 32, 38, 30, 0, -27 },
  { 9562, 29, 27, 30, 0, -27 },
  { 9660, 20, 49, 30, 7, -40 },
  { 9783, 11, 46, 30, 9, -36 },
  { 9847, 19, 49, 30, 5, -40 },
  { 9964, 28, 12, 30, 0, -21 },
};

const GFXfont RobotoMono_BoldItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic51pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_BOLDITALIC51PT7B_H_
