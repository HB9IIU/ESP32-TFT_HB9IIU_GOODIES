#ifndef _ROBOTOMONO_BOLDITALIC30PT7B_H_
#define _ROBOTOMONO_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0x71, 0xDC,
  0x77, 0x1D, 0xC6, 0xE3, 0xB8, 0xEE, 0x3B, 0x8C, 0x00, 0xE3, 0x80, 0x39,
  0xC0, 0x0C, 0x70, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x91, 0xFF, 0xF8,
  0xFF, 0xFE, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E,
  0x30, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x71, 0x80, 0x18, 0xE0, 0x0E, 0x30,
  0x03, 0x9C, 0x00, 0xC7, 0x00, 0x71, 0x80, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E,
  0x78, 0x3E, 0x78, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x1C, 0x01, 0xF8, 0x07, 0xF0, 0x39, 0xC4, 0xE7,
  0x1F, 0x9C, 0xEE, 0x77, 0x3F, 0x98, 0x7E, 0xC0, 0xE7, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x3B, 0xE0, 0xDF, 0xC6, 0x77, 0x3B, 0x8D, 0xCE, 0x72,
  0x39, 0xC0, 0xE7, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x60, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x78,
  0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x39, 0xEF,
  0x3D, 0xE7, 0xDE, 0xF1, 0xFE, 0x78, 0xFF, 0x3C, 0x3F, 0x1E, 0x1F, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFE, 0xF8, 0x3B, 0xDC, 0xE7, 0x39, 0xDC, 0x00,
  0x80, 0x60, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x06,
  0x00, 0x80, 0x04, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x1C, 0x0F, 0x00, 0xC0, 0x10, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x07, 0x18, 0xCF, 0xB7, 0xFF, 0xFF, 0x87, 0xF8,
  0x07, 0x80, 0x1F, 0x80, 0x73, 0x01, 0xE7, 0x07, 0x8F, 0x06, 0x0C, 0x04,
  0x10, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0xF3, 0xCF, 0x39,
  0xE7, 0x9C, 0xE1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7,
  0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x7D, 0xE3, 0xFF, 0x3F, 0xFD, 0xEF, 0xFE, 0x3F, 0xF1, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0x0F, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0x00, 0xE0, 0xF8, 0xFF, 0x3F, 0xE7, 0xFC, 0xE7, 0xA0, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0x00, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E,
  0x1E, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xDE, 0x07, 0xBC, 0x07, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x78,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x7C, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0x78, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0x04, 0x03, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x39, 0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0x1F, 0x78, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0x8F, 0x8F, 0xFE, 0x3F, 0xF0,
  0x3F, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x3F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0x0F, 0xBE, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0xFB, 0xE3, 0xE3, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00,
  0x03, 0x80, 0x3F, 0x81, 0xFF, 0x0F, 0xFE, 0x7C, 0x79, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xDE, 0x3E, 0x7F, 0xF8, 0xFF,
  0xE1, 0xF7, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0xE0, 0x7F,
  0x01, 0xF0, 0x00, 0x1E, 0x3E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0xF8, 0xFC, 0xF8, 0x78, 0x07, 0x07, 0xC3, 0xE1,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F, 0xE3, 0xFC, 0x0F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0x3F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x30, 0x00, 0xF0, 0x03, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x3F, 0x07, 0xFC, 0xFF,
  0xC7, 0xF8, 0x1F, 0x80, 0xF0, 0x02, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x1F,
  0xFD, 0xFF, 0xFF, 0x0F, 0xF8, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0x0E, 0x1C, 0x07, 0x38, 0xE3, 0x31, 0xFB, 0x73, 0xFB, 0x67, 0x33,
  0xE6, 0x33, 0xEE, 0x33, 0xCE, 0x73, 0xCC, 0x63, 0xCC, 0x66, 0xCC, 0xE6,
  0xCF, 0xFC, 0xCF, 0x7C, 0xC2, 0x10, 0xE0, 0x00, 0x78, 0xC0, 0x3F, 0xC0,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xCE, 0x03, 0xC7, 0x01,
  0xE3, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1E, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x78, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x3E, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x1F, 0x1E, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00,
  0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C, 0x78,
  0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x1E, 0x3C, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x79, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x7E, 0x1F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0xFE, 0xF0, 0xFE,
  0xF0, 0xFE, 0xF1, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x78, 0x3C, 0x7C, 0x7C,
  0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x0F, 0x03, 0xC3, 0xC1, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3C,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x0E, 0x0F,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF1, 0xE0, 0x78, 0xF0, 0x7C,
  0x7C, 0x7C, 0x1F, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0x03, 0xF0,
  0xF0, 0x7C, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE3, 0xE0,
  0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xE7, 0x80, 0x7C, 0x78, 0x07, 0x87,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0x6E, 0xE1, 0xDB, 0xF8, 0x76, 0xFE, 0x3D, 0xF7, 0x8F,
  0x7D, 0xC3, 0xDE, 0x70, 0xF7, 0xBC, 0x39, 0xCF, 0x0E, 0x73, 0xC7, 0x80,
  0xF1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x01, 0xE1, 0xC0, 0x78,
  0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E,
  0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xFC, 0xF8, 0x7F, 0x3C, 0x3D, 0xCF, 0x0F,
  0x73, 0xC3, 0xDE, 0xF0, 0xF3, 0xBC, 0x3C, 0xFE, 0x0F, 0x3F, 0x87, 0x8F,
  0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xC3, 0xE0, 0xF0,
  0xF0, 0x3C, 0x00, 0x00, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E,
  0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF8, 0x3C, 0x78, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C,
  0xF0, 0x3E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C, 0x78, 0x78, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x10,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x3E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x07, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0x1E, 0x07, 0x87, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1F, 0x00,
  0x00, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x1E, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3E, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x8F, 0x03,
  0xCF, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC1, 0xE3, 0xE0, 0xF1, 0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x7C, 0x1F, 0xFE,
  0x07, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF8, 0x3C, 0x78,
  0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0xF1, 0xDE, 0x79, 0xEF, 0x3C,
  0xF7, 0xBE, 0x73, 0xDF, 0x39, 0xEF, 0xBC, 0xF7, 0xDE, 0x7F, 0xEE, 0x3F,
  0xFF, 0x1D, 0xBF, 0x8F, 0xDF, 0x87, 0xEF, 0xC3, 0xE7, 0xE1, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x00, 0x0F,
  0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x03, 0xCF, 0x80,
  0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBC,
  0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x03, 0xE1, 0xF0, 0x3C, 0x0F, 0x07, 0xC0,
  0xF0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x9E, 0x0F, 0x8F, 0x07,
  0x87, 0x87, 0xC3, 0xC3, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x4F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0xE1, 0xE3, 0xC7, 0x8F, 0x0E,
  0x1C, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38, 0x70,
  0xE1, 0xE3, 0xC7, 0x80, 0x0F, 0xE1, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0xEC, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0x77,
  0x07, 0xF0, 0x70, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xF1, 0xE3, 0x8F,
  0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0xCF, 0x0F, 0x7C, 0x3C, 0x00, 0xF0, 0x3F,
  0xCF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xFF,
  0xE7, 0xFF, 0x8F, 0xDE, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF8,
  0xF1, 0xE1, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C,
  0xE0, 0x7B, 0xC0, 0xF7, 0xC3, 0xCF, 0xFF, 0x9F, 0xFE, 0x39, 0xF8, 0x00,
  0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC1, 0xE7, 0x87,
  0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x0F, 0xBE, 0x1F,
  0xFE, 0x1F, 0xFF, 0x0F, 0x8F, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xE1,
  0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x1F, 0x0F, 0x1F,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7D, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x87, 0xC3, 0x87, 0xFF, 0x8F, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x23, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xE7, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0x78,
  0x00, 0x3C, 0x10, 0x3E, 0x1C, 0x3E, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3C, 0x00,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xF8,
  0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x87, 0xFC, 0x3F, 0xC1, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x3F, 0x3C, 0x3E, 0x1E, 0x3E, 0x0F, 0x3E, 0x07, 0x3E, 0x07, 0xBE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7C, 0xF0, 0x3C,
  0x7C, 0x1E, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xE3, 0xC1, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xFD, 0xFF,
  0xFF, 0xFF, 0x80, 0x3D, 0xCF, 0x1D, 0xFF, 0x8F, 0xFF, 0xE7, 0xBC, 0xF3,
  0x9E, 0x7B, 0xCF, 0x39, 0xE7, 0x9C, 0xF3, 0x8E, 0x71, 0xCF, 0x39, 0xE7,
  0xBC, 0xF3, 0xDE, 0x79, 0xCF, 0x3C, 0xE7, 0x9C, 0x73, 0x8E, 0x79, 0xCF,
  0x3C, 0x1E, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0xF8, 0x3C, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xF1, 0xE7, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0xC1, 0xE7, 0x87, 0x8F, 0xFF, 0x0F,
  0xFC, 0x0F, 0xE0, 0x0F, 0x7C, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xF1, 0xE0,
  0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xE1, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7B,
  0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x00, 0x07, 0xCF, 0x1F, 0xEE, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0x78, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0xFC,
  0xF7, 0xF3, 0xFF, 0x8F, 0xFE, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xF1, 0xE0, 0xF3, 0xC1, 0xE7,
  0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF7, 0x81,
  0xEF, 0x03, 0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xE3, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9F, 0xFF, 0x1F, 0xDC, 0x1F,
  0x38, 0xF0, 0x1F, 0xF0, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x3D, 0xE0, 0x3D, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0xE3, 0x8F, 0xE3,
  0x8F, 0xE3, 0x8E, 0xE7, 0x9E, 0xE7, 0x9E, 0xE7, 0x9C, 0xEF, 0xBC, 0xED,
  0xBC, 0xED, 0xB8, 0xFD, 0xB8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0x1E, 0x07, 0xC7, 0x83, 0xE0, 0xF1, 0xF0,
  0x3C, 0x78, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F,
  0x07, 0xC1, 0xE3, 0xE0, 0x78, 0x3C, 0x03, 0xE7, 0xC0, 0xF8, 0x78, 0x1E,
  0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xE0,
  0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE4, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0xF0, 0x1F, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60,
  0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61,
  0xC3, 0x80, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0xF8, 0x3E,
  0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x00, 0x1F, 0xC1, 0xDF, 0xF1, 0xDE,
  0x7F, 0xEE, 0x1F, 0xE1, 0x03, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 21, 18, 5, -21 },
  { 22, 10, 8, 18, 5, -23 },
  { 32, 18, 21, 18, 0, -21 },
  { 80, 16, 28, 18, 1, -25 },
  { 136, 14, 22, 18, 2, -22 },
  { 175, 17, 22, 18, 0, -22 },
  { 222, 5, 8, 18, 7, -23 },
  { 227, 10, 31, 18, 5, -24 },
  { 266, 11, 31, 18, 2, -24 },
  { 309, 15, 15, 18, 2, -21 },
  { 338, 15, 16, 18, 1, -18 },
  { 368, 6, 10, 18, 3, -4 },
  { 376, 12, 3, 18, 4, -11 },
  { 381, 5, 5, 18, 5, -5 },
  { 385, 16, 23, 18, 1, -21 },
  { 431, 14, 22, 18, 2, -22 },
  { 470, 11, 21, 18, 3, -21 },
  { 499, 16, 22, 18, 0, -22 },
  { 543, 16, 22, 18, 1, -22 },
  { 587, 16, 21, 18, 0, -21 },
  { 629, 16, 21, 18, 1, -21 },
  { 671, 14, 22, 18, 1, -22 },
  { 710, 15, 21, 18, 2, -21 },
  { 750, 15, 22, 18, 1, -22 },
  { 792, 14, 22, 18, 2, -22 },
  { 831, 8, 17, 18, 5, -17 },
  { 848, 9, 23, 18, 4, -17 },
  { 874, 14, 14, 18, 2, -16 },
  { 899, 16, 10, 18, 1, -14 },
  { 919, 14, 14, 18, 1, -16 },
  { 944, 13, 22, 18, 4, -22 },
  { 980, 16, 21, 18, 1, -21 },
  { 1022, 17, 21, 18, -1, -21 },
  { 1067, 18, 21, 18, 0, -21 },
  { 1115, 16, 22, 18, 1, -22 },
  { 1159, 17, 21, 18, 0, -21 },
  { 1204, 17, 21, 18, 1, -21 },
  { 1249, 17, 21, 18, 1, -21 },
  { 1294, 16, 22, 18, 1, -22 },
  { 1338, 18, 21, 18, 0, -21 },
  { 1386, 16, 21, 18, 1, -21 },
  { 1428, 17, 21, 18, 1, -21 },
  { 1473, 20, 21, 18, 0, -21 },
  { 1526, 14, 21, 18, 1, -21 },
  { 1563, 18, 21, 18, 0, -21 },
  { 1611, 18, 21, 18, 0, -21 },
  { 1659, 16, 22, 18, 1, -22 },
  { 1703, 17, 21, 18, 1, -21 },
  { 1748, 16, 26, 18, 1, -22 },
  { 1800, 18, 21, 18, 0, -21 },
  { 1848, 17, 22, 18, 1, -22 },
  { 1895, 17, 21, 18, 2, -21 },
  { 1940, 17, 21, 18, 1, -21 },
  { 1985, 17, 21, 18, 2, -21 },
  { 2030, 17, 21, 18, 2, -21 },
  { 2075, 20, 21, 18, -1, -21 },
  { 2128, 17, 21, 18, 3, -21 },
  { 2173, 18, 21, 18, 0, -21 },
  { 2221, 11, 30, 18, 4, -25 },
  { 2263, 7, 23, 18, 6, -21 },
  { 2284, 11, 30, 18, 4, -25 },
  { 2326, 12, 11, 18, 3, -21 },
  { 2343, 14, 3, 18, 0, 0 },
  { 2349, 6, 4, 18, 8, -22 },
  { 2352, 14, 16, 18, 1, -16 },
  { 2380, 15, 23, 18, 1, -23 },
  { 2424, 15, 16, 18, 1, -16 },
  { 2454, 17, 23, 18, 1, -23 },
  { 2503, 15, 16, 18, 1, -16 },
  { 2533, 17, 23, 18, 2, -23 },
  { 2582, 17, 22, 18, 0, -16 },
  { 2629, 16, 23, 18, 0, -23 },
  { 2675, 13, 22, 18, 2, -22 },
  { 2711, 13, 28, 18, 1, -22 },
  { 2757, 17, 23, 18, 1, -23 },
  { 2806, 14, 23, 18, 1, -23 },
  { 2847, 17, 16, 18, 0, -16 },
  { 2881, 16, 16, 18, 0, -16 },
  { 2913, 15, 16, 18, 1, -16 },
  { 2943, 17, 22, 18, -1, -16 },
  { 2990, 16, 22, 18, 1, -16 },
  { 3034, 14, 16, 18, 3, -16 },
  { 3062, 15, 16, 18, 1, -16 },
  { 3092, 14, 20, 18, 2, -20 },
  { 3127, 15, 16, 18, 2, -16 },
  { 3157, 16, 16, 18, 2, -16 },
  { 3189, 16, 16, 18, 2, -16 },
  { 3221, 18, 16, 18, 0, -16 },
  { 3257, 19, 22, 18, 0, -16 },
  { 3310, 17, 16, 18, 0, -16 },
  { 3344, 12, 28, 18, 4, -23 },
  { 3386, 7, 27, 18, 5, -21 },
  { 3410, 11, 28, 18, 3, -23 },
  { 3449, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic30pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_BOLDITALIC30PT7B_H_
