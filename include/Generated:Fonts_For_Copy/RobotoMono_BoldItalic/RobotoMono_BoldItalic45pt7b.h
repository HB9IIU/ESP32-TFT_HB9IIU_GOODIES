#ifndef _ROBOTOMONO_BOLDITALIC45PT7B_H_
#define _ROBOTOMONO_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xC0, 0x3E, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xEF, 0x87, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0x71, 0xE1, 0xE7, 0x83, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x01, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x1E,
  0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0x78,
  0x78, 0x33, 0xC3, 0xC3, 0xDE, 0x1E, 0x3C, 0xF0, 0xF1, 0xE7, 0x87, 0x9E,
  0x3C, 0x79, 0xE1, 0xFF, 0xCE, 0x07, 0xFC, 0xF0, 0x1F, 0xCF, 0x00, 0x30,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC3, 0x00, 0x3C, 0xFE, 0x01, 0xCF, 0xF8, 0x1E, 0xFF, 0xE1, 0xE7,
  0x8F, 0x1E, 0x7C, 0x78, 0xF3, 0xC3, 0xCF, 0x1E, 0x1E, 0x70, 0xF0, 0xF0,
  0x87, 0x87, 0x80, 0x3E, 0x7C, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xC7, 0xFF, 0x03,
  0xE7, 0xFF, 0xC3, 0xE7, 0xF7, 0xF1, 0xF3, 0xF1, 0xF9, 0xFB, 0xF8, 0xFE,
  0xFD, 0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xFE, 0x7E, 0x07, 0xFE, 0x3F, 0x01,
  0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xF3, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFD, 0xF8, 0x0F, 0xF8, 0xFE, 0x00, 0x3E, 0x78, 0xF3,
  0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xF3, 0xC7, 0x80, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0x03, 0xC0, 0xCF, 0x0F, 0x0F,
  0x7F, 0x39, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x0F, 0x8F,
  0x00, 0x7E, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x81, 0xF0, 0x1C, 0x07, 0x80,
  0x30, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0xF8, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x1F, 0x1F, 0xDF, 0xEF, 0xFF,
  0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF,
  0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x03, 0xF9, 0xF8, 0x1F, 0xE7, 0xE1,
  0xFF, 0x9F, 0x8F, 0xFE, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7, 0xEF, 0xFE, 0x3F,
  0x3F, 0xF0, 0xFC, 0xFF, 0x83, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03,
  0xF0, 0x7F, 0x3F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1E, 0x00, 0xFE,
  0x07, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0xFC, 0xFC,
  0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC1,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x7F, 0x03, 0xEF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8,
  0xFF, 0x7F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xFE, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xC1, 0xF9,
  0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xEF,
  0xC0, 0xFE, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0x7E, 0x00, 0xE3, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x01, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x0F,
  0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x40, 0x07, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x1E,
  0x1F, 0x8F, 0x1E, 0x1F, 0xE3, 0x8F, 0x1F, 0xF9, 0xCF, 0x1F, 0x38, 0xE7,
  0x9F, 0x1C, 0x77, 0x8F, 0x0E, 0x3B, 0xCF, 0x0F, 0x1D, 0xC7, 0x87, 0x1E,
  0xE3, 0x83, 0x8E, 0xF3, 0xC3, 0xC7, 0x79, 0xE1, 0xE3, 0xBC, 0xF0, 0xE1,
  0xDE, 0x78, 0x71, 0xCE, 0x3C, 0x78, 0xE7, 0x1E, 0x7C, 0xF3, 0xC7, 0xFF,
  0xF1, 0xE3, 0xF7, 0xF0, 0xF0, 0xF1, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0xC7, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x0F, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0x83, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0xFE, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xF7, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0x01, 0xF8,
  0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x81, 0xFE, 0x00, 0x7E, 0x0F,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xBF, 0xF8, 0x3E, 0xF7, 0xBE,
  0x07, 0xDF, 0xF7, 0xC0, 0xFB, 0xFC, 0xF8, 0x1F, 0x7F, 0xBF, 0x07, 0xE7,
  0xE7, 0xE0, 0xFC, 0xFC, 0xF8, 0x1F, 0x9F, 0x9F, 0x03, 0xE3, 0xE3, 0xE0,
  0x7C, 0x7C, 0xFC, 0x0F, 0x8F, 0x1F, 0x83, 0xF1, 0xE3, 0xF0, 0x7E, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xFC, 0x07,
  0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x07, 0xE0, 0x3F,
  0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x3F, 0xF0, 0x7E,
  0x07, 0xFF, 0x1F, 0xC0, 0xFF, 0xE3, 0xF0, 0x1F, 0xBC, 0x7E, 0x07, 0xE7,
  0x8F, 0xC0, 0xFC, 0xF9, 0xF8, 0x1F, 0x9F, 0x3F, 0x03, 0xF1, 0xEF, 0xE0,
  0x7E, 0x3D, 0xF8, 0x1F, 0xC7, 0xFF, 0x03, 0xF0, 0xFF, 0xE0, 0x7E, 0x0F,
  0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xE0, 0x3F, 0x07, 0xFC, 0x0F,
  0xE0, 0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x3F,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x0F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xC0,
  0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x07, 0xFD, 0xFF,
  0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x80,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x1E, 0x0F,
  0xFF, 0x0F, 0x83, 0xEF, 0xC3, 0xE1, 0xFB, 0xF0, 0xF8, 0x7E, 0xFC, 0x7E,
  0x1F, 0x3F, 0x1F, 0x87, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC,
  0xFE, 0x3E, 0x3F, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xE7, 0xF9, 0xF0,
  0xF9, 0xFE, 0x7C, 0x3E, 0x7F, 0xBF, 0x0F, 0x9F, 0xEF, 0xC3, 0xEF, 0x7B,
  0xE0, 0xFB, 0xDE, 0xF8, 0x3E, 0xF7, 0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F,
  0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0x9F, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x40, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x7C, 0x07, 0x9F, 0x03, 0xE3,
  0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0x79,
  0xF0, 0x1E, 0xF8, 0x07, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xE0, 0xF0,
  0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x1F, 0xE7, 0xF8, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB,
  0xF0, 0x0F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xBF, 0x03, 0xFC, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7C,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xF3, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFD, 0xFF, 0xC1, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFE,
  0x07, 0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7E, 0x1F, 0xE7, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x1F, 0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x01, 0xFC, 0x3F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFB,
  0xE0, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x07, 0xE3, 0xF8, 0x0F,
  0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0x07, 0xF0, 0x1E, 0x1F, 0xFB, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0x82, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0x01,
  0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFD, 0xF0, 0x07, 0xFB, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x20, 0x07, 0xE0, 0x70, 0x0F, 0xE0, 0xFE, 0x7F, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x7C, 0xFF, 0xC1, 0xFB, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x08, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x23, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0xE1, 0xF8, 0x1F, 0xE0, 0xF8, 0x1F, 0xE0, 0xFC, 0x1F,
  0xE0, 0x7E, 0x1F, 0xE0, 0x3F, 0x1F, 0xE0, 0x1F, 0x9F, 0xE0, 0x0F, 0xDF,
  0xE0, 0x0F, 0xDF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xCF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x03,
  0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xDF, 0x1F, 0x03, 0xEF, 0xEF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xE3, 0xF3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3,
  0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F,
  0xC7, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F,
  0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3E,
  0x3F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0x0F,
  0x87, 0xE0, 0x1F, 0x3F, 0xF0, 0x7E, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xC7, 0xE0, 0x7F,
  0x1F, 0xE7, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x01, 0xF7, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFD, 0xFF, 0xC0, 0x7E, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x7E, 0x0F, 0xFE, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xFD, 0xFF, 0x87, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xF3, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0x87, 0xFC, 0x3E, 0x3F, 0xE0, 0xFB, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xC3, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0xFE, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x81,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0xF8, 0x07, 0xF1, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F,
  0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0xF8,
  0x7E, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x1E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xDF, 0x87, 0xC3,
  0xEF, 0xC7, 0xE3, 0xF7, 0xE3, 0xF1, 0xF3, 0xE3, 0xF8, 0xF9, 0xF1, 0xFC,
  0xFC, 0xF8, 0xFE, 0x7C, 0x7C, 0xFF, 0x3E, 0x3E, 0x7F, 0xBF, 0x1F, 0x3B,
  0xDF, 0x0F, 0xBD, 0xEF, 0x87, 0xDE, 0xF7, 0xC3, 0xEE, 0x7F, 0xC1, 0xFF,
  0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0x80,
  0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xF8, 0x03, 0xCF, 0xFE, 0x03, 0xEF, 0xFF, 0xC1, 0xE7, 0xFF, 0xF3, 0xF3,
  0xE1, 0xFF, 0xFB, 0xE0, 0x7F, 0xF9, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x70, 0x00,
};

const GFXglyph RobotoMono_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 32, 26, 8, -32 },
  { 45, 15, 12, 26, 7, -34 },
  { 68, 26, 32, 26, 0, -32 },
  { 172, 24, 42, 26, 2, -37 },
  { 298, 21, 33, 26, 3, -33 },
  { 385, 25, 33, 26, 1, -33 },
  { 489, 7, 12, 26, 11, -34 },
  { 500, 15, 46, 26, 7, -36 },
  { 587, 15, 46, 26, 4, -36 },
  { 674, 22, 23, 26, 3, -32 },
  { 738, 22, 24, 26, 2, -27 },
  { 804, 10, 14, 26, 4, -5 },
  { 822, 18, 5, 26, 6, -17 },
  { 834, 9, 8, 26, 7, -8 },
  { 843, 23, 35, 26, 2, -32 },
  { 944, 22, 34, 26, 3, -33 },
  { 1038, 16, 32, 26, 5, -32 },
  { 1102, 24, 32, 26, 0, -32 },
  { 1198, 24, 32, 26, 1, -32 },
  { 1294, 24, 32, 26, 0, -32 },
  { 1390, 24, 33, 26, 2, -32 },
  { 1489, 21, 33, 26, 2, -32 },
  { 1576, 23, 32, 26, 3, -32 },
  { 1668, 23, 32, 26, 1, -32 },
  { 1760, 21, 32, 26, 3, -32 },
  { 1844, 11, 26, 26, 8, -26 },
  { 1880, 14, 35, 26, 6, -26 },
  { 1942, 21, 21, 26, 3, -24 },
  { 1998, 23, 15, 26, 2, -21 },
  { 2042, 21, 21, 26, 2, -24 },
  { 2098, 21, 33, 26, 5, -33 },
  { 2185, 25, 32, 26, 1, -32 },
  { 2285, 26, 32, 26, -2, -32 },
  { 2389, 26, 32, 26, 0, -32 },
  { 2493, 24, 34, 26, 2, -33 },
  { 2595, 25, 32, 26, 0, -32 },
  { 2695, 26, 32, 26, 1, -32 },
  { 2799, 26, 32, 26, 1, -32 },
  { 2903, 24, 32, 26, 2, -32 },
  { 2999, 27, 32, 26, 0, -32 },
  { 3107, 23, 32, 26, 2, -32 },
  { 3199, 25, 32, 26, 2, -32 },
  { 3299, 30, 32, 26, 0, -32 },
  { 3419, 21, 32, 26, 1, -32 },
  { 3503, 27, 32, 26, 0, -32 },
  { 3611, 27, 32, 26, 0, -32 },
  { 3719, 24, 32, 26, 2, -32 },
  { 3815, 26, 32, 26, 1, -32 },
  { 3919, 24, 38, 26, 2, -32 },
  { 4033, 26, 32, 26, 0, -32 },
  { 4137, 25, 32, 26, 1, -32 },
  { 4237, 26, 32, 26, 3, -32 },
  { 4341, 25, 33, 26, 2, -32 },
  { 4445, 25, 32, 26, 4, -32 },
  { 4545, 26, 32, 26, 3, -32 },
  { 4649, 31, 32, 26, -2, -32 },
  { 4773, 26, 32, 26, 4, -32 },
  { 4877, 27, 32, 26, 0, -32 },
  { 4985, 17, 44, 26, 5, -37 },
  { 5079, 11, 35, 26, 8, -32 },
  { 5128, 17, 44, 26, 5, -37 },
  { 5222, 18, 17, 26, 5, -32 },
  { 5261, 20, 5, 26, 0, 0 },
  { 5274, 9, 6, 26, 12, -32 },
  { 5281, 22, 24, 26, 1, -24 },
  { 5347, 23, 34, 26, 1, -34 },
  { 5445, 22, 25, 26, 2, -24 },
  { 5514, 25, 34, 26, 2, -34 },
  { 5621, 22, 24, 26, 2, -24 },
  { 5687, 24, 35, 26, 4, -35 },
  { 5792, 24, 33, 26, 1, -24 },
  { 5891, 23, 34, 26, 1, -34 },
  { 5989, 20, 33, 26, 2, -33 },
  { 6072, 21, 43, 26, 1, -33 },
  { 6185, 25, 34, 26, 1, -34 },
  { 6292, 20, 34, 26, 2, -34 },
  { 6377, 26, 24, 26, -1, -24 },
  { 6455, 23, 24, 26, 1, -24 },
  { 6524, 22, 25, 26, 2, -24 },
  { 6593, 25, 33, 26, -1, -24 },
  { 6697, 23, 33, 26, 2, -24 },
  { 6792, 22, 24, 26, 4, -24 },
  { 6858, 22, 24, 26, 2, -24 },
  { 6924, 20, 30, 26, 4, -30 },
  { 6999, 23, 25, 26, 2, -24 },
  { 7071, 23, 24, 26, 3, -24 },
  { 7140, 25, 24, 26, 2, -24 },
  { 7215, 27, 24, 26, 0, -24 },
  { 7296, 28, 34, 26, 0, -24 },
  { 7415, 25, 24, 26, 0, -24 },
  { 7490, 18, 43, 26, 6, -35 },
  { 7587, 10, 41, 26, 8, -32 },
  { 7639, 18, 43, 26, 4, -35 },
  { 7736, 25, 10, 26, 0, -18 },
};

const GFXfont RobotoMono_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic45pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_BOLDITALIC45PT7B_H_
