#ifndef _ROBOTOMONO_BOLDITALIC33PT7B_H_
#define _ROBOTOMONO_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7C, 0x78, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF8, 0xF8, 0xF0,
  0x38, 0xE7, 0x1D, 0xE3, 0xB8, 0x77, 0x0E, 0xE3, 0x9C, 0x73, 0x8E, 0xE1,
  0xC0, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x03, 0x8E, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x0E, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x70,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x00, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3E, 0x1E, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x3C, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0xC1, 0xF1,
  0xF8, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xF3, 0x84,
  0xE3, 0x8E, 0xE3, 0x9C, 0xE3, 0x9C, 0xE7, 0xB8, 0x7F, 0x70, 0x7E, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x3C, 0x0E, 0xFE,
  0x0C, 0xFF, 0x1D, 0xC7, 0x39, 0xC7, 0x71, 0xC7, 0x11, 0xC7, 0x01, 0xCE,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x78, 0xF0, 0x07,
  0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC3, 0xCF, 0xFC, 0x7B, 0xE7, 0xDE, 0x7C, 0x7B, 0xCF, 0x0F, 0xF1, 0xE0,
  0xFE, 0x3C, 0x1F, 0x87, 0xC7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0x3E, 0x7B, 0xDE, 0xE7, 0x39, 0xDC, 0xE0, 0x00, 0x60, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0C, 0x00, 0x04, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41,
  0x82, 0xF1, 0x9E, 0xFD, 0xFE, 0x7F, 0xFF, 0x07, 0xE0, 0x07, 0x80, 0x0F,
  0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0xF8, 0xF0, 0x70, 0x70, 0x20, 0x40, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x3C, 0x79, 0xF3, 0xC7, 0x8F, 0x3C, 0x71, 0xC0, 0x80, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFF, 0x80, 0x11, 0xF7, 0xFF, 0x7D, 0xE0, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x7C, 0x1F,
  0x78, 0x3F, 0x78, 0xFF, 0x79, 0xFF, 0x7B, 0xDE, 0xFF, 0x1E, 0xFE, 0x1E,
  0xF8, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0x7C, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0xE0, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFD, 0xF7, 0xB0, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F,
  0x0F, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x3C, 0xF8, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xBC, 0x07,
  0x9F, 0x07, 0xCF, 0xC7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xBC, 0x07, 0xDE, 0x03, 0xDF, 0x03, 0xCF, 0x83, 0xC7, 0x83, 0xC3,
  0xC1, 0xE1, 0xE1, 0xE0, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xF1, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x60, 0x3D, 0xFC,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x0F,
  0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x7E, 0x7C, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F,
  0x0F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xE1, 0xF0,
  0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0x9F, 0x07, 0xCF,
  0xC7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x7E, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xBC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7C, 0x00, 0x08, 0x1E, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xF8, 0xFC,
  0xFC, 0xF8, 0xF8, 0x01, 0x00, 0xF8, 0x1F, 0x07, 0xF0, 0x7C, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x04, 0x00, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x3E, 0x01, 0xFE, 0x07,
  0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x08, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x7F, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0xF0,
  0x00, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0xC3,
  0xDF, 0x07, 0xFC, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38, 0x0E, 0x1C, 0x01, 0xCE,
  0x3F, 0x73, 0x9F, 0xCD, 0xCF, 0x73, 0x77, 0x1C, 0xF9, 0xC6, 0x3E, 0x71,
  0x9F, 0xB8, 0xE7, 0xCE, 0x39, 0xB3, 0x8C, 0x6C, 0xE3, 0x3B, 0x3F, 0xCC,
  0xC7, 0xFE, 0x39, 0xE7, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0xE0, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xBC, 0x01, 0xE7,
  0x00, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xC0, 0x7D, 0xF0,
  0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3C, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0x83, 0xF0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0xC0,
  0x78, 0xF0, 0x1F, 0x1E, 0x07, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x1E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE,
  0x1F, 0x0F, 0x87, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x0F, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xCF, 0x81, 0xF1, 0xE0, 0x78,
  0x7E, 0x7E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0x8F, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1F,
  0x01, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x7C,
  0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x7F, 0x9E,
  0x1F, 0xEF, 0x8F, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xC7, 0x80,
  0xF1, 0xF0, 0x7C, 0x7E, 0x7F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0x81, 0xFC, 0x3C, 0x07, 0xC0,
  0xF0, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF3,
  0xF0, 0x07, 0x9F, 0x80, 0x1E, 0xFC, 0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07,
  0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xDF, 0xE1,
  0xFD, 0xDE, 0x1E, 0xFF, 0xC1, 0xEF, 0xBC, 0x3C, 0xFB, 0xC3, 0xCF, 0x3C,
  0x3C, 0xF3, 0xC3, 0xCE, 0x7C, 0x3C, 0xE7, 0x83, 0xC0, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87,
  0xE1, 0xF1, 0xFC, 0x3E, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFF, 0x1E, 0x1E,
  0xE7, 0xC3, 0xDC, 0xF8, 0xFB, 0x9F, 0x1F, 0x7B, 0xC3, 0xE7, 0x78, 0x78,
  0xEF, 0x0F, 0x1F, 0xE1, 0xE3, 0xFC, 0x7C, 0x7F, 0x8F, 0x87, 0xE1, 0xE0,
  0xFC, 0x3C, 0x1F, 0x87, 0x83, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x0F, 0x8F, 0x81,
  0xE3, 0xC0, 0x78, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x7D,
  0xE0, 0x1E, 0x78, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF1, 0xE0, 0xF8, 0x7E, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x78, 0x3F, 0x1E, 0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E,
  0x07, 0xCF, 0x01, 0xF3, 0xC1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x0F, 0x87, 0x81, 0xE3, 0xE0,
  0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1F,
  0x78, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xCF, 0x81, 0xF1, 0xE0, 0xF8, 0x7E, 0x7E, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x83, 0xF0, 0xF0, 0x3E,
  0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0xF8,
  0x78, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0x0F, 0x01,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87,
  0x80, 0xF0, 0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xBC, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x7C, 0x7E, 0x3F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3C, 0x0F,
  0x0F, 0x87, 0xC3, 0xF3, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00,
  0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x8F,
  0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0xE1, 0xEE, 0x1C, 0x79, 0xC7, 0x8F, 0x78,
  0xF1, 0xEF, 0x1E, 0x3D, 0xE7, 0xCF, 0x3C, 0xF9, 0xE7, 0x9F, 0x3C, 0xF7,
  0xEF, 0x1E, 0xFD, 0xE3, 0xDF, 0xBC, 0x7B, 0xF7, 0x8F, 0xEF, 0xE1, 0xFD,
  0xFC, 0x3F, 0xBF, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x00, 0x0F,
  0x80, 0xFC, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xC3,
  0xE0, 0x0F, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3C,
  0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xEF, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F,
  0x87, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xF3, 0xE0, 0x1E, 0xF8,
  0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x70, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x9E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xC0, 0xE7, 0x07, 0x9E, 0x3C,
  0x38, 0xE0, 0xE7, 0x83, 0xBC, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xE0, 0xF1, 0xE3, 0x8F, 0x1C, 0x01, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3E, 0x1F, 0x3C, 0x1F, 0x00, 0x1F, 0x03, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFE, 0x7C, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF0, 0x3E, 0xF8, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xBE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x70, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFF, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x3E,
  0xFE, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xF3, 0xF0, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xDE, 0x0F, 0xBE, 0x3E,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x1E,
  0x3C, 0x0F, 0xF7, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0xC3, 0xC0,
  0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x03,
  0xE3, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xFC, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xBC, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xF0, 0xF1, 0xF0, 0x79, 0xF0, 0x3E, 0xF0, 0x1F, 0x7F,
  0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xDF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x61,
  0xF8, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xF0, 0x81, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFE,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x0F, 0xC7, 0x81, 0xF3, 0xE0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x3C,
  0x0F, 0x0F, 0x07, 0xC3, 0xF3, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xF7,
  0xC0, 0x01, 0xE0, 0x80, 0xF8, 0x30, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x70, 0x3E, 0xFE,
  0x1E, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x7D, 0xF0,
  0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xDF, 0x03, 0xEF,
  0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x00, 0x00,
  0x70, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x21, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x07, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x01, 0x3E, 0x0F,
  0x8F, 0x87, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xCF, 0x01, 0xE3,
  0xE0, 0xF8, 0x78, 0x3E, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F,
  0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0x00, 0x71, 0x83, 0xDF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xE7, 0x9E,
  0x3C, 0xF3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x3C, 0x71, 0xE7, 0x9E, 0x3C,
  0xF3, 0xC7, 0x1E, 0x79, 0xE7, 0x8F, 0x3C, 0xF1, 0xE7, 0x9E, 0x38, 0xF3,
  0xCF, 0x1E, 0x79, 0xE7, 0x9F, 0x3C, 0xF0, 0x00, 0x38, 0x1E, 0x7F, 0x0F,
  0x7F, 0xC7, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E,
  0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xEF, 0x81, 0xF7, 0xC0,
  0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x00, 0x01, 0xE0,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0,
  0x3C, 0xF0, 0x1F, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF,
  0x81, 0xF3, 0xC1, 0xF1, 0xF1, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x9E, 0x03, 0xDF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x87,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x83, 0xE3, 0xF1, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0x7F, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0xFB, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xE1, 0xF9, 0xE0, 0x79, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0xDF, 0x03, 0xC7,
  0x81, 0xE3, 0xC1, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xDE,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x1E, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xE0, 0xF9, 0xE0, 0x7C, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0xCF, 0x01, 0xF7, 0xC0, 0xF9, 0xE0, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x60, 0xFF, 0xC1, 0xFF, 0x81, 0xFE,
  0x00, 0x3C, 0x0F, 0xBE, 0x07, 0x9F, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xF3,
  0xC0, 0xF9, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x1F, 0x3C, 0x0F,
  0x9E, 0x07, 0x8F, 0x07, 0xC7, 0xE7, 0xE3, 0xFF, 0xF0, 0xFF, 0x78, 0x3F,
  0x3C, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0xC3,
  0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x0E, 0x78, 0x07,
  0x3C, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0xF1, 0xC3, 0xFC, 0x71, 0xEF, 0x3C, 0x7B, 0xCF, 0x1E,
  0xE3, 0xCF, 0x39, 0xF3, 0xCE, 0x7C, 0xE3, 0xBB, 0x78, 0xEE, 0xDE, 0x3B,
  0x37, 0x0F, 0xCD, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0xF0, 0x7C, 0x0F,
  0x8F, 0x80, 0x79, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFB, 0xC0,
  0x1F, 0x3E, 0x01, 0xF1, 0xE0, 0x3E, 0x1F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0xF0, 0x0F, 0x87, 0x80, 0xF8, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x07, 0x9E,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x0F,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x30, 0x0E, 0x1C, 0x38,
  0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x00,
  0x04, 0x00, 0x38, 0x03, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x7C,
  0x03, 0xC0, 0x18, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x77, 0xFE, 0x3D, 0xEF,
  0xFF, 0xF0, 0xFF, 0xB8, 0x1F, 0xC0, 0x01, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 11, 9, 19, 5, -25 },
  { 37, 19, 23, 19, 0, -23 },
  { 92, 18, 30, 19, 1, -27 },
  { 160, 16, 24, 19, 2, -24 },
  { 208, 19, 24, 19, 0, -24 },
  { 265, 5, 9, 19, 8, -25 },
  { 271, 11, 33, 19, 5, -26 },
  { 317, 11, 33, 19, 3, -26 },
  { 363, 16, 16, 19, 3, -23 },
  { 395, 17, 17, 19, 1, -19 },
  { 432, 7, 11, 19, 3, -4 },
  { 442, 14, 3, 19, 4, -12 },
  { 448, 6, 6, 19, 5, -6 },
  { 453, 18, 25, 19, 1, -23 },
  { 510, 16, 24, 19, 2, -24 },
  { 558, 11, 23, 19, 4, -23 },
  { 590, 18, 24, 19, 0, -24 },
  { 644, 17, 24, 19, 1, -24 },
  { 695, 17, 23, 19, 0, -23 },
  { 744, 18, 23, 19, 1, -23 },
  { 796, 16, 24, 19, 1, -24 },
  { 844, 17, 23, 19, 2, -23 },
  { 893, 17, 24, 19, 1, -24 },
  { 944, 16, 24, 19, 2, -24 },
  { 992, 8, 19, 19, 6, -19 },
  { 1011, 11, 26, 19, 4, -19 },
  { 1047, 16, 16, 19, 2, -18 },
  { 1079, 16, 10, 19, 2, -15 },
  { 1099, 16, 16, 19, 1, -18 },
  { 1131, 15, 24, 19, 4, -24 },
  { 1176, 18, 23, 19, 1, -23 },
  { 1228, 18, 23, 19, -1, -23 },
  { 1280, 19, 23, 19, 0, -23 },
  { 1335, 18, 24, 19, 1, -24 },
  { 1389, 19, 23, 19, 0, -23 },
  { 1444, 19, 23, 19, 1, -23 },
  { 1499, 19, 23, 19, 1, -23 },
  { 1554, 18, 24, 19, 1, -24 },
  { 1608, 19, 23, 19, 0, -23 },
  { 1663, 18, 23, 19, 1, -23 },
  { 1715, 19, 23, 19, 1, -23 },
  { 1770, 22, 23, 19, 0, -23 },
  { 1834, 15, 23, 19, 1, -23 },
  { 1878, 20, 23, 19, 0, -23 },
  { 1936, 19, 23, 19, 0, -23 },
  { 1991, 18, 24, 19, 1, -24 },
  { 2045, 18, 23, 19, 1, -23 },
  { 2097, 18, 28, 19, 1, -24 },
  { 2160, 19, 23, 19, 0, -23 },
  { 2215, 18, 24, 19, 1, -24 },
  { 2269, 19, 23, 19, 2, -23 },
  { 2324, 18, 23, 19, 2, -23 },
  { 2376, 18, 23, 19, 3, -23 },
  { 2428, 19, 23, 19, 2, -23 },
  { 2483, 22, 23, 19, -1, -23 },
  { 2547, 19, 23, 19, 3, -23 },
  { 2602, 20, 23, 19, 0, -23 },
  { 2660, 12, 32, 19, 4, -27 },
  { 2708, 8, 25, 19, 6, -23 },
  { 2733, 12, 32, 19, 4, -27 },
  { 2781, 14, 12, 19, 3, -23 },
  { 2802, 15, 4, 19, 0, 0 },
  { 2810, 6, 5, 19, 9, -24 },
  { 2814, 16, 18, 19, 1, -18 },
  { 2850, 16, 25, 19, 1, -25 },
  { 2900, 15, 18, 19, 2, -18 },
  { 2934, 19, 25, 19, 1, -25 },
  { 2994, 17, 18, 19, 1, -18 },
  { 3033, 18, 26, 19, 3, -26 },
  { 3092, 18, 25, 19, 0, -18 },
  { 3149, 17, 25, 19, 1, -25 },
  { 3203, 14, 24, 19, 2, -24 },
  { 3245, 15, 31, 19, 1, -24 },
  { 3304, 18, 25, 19, 1, -25 },
  { 3361, 15, 25, 19, 1, -25 },
  { 3408, 19, 18, 19, -1, -18 },
  { 3451, 17, 18, 19, 1, -18 },
  { 3490, 17, 18, 19, 1, -18 },
  { 3529, 18, 25, 19, -1, -18 },
  { 3586, 17, 25, 19, 1, -18 },
  { 3640, 16, 18, 19, 3, -18 },
  { 3676, 17, 18, 19, 1, -18 },
  { 3715, 15, 22, 19, 3, -22 },
  { 3757, 17, 17, 19, 2, -17 },
  { 3794, 17, 17, 19, 2, -17 },
  { 3831, 18, 17, 19, 2, -17 },
  { 3870, 20, 17, 19, 0, -17 },
  { 3913, 21, 24, 19, 0, -17 },
  { 3976, 19, 17, 19, 0, -17 },
  { 4017, 12, 32, 19, 5, -26 },
  { 4065, 7, 30, 19, 6, -23 },
  { 4092, 13, 32, 19, 3, -26 },
  { 4144, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic33pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_BOLDITALIC33PT7B_H_
