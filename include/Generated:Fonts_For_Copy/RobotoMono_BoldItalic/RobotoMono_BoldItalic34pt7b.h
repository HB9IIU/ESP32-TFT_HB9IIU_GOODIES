#ifndef _ROBOTOMONO_BOLDITALIC34PT7B_H_
#define _ROBOTOMONO_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0x87, 0xC3, 0xE0, 0xE0, 0x70, 0xEE, 0x3D, 0xC7, 0xF8, 0xEF, 0x1D, 0xC3,
  0xB8, 0x77, 0x1C, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0x81, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0xE3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x7E,
  0x1F, 0x07, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xE3,
  0xE0, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x77, 0x1C, 0x73, 0x8E, 0x71,
  0xC7, 0x38, 0xFF, 0xB8, 0x3F, 0xB8, 0x0F, 0x9C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0xFC, 0x0E, 0xFF, 0x07, 0x7F, 0x87,
  0x79, 0xC7, 0x38, 0xE7, 0x1C, 0x70, 0x8E, 0x38, 0x07, 0xBC, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9F,
  0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC1,
  0xC7, 0xFC, 0x79, 0xF7, 0xCF, 0x7C, 0xF9, 0xEF, 0x8F, 0xF9, 0xE1, 0xFF,
  0x3C, 0x1F, 0xC7, 0xC1, 0xF0, 0xFC, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x0F, 0xE7, 0xC0, 0x39, 0xDE, 0xF7, 0xB9, 0xCE, 0x77, 0x00, 0x00, 0x20,
  0x06, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x18, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x41, 0xC1, 0x71, 0xC7, 0xFD, 0xBF, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0x80,
  0x0F, 0xC0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xF0, 0xF8, 0x78, 0x30, 0x70,
  0x10, 0x20, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x3C,
  0x79, 0xE0, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x73, 0xEF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF1,
  0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F,
  0x0F, 0xCF, 0x1F, 0xE7, 0x9F, 0xF3, 0xFE, 0xFB, 0xFC, 0x7D, 0xFC, 0x3E,
  0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC3, 0xE7,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x3E, 0x0F,
  0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0xE3, 0xC8, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xCF, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFE, 0x1F, 0x8F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0xF3,
  0xE0, 0x7C, 0xF8, 0x3F, 0x3F, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x78, 0xF0, 0x3C, 0x7C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x0C,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x3E, 0x07,
  0xCF, 0x81, 0xF1, 0xE0, 0xF8, 0x7E, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0xF8, 0x1F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x87, 0xC7, 0xE7, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x20, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0xC7, 0xC1, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0xE0, 0xFD, 0xF8, 0xF8, 0x3E, 0x78, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE3, 0xF3, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x07, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3F, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7E, 0x7E, 0x3F, 0xFE, 0x3F,
  0xFE, 0x0F, 0xBE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF8, 0xFC,
  0xFC, 0xFC, 0x78, 0x01, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0,
  0x78, 0x1E, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03,
  0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00,
  0x04, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0x80, 0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFC, 0x7F,
  0xE0, 0x7F, 0x80, 0x7C, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x01, 0x80, 0x1F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xE7, 0xFF, 0x07, 0xFE, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x07, 0x80, 0xE1, 0xE0, 0x1C, 0x38, 0xF1, 0x8E, 0x3F,
  0xB9, 0x8F, 0xE7, 0x73, 0x8C, 0xEE, 0xE3, 0x9F, 0x9C, 0x73, 0x73, 0x8C,
  0x6E, 0x61, 0x8D, 0xDC, 0x73, 0xB3, 0x8E, 0x66, 0x71, 0xCC, 0xC7, 0xFF,
  0x9C, 0xFF, 0xE3, 0x8E, 0x78, 0x70, 0x00, 0x07, 0x00, 0x00, 0xFD, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x7C, 0x78,
  0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0x01, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03,
  0xE1, 0xE0, 0x7E, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xE0,
  0xFC, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C,
  0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1,
  0xF8, 0xFC, 0x3E, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1F, 0x3C, 0x03, 0xEF,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x3C,
  0x07, 0x87, 0xC1, 0xF0, 0xFE, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xC0, 0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F,
  0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x7E, 0x3E,
  0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0xFC, 0x3E,
  0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x00, 0x2F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xFF, 0x9E, 0x1F, 0xE7, 0xC3,
  0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC0,
  0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1,
  0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x07,
  0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x81, 0xF0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x1F, 0x01, 0xE3,
  0xE0, 0x7C, 0x7C, 0x1F, 0x07, 0xEF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0x80, 0xFE, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x78,
  0x1F, 0x00, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x9F,
  0x80, 0x1F, 0x7E, 0x00, 0x3D, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x9F, 0x00,
  0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F,
  0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F,
  0x07, 0xE7, 0xF8, 0x7B, 0xBF, 0x83, 0xDF, 0xFC, 0x1E, 0xFD, 0xE0, 0xF7,
  0xEF, 0x07, 0xBE, 0x78, 0x7D, 0xF7, 0x83, 0xCF, 0x3C, 0x1E, 0x79, 0xE0,
  0xF3, 0x8F, 0x07, 0x9C, 0x78, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x1F,
  0x01, 0xE0, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1E,
  0x0F, 0xC1, 0xE1, 0xFC, 0x3E, 0x1F, 0xE3, 0xE1, 0xFE, 0x3E, 0x1F, 0xE3,
  0xE1, 0xEE, 0x3C, 0x1E, 0xF3, 0xC3, 0xEF, 0x7C, 0x3E, 0x77, 0xC3, 0xE7,
  0x7C, 0x3C, 0x7F, 0xC3, 0xC7, 0xF8, 0x3C, 0x3F, 0x87, 0xC3, 0xF8, 0x7C,
  0x3F, 0x87, 0xC3, 0xF8, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F,
  0x81, 0xF0, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F,
  0x9F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00,
  0xF7, 0xC0, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xF9, 0xE0, 0x7C, 0x7C,
  0x3F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x3E, 0x3C,
  0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8,
  0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0x87, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0x78,
  0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03,
  0xEF, 0x80, 0xF9, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x04, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x03, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xE1, 0xE0, 0x3E, 0x1E, 0x07, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x8F,
  0x80, 0x7C, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF8, 0xFC, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x7C,
  0x07, 0xCF, 0x80, 0xF8, 0xFE, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x3C,
  0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03,
  0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xE1, 0xF0, 0xFC,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C,
  0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0xF1, 0xF7, 0x8F, 0x1E, 0x78, 0xF1,
  0xE7, 0x9F, 0x3E, 0x79, 0xF3, 0xC7, 0x9F, 0x3C, 0x7B, 0xF3, 0xCF, 0x3F,
  0x78, 0xF3, 0xF7, 0x8F, 0x3F, 0x78, 0xF7, 0x77, 0x8F, 0x77, 0xF0, 0xF7,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80,
  0xF8, 0x78, 0x0F, 0x07, 0x80, 0x0F, 0x80, 0x7E, 0x0F, 0x81, 0xF8, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x79,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x9E, 0x00, 0x3E, 0x3E, 0x00,
  0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xEF, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x1E, 0x7C, 0x03,
  0xDF, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xFF,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC0, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0x78, 0x7B, 0xC7, 0x8E, 0x3C, 0x73, 0xC3, 0x9E,
  0x1F, 0xE0, 0xFE, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0xF0, 0xF1, 0xE1, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF,
  0x3F, 0x1F, 0x3E, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F, 0xFF,
  0x7F, 0xFF, 0x7C, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xFC, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xBE, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE3, 0xE0, 0xF9, 0xE0, 0x7C,
  0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03, 0xEF, 0x01,
  0xE7, 0x81, 0xF7, 0xE0, 0xFB, 0xF9, 0xF9, 0xFF, 0xF8, 0xF7, 0xFC, 0x79,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0x7E, 0x7C, 0x1F,
  0x78, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x3E, 0xF8, 0x3C, 0xFC, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x0F, 0xEF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFD, 0xFC, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0,
  0x3E, 0x3E, 0x1F, 0x0F, 0xDF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xCF,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF7, 0xE3, 0xE0, 0xF9,
  0xE0, 0x3D, 0xF0, 0x1E, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x61, 0xFC, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xF7, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF9, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xEF,
  0xE1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07,
  0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x1F,
  0x0F, 0xCF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFD, 0xE0, 0x00, 0x7C,
  0x10, 0x0F, 0x83, 0x03, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x7E, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xF7, 0xF3, 0xE0, 0xF9, 0xE0, 0x7C, 0xF0, 0x1E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0xE7, 0xC1, 0xF0, 0xF8, 0x7C,
  0x1F, 0x1F, 0x03, 0xCF, 0xC0, 0x7B, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0x8F, 0x81,
  0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF0, 0x3F, 0x1E, 0x03, 0xE0,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x0E, 0xFB, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xF7, 0xFF, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3E, 0x78, 0xF3, 0xC7, 0x9E,
  0x3C, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x7C, 0xF1,
  0xE7, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x9E,
  0x3C, 0x1E, 0x7E, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF7, 0xF3, 0xE0, 0xF9,
  0xE0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03,
  0xCF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0,
  0x1E, 0x78, 0x0F, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xF7,
  0xE3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xE7, 0x81, 0xF3, 0xE0, 0xF9, 0xF9, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xBF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0xE7, 0xE1, 0xFF, 0xF8, 0x3D, 0xFE, 0x07,
  0x9F, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0x8F, 0xFF, 0xCF,
  0xFF, 0xCF, 0xEF, 0xE7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3E,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0xC3,
  0xE3, 0xF3, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xBE, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x1E, 0x3F, 0x1E, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xC2, 0x3F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3C, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x79, 0xF0, 0xFC, 0xFF, 0xFC, 0x3F,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7E, 0x60, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x3C, 0x07,
  0x9E, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0,
  0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF,
  0x03, 0xE7, 0xC1, 0xF3, 0xF3, 0xF8, 0xFF, 0xF8, 0x7F, 0xBC, 0x1F, 0x9E,
  0x00, 0xF8, 0x07, 0xDE, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x7C, 0x1F,
  0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xCF, 0x9E, 0xF3, 0xE7, 0xBC, 0xF9, 0xEF, 0x7E, 0xF3, 0xDF, 0xBC,
  0xE6, 0xEF, 0x3B, 0xBF, 0x8E, 0xEF, 0xE3, 0xB3, 0xF8, 0xFC, 0xFC, 0x3E,
  0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x00, 0x1F,
  0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0x78, 0xF8, 0x07, 0xDF, 0x80,
  0x3D, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xBE, 0x01, 0xFB, 0xE0, 0x1F, 0x1F,
  0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0x8F, 0x80, 0x78, 0x3E, 0x00, 0xF8, 0xF0,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x83, 0xE0,
  0x3C, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xEF,
  0x80, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x08, 0x03,
  0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x1F, 0xC0, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00,
  0xE0, 0x03, 0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x04, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3F,
  0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xF0,
  0x1F, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x1D, 0xFF, 0x07, 0xBF,
  0xF9, 0xEF, 0x1F, 0xFD, 0xC1, 0xFF, 0x18, 0x0F, 0xE0, 0x00, 0x70,
};

const GFXglyph RobotoMono_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 24, 20, 6, -24 },
  { 28, 11, 9, 20, 6, -26 },
  { 41, 20, 24, 20, 0, -24 },
  { 101, 19, 32, 20, 1, -28 },
  { 177, 17, 25, 20, 2, -25 },
  { 231, 19, 25, 20, 0, -25 },
  { 291, 5, 10, 20, 8, -26 },
  { 298, 12, 35, 20, 5, -27 },
  { 351, 11, 35, 20, 3, -27 },
  { 400, 16, 17, 20, 3, -24 },
  { 434, 17, 18, 20, 1, -20 },
  { 473, 7, 11, 20, 3, -4 },
  { 483, 14, 4, 20, 4, -13 },
  { 490, 6, 6, 20, 6, -6 },
  { 495, 18, 26, 20, 1, -24 },
  { 554, 17, 25, 20, 2, -25 },
  { 608, 12, 24, 20, 4, -24 },
  { 644, 18, 25, 20, 0, -25 },
  { 701, 18, 25, 20, 1, -25 },
  { 758, 18, 24, 20, 0, -24 },
  { 812, 18, 24, 20, 1, -24 },
  { 866, 17, 24, 20, 1, -24 },
  { 917, 18, 24, 20, 2, -24 },
  { 971, 17, 25, 20, 1, -25 },
  { 1025, 16, 25, 20, 2, -25 },
  { 1075, 8, 20, 20, 6, -20 },
  { 1095, 11, 27, 20, 4, -20 },
  { 1133, 16, 16, 20, 2, -18 },
  { 1165, 17, 11, 20, 2, -16 },
  { 1189, 16, 16, 20, 1, -18 },
  { 1221, 15, 25, 20, 4, -25 },
  { 1268, 19, 24, 20, 1, -24 },
  { 1325, 19, 24, 20, -1, -24 },
  { 1382, 20, 24, 20, 0, -24 },
  { 1442, 19, 25, 20, 1, -25 },
  { 1502, 19, 24, 20, 0, -24 },
  { 1559, 20, 24, 20, 1, -24 },
  { 1619, 20, 24, 20, 1, -24 },
  { 1679, 19, 25, 20, 1, -25 },
  { 1739, 20, 24, 20, 0, -24 },
  { 1799, 18, 24, 20, 1, -24 },
  { 1853, 19, 24, 20, 1, -24 },
  { 1910, 23, 24, 20, 0, -24 },
  { 1979, 16, 24, 20, 1, -24 },
  { 2027, 21, 24, 20, 0, -24 },
  { 2090, 20, 24, 20, 0, -24 },
  { 2150, 18, 25, 20, 1, -25 },
  { 2207, 19, 24, 20, 1, -24 },
  { 2264, 18, 29, 20, 1, -25 },
  { 2330, 20, 24, 20, 0, -24 },
  { 2390, 19, 25, 20, 1, -25 },
  { 2450, 20, 24, 20, 2, -24 },
  { 2510, 18, 24, 20, 2, -24 },
  { 2564, 19, 24, 20, 3, -24 },
  { 2621, 20, 24, 20, 2, -24 },
  { 2681, 23, 24, 20, -1, -24 },
  { 2750, 19, 24, 20, 3, -24 },
  { 2807, 21, 24, 20, 0, -24 },
  { 2870, 12, 34, 20, 4, -28 },
  { 2921, 9, 26, 20, 6, -24 },
  { 2951, 13, 34, 20, 4, -28 },
  { 3007, 13, 13, 20, 4, -24 },
  { 3029, 15, 4, 20, 0, 0 },
  { 3037, 7, 5, 20, 9, -25 },
  { 3042, 16, 18, 20, 1, -18 },
  { 3078, 17, 26, 20, 1, -26 },
  { 3134, 16, 18, 20, 2, -18 },
  { 3170, 18, 26, 20, 2, -26 },
  { 3229, 17, 18, 20, 1, -18 },
  { 3268, 18, 26, 20, 3, -26 },
  { 3327, 19, 25, 20, 0, -18 },
  { 3387, 17, 26, 20, 1, -26 },
  { 3443, 15, 25, 20, 2, -25 },
  { 3490, 15, 32, 20, 1, -25 },
  { 3550, 19, 26, 20, 1, -26 },
  { 3612, 16, 26, 20, 1, -26 },
  { 3664, 20, 18, 20, -1, -18 },
  { 3709, 17, 18, 20, 1, -18 },
  { 3748, 17, 18, 20, 1, -18 },
  { 3787, 19, 25, 20, -1, -18 },
  { 3847, 17, 25, 20, 2, -18 },
  { 3901, 16, 18, 20, 3, -18 },
  { 3937, 17, 18, 20, 1, -18 },
  { 3976, 15, 22, 20, 3, -22 },
  { 4018, 17, 18, 20, 2, -18 },
  { 4057, 18, 18, 20, 2, -18 },
  { 4098, 18, 18, 20, 2, -18 },
  { 4139, 20, 18, 20, 0, -18 },
  { 4184, 21, 25, 20, 0, -18 },
  { 4250, 19, 18, 20, 0, -18 },
  { 4293, 13, 33, 20, 5, -27 },
  { 4347, 8, 31, 20, 6, -24 },
  { 4378, 13, 33, 20, 3, -27 },
  { 4432, 19, 8, 20, 0, -14 },
};

const GFXfont RobotoMono_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic34pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_BOLDITALIC34PT7B_H_
