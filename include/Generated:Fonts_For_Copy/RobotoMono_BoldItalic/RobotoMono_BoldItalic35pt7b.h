#ifndef _ROBOTOMONO_BOLDITALIC35PT7B_H_
#define _ROBOTOMONO_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x00, 0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0xFF,
  0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x03,
  0x8E, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xF1, 0xC0,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0xBF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1E, 0x38,
  0xCE, 0x1C, 0x77, 0x0E, 0x73, 0x8F, 0x71, 0xE7, 0x38, 0x7F, 0xB8, 0x3F,
  0xB8, 0x03, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x20,
  0x0E, 0xFE, 0x0E, 0xFF, 0x07, 0x7B, 0xC7, 0x38, 0xE7, 0x3C, 0x73, 0x9E,
  0x38, 0x8F, 0x3C, 0x03, 0x9C, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0x9F, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x0F, 0x1F, 0xF0, 0xF3,
  0xEF, 0x9F, 0x7C, 0x7D, 0xE7, 0xC7, 0xFE, 0x78, 0x3F, 0xC7, 0x83, 0xFC,
  0x7C, 0x1F, 0x87, 0xEF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xE7,
  0xE0, 0x7B, 0x9D, 0xEF, 0x7B, 0x9C, 0xE0, 0x00, 0x10, 0x07, 0x00, 0xF0,
  0x1F, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x06, 0x00,
  0x20, 0x04, 0x00, 0x60, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x03, 0x0E, 0x1B, 0xE7, 0x3D, 0xFF, 0xFF,
  0x7F, 0xFF, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEE, 0x01, 0xE3,
  0x81, 0xE1, 0xE1, 0xF0, 0xF0, 0x30, 0x30, 0x00, 0x10, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFA, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C,
  0x7C, 0x78, 0xF0, 0x20, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF0,
  0x3E, 0x78, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x1F, 0xEF, 0x9F, 0xF7,
  0xBE, 0xF3, 0xFE, 0x7B, 0xFC, 0x7D, 0xFC, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xC3, 0xF7, 0xE1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x0F, 0x07, 0xF3, 0xFE, 0x7F, 0xEF,
  0xFE, 0xFB, 0xEC, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF9, 0xF0,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x1F, 0xBF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xEF, 0x80,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0x87, 0xC3, 0xC1,
  0xF1, 0xF0, 0x7C, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xF3, 0xF0, 0x08, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x87,
  0xC1, 0xF0, 0xFE, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x30, 0x1E, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xF3, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F,
  0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x03, 0xE7, 0xC1, 0xF1, 0xFB, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0x87,
  0xC3, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xE3,
  0xF1, 0xF0, 0x7C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C,
  0xFC, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0,
  0x79, 0xF0, 0x3C, 0xF0, 0x1F, 0x78, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xCF,
  0x83, 0xE7, 0xC3, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0x9E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x0F, 0x8F, 0xE7, 0xF1, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x0F, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x38, 0x04, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x18, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF,
  0xC7, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03,
  0xC1, 0xE0, 0xE0, 0x0C, 0x38, 0x01, 0xCF, 0x3F, 0xB9, 0xCF, 0xF3, 0x73,
  0xCE, 0x6E, 0x71, 0x8D, 0xDE, 0x31, 0xF3, 0x8E, 0x7E, 0x71, 0xCF, 0xCE,
  0x39, 0xF9, 0x86, 0x37, 0x31, 0xC6, 0xC7, 0x39, 0x9C, 0xFF, 0xF3, 0x9F,
  0x7C, 0x71, 0xC7, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC3,
  0xC0, 0x7C, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x83, 0xF0, 0xF0, 0x1F, 0x0F, 0x00,
  0xF1, 0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF3, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x8F, 0xC0, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xE1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8,
  0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x0F, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC7, 0xFC, 0xF0, 0xFF, 0x9E, 0x1F, 0xF7, 0xC3, 0xFE, 0xF8, 0x07, 0xDF,
  0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0x83, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF8, 0x0F, 0x07, 0xC0,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F,
  0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x0F,
  0x8F, 0x81, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x07,
  0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xE0, 0xF8, 0x03, 0xC3, 0xE0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xDF, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xBF,
  0xC3, 0xDD, 0xDE, 0x1E, 0xFE, 0xF0, 0xF7, 0xEF, 0x07, 0xBF, 0x78, 0x3D,
  0xFB, 0xC3, 0xEF, 0x9E, 0x1F, 0x7C, 0xF0, 0xF3, 0xCF, 0x87, 0x8E, 0x78,
  0x3C, 0x63, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0x80,
  0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x7E, 0x07, 0x83, 0xF0, 0x3C, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x07, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3C, 0x1F, 0xE3, 0xE0,
  0xFF, 0x1F, 0x07, 0xFC, 0xF8, 0x3D, 0xE7, 0xC3, 0xE7, 0x3E, 0x1F, 0x39,
  0xE0, 0xF9, 0xFF, 0x07, 0xCF, 0xF8, 0x3C, 0x3F, 0xC1, 0xE1, 0xFE, 0x1F,
  0x0F, 0xE0, 0xF8, 0x7F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xE0, 0x7E,
  0x0F, 0x03, 0xF0, 0xF8, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF9, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0x80,
  0x3C, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xF3, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xE1,
  0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x00, 0x60, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x83, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF1,
  0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xE0, 0x7E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x1E,
  0x03, 0xC1, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0x80, 0x7C, 0xF8, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xF0, 0x1E,
  0x3E, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x7C,
  0x0F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x01,
  0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0xF8, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x79, 0xF0,
  0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x70, 0xF7, 0x8F, 0x0F, 0x78, 0xF1, 0xF7, 0x8F,
  0x1E, 0x79, 0xF1, 0xE7, 0x9F, 0x1E, 0x79, 0xF3, 0xC7, 0x9F, 0x3C, 0x7B,
  0xF3, 0xC7, 0xBF, 0x7C, 0xFB, 0xF7, 0x8F, 0x7F, 0x78, 0xF7, 0x77, 0x8F,
  0x77, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x00, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x7E,
  0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xF0,
  0x01, 0xE3, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xCF, 0x80,
  0x0F, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0,
  0x3E, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xF7,
  0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x83, 0xC1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xE7, 0x07, 0x9C, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E, 0x0E,
  0xF0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x78,
  0xF0, 0xF0, 0xE0, 0x01, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3,
  0xE0, 0xF9, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0x9F, 0xFF,
  0x9F, 0xFF, 0xCF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xF9,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xE7, 0xC0, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x70, 0x1E, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x03,
  0xEF, 0x01, 0xF7, 0x80, 0xF7, 0xE0, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xF7,
  0xFC, 0x79, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x1E, 0xF8, 0x3E, 0x7E, 0xFC,
  0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1E,
  0x3C, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x0F, 0xC7, 0xC1,
  0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x1E, 0x03,
  0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xF7, 0x80, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x87, 0xC0, 0x60, 0xFE, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF1, 0x90, 0x3F,
  0xDE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC3,
  0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xEF, 0x80, 0x00, 0xF0, 0x20, 0x1F,
  0x03, 0x03, 0xF0, 0x7C, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0xF0, 0x1E, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFC, 0x3E, 0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7D, 0xF0,
  0x1E, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xCF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x01, 0x1E, 0x07, 0xC7, 0xC3, 0xF0, 0xF8, 0xFC, 0x1F,
  0x3F, 0x03, 0xEF, 0xC0, 0x7B, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0x87, 0xC1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0x78, 0xC0, 0xF7, 0xDF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xF7, 0xCF, 0x0F, 0x1E, 0x78, 0x79, 0xF3, 0xC7, 0xCF, 0x1E,
  0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7C, 0x78, 0xF3, 0xC3, 0xCF,
  0x9E, 0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xE3,
  0xC7, 0x9E, 0x3E, 0x78, 0xF0, 0x16, 0x3C, 0x07, 0xBF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0x0F, 0x8F, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x7C,
  0x07, 0x9F, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0x9E, 0x03,
  0xEF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF0,
  0x00, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x0F, 0x8F,
  0x83, 0xE7, 0xC0, 0x79, 0xF0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xEF, 0x80,
  0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x9E, 0x03, 0xC7, 0xC1, 0xF1, 0xFD, 0xF8,
  0x3F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x05, 0x9E, 0x00, 0xF7, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xE0, 0x3E, 0x3C, 0x0F, 0x8F, 0xC1, 0xF1, 0xFE, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xF3, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xFB, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x7B, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF8, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x01,
  0xE7, 0x81, 0xF3, 0xE0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F,
  0xEF, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x01, 0x1F, 0x0F, 0x3F, 0xC7, 0xBF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF1, 0xF0, 0x7C, 0x7F, 0xFF,
  0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xF8, 0x3E, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xCF, 0x80, 0xB0, 0x00, 0x7C, 0x03,
  0xEF, 0x00, 0xFB, 0xE0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xC1,
  0xE1, 0xF0, 0x78, 0x78, 0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D,
  0xE0, 0x0F, 0x78, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF1, 0xE3, 0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x79, 0xF1,
  0xEF, 0x3E, 0x79, 0xE7, 0xCF, 0x3D, 0xF9, 0xE7, 0xBF, 0x78, 0xF6, 0xEF,
  0x1F, 0xDD, 0xE3, 0xFB, 0xF8, 0x76, 0x7F, 0x0F, 0xCF, 0xE1, 0xF9, 0xF8,
  0x3E, 0x3F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1E, 0x0F, 0x00, 0x1F, 0x01,
  0xF8, 0x7C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x9F, 0x80, 0x3D, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xCF, 0x80, 0x7C,
  0x7C, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x3E, 0x00,
  0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1E,
  0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x38, 0x03, 0xC0, 0x3E,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0xFC, 0x1F, 0xC0, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x03,
  0x00, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x07, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x1D,
  0xFF, 0x87, 0xBF, 0xFD, 0xFF, 0x0F, 0xFD, 0xC0, 0xFF, 0x88, 0x0F, 0xE0,
  0x00, 0x20,
};

const GFXglyph RobotoMono_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 25, 21, 6, -25 },
  { 30, 11, 9, 21, 6, -26 },
  { 43, 21, 25, 21, 0, -25 },
  { 109, 18, 33, 21, 2, -29 },
  { 184, 17, 25, 21, 2, -25 },
  { 238, 20, 25, 21, 0, -25 },
  { 301, 5, 9, 21, 9, -26 },
  { 307, 12, 36, 21, 5, -28 },
  { 361, 12, 36, 21, 3, -28 },
  { 415, 17, 18, 21, 3, -25 },
  { 454, 18, 19, 21, 1, -21 },
  { 497, 8, 11, 21, 3, -4 },
  { 508, 15, 4, 21, 4, -13 },
  { 516, 6, 6, 21, 6, -6 },
  { 521, 19, 27, 21, 1, -25 },
  { 586, 17, 25, 21, 2, -25 },
  { 640, 12, 25, 21, 4, -25 },
  { 678, 19, 25, 21, 0, -25 },
  { 738, 18, 25, 21, 1, -25 },
  { 795, 18, 25, 21, 0, -25 },
  { 852, 19, 25, 21, 1, -25 },
  { 912, 17, 25, 21, 1, -25 },
  { 966, 18, 25, 21, 2, -25 },
  { 1023, 18, 25, 21, 1, -25 },
  { 1080, 17, 25, 21, 2, -25 },
  { 1134, 9, 20, 21, 6, -20 },
  { 1157, 10, 27, 21, 5, -20 },
  { 1191, 17, 16, 21, 2, -19 },
  { 1225, 17, 11, 21, 2, -16 },
  { 1249, 17, 17, 21, 1, -19 },
  { 1286, 16, 25, 21, 4, -25 },
  { 1336, 19, 25, 21, 1, -25 },
  { 1396, 20, 25, 21, -1, -25 },
  { 1459, 20, 25, 21, 0, -25 },
  { 1522, 19, 25, 21, 1, -25 },
  { 1582, 20, 25, 21, 0, -25 },
  { 1645, 20, 25, 21, 1, -25 },
  { 1708, 20, 25, 21, 1, -25 },
  { 1771, 19, 25, 21, 1, -25 },
  { 1831, 21, 25, 21, 0, -25 },
  { 1897, 19, 25, 21, 1, -25 },
  { 1957, 20, 25, 21, 1, -25 },
  { 2020, 23, 25, 21, 0, -25 },
  { 2092, 16, 25, 21, 1, -25 },
  { 2142, 21, 25, 21, 0, -25 },
  { 2208, 21, 25, 21, 0, -25 },
  { 2274, 19, 25, 21, 1, -25 },
  { 2334, 20, 25, 21, 1, -25 },
  { 2397, 19, 29, 21, 1, -25 },
  { 2466, 20, 25, 21, 0, -25 },
  { 2529, 20, 25, 21, 1, -25 },
  { 2592, 20, 25, 21, 2, -25 },
  { 2655, 19, 25, 21, 2, -25 },
  { 2715, 19, 25, 21, 3, -25 },
  { 2775, 20, 25, 21, 2, -25 },
  { 2838, 24, 25, 21, -1, -25 },
  { 2913, 20, 25, 21, 3, -25 },
  { 2976, 21, 25, 21, 0, -25 },
  { 3042, 13, 35, 21, 4, -29 },
  { 3099, 8, 27, 21, 7, -25 },
  { 3126, 13, 35, 21, 4, -29 },
  { 3183, 14, 13, 21, 4, -25 },
  { 3206, 16, 4, 21, 0, 0 },
  { 3214, 7, 5, 21, 9, -25 },
  { 3219, 17, 19, 21, 1, -19 },
  { 3260, 17, 26, 21, 1, -26 },
  { 3316, 16, 19, 21, 2, -19 },
  { 3354, 19, 26, 21, 2, -26 },
  { 3416, 18, 19, 21, 1, -19 },
  { 3459, 19, 27, 21, 3, -27 },
  { 3524, 20, 26, 21, 0, -19 },
  { 3589, 18, 26, 21, 1, -26 },
  { 3648, 15, 26, 21, 2, -26 },
  { 3697, 16, 34, 21, 1, -26 },
  { 3765, 19, 26, 21, 1, -26 },
  { 3827, 16, 26, 21, 1, -26 },
  { 3879, 21, 19, 21, -1, -19 },
  { 3929, 18, 19, 21, 1, -19 },
  { 3972, 18, 19, 21, 1, -19 },
  { 4015, 19, 26, 21, -1, -19 },
  { 4077, 17, 26, 21, 2, -19 },
  { 4133, 17, 19, 21, 3, -19 },
  { 4174, 18, 19, 21, 1, -19 },
  { 4217, 16, 23, 21, 3, -23 },
  { 4263, 18, 18, 21, 2, -18 },
  { 4304, 18, 19, 21, 3, -19 },
  { 4347, 19, 18, 21, 2, -18 },
  { 4390, 21, 18, 21, 0, -18 },
  { 4438, 22, 26, 21, 0, -18 },
  { 4510, 20, 18, 21, 0, -18 },
  { 4555, 13, 33, 21, 5, -27 },
  { 4609, 8, 32, 21, 6, -25 },
  { 4641, 14, 33, 21, 3, -27 },
  { 4699, 19, 8, 21, 0, -14 },
};

const GFXfont RobotoMono_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic35pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_BOLDITALIC35PT7B_H_
