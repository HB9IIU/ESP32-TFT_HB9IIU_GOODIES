#ifndef _UBUNTUSANSMONO_MEDIUMITALIC9PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x21, 0x80, 0xB7, 0x00, 0x2B, 0xD5, 0xB6, 0x50, 0x11, 0xD0,
  0xC1, 0x0B, 0xC8, 0x6E, 0xC5, 0x0E, 0x6A, 0x40, 0x32, 0x88, 0xD9, 0x78,
  0xE0, 0x12, 0x48, 0x88, 0x84, 0x40, 0x21, 0x11, 0x13, 0x24, 0x80, 0x4F,
  0xE6, 0x11, 0x3E, 0x42, 0x00, 0x7C, 0xE0, 0x70, 0x04, 0x20, 0x84, 0x10,
  0x82, 0x10, 0xC0, 0x3A, 0x5B, 0x19, 0x38, 0x35, 0x12, 0x2F, 0x78, 0x44,
  0x44, 0x78, 0x78, 0x4C, 0x21, 0x78, 0x19, 0x55, 0x27, 0x98, 0x39, 0x1C,
  0x21, 0x78, 0x3A, 0x1C, 0x9C, 0xB8, 0xF9, 0x88, 0x84, 0x40, 0x3A, 0x4C,
  0xA9, 0x38, 0x7A, 0x52, 0x71, 0x70, 0x4C, 0x2C, 0x4C, 0x2D, 0x80, 0x09,
  0xB0, 0x60, 0x78, 0x7C, 0x41, 0x87, 0xC0, 0x71, 0x24, 0x0C, 0x3A, 0x6F,
  0x5A, 0xC9, 0xC0, 0x33, 0x55, 0xB9, 0x7A, 0x5C, 0xB9, 0xF8, 0x78, 0x88,
  0x8E, 0x7A, 0x52, 0x99, 0x70, 0x3A, 0x1C, 0x84, 0x78, 0x3A, 0x1C, 0x84,
  0x40, 0x3A, 0x11, 0x1D, 0x38, 0x4A, 0x5E, 0x99, 0x48, 0x78, 0x88, 0x42,
  0x78, 0x38, 0x42, 0x21, 0x78, 0x6D, 0x46, 0x18, 0x92, 0x40, 0x64, 0x44,
  0x8F, 0x6B, 0xDF, 0x58, 0xC8, 0x6B, 0x5A, 0xD9, 0x48, 0x3A, 0x53, 0x19,
  0x38, 0x7A, 0x52, 0xE8, 0x40, 0x3A, 0x53, 0x19, 0x38, 0x82, 0x7A, 0x56,
  0xC9, 0x48, 0x7A, 0x18, 0x21, 0x78, 0xF9, 0x10, 0x84, 0x60, 0x4A, 0x52,
  0x99, 0x38, 0x9C, 0xA9, 0x4C, 0x60, 0x45, 0x26, 0xAA, 0xD2, 0x40, 0x6C,
  0xC3, 0x0C, 0x52, 0x40, 0x9C, 0x98, 0x84, 0x60, 0x78, 0x88, 0x44, 0x78,
  0x34, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0xAA, 0xC0, 0x38, 0x84, 0x22, 0x10,
  0x84, 0xC0, 0x66, 0x90, 0xF8, 0x90, 0x3A, 0x65, 0x27, 0x00, 0x22, 0x1C,
  0x94, 0xCB, 0xC0, 0x3A, 0x21, 0x07, 0x00, 0x08, 0x4E, 0x99, 0x49, 0xC0,
  0x32, 0x7D, 0x07, 0x00, 0x1C, 0x87, 0x88, 0x20, 0x84, 0x10, 0x80, 0x3A,
  0x55, 0x27, 0x4B, 0x80, 0x22, 0x1C, 0xB5, 0x4A, 0x40, 0x63, 0x24, 0x98,
  0x18, 0x1C, 0x21, 0x08, 0x94, 0xC0, 0x21, 0x12, 0xA6, 0x3A, 0x40, 0xE9,
  0x24, 0x98, 0x7B, 0x6B, 0x29, 0x00, 0x72, 0x54, 0xA9, 0x00, 0x32, 0x63,
  0x27, 0x00, 0x72, 0x53, 0x2F, 0x42, 0x00, 0x3A, 0x75, 0x27, 0x08, 0x80,
  0x3A, 0x10, 0x8C, 0x00, 0x3A, 0x08, 0x2F, 0x00, 0x4F, 0x44, 0x8E, 0x4A,
  0x55, 0x27, 0x00, 0x99, 0xAC, 0xC0, 0x4B, 0x6B, 0xA9, 0x00, 0x4B, 0x88,
  0xA9, 0x00, 0x24, 0x92, 0x8A, 0x10, 0x8C, 0x00, 0x78, 0x88, 0x8F, 0x00,
  0x34, 0x44, 0x88, 0x88, 0x60, 0x24, 0xA4, 0x94, 0x80, 0x71, 0x11, 0x12,
  0x24, 0xC0, 0xF8,
};

const GFXglyph UbuntuSansMono_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 6, 5, 1, -6 },
  { 4, 3, 3, 5, 2, -7 },
  { 6, 5, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 5, 6, 5, 0, -6 },
  { 24, 1, 3, 5, 3, -7 },
  { 25, 4, 9, 5, 1, -7 },
  { 30, 4, 9, 5, 0, -7 },
  { 35, 4, 4, 5, 1, -6 },
  { 37, 5, 5, 5, 0, -5 },
  { 41, 2, 3, 5, 1, -2 },
  { 42, 3, 1, 5, 1, -3 },
  { 43, 2, 2, 5, 1, -2 },
  { 44, 6, 9, 5, -1, -7 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 5, 6, 5, 1, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 3, 5, 5, 1, -5 },
  { 92, 3, 6, 5, 1, -5 },
  { 95, 5, 4, 5, 0, -5 },
  { 98, 5, 3, 5, 0, -4 },
  { 100, 5, 4, 5, 0, -5 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 5, 7, 5, 0, -6 },
  { 111, 4, 6, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 5, 6, 5, 0, -6 },
  { 149, 6, 6, 5, 0, -6 },
  { 154, 4, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 8, 5, 0, -6 },
  { 178, 5, 6, 5, 0, -6 },
  { 182, 5, 6, 5, 0, -6 },
  { 186, 5, 6, 5, 1, -6 },
  { 190, 5, 6, 5, 0, -6 },
  { 194, 5, 6, 5, 1, -6 },
  { 198, 6, 6, 5, 0, -6 },
  { 203, 6, 6, 5, 0, -6 },
  { 208, 5, 6, 5, 1, -6 },
  { 212, 5, 6, 5, 0, -6 },
  { 216, 4, 9, 5, 1, -7 },
  { 221, 2, 9, 5, 2, -7 },
  { 224, 5, 9, 5, 0, -7 },
  { 230, 4, 3, 5, 1, -6 },
  { 232, 5, 1, 5, -1, 1 },
  { 233, 2, 2, 5, 2, -7 },
  { 234, 5, 5, 5, 0, -5 },
  { 238, 5, 7, 5, 0, -7 },
  { 243, 5, 5, 5, 0, -5 },
  { 247, 5, 7, 5, 0, -7 },
  { 252, 5, 5, 5, 0, -5 },
  { 256, 6, 9, 5, 0, -7 },
  { 263, 5, 7, 5, 0, -5 },
  { 268, 5, 7, 5, 0, -7 },
  { 273, 3, 7, 5, 1, -7 },
  { 276, 5, 9, 5, 0, -7 },
  { 282, 5, 7, 5, 0, -7 },
  { 287, 3, 7, 5, 1, -7 },
  { 290, 5, 5, 5, 0, -5 },
  { 294, 5, 5, 5, 0, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 5, 7, 5, 0, -5 },
  { 307, 5, 7, 5, 0, -5 },
  { 312, 5, 5, 5, 0, -5 },
  { 316, 5, 5, 5, 0, -5 },
  { 320, 4, 6, 5, 1, -6 },
  { 323, 5, 5, 5, 0, -5 },
  { 327, 4, 5, 5, 1, -5 },
  { 330, 5, 5, 5, 0, -5 },
  { 334, 5, 5, 5, 0, -5 },
  { 338, 6, 7, 5, -1, -5 },
  { 344, 5, 5, 5, 0, -5 },
  { 348, 4, 9, 5, 1, -7 },
  { 353, 3, 9, 5, 1, -7 },
  { 357, 4, 9, 5, 0, -7 },
  { 362, 5, 1, 5, 0, -3 },
};

const GFXfont UbuntuSansMono_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic9pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC9PT7B_H_
