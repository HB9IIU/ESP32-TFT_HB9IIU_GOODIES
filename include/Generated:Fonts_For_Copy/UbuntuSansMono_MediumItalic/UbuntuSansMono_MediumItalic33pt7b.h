#ifndef _UBUNTUSANSMONO_MEDIUMITALIC33PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x0F,
  0x87, 0xC3, 0xC0, 0x38, 0xF7, 0x8F, 0x78, 0xE7, 0x8E, 0x71, 0xE7, 0x1C,
  0x71, 0xC6, 0x1C, 0xE1, 0x8C, 0x18, 0x00, 0x78, 0xF0, 0x07, 0x0E, 0x00,
  0x71, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x38, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x38, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x83, 0x87, 0x00, 0x38, 0x70, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0x06, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE2, 0x01, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x1C, 0x1F,
  0x80, 0xE0, 0xE7, 0x07, 0x03, 0x1C, 0x38, 0x0C, 0x71, 0xC0, 0x71, 0xC7,
  0x01, 0xC6, 0x38, 0x07, 0x39, 0xC0, 0x1C, 0xCE, 0x00, 0x3F, 0x70, 0x00,
  0xFB, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x77, 0x80, 0x03, 0xBF, 0x00, 0x1D,
  0xFE, 0x00, 0xE7, 0x38, 0x07, 0x18, 0xE0, 0x38, 0xE3, 0x80, 0xE3, 0x8C,
  0x07, 0x0E, 0x70, 0x38, 0x39, 0xC1, 0xC0, 0xFE, 0x0E, 0x01, 0xF0, 0x00,
  0x01, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x78, 0x0F, 0xF0, 0x07, 0xC0,
  0x0F, 0x87, 0x3F, 0xC7, 0x79, 0xCF, 0x71, 0xEE, 0xE0, 0xFE, 0xE0, 0x7C,
  0xE0, 0x78, 0xE0, 0x78, 0xF0, 0xFC, 0xFF, 0xFC, 0x7F, 0xDE, 0x3F, 0x1E,
  0x3C, 0xF7, 0x9E, 0x79, 0xC7, 0x1C, 0x63, 0x80, 0x00, 0x08, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x1E, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x02, 0x1C, 0x27,
  0x19, 0xCF, 0xB7, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x7B,
  0xC1, 0xF3, 0xC1, 0xC7, 0x81, 0x84, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x02, 0x07, 0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x1C, 0x1E,
  0x3E, 0x7E, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x11, 0xEF, 0xFF, 0xFB,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C,
  0x07, 0x38, 0x07, 0x78, 0x07, 0x78, 0x07, 0x71, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xE3, 0xCE, 0xE1, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x78, 0xF0, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x04,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0x7D, 0xC1,
  0xEF, 0x04, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE1, 0xC0, 0xF0, 0x40, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0C, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF1, 0x80, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1D, 0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x03, 0x8F, 0x01, 0xC3, 0xC0,
  0xE0, 0xE0, 0x78, 0x38, 0x3C, 0x0E, 0x0E, 0x07, 0x87, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x10, 0x1F, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3D, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x3C,
  0xE0, 0x1E, 0x70, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x80, 0x04, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0,
  0x38, 0x38, 0x1E, 0x0F, 0x07, 0x03, 0xE7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xFC, 0x0F, 0x0F, 0x87, 0x81, 0xE1, 0xC0, 0x38, 0xF0, 0x0E, 0x3C,
  0x03, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0x7E, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x08, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE0, 0xF1,
  0xE0, 0x78, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x3C, 0x03, 0x9E, 0x03,
  0xCF, 0x81, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x03, 0xF0, 0x00, 0x04, 0x0F, 0x87, 0xC3, 0xF1, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xC3, 0xF1, 0xF8, 0xF8, 0x7C,
  0x00, 0x00, 0x80, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x00, 0xF0, 0x3E, 0x0F, 0xC0, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF,
  0x01, 0xFC, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x30, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x7F,
  0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC4, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7E, 0x7C,
  0x3E, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x73, 0xC0, 0x1C, 0xE0, 0xFF, 0x38,
  0x7F, 0xDC, 0x3F, 0xF7, 0x1E, 0x39, 0xCF, 0x0E, 0xF3, 0x83, 0xB8, 0xE1,
  0xEE, 0x38, 0x73, 0x8E, 0x1C, 0xE3, 0x87, 0x38, 0xE3, 0xCE, 0x3C, 0xE3,
  0x8F, 0xF8, 0xE1, 0xFE, 0x3C, 0x08, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xF0, 0x1C, 0x3C, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xC0, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3C,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1C, 0x1F, 0x07, 0x03, 0xC3,
  0xC0, 0x70, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x07, 0x87, 0x8F, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1E,
  0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E,
  0x06, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x20, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70,
  0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x0F,
  0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xC3, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0,
  0x21, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x79,
  0xC0, 0x38, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x07, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x04, 0x00, 0x07, 0x80, 0xF0, 0x78, 0x0F,
  0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0E, 0x01,
  0xE1, 0xE0, 0x1C, 0x1E, 0x03, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x78, 0x38, 0x07, 0x83, 0x80, 0x70, 0x78,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x21, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x04, 0x03, 0xC1, 0x81, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x10, 0x00, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x0E,
  0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xCF, 0x80,
  0x0E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xDE,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0x00,
  0x01, 0xC0, 0x78, 0x0E, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x8D, 0xC0, 0xDC, 0xEC, 0x0E, 0x66, 0xE0,
  0x73, 0x77, 0x03, 0x9B, 0x38, 0x38, 0xF1, 0xC1, 0xC7, 0x9E, 0x0E, 0x38,
  0xE0, 0xF1, 0xC7, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x1E,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x0E, 0x0F,
  0xC0, 0xE0, 0xFC, 0x0E, 0x0E, 0xE1, 0xE0, 0xEE, 0x1C, 0x1E, 0xE1, 0xC1,
  0xCE, 0x1C, 0x1C, 0x73, 0xC1, 0xC7, 0x38, 0x3C, 0x73, 0x83, 0x87, 0x38,
  0x38, 0x37, 0x83, 0x83, 0xF0, 0x78, 0x3F, 0x07, 0x03, 0xF0, 0x70, 0x1F,
  0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1E, 0x0F, 0x03, 0x87, 0x80,
  0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x39,
  0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x07, 0x87, 0x03, 0xC1, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x03, 0xC3, 0xE0, 0x70, 0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x01, 0xC1, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x1F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1E, 0x0F, 0x03, 0x87,
  0x80, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xE7, 0x80,
  0x39, 0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x03, 0xE1, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1C, 0x1F, 0x07, 0x03, 0xC3, 0xC0, 0x70, 0xF0, 0x1C, 0x38, 0x0F,
  0x0E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFC, 0x03, 0xC7, 0x80, 0xF0, 0xE0, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x81,
  0xC1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x03, 0x8F, 0x00, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x40, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x30, 0x0F, 0x07, 0xFF, 0xE1,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xC0, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x38, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x1C, 0x3C, 0x03,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xF8, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xDC,
  0x01, 0xEE, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x78, 0xF0, 0x38,
  0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x8F, 0x03, 0xC7,
  0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE3, 0x8E, 0x0F, 0x3C, 0x70, 0x71,
  0xE3, 0x83, 0x9F, 0x38, 0x1D, 0xD9, 0xC0, 0xEC, 0xCE, 0x06, 0xE7, 0x60,
  0x76, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0x83,
  0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x0F, 0x01,
  0xE0, 0x1C, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x8F, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xF3, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07,
  0x81, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x00, 0xF0,
  0x07, 0xFC, 0x01, 0xEF, 0x00, 0xF1, 0xC0, 0x78, 0x70, 0x1E, 0x1C, 0x0F,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xDC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF0, 0xE1, 0xC3,
  0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7,
  0x8F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x07,
  0xBC, 0x0F, 0x1C, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x0E, 0x78, 0x0F, 0xF0,
  0x0F, 0x20, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x20, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xE1, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xE1,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xCF, 0x00, 0x00, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x70, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0x70, 0x1E, 0x70, 0x3C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x00, 0x3C, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFD, 0xE1, 0xF0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x10, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3B,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x70, 0x78, 0x1E,
  0x0F, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x0E, 0x0E, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x38, 0x1E, 0x1F, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFB, 0xC0, 0x00, 0x78, 0x03, 0xFE, 0x0F, 0xFF, 0x1F,
  0x9F, 0x3E, 0x07, 0x3C, 0x07, 0x78, 0x07, 0x78, 0x0F, 0x70, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF0, 0xF8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x04, 0x7F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x04, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xF9, 0xF0, 0x7C,
  0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0x80,
  0x70, 0x70, 0x1E, 0x0E, 0x03, 0xC1, 0xC0, 0x78, 0x3C, 0x1E, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xEF, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x06, 0x07, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x40,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x38, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1,
  0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x38, 0x70, 0x1C, 0x78, 0x1E, 0x00, 0x00, 0x80, 0x3C, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x47, 0xF8, 0x7F, 0x8F, 0xF8,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0x80,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x60, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x81, 0xF0, 0xE0, 0xF0, 0x78, 0x78,
  0x1E, 0x3C, 0x07, 0x1E, 0x01, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xBE, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x07,
  0x83, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x07, 0x80, 0xFF, 0xBF, 0xEF, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x17,
  0xFD, 0xFF, 0x3F, 0xC0, 0x01, 0x02, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7B,
  0xEF, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE7, 0x9E, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF,
  0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x00, 0x60, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70,
  0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x38, 0x00, 0x60, 0x03,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0x78,
  0x07, 0x78, 0x07, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0,
  0x3E, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x38, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0x3F, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x1C, 0x3C, 0x07, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E,
  0x1C, 0x07, 0x87, 0x03, 0xC3, 0xC3, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1,
  0xF0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x38, 0x0F,
  0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xE0, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x0F, 0xDC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xDE, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x60, 0x3C,
  0x7F, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x0F, 0xFF, 0xDF, 0xFF, 0x7F, 0xFE, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x41, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00,
  0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x78,
  0xE0, 0x78, 0xF0, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0x3C, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x70, 0x78,
  0x70, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xC0, 0x7B, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xEF, 0x00,
  0x39, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x0E, 0x38, 0xE3, 0xC7, 0x1C, 0x78,
  0xE3, 0x9F, 0x38, 0x73, 0x67, 0x0E, 0xEC, 0xE1, 0x99, 0xB8, 0x77, 0x37,
  0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x70,
  0x00, 0x0F, 0x81, 0xF0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x78, 0x01,
  0xCF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x9E, 0x01, 0xF1, 0xE0,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x78, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x71,
  0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x01, 0x07, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x0E, 0x02, 0x1F, 0xC1, 0xCF, 0xF1, 0xCF, 0xFF, 0xEE, 0x1F,
  0xE7, 0x03, 0xE0,
};

const GFXglyph UbuntuSansMono_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 23, 18, 5, -23 },
  { 27, 12, 10, 18, 6, -25 },
  { 42, 20, 23, 18, 0, -23 },
  { 100, 17, 30, 18, 1, -26 },
  { 164, 22, 24, 18, -1, -23 },
  { 230, 16, 23, 18, 1, -23 },
  { 276, 6, 10, 18, 9, -25 },
  { 284, 14, 32, 18, 4, -26 },
  { 340, 15, 32, 18, 0, -26 },
  { 400, 15, 14, 18, 3, -23 },
  { 427, 16, 16, 18, 1, -18 },
  { 459, 9, 11, 18, 2, -6 },
  { 472, 9, 3, 18, 5, -11 },
  { 476, 6, 6, 18, 5, -6 },
  { 481, 21, 32, 18, -2, -26 },
  { 565, 16, 24, 18, 2, -23 },
  { 613, 14, 23, 18, 2, -23 },
  { 654, 17, 23, 18, 1, -23 },
  { 703, 18, 24, 18, 0, -23 },
  { 757, 18, 23, 18, 0, -23 },
  { 809, 19, 24, 18, 0, -23 },
  { 866, 17, 24, 18, 2, -23 },
  { 917, 18, 23, 18, 3, -23 },
  { 969, 18, 24, 18, 1, -23 },
  { 1023, 17, 23, 18, 1, -23 },
  { 1072, 9, 18, 18, 5, -18 },
  { 1093, 12, 23, 18, 2, -18 },
  { 1128, 17, 15, 18, 1, -17 },
  { 1160, 17, 10, 18, 1, -15 },
  { 1182, 16, 15, 18, 1, -17 },
  { 1212, 14, 23, 18, 4, -23 },
  { 1253, 18, 28, 18, 1, -23 },
  { 1316, 18, 23, 18, -2, -23 },
  { 1368, 18, 23, 18, 0, -23 },
  { 1420, 18, 24, 18, 2, -23 },
  { 1474, 18, 23, 18, 0, -23 },
  { 1526, 19, 23, 18, 1, -23 },
  { 1581, 19, 23, 18, 1, -23 },
  { 1636, 17, 24, 18, 2, -23 },
  { 1687, 20, 23, 18, 0, -23 },
  { 1745, 18, 23, 18, 1, -23 },
  { 1797, 18, 24, 18, 1, -23 },
  { 1851, 21, 23, 18, 0, -23 },
  { 1912, 15, 23, 18, 0, -23 },
  { 1956, 21, 23, 18, -1, -23 },
  { 2017, 20, 23, 18, 0, -23 },
  { 2075, 18, 24, 18, 1, -23 },
  { 2129, 19, 23, 18, 0, -23 },
  { 2184, 18, 29, 18, 1, -23 },
  { 2250, 18, 23, 18, 0, -23 },
  { 2302, 19, 24, 18, 0, -23 },
  { 2359, 17, 23, 18, 4, -23 },
  { 2408, 19, 24, 18, 1, -23 },
  { 2465, 17, 23, 18, 4, -23 },
  { 2514, 21, 23, 18, 0, -23 },
  { 2575, 22, 23, 18, -1, -23 },
  { 2639, 18, 23, 18, 4, -23 },
  { 2691, 20, 23, 18, 0, -23 },
  { 2749, 17, 32, 18, 2, -26 },
  { 2817, 7, 32, 18, 6, -26 },
  { 2845, 18, 32, 18, -1, -26 },
  { 2917, 16, 13, 18, 2, -23 },
  { 2943, 17, 3, 18, -2, 3 },
  { 2950, 7, 7, 18, 8, -26 },
  { 2957, 17, 18, 18, 1, -18 },
  { 2996, 16, 26, 18, 1, -26 },
  { 3048, 17, 18, 18, 1, -18 },
  { 3087, 19, 26, 18, 1, -26 },
  { 3149, 16, 18, 18, 1, -18 },
  { 3185, 23, 32, 18, -2, -26 },
  { 3277, 19, 24, 18, -1, -18 },
  { 3334, 17, 26, 18, 0, -26 },
  { 3390, 12, 26, 18, 3, -26 },
  { 3429, 18, 32, 18, -1, -26 },
  { 3501, 18, 26, 18, 1, -26 },
  { 3560, 10, 25, 18, 5, -25 },
  { 3592, 18, 18, 18, 0, -18 },
  { 3633, 16, 18, 18, 1, -18 },
  { 3669, 16, 18, 18, 1, -18 },
  { 3705, 18, 24, 18, -1, -18 },
  { 3759, 17, 24, 18, 1, -18 },
  { 3810, 16, 18, 18, 2, -18 },
  { 3846, 16, 18, 18, 1, -18 },
  { 3882, 15, 22, 18, 3, -22 },
  { 3924, 16, 17, 18, 2, -17 },
  { 3958, 16, 17, 18, 3, -17 },
  { 3992, 19, 17, 18, 1, -17 },
  { 4033, 20, 17, 18, -1, -17 },
  { 4076, 21, 23, 18, -2, -17 },
  { 4137, 17, 17, 18, 1, -17 },
  { 4174, 18, 32, 18, 2, -26 },
  { 4246, 11, 32, 18, 4, -26 },
  { 4290, 17, 32, 18, -1, -26 },
  { 4358, 17, 6, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic33pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC33PT7B_H_
