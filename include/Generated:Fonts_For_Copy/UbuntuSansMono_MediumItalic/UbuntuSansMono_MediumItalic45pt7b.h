#ifndef _UBUNTUSANSMONO_MEDIUMITALIC45PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x04, 0x00, 0x3E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0x00, 0x07, 0x83, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x80, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1E, 0x03, 0xE0,
  0x04, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x20, 0x01, 0xF0, 0x38, 0x07, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x02, 0x01, 0xFC, 0x00, 0x78,
  0x07, 0xFC, 0x01, 0xE0, 0x0F, 0x78, 0x07, 0x80, 0x3C, 0x78, 0x0F, 0x00,
  0x70, 0xF0, 0x3C, 0x00, 0xE1, 0xE0, 0xF0, 0x03, 0xC3, 0x83, 0xC0, 0x07,
  0x87, 0x0F, 0x00, 0x0E, 0x0E, 0x3C, 0x00, 0x1C, 0x3C, 0xF8, 0x00, 0x3C,
  0x71, 0xE0, 0x00, 0x7B, 0xE7, 0x80, 0x00, 0x7F, 0x9E, 0x00, 0x00, 0xFE,
  0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x03, 0xCF,
  0x3C, 0x00, 0x0F, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x70, 0x00, 0xF8, 0xE0,
  0xE0, 0x01, 0xE1, 0xC3, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x1E, 0x0F, 0x0F,
  0x00, 0x78, 0x1E, 0x1C, 0x01, 0xE0, 0x1C, 0x78, 0x07, 0x80, 0x3D, 0xE0,
  0x0F, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x7C, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3E,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x1D, 0x07, 0xF8,
  0x3C, 0x1F, 0xF8, 0x78, 0x7D, 0xF0, 0xF1, 0xF1, 0xF3, 0xC7, 0xC3, 0xE7,
  0x8F, 0x03, 0xFE, 0x3E, 0x03, 0xFC, 0x7C, 0x07, 0xF0, 0xF0, 0x07, 0xE1,
  0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x87, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xBE, 0x0F, 0xFE, 0x3C, 0x0F, 0xF0, 0x7C, 0x3E, 0x7D, 0xFB, 0xE7,
  0xCF, 0x9F, 0x7C, 0xF9, 0xF3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x40, 0xF0, 0x47, 0x8F, 0x1E, 0x7C,
  0xE7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFC, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xBC, 0x00, 0xFB, 0xF0, 0x1F, 0x9F, 0x03, 0xF1, 0xF8,
  0x1F, 0x0F, 0x80, 0xE0, 0xE0, 0x04, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x7E,
  0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0xE0, 0x3C,
  0x07, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xE7,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF0, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE,
  0x7C, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xDF, 0xC0, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0x87, 0x87,
  0x9F, 0x1F, 0x0F, 0x3E, 0x3F, 0x3E, 0x7C, 0x7C, 0x7C, 0xF0, 0xF8, 0xFB,
  0xE1, 0xE1, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0,
  0x3F, 0x03, 0xE0, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xCF, 0x80, 0xE1, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFD, 0xFE,
  0x03, 0xC0, 0x3E, 0x01, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0xFF,
  0x00, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x30, 0x03, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E,
  0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x03, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFC, 0x03, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E,
  0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE4, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0x0F, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xFC, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7E, 0x3F, 0x81, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8,
  0xFE, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7E, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0xC3, 0xF8,
  0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x18, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x06, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x1F, 0xC4, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xC1, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x0F,
  0x80, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x7F, 0xE3, 0xC0, 0xFF, 0xF3,
  0xE0, 0xFF, 0xF9, 0xE0, 0xFF, 0xF8, 0xF0, 0xFC, 0x3C, 0xF8, 0xFC, 0x3E,
  0x7C, 0x7C, 0x1F, 0x3C, 0x3C, 0x0F, 0x1E, 0x3E, 0x07, 0x8F, 0x1F, 0x07,
  0xC7, 0x8F, 0x03, 0xE7, 0xC7, 0x81, 0xE3, 0xE3, 0xC0, 0xF1, 0xF1, 0xE0,
  0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3C, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F,
  0xFF, 0x07, 0x83, 0xFF, 0x83, 0xC0, 0x7F, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x20, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x1E,
  0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1F, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x3C, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x7F,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x0C, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x40, 0x7E, 0x01,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3E, 0x01,
  0xFC, 0x1F, 0x01, 0xFC, 0x0F, 0x83, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x7E, 0x03, 0xF0, 0x06,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x7E, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x10, 0x03, 0xF0, 0x1E, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x01,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x1D, 0xC1, 0xDE, 0x03, 0xDC, 0x3D, 0xC0, 0x3D, 0xC3,
  0xBC, 0x03, 0xDE, 0x7B, 0xC0, 0x79, 0xE7, 0x3C, 0x07, 0x9E, 0xF3, 0xC0,
  0x79, 0xEE, 0x7C, 0x0F, 0x8F, 0xC7, 0x80, 0xF0, 0xFC, 0x78, 0x0F, 0x0F,
  0x87, 0x80, 0xF0, 0xF8, 0x78, 0x1F, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0xF0,
  0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF8,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xE0,
  0x0F, 0x81, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x3C, 0x07, 0xF8, 0x07, 0x80,
  0xFF, 0x01, 0xF0, 0x3F, 0xE0, 0x3E, 0x07, 0xFC, 0x07, 0x80, 0xF3, 0xC0,
  0xF0, 0x1E, 0x78, 0x3E, 0x03, 0xCF, 0x07, 0xC0, 0xF8, 0xF0, 0xF0, 0x1E,
  0x1E, 0x1E, 0x03, 0xC3, 0xC7, 0xC0, 0x78, 0x78, 0xF8, 0x1F, 0x07, 0x1E,
  0x03, 0xE0, 0xF3, 0xC0, 0x78, 0x1E, 0xF8, 0x0F, 0x03, 0xDF, 0x03, 0xE0,
  0x7B, 0xC0, 0x7C, 0x07, 0x78, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0,
  0x7C, 0x03, 0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xE0, 0x07, 0xE0, 0x3C, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xDF, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F,
  0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0,
  0x3E, 0x01, 0xFC, 0x0F, 0x8F, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F,
  0x83, 0xE0, 0x7E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x1F, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0x00, 0x7E,
  0x00, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x0F, 0x80, 0xE0, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E,
  0x00, 0x78, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8,
  0x1E, 0x00, 0x0F, 0x81, 0xE1, 0xE0, 0xF0, 0x1E, 0x1E, 0x0F, 0x03, 0xE3,
  0xE1, 0xF0, 0x3C, 0x3F, 0x1E, 0x03, 0xC7, 0xF1, 0xE0, 0x3C, 0x7F, 0x1E,
  0x03, 0xCF, 0x73, 0xC0, 0x38, 0xE7, 0x3C, 0x07, 0x9C, 0x73, 0xC0, 0x7B,
  0xC7, 0x3C, 0x07, 0xB8, 0x77, 0x80, 0x7F, 0x87, 0x78, 0x07, 0x70, 0x77,
  0x80, 0x7F, 0x07, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x80,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3C, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0,
  0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0xF9, 0xF8,
  0x03, 0xEF, 0xC0, 0x0F, 0x9E, 0x00, 0x1F, 0x10, 0x00, 0x60, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0x18,
  0x1E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x03, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xF0, 0x78, 0x7F,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF1, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3F, 0x03, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xBE,
  0x07, 0xFC, 0x78, 0x01, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF3, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFC, 0x7F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0x7C,
  0x03, 0xF1, 0xF0, 0x1F, 0xC7, 0xC1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8, 0x38, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x30, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0xF8, 0x1F, 0xC0, 0x78, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x7C, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xE0,
  0xFC, 0x7E, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFD,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x10, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFE, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x3F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00,
  0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x00, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC1, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x02, 0x00, 0xFC, 0x01,
  0xC0, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x10, 0x7E, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xF0,
  0x07, 0xC3, 0xF0, 0x03, 0xE7, 0xF0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x81, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF0, 0x06, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0xFF, 0xDF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0x87, 0xC7, 0xC1, 0xE1, 0xE1,
  0xF0, 0x78, 0x78, 0x78, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC3,
  0xC3, 0xE0, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x07,
  0x87, 0xC7, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xE3,
  0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F,
  0x8F, 0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x7F, 0x03, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xC3, 0xF8, 0x0F, 0x87,
  0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x0F,
  0x87, 0xE0, 0x7E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x01, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xF0,
  0x38, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x0C, 0x01, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x02, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x01, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3E, 0x00, 0x40, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xF3, 0xC1, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0xF8, 0x7C,
  0x78, 0x7C, 0x3C, 0x7C, 0x7E, 0x1E, 0x3C, 0x3F, 0x1E, 0x1E, 0x3F, 0x8F,
  0x0F, 0x1D, 0xE7, 0x87, 0x9E, 0xF7, 0x83, 0xDE, 0x7B, 0xC1, 0xEE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x40, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x0C,
  0x1F, 0xF0, 0x3C, 0x7F, 0xF0, 0xF9, 0xFF, 0xFF, 0xE7, 0xC7, 0xFF, 0xCF,
  0x07, 0xFF, 0x3C, 0x03, 0xFC, 0x08, 0x01, 0xE0,
};

const GFXglyph UbuntuSansMono_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 13, 32, 25, 7, -31 },
  { 53, 16, 13, 25, 9, -34 },
  { 79, 27, 31, 25, 0, -31 },
  { 184, 24, 40, 25, 1, -35 },
  { 304, 31, 33, 25, -2, -32 },
  { 432, 23, 32, 25, 1, -32 },
  { 524, 7, 14, 25, 13, -34 },
  { 537, 20, 44, 25, 5, -36 },
  { 647, 19, 44, 25, 1, -36 },
  { 752, 20, 19, 25, 5, -31 },
  { 800, 22, 22, 25, 2, -24 },
  { 861, 12, 15, 25, 3, -8 },
  { 884, 14, 5, 25, 6, -15 },
  { 893, 8, 9, 25, 7, -8 },
  { 902, 30, 43, 25, -3, -35 },
  { 1064, 23, 33, 25, 2, -32 },
  { 1159, 19, 31, 25, 2, -31 },
  { 1233, 24, 32, 25, 1, -32 },
  { 1329, 24, 33, 25, 0, -32 },
  { 1428, 25, 31, 25, 0, -31 },
  { 1525, 26, 32, 25, 0, -31 },
  { 1629, 23, 32, 25, 3, -31 },
  { 1721, 23, 31, 25, 5, -31 },
  { 1811, 23, 33, 25, 2, -32 },
  { 1906, 24, 32, 25, 1, -32 },
  { 2002, 11, 25, 25, 7, -24 },
  { 2037, 15, 31, 25, 3, -24 },
  { 2096, 23, 20, 25, 2, -23 },
  { 2154, 24, 14, 25, 1, -20 },
  { 2196, 22, 20, 25, 1, -23 },
  { 2251, 18, 33, 25, 6, -32 },
  { 2326, 25, 39, 25, 1, -32 },
  { 2448, 24, 31, 25, -2, -31 },
  { 2541, 25, 32, 25, 0, -32 },
  { 2641, 24, 33, 25, 3, -32 },
  { 2740, 25, 32, 25, 0, -32 },
  { 2840, 26, 31, 25, 1, -31 },
  { 2941, 26, 31, 25, 1, -31 },
  { 3042, 24, 33, 25, 2, -32 },
  { 3141, 27, 31, 25, 0, -31 },
  { 3246, 25, 31, 25, 1, -31 },
  { 3343, 25, 32, 25, 1, -31 },
  { 3443, 28, 31, 25, 0, -31 },
  { 3552, 19, 31, 25, 1, -31 },
  { 3626, 28, 31, 25, -1, -31 },
  { 3735, 27, 31, 25, 0, -31 },
  { 3840, 23, 33, 25, 2, -32 },
  { 3935, 26, 32, 25, 0, -32 },
  { 4039, 23, 40, 25, 2, -32 },
  { 4154, 25, 32, 25, 0, -32 },
  { 4254, 26, 33, 25, 0, -32 },
  { 4362, 23, 31, 25, 5, -31 },
  { 4452, 25, 32, 25, 2, -31 },
  { 4552, 24, 31, 25, 5, -31 },
  { 4645, 28, 31, 25, 1, -31 },
  { 4754, 31, 31, 25, -2, -31 },
  { 4875, 24, 31, 25, 5, -31 },
  { 4968, 27, 31, 25, 0, -31 },
  { 5073, 23, 43, 25, 3, -35 },
  { 5197, 9, 43, 25, 9, -35 },
  { 5246, 24, 43, 25, -1, -35 },
  { 5375, 22, 17, 25, 3, -31 },
  { 5422, 23, 4, 25, -3, 4 },
  { 5434, 9, 9, 25, 11, -35 },
  { 5445, 22, 25, 25, 2, -24 },
  { 5514, 22, 36, 25, 1, -35 },
  { 5613, 22, 25, 25, 2, -24 },
  { 5682, 25, 36, 25, 2, -35 },
  { 5795, 22, 25, 25, 2, -24 },
  { 5864, 30, 43, 25, -2, -35 },
  { 6026, 26, 32, 25, -1, -24 },
  { 6130, 23, 35, 25, 0, -35 },
  { 6231, 16, 35, 25, 4, -35 },
  { 6301, 25, 44, 25, -1, -35 },
  { 6439, 25, 35, 25, 1, -35 },
  { 6549, 15, 36, 25, 6, -35 },
  { 6617, 26, 24, 25, -1, -24 },
  { 6695, 22, 24, 25, 1, -24 },
  { 6761, 22, 25, 25, 2, -24 },
  { 6830, 25, 32, 25, -1, -24 },
  { 6930, 23, 32, 25, 2, -24 },
  { 7022, 23, 24, 25, 2, -24 },
  { 7091, 22, 25, 25, 1, -24 },
  { 7160, 20, 32, 25, 4, -31 },
  { 7240, 22, 24, 25, 2, -23 },
  { 7306, 21, 23, 25, 4, -23 },
  { 7367, 25, 23, 25, 2, -23 },
  { 7439, 27, 23, 25, -1, -23 },
  { 7517, 28, 31, 25, -3, -23 },
  { 7626, 23, 23, 25, 1, -23 },
  { 7693, 24, 43, 25, 3, -35 },
  { 7822, 16, 43, 25, 5, -35 },
  { 7908, 24, 43, 25, -2, -35 },
  { 8037, 23, 8, 25, 1, -17 },
};

const GFXfont UbuntuSansMono_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC45PT7B_H_
