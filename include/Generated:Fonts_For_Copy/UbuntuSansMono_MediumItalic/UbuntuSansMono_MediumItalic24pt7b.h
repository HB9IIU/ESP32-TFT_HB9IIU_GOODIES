#ifndef _UBUNTUSANSMONO_MEDIUMITALIC24PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0x8E, 0x30, 0xC7, 0x00, 0x01, 0x0E,
  0x38, 0xE0, 0x67, 0xE7, 0xE6, 0xC6, 0xC6, 0xC4, 0x8C, 0x01, 0x8C, 0x0E,
  0x70, 0x31, 0x80, 0xC6, 0x07, 0x38, 0xFF, 0xF3, 0xFF, 0xC3, 0x18, 0x0C,
  0xE0, 0x63, 0x01, 0x8C, 0x3F, 0xFE, 0xFF, 0xF1, 0xCE, 0x06, 0x30, 0x18,
  0xC0, 0xC6, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x7E, 0x1F, 0xF1, 0xC3,
  0x38, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x0E,
  0x00, 0xE8, 0x1C, 0xFF, 0xCF, 0xF8, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x07, 0x03, 0x0F, 0x86, 0x19, 0x8C, 0x19, 0x8C, 0x11, 0x98, 0x13, 0x30,
  0x1F, 0x60, 0x1E, 0xC0, 0x01, 0x80, 0x03, 0xB8, 0x03, 0x7C, 0x06, 0xCC,
  0x0C, 0xCC, 0x18, 0xCC, 0x30, 0x98, 0x70, 0xD8, 0xE0, 0xF0, 0x03, 0xC0,
  0x3F, 0x03, 0x9C, 0x18, 0xE1, 0xC6, 0x0E, 0x70, 0x37, 0x01, 0xF0, 0x1E,
  0x39, 0xF9, 0x9C, 0xEC, 0xC3, 0xCE, 0x1E, 0x70, 0x63, 0x87, 0x8F, 0xEC,
  0x3E, 0x70, 0x76, 0xEE, 0xEC, 0xC0, 0x00, 0x80, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x40,
  0x02, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x18, 0x02, 0x00, 0x0C, 0x03, 0x00,
  0xC3, 0x33, 0xFF, 0xFF, 0xE1, 0xE0, 0xFC, 0x73, 0x8C, 0xC2, 0x20, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x0F, 0xFF, 0xFF, 0xE0, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0xF3, 0xCF, 0x18, 0xEF, 0x30, 0x7F,
  0xFC, 0xEF, 0xFE, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0xFE, 0x1E, 0x73, 0x87, 0x38, 0x37, 0x03, 0x70, 0x36, 0x77, 0x67,
  0x7E, 0x67, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0x87, 0xF8, 0x3E,
  0x00, 0x00, 0xC0, 0x70, 0x7C, 0x7F, 0x3D, 0x84, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE1, 0xFF, 0xFF, 0xC0, 0x07,
  0xC1, 0xFE, 0x1C, 0xF1, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x03, 0xE0, 0x7F, 0x83, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0xFC, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x31,
  0x07, 0x8F, 0xF8, 0xFF, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x3B, 0x03, 0xB8, 0x39, 0xC3, 0x8C, 0x38, 0x61, 0x87, 0x18, 0x38, 0xFF,
  0xEF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x03, 0xFC, 0x1F,
  0xF0, 0x7F, 0x81, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xE0, 0x1F,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x84, 0x1E, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x38, 0x0F, 0xC1, 0xFC, 0x1E, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0xE3, 0x07, 0x38, 0x19, 0xC0, 0xCE, 0x06,
  0x70, 0x71, 0xC7, 0x0F, 0xF8, 0x3F, 0x00, 0x3F, 0xF9, 0xFF, 0xDF, 0xFC,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0xFF, 0x1C, 0x71, 0x83, 0x38, 0x33, 0x83, 0x38, 0x71, 0xFE, 0x1F,
  0x83, 0xBC, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCF, 0xFC, 0x3F,
  0x00, 0x07, 0xC1, 0xFE, 0x3C, 0x73, 0x87, 0x30, 0x37, 0x03, 0x70, 0x37,
  0x07, 0x3F, 0xF3, 0xFF, 0x0C, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0x0F,
  0xE0, 0xF8, 0x00, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0xE3, 0xCF, 0x38,
  0x0E, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x3C, 0x3C,
  0x18, 0x38, 0xF0, 0xC0, 0x00, 0x30, 0x1F, 0x0F, 0xE3, 0xF0, 0xF8, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1C, 0x00, 0x40, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE, 0x30, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x1E, 0x0F, 0xC3, 0xF0, 0xF8, 0x0E,
  0x00, 0x80, 0x00, 0x1F, 0x0F, 0xF2, 0x3C, 0x07, 0x01, 0xC0, 0x60, 0x78,
  0x3C, 0x1C, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x08, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0xE0, 0x7F, 0x87, 0x8E, 0x70, 0x33, 0x01, 0xB8, 0x7D, 0x8F,
  0xEC, 0xF6, 0xEE, 0x36, 0x71, 0xB3, 0x1D, 0x98, 0xEC, 0xC6, 0x67, 0x33,
  0x3F, 0x98, 0x78, 0xE0, 0x03, 0x00, 0x1F, 0x60, 0x7E, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0x60, 0x3B, 0x01, 0x98, 0x18, 0xC0,
  0xC6, 0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x7F, 0xF3, 0xFF, 0xB8, 0x1D, 0xC0,
  0xFC, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x7F, 0x83, 0xBE, 0x38, 0x71, 0xC1,
  0x8C, 0x1C, 0x61, 0xC7, 0xFC, 0x3F, 0xE1, 0x8F, 0x8C, 0x1C, 0xE0, 0x67,
  0x07, 0x38, 0x39, 0x87, 0x9F, 0xF8, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0xC3,
  0xCE, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC1, 0x0F, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x07, 0xFC, 0x38, 0x71, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x39, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x30, 0x73, 0x8F,
  0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xC1, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x87, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xC7, 0xCC, 0x38, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x17, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0x61, 0xC3, 0x0F, 0xF8, 0x3F, 0xC0, 0x0E, 0x0E, 0x18, 0x18, 0x70, 0x70,
  0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x0E, 0x0E, 0x1F, 0xFC, 0x3F, 0xF8, 0x60,
  0x61, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0C, 0x0C, 0x38, 0x18, 0x70, 0x70,
  0xE0, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x86, 0x1C, 0x3F, 0xF0,
  0x3F, 0x00, 0x0E, 0x0E, 0x18, 0x38, 0x30, 0xE0, 0xE3, 0x81, 0xCE, 0x03,
  0x38, 0x06, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0xCE, 0x03, 0x9C,
  0x07, 0x1C, 0x0E, 0x38, 0x18, 0x38, 0x70, 0x70, 0xE0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x06,
  0x0E, 0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xF3, 0x61, 0xE7, 0x86, 0xDB, 0x0C,
  0xB6, 0x19, 0xCC, 0x73, 0x98, 0xC6, 0x71, 0x80, 0xC3, 0x01, 0x8E, 0x03,
  0x18, 0x0E, 0x30, 0x1C, 0xE0, 0x30, 0x0C, 0x0E, 0x1C, 0x18, 0x78, 0x30,
  0xF0, 0xE1, 0xF1, 0xC3, 0x63, 0x0E, 0xC6, 0x1D, 0x8C, 0x33, 0xB8, 0x63,
  0x61, 0xC6, 0xC3, 0x8D, 0x86, 0x1F, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0x70,
  0xC0, 0xE0, 0x03, 0xC0, 0x7F, 0x07, 0x9C, 0x70, 0x63, 0x83, 0x38, 0x1D,
  0xC0, 0xCC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x70,
  0x63, 0x8F, 0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0x87,
  0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x86, 0x0E, 0x38, 0xF0, 0xFF, 0x83,
  0xF8, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x7F, 0x07, 0x9C, 0x70, 0x63, 0x83, 0x38, 0x1D, 0xC0, 0xCC,
  0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x63, 0x8F,
  0x0F, 0xF0, 0x3F, 0x00, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x7F, 0x83, 0x1E, 0x38, 0x71, 0xC1, 0x8C, 0x1C, 0x60, 0xE7, 0x0E,
  0x3F, 0xF1, 0xFE, 0x0F, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0x61, 0x83, 0x9C,
  0x1C, 0xE0, 0x60, 0x03, 0xF0, 0x1F, 0xF0, 0xF1, 0x87, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x86, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x18,
  0x1C, 0x60, 0x63, 0x83, 0x8E, 0x0E, 0x30, 0x38, 0xC0, 0xC7, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x0E,
  0x1C, 0x1F, 0xE0, 0x7F, 0x00, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0E, 0xC0,
  0xEC, 0x1C, 0xC1, 0xCC, 0x38, 0xE3, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x70, 0x00, 0x1C, 0x06, 0x38, 0x1C, 0x60,
  0x38, 0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x66, 0x19, 0xCC, 0x33, 0x98,
  0xEF, 0x71, 0xB6, 0xC3, 0x6D, 0x87, 0x9B, 0x0F, 0x3C, 0x1C, 0x38, 0x38,
  0x70, 0xE0, 0xC0, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x03, 0x1C, 0x03,
  0xB8, 0x03, 0xB0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x0E, 0x70, 0x1C, 0x70, 0x38, 0x30, 0x70, 0x30, 0xF0,
  0x38, 0xE0, 0x3F, 0x03, 0xB8, 0x39, 0xC1, 0xC6, 0x1C, 0x31, 0xC1, 0xCE,
  0x0E, 0xE0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07,
  0xF0, 0x7F, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xCC, 0xEE,
  0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x77, 0x77, 0x77, 0x73, 0x30, 0x07, 0xF0,
  0x7F, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0x00, 0xF0,
  0x3E, 0x06, 0xC1, 0xDC, 0x73, 0x9C, 0x37, 0x07, 0xC0, 0xE8, 0x10, 0x7F,
  0xFF, 0xFF, 0x80, 0x46, 0x38, 0xF1, 0x00, 0x03, 0xE1, 0xFF, 0x3E, 0xF7,
  0x86, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF,
  0xFC, 0x7E, 0xC0, 0x01, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x77, 0x03, 0xFE, 0x1E, 0xF0, 0xC1, 0x8E, 0x0E, 0x70, 0x73, 0x83,
  0x18, 0x39, 0xC1, 0xCE, 0x1C, 0x71, 0xE3, 0xFE, 0x3F, 0xC0, 0x03, 0xE1,
  0xFF, 0x3F, 0x67, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x47, 0xFC, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xF0, 0xE1, 0x87,
  0x06, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x0E, 0x0C, 0x38, 0x70, 0xE1, 0xC1,
  0xFF, 0x07, 0xEE, 0x00, 0x07, 0x81, 0xFE, 0x3C, 0xF7, 0x07, 0x70, 0x7E,
  0x0E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xF0, 0x47, 0xFC, 0x3F, 0xC0,
  0x00, 0x0E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x40, 0x00,
  0x00, 0xF8, 0x0F, 0xF0, 0x79, 0xC3, 0x87, 0x1C, 0x18, 0x60, 0xE3, 0x83,
  0x8E, 0x0E, 0x38, 0x30, 0xE1, 0xC1, 0xFF, 0x07, 0xFC, 0x00, 0x60, 0x03,
  0x84, 0x0E, 0x1F, 0xF0, 0xFF, 0x80, 0x20, 0x00, 0x02, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1F, 0x81, 0xFE, 0x1F, 0xF3, 0x87, 0x38,
  0x73, 0x87, 0x30, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xE6, 0x0C, 0xE1,
  0xC0, 0x02, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0xFE, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x3C, 0x0F, 0xC3, 0xE0, 0x00,
  0x10, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x43, 0x81,
  0xFE, 0x0F, 0xF0, 0x02, 0x00, 0x02, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0xE7, 0x0E, 0x38, 0xE1, 0xDE, 0x0D, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0x9C, 0x1C, 0x70, 0xE3, 0x87, 0x0E, 0x30, 0x70,
  0x7E, 0x7E, 0xFE, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x71, 0x7F, 0x3F, 0x0E, 0x71, 0xFF, 0xCE, 0xEE,
  0x67, 0x33, 0x31, 0x99, 0x9D, 0xCC, 0xCC, 0xE6, 0x60, 0x33, 0x03, 0xB8,
  0x19, 0x80, 0xCC, 0x06, 0x00, 0x07, 0xC1, 0xFF, 0x1F, 0xF1, 0x87, 0x18,
  0x33, 0x87, 0x38, 0x73, 0x07, 0x30, 0x67, 0x06, 0x70, 0xE7, 0x0E, 0xE0,
  0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x06, 0x70, 0x7E, 0x07, 0xE0, 0x6E,
  0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x3F,
  0xE0, 0xE7, 0x83, 0x06, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0x86, 0x0E, 0x38,
  0x38, 0xE1, 0xC3, 0x8F, 0x0F, 0xF8, 0x7F, 0x81, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0xFF, 0x3F, 0x73, 0x87, 0x70, 0x66, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xC7, 0xFC, 0x3F, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x03, 0xF1, 0xFF, 0x1F, 0xE3, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x00, 0x07, 0xC3, 0xFC, 0x73, 0x9C, 0x03, 0x80, 0x78, 0x07, 0xE0, 0x3E,
  0x01, 0xC0, 0x39, 0x07, 0x7F, 0xCF, 0xF0, 0x0E, 0x01, 0xC0, 0x30, 0x3F,
  0xF7, 0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xF1, 0x0F, 0xE0, 0xFC, 0x38, 0x73, 0x07, 0x30, 0x67, 0x06, 0x70,
  0xE7, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE3, 0xC7, 0xFC, 0x7E,
  0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0C, 0x61, 0xC6, 0x18, 0x63, 0x87,
  0x70, 0x77, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x38, 0x00, 0x60, 0x1D, 0x80,
  0x66, 0x03, 0x98, 0xCE, 0xE7, 0x33, 0x9C, 0xCC, 0xF6, 0x36, 0xD8, 0xDB,
  0x63, 0xCF, 0x0F, 0x3C, 0x38, 0xE0, 0xC3, 0x80, 0x1C, 0x0E, 0x1C, 0x38,
  0x38, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x1D, 0xC0, 0x71, 0x81, 0xC3, 0x8F, 0x07, 0x00, 0x0E, 0x07, 0x0E,
  0x0E, 0x06, 0x0E, 0x06, 0x0C, 0x06, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07,
  0x38, 0x07, 0x30, 0x03, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0xFF,
  0xC7, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x0F,
  0x00, 0xF0, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0xF0, 0x3E, 0x00, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xF0, 0x0F, 0x80, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x7F, 0x03, 0xF0, 0x00, 0x3C, 0x37, 0xF7, 0xE7, 0xEC,
  0x3C,
};

const GFXglyph UbuntuSansMono_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 17, 13, 4, -17 },
  { 14, 8, 7, 13, 5, -18 },
  { 21, 14, 17, 13, 0, -17 },
  { 51, 12, 22, 13, 1, -19 },
  { 84, 16, 17, 13, -1, -17 },
  { 118, 13, 17, 13, 0, -17 },
  { 146, 4, 7, 13, 7, -18 },
  { 150, 10, 24, 13, 3, -19 },
  { 180, 11, 24, 13, 0, -19 },
  { 213, 10, 11, 13, 3, -17 },
  { 227, 12, 12, 13, 1, -13 },
  { 245, 6, 8, 13, 2, -4 },
  { 251, 7, 2, 13, 3, -8 },
  { 253, 4, 4, 13, 4, -4 },
  { 255, 15, 23, 13, -1, -19 },
  { 299, 12, 17, 13, 1, -17 },
  { 325, 10, 17, 13, 1, -17 },
  { 347, 12, 17, 13, 1, -17 },
  { 373, 13, 17, 13, 0, -17 },
  { 401, 13, 17, 13, 0, -17 },
  { 429, 14, 17, 13, 0, -17 },
  { 459, 13, 17, 13, 1, -17 },
  { 487, 13, 17, 13, 2, -17 },
  { 515, 12, 17, 13, 1, -17 },
  { 541, 12, 17, 13, 1, -17 },
  { 567, 6, 12, 13, 4, -12 },
  { 576, 8, 16, 13, 2, -12 },
  { 592, 12, 11, 13, 1, -12 },
  { 609, 13, 8, 13, 0, -11 },
  { 622, 12, 11, 13, 1, -12 },
  { 639, 10, 17, 13, 3, -17 },
  { 661, 13, 21, 13, 1, -17 },
  { 696, 13, 17, 13, -1, -17 },
  { 724, 13, 17, 13, 0, -17 },
  { 752, 13, 17, 13, 1, -17 },
  { 780, 13, 17, 13, 0, -17 },
  { 808, 13, 17, 13, 1, -17 },
  { 836, 14, 17, 13, 1, -17 },
  { 866, 13, 17, 13, 1, -17 },
  { 894, 15, 17, 13, 0, -17 },
  { 926, 14, 17, 13, 0, -17 },
  { 956, 14, 17, 13, 0, -17 },
  { 986, 15, 17, 13, 0, -17 },
  { 1018, 11, 17, 13, 0, -17 },
  { 1042, 15, 17, 13, -1, -17 },
  { 1074, 15, 17, 13, 0, -17 },
  { 1106, 13, 17, 13, 1, -17 },
  { 1134, 14, 17, 13, 0, -17 },
  { 1164, 13, 21, 13, 1, -17 },
  { 1199, 13, 17, 13, 0, -17 },
  { 1227, 14, 17, 13, 0, -17 },
  { 1257, 12, 17, 13, 3, -17 },
  { 1283, 14, 17, 13, 1, -17 },
  { 1313, 12, 17, 13, 3, -17 },
  { 1339, 15, 17, 13, 0, -17 },
  { 1371, 16, 17, 13, -1, -17 },
  { 1405, 13, 17, 13, 3, -17 },
  { 1433, 14, 17, 13, 0, -17 },
  { 1463, 12, 23, 13, 2, -19 },
  { 1498, 4, 23, 13, 5, -19 },
  { 1510, 12, 23, 13, 0, -19 },
  { 1545, 11, 10, 13, 2, -17 },
  { 1559, 13, 2, 13, -2, 2 },
  { 1563, 5, 5, 13, 6, -19 },
  { 1567, 12, 13, 13, 1, -13 },
  { 1587, 13, 19, 13, 0, -19 },
  { 1618, 12, 13, 13, 1, -13 },
  { 1638, 14, 19, 13, 1, -19 },
  { 1672, 12, 13, 13, 1, -13 },
  { 1692, 16, 24, 13, -1, -19 },
  { 1740, 14, 18, 13, -1, -13 },
  { 1772, 12, 19, 13, 0, -19 },
  { 1801, 9, 19, 13, 2, -19 },
  { 1823, 14, 24, 13, -1, -19 },
  { 1865, 13, 19, 13, 1, -19 },
  { 1896, 8, 19, 13, 3, -19 },
  { 1915, 13, 13, 13, 0, -13 },
  { 1937, 12, 13, 13, 0, -13 },
  { 1957, 12, 13, 13, 1, -13 },
  { 1977, 14, 17, 13, -1, -13 },
  { 2007, 12, 17, 13, 1, -13 },
  { 2033, 12, 13, 13, 1, -13 },
  { 2053, 11, 13, 13, 1, -13 },
  { 2071, 11, 16, 13, 2, -16 },
  { 2093, 12, 13, 13, 1, -13 },
  { 2113, 12, 13, 13, 2, -13 },
  { 2133, 14, 13, 13, 1, -13 },
  { 2156, 15, 13, 13, -1, -13 },
  { 2181, 16, 18, 13, -2, -13 },
  { 2217, 13, 13, 13, 0, -13 },
  { 2239, 12, 23, 13, 2, -19 },
  { 2274, 8, 23, 13, 3, -19 },
  { 2297, 13, 23, 13, -1, -19 },
  { 2335, 12, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC24PT7B_H_
