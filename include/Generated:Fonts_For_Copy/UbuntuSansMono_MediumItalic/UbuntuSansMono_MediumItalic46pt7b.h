#ifndef _UBUNTUSANSMONO_MEDIUMITALIC46PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x10, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C,
  0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8,
  0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x01,
  0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80, 0x03,
  0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x00, 0xFC, 0x01, 0x80, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0x00, 0x0F, 0xC0, 0xF0, 0x1F, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xC0,
  0x1C, 0x78, 0x0F, 0x00, 0x78, 0xF0, 0x1E, 0x00, 0xE1, 0xE0, 0x78, 0x03,
  0xC3, 0xC1, 0xE0, 0x07, 0x87, 0x87, 0x80, 0x0F, 0x0E, 0x1E, 0x00, 0x1E,
  0x1C, 0x78, 0x00, 0x3C, 0x79, 0xF0, 0x00, 0x79, 0xE3, 0xC0, 0x00, 0xFF,
  0xCF, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0x79,
  0xFE, 0x00, 0x01, 0xE7, 0xFC, 0x00, 0x07, 0x9E, 0x38, 0x00, 0x1E, 0x3C,
  0x78, 0x00, 0x78, 0x70, 0xF0, 0x01, 0xF1, 0xE1, 0xE0, 0x03, 0xC3, 0xC3,
  0x80, 0x0F, 0x07, 0x07, 0x00, 0x3C, 0x0E, 0x1E, 0x00, 0xF0, 0x1C, 0x3C,
  0x03, 0xC0, 0x38, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1E, 0x00, 0xFF, 0x80,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0x80, 0x3E,
  0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x81,
  0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3E, 0x7E, 0x00, 0x7D, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C,
  0x7F, 0xF0, 0xF1, 0xF9, 0xF1, 0xE3, 0xE3, 0xE7, 0xCF, 0x83, 0xEF, 0x1E,
  0x03, 0xFE, 0x7C, 0x07, 0xF8, 0xF8, 0x07, 0xF1, 0xF0, 0x0F, 0xC3, 0xE0,
  0x1F, 0x87, 0xC0, 0x7F, 0x0F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xBE, 0x1F, 0xFC, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x0F, 0x0E, 0x7C, 0xF3,
  0xEF, 0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF0, 0xF8, 0x06, 0x06, 0x00, 0x20, 0x40, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x01, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0xFF, 0x0F, 0xE0, 0x78, 0x08,
  0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0xFF, 0xF8, 0x1C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC3, 0x87,
  0xDF, 0x8F, 0x8F, 0xBE, 0x3F, 0x1F, 0x7C, 0x7E, 0x3E, 0xF8, 0xFC, 0xF9,
  0xF1, 0xF1, 0xF7, 0xC1, 0xC3, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0,
  0x0F, 0x87, 0xE0, 0x3E, 0x07, 0xC1, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE7, 0xC0, 0x78, 0xFC, 0x06,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x3F,
  0x01, 0x80, 0x1F, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0x01, 0xF8, 0x01, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x3F,
  0x83, 0x80, 0x3F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1C, 0x03, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x7D, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x87, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03,
  0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0,
  0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0xFC, 0x03, 0xF3, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xDF, 0xE0, 0x1F, 0x07, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0x3F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0x00, 0x7C, 0x1F,
  0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x0F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x3F, 0xF7, 0xC0, 0x03, 0x87, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x78,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x18, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C,
  0x0F, 0xFF, 0x1E, 0x07, 0xFF, 0x8F, 0x83, 0xFF, 0xE3, 0xC1, 0xFF, 0xF8,
  0xF0, 0xFC, 0x3E, 0x7C, 0x3E, 0x0F, 0x1F, 0x1F, 0x03, 0xC7, 0x87, 0x81,
  0xF1, 0xE3, 0xE0, 0x7C, 0x78, 0xF8, 0x1E, 0x1E, 0x3E, 0x07, 0x8F, 0x8F,
  0x83, 0xE3, 0xE3, 0xE0, 0xF8, 0xF8, 0xF8, 0x3C, 0x3E, 0x3E, 0x0F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE1, 0xFF, 0xF0, 0x78, 0x3F, 0xF8, 0x1E, 0x07, 0xFE,
  0x07, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x1E,
  0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x03,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x07, 0xC3, 0xFE, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x70, 0x1F, 0x80, 0x08, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x08, 0x07, 0xF0, 0x1C, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3E, 0x0F, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3E, 0x01, 0xFC, 0x1F, 0x01, 0xFC,
  0x0F, 0x83, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x38, 0x1F, 0xC0, 0x08, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03,
  0x00, 0x7E, 0x01, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x01, 0xDE, 0x1D, 0xE0, 0x3D, 0xE3, 0xDE, 0x03, 0xDE,
  0x39, 0xE0, 0x3D, 0xE7, 0x9E, 0x07, 0x8E, 0x73, 0xC0, 0x78, 0xEF, 0x3C,
  0x07, 0x8E, 0xE3, 0xC0, 0xF8, 0xFE, 0x3C, 0x0F, 0x0F, 0xC7, 0xC0, 0xF0,
  0xFC, 0x78, 0x0F, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x78, 0x1E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8,
  0x01, 0xE0, 0x1F, 0x80, 0x1E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x3E,
  0x03, 0xFC, 0x03, 0xC0, 0x3F, 0xC0, 0x3C, 0x07, 0xDE, 0x07, 0xC0, 0x7D,
  0xE0, 0x7C, 0x07, 0xDE, 0x07, 0xC0, 0x79, 0xE0, 0x78, 0x07, 0x8F, 0x0F,
  0x80, 0xF8, 0xF0, 0xF8, 0x0F, 0x8F, 0x0F, 0x80, 0xF0, 0xF0, 0xF0, 0x0F,
  0x07, 0x8F, 0x01, 0xF0, 0x79, 0xF0, 0x1F, 0x07, 0x9F, 0x01, 0xE0, 0x79,
  0xE0, 0x1E, 0x03, 0x9E, 0x03, 0xE0, 0x3F, 0xE0, 0x3E, 0x03, 0xFE, 0x03,
  0xC0, 0x3F, 0xC0, 0x3C, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x01,
  0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x78, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7C,
  0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x3E,
  0x01, 0xF8, 0x1F, 0x1F, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7E, 0x00, 0xC0, 0x1F, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x80,
  0x03, 0xF0, 0x3C, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80,
  0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x1F, 0x0F, 0x81,
  0xE1, 0xF0, 0xF0, 0x3E, 0x3F, 0x0F, 0x03, 0xC3, 0xF1, 0xF0, 0x3C, 0x7F,
  0x1E, 0x03, 0xC7, 0x71, 0xE0, 0x3C, 0xF7, 0x1E, 0x03, 0xCE, 0x73, 0xE0,
  0x79, 0xE7, 0x3C, 0x07, 0xBC, 0x73, 0xC0, 0x7B, 0xC7, 0xBC, 0x07, 0xF8,
  0x7F, 0x80, 0x77, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0x3C, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE1, 0xF0,
  0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8,
  0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x38, 0x00, 0x78, 0x40, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x10, 0x0C, 0x07, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x0F, 0x87, 0xE0,
  0x1F, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x3F, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFE, 0xF0, 0x1F, 0xF1, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x1C, 0x00, 0x7D, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0x80, 0x7F, 0x1F, 0x01,
  0xFC, 0x3E, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x01,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xDF, 0x00, 0x7F, 0xC7, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0x01, 0xF1, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x61, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x41, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0x03, 0xF0, 0x3F, 0x80, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x70, 0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x18, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xC0, 0xFE, 0x0F, 0x80,
  0xFC, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0xC7, 0xE0, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC1, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0x00, 0x7E, 0x00,
  0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07,
  0xC1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFE, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7C, 0x01,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0xDF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x80, 0x40, 0x01, 0xFF, 0x3F, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xC7, 0xC7, 0xC1,
  0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x87,
  0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x01,
  0xF0, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x3F,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E,
  0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xFB,
  0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0x7E, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x83, 0xE0, 0x3F, 0x81, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0x20, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0x87, 0xF0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F,
  0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x07, 0xE0, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xC0,
  0x02, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x01, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x01, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0x00, 0x0F, 0x83,
  0x80, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x05, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0C,
  0x00, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xF8, 0xF8, 0x01, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F, 0x00, 0x7E,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7E, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x1E,
  0x07, 0x03, 0xC7, 0x83, 0xC1, 0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x7E, 0x1E,
  0x1E, 0x1F, 0x8F, 0x8F, 0x8F, 0xE3, 0xC3, 0xE3, 0xF8, 0xF0, 0xF1, 0xFE,
  0x78, 0x3C, 0x77, 0x9E, 0x0F, 0x3D, 0xE7, 0x83, 0xDE, 0x3B, 0xC0, 0xF7,
  0x8E, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x81, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x08, 0x0F, 0xF0, 0x0F, 0x1F, 0xFC, 0x1F, 0x3F, 0xFE, 0x3E, 0x3F, 0xFF,
  0xFE, 0x7C, 0x3F, 0xFC, 0x78, 0x1F, 0xF8, 0xF0, 0x07, 0xF0, 0x00, 0x01,
  0x80,
};

const GFXglyph UbuntuSansMono_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 13, 33, 26, 7, -32 },
  { 55, 16, 14, 26, 9, -35 },
  { 83, 27, 32, 26, 0, -32 },
  { 191, 25, 41, 26, 1, -36 },
  { 320, 31, 34, 26, -2, -33 },
  { 452, 23, 33, 26, 1, -33 },
  { 547, 8, 14, 26, 13, -35 },
  { 561, 20, 45, 26, 5, -36 },
  { 674, 20, 45, 26, 1, -36 },
  { 787, 20, 20, 26, 5, -32 },
  { 837, 22, 23, 26, 2, -25 },
  { 901, 12, 16, 26, 3, -8 },
  { 925, 14, 5, 26, 6, -16 },
  { 934, 8, 9, 26, 7, -8 },
  { 943, 30, 45, 26, -3, -36 },
  { 1112, 23, 34, 26, 2, -33 },
  { 1210, 20, 32, 26, 2, -32 },
  { 1290, 24, 33, 26, 1, -33 },
  { 1389, 25, 34, 26, 0, -33 },
  { 1496, 25, 32, 26, 0, -32 },
  { 1596, 27, 33, 26, 0, -32 },
  { 1708, 24, 33, 26, 3, -32 },
  { 1807, 24, 32, 26, 5, -32 },
  { 1903, 24, 34, 26, 2, -33 },
  { 2005, 25, 33, 26, 1, -33 },
  { 2109, 12, 25, 26, 7, -24 },
  { 2147, 16, 32, 26, 3, -24 },
  { 2211, 23, 21, 26, 2, -24 },
  { 2272, 24, 15, 26, 1, -21 },
  { 2317, 23, 21, 26, 1, -24 },
  { 2378, 19, 34, 26, 6, -33 },
  { 2459, 26, 40, 26, 1, -33 },
  { 2589, 24, 32, 26, -2, -32 },
  { 2685, 25, 32, 26, 0, -32 },
  { 2785, 25, 34, 26, 3, -33 },
  { 2892, 25, 32, 26, 0, -32 },
  { 2992, 26, 32, 26, 1, -32 },
  { 3096, 27, 32, 26, 1, -32 },
  { 3204, 25, 34, 26, 2, -33 },
  { 3311, 28, 32, 26, 0, -32 },
  { 3423, 26, 32, 26, 1, -32 },
  { 3527, 26, 33, 26, 1, -32 },
  { 3635, 29, 32, 26, 0, -32 },
  { 3751, 19, 32, 26, 1, -32 },
  { 3827, 28, 32, 26, -1, -32 },
  { 3939, 28, 32, 26, 0, -32 },
  { 4051, 24, 34, 26, 2, -33 },
  { 4153, 26, 32, 26, 0, -32 },
  { 4257, 24, 42, 26, 2, -33 },
  { 4383, 25, 32, 26, 0, -32 },
  { 4483, 26, 34, 26, 0, -33 },
  { 4594, 24, 32, 26, 5, -32 },
  { 4690, 26, 33, 26, 2, -32 },
  { 4798, 25, 32, 26, 5, -32 },
  { 4898, 28, 32, 26, 1, -32 },
  { 5010, 31, 32, 26, -2, -32 },
  { 5134, 24, 32, 26, 6, -32 },
  { 5230, 28, 32, 26, 0, -32 },
  { 5342, 24, 45, 26, 3, -36 },
  { 5477, 9, 45, 26, 9, -36 },
  { 5528, 24, 45, 26, -1, -36 },
  { 5663, 22, 18, 26, 3, -32 },
  { 5713, 24, 5, 26, -3, 4 },
  { 5728, 10, 10, 26, 11, -36 },
  { 5741, 23, 26, 26, 2, -25 },
  { 5816, 23, 37, 26, 1, -36 },
  { 5923, 23, 26, 26, 2, -25 },
  { 5998, 26, 37, 26, 2, -36 },
  { 6119, 22, 26, 26, 2, -25 },
  { 6191, 31, 45, 26, -2, -36 },
  { 6366, 26, 34, 26, -1, -25 },
  { 6477, 23, 36, 26, 0, -36 },
  { 6581, 17, 36, 26, 4, -36 },
  { 6658, 25, 45, 26, -1, -36 },
  { 6799, 26, 36, 26, 1, -36 },
  { 6916, 14, 36, 26, 7, -35 },
  { 6979, 26, 24, 26, -1, -24 },
  { 7057, 23, 25, 26, 1, -25 },
  { 7129, 22, 26, 26, 2, -25 },
  { 7201, 25, 34, 26, -1, -25 },
  { 7308, 23, 34, 26, 2, -25 },
  { 7406, 23, 25, 26, 2, -25 },
  { 7478, 23, 26, 26, 1, -25 },
  { 7553, 20, 32, 26, 5, -31 },
  { 7633, 23, 25, 26, 2, -24 },
  { 7705, 22, 24, 26, 4, -24 },
  { 7771, 26, 24, 26, 2, -24 },
  { 7849, 27, 24, 26, -1, -24 },
  { 7930, 29, 33, 26, -3, -24 },
  { 8050, 24, 24, 26, 1, -24 },
  { 8122, 25, 45, 26, 3, -36 },
  { 8263, 16, 45, 26, 5, -36 },
  { 8353, 25, 45, 26, -2, -36 },
  { 8494, 24, 9, 26, 1, -18 },
};

const GFXfont UbuntuSansMono_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic46pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC46PT7B_H_
