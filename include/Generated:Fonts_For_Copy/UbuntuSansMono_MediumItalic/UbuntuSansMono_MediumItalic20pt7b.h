#ifndef _UBUNTUSANSMONO_MEDIUMITALIC20PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x60, 0x00, 0x38, 0xE3, 0x80,
  0x67, 0xDF, 0x36, 0x6C, 0xD1, 0x00, 0x03, 0x30, 0x66, 0x06, 0x60, 0xC4,
  0x3F, 0xF4, 0x8C, 0x19, 0x81, 0x98, 0x33, 0x2F, 0xFC, 0x62, 0x06, 0x60,
  0x66, 0x0C, 0xC0, 0x03, 0x00, 0xC0, 0x30, 0x7F, 0x3D, 0xCC, 0x03, 0x00,
  0xE0, 0x3C, 0x03, 0xC0, 0x30, 0x0E, 0x03, 0xB1, 0xCF, 0xF0, 0xF0, 0x30,
  0x0C, 0x00, 0x0E, 0x0C, 0x68, 0x61, 0x23, 0x0C, 0x98, 0x36, 0xC0, 0xFE,
  0x01, 0x90, 0x00, 0xD8, 0x06, 0xF0, 0x36, 0xC1, 0x93, 0x0C, 0x48, 0x21,
  0x63, 0x07, 0x00, 0x07, 0x83, 0xF1, 0x8C, 0x62, 0x19, 0x86, 0xC0, 0xE0,
  0xF3, 0x66, 0xD9, 0xEC, 0x3B, 0x8E, 0x7F, 0x9F, 0x70, 0x7F, 0x6D, 0x00,
  0x01, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0E, 0x02, 0x00, 0x04,
  0x07, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x08, 0x00, 0x1C, 0x06,
  0x12, 0x5F, 0xF7, 0xF0, 0xE0, 0xD8, 0xEE, 0x22, 0x00, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0xFF, 0xFF, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x00, 0x38, 0xF3,
  0x86, 0x33, 0x80, 0xFF, 0xE0, 0xEF, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x0F, 0x87, 0xE3, 0x8D, 0xC3, 0x60, 0xD9, 0x3E,
  0xCF, 0x37, 0xC1, 0xB0, 0x6C, 0x3B, 0x1C, 0xFE, 0x1F, 0x00, 0x03, 0x07,
  0x1F, 0x3F, 0x26, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF,
  0x0F, 0xC3, 0xFC, 0x41, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xC3, 0xF8, 0x43,
  0x80, 0x30, 0x0C, 0x03, 0x83, 0xC0, 0x7C, 0x01, 0xC0, 0x18, 0x07, 0x00,
  0xC7, 0xF9, 0xFE, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0x60, 0xCC, 0x33,
  0x8C, 0x61, 0x8C, 0x61, 0x9F, 0xFB, 0xFF, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0x07, 0xF0, 0xFE, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x1F, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x7F, 0x8F, 0xE0, 0x01, 0xE0, 0xF8,
  0x78, 0x1C, 0x03, 0x00, 0xCC, 0x1F, 0xE7, 0x0C, 0xC1, 0x98, 0x33, 0x06,
  0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x0C, 0x07, 0x03,
  0x80, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x0F,
  0x87, 0xF3, 0x0C, 0xC3, 0x30, 0xCE, 0x61, 0xF0, 0xFC, 0x63, 0xB0, 0x6C,
  0x1B, 0x0E, 0xFF, 0x1F, 0x80, 0x1F, 0x8F, 0xE3, 0x0D, 0x83, 0x60, 0xD8,
  0x37, 0x1C, 0xFF, 0x1D, 0x80, 0xE0, 0x70, 0x38, 0xFC, 0x3C, 0x00, 0x39,
  0xCE, 0x00, 0x00, 0x1C, 0xF7, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x3C, 0x70, 0x61, 0x8E, 0x00, 0x00, 0xC1, 0xF3, 0xF3, 0xE0, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x07,
  0xFD, 0xFF, 0x80, 0x30, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xC3, 0xE7, 0xE3,
  0xC0, 0x40, 0x00, 0x7E, 0x7F, 0x03, 0x07, 0x06, 0x0C, 0x38, 0x30, 0x60,
  0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x0F, 0xC3, 0xF8, 0xC1, 0xB8, 0x36, 0x3F,
  0x8F, 0xB3, 0x36, 0xC6, 0xD8, 0xD3, 0x32, 0x66, 0x6F, 0xCC, 0xF9, 0x80,
  0x38, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0x60, 0x6C,
  0x19, 0x83, 0x30, 0xC7, 0x18, 0xE7, 0xFC, 0xFF, 0xB0, 0x76, 0x0F, 0x81,
  0xC0, 0x1F, 0x83, 0xFC, 0x61, 0x8C, 0x33, 0x86, 0x63, 0x8F, 0xE1, 0xFE,
  0x70, 0xCC, 0x19, 0x83, 0x30, 0xEF, 0xF9, 0xFC, 0x00, 0x07, 0xC3, 0xFC,
  0xE0, 0x98, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x1C, 0x73, 0x06,
  0x60, 0xCC, 0x1B, 0x87, 0x60, 0xCC, 0x19, 0x87, 0x71, 0xCF, 0xF1, 0xF8,
  0x00, 0x1F, 0xE3, 0xFC, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xE3, 0xF8,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xC3, 0xFC, 0xE1, 0x18, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x0E, 0xC1, 0x98, 0x33, 0x0E, 0x71, 0x87, 0xF0, 0x7E,
  0x00, 0x18, 0x31, 0x83, 0x18, 0x73, 0x86, 0x30, 0x63, 0x06, 0x3F, 0xE7,
  0xFC, 0x60, 0xC6, 0x0C, 0x61, 0xCE, 0x18, 0xC1, 0x8C, 0x18, 0x0F, 0xF1,
  0xFE, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x84,
  0x38, 0xFF, 0x07, 0xE0, 0x1C, 0x31, 0x86, 0x18, 0xC1, 0x98, 0x3B, 0x03,
  0x60, 0x3C, 0x03, 0xE0, 0x76, 0x06, 0x70, 0x63, 0x06, 0x38, 0xE1, 0x8C,
  0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x07, 0xFF, 0xFC, 0x06, 0x18, 0x71, 0xC3, 0x8E, 0x1C, 0xA1,
  0xED, 0x0D, 0x58, 0x4E, 0xC6, 0x66, 0x33, 0x21, 0x83, 0x18, 0x18, 0xC0,
  0xC6, 0x06, 0x70, 0x60, 0x18, 0x31, 0xC3, 0x1C, 0x33, 0x46, 0x36, 0x63,
  0x66, 0x36, 0x66, 0x2C, 0x62, 0xC6, 0x3C, 0x63, 0xC6, 0x38, 0xC1, 0x8C,
  0x18, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x60, 0xD8, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x6C, 0x3B, 0x0C, 0xFE, 0x1F, 0x00, 0x1F, 0xC3, 0xFC, 0x61, 0x8C,
  0x33, 0x86, 0x60, 0xCC, 0x39, 0xFE, 0x3F, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x00, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x60, 0xD8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x6C, 0x3B, 0x0C, 0xFE, 0x1F, 0x03, 0x00, 0xE0, 0x1E,
  0x01, 0x80, 0x1F, 0x83, 0xF8, 0x63, 0x8C, 0x33, 0x86, 0x61, 0xCC, 0x71,
  0xFC, 0x7F, 0x0C, 0x61, 0x8C, 0x30, 0xCE, 0x19, 0x83, 0x00, 0x07, 0xE3,
  0xFC, 0x60, 0x8C, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x38,
  0x07, 0x20, 0xC7, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x00,
  0x30, 0x66, 0x0C, 0xC3, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x77, 0x0C, 0xC1,
  0x98, 0x33, 0x0E, 0x61, 0x8F, 0xF0, 0xFC, 0x00, 0xE0, 0xFC, 0x1B, 0x83,
  0x70, 0xCE, 0x19, 0xC6, 0x38, 0xC7, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x3C,
  0x07, 0x00, 0xE0, 0x00, 0x18, 0x19, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x02,
  0x1B, 0x31, 0x99, 0x8D, 0xCC, 0x6B, 0x43, 0xDE, 0x14, 0xF0, 0xE7, 0x0E,
  0x38, 0x71, 0xC0, 0x0C, 0x1C, 0x38, 0xE0, 0x63, 0x01, 0x98, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x37, 0x01, 0xCC, 0x0E, 0x30,
  0x70, 0xC3, 0x83, 0x80, 0xE0, 0xEC, 0x19, 0x87, 0x30, 0xC6, 0x30, 0x6C,
  0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xE0, 0xF8,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF0, 0x7E,
  0x00, 0xCC, 0xCC, 0xCE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x77, 0x73, 0x0F,
  0xC3, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x0F, 0xC3, 0xE0,
  0x07, 0x01, 0xC0, 0xF0, 0x66, 0x39, 0x9C, 0x6E, 0x0D, 0x02, 0x7F, 0xFF,
  0xFC, 0xCE, 0x31, 0x07, 0x07, 0xF7, 0x99, 0x86, 0xE1, 0xB0, 0xEC, 0x33,
  0x0C, 0xC3, 0x3F, 0xC7, 0xF0, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0xC1, 0xFC, 0xE3, 0x30, 0xCC, 0x33, 0x0D, 0xC3, 0x61, 0xD8, 0xE7, 0xF3,
  0xF8, 0x07, 0x87, 0xF7, 0x89, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x3F, 0xC7, 0xF0, 0x00, 0x20, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x0F, 0x87,
  0xF1, 0xCE, 0x61, 0x9C, 0x33, 0x06, 0x61, 0xCC, 0x31, 0x86, 0x3F, 0xC3,
  0xFC, 0x07, 0x0F, 0xE7, 0x1D, 0x87, 0xC1, 0xBF, 0xEF, 0xE3, 0x00, 0xC0,
  0x3F, 0xC7, 0xF0, 0x00, 0x14, 0x03, 0xE0, 0x1C, 0x80, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0xFF, 0x04, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x02, 0x70, 0x0F, 0x80,
  0x38, 0x00, 0x01, 0xE0, 0x7F, 0x0E, 0x71, 0x86, 0x38, 0x63, 0x06, 0x30,
  0xE3, 0x0C, 0x39, 0xC1, 0xFC, 0x00, 0xC0, 0x18, 0x43, 0x8F, 0xF0, 0x3C,
  0x00, 0x04, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x07, 0xC3, 0xF8, 0xE7, 0x30,
  0xCC, 0x37, 0x0D, 0x86, 0x61, 0x98, 0x66, 0x1B, 0x0E, 0x08, 0x38, 0x70,
  0x40, 0x00, 0xBE, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0F, 0x8F, 0x00,
  0x20, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x08, 0xE3,
  0xF8, 0x1E, 0x00, 0x02, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x81,
  0x18, 0xE1, 0x9C, 0x3B, 0x03, 0xE0, 0x3C, 0x03, 0x60, 0x77, 0x06, 0x30,
  0x63, 0x8E, 0x1C, 0xF8, 0x61, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38,
  0xE3, 0xF7, 0xC0, 0x0C, 0xC7, 0xFC, 0xD9, 0x93, 0x36, 0x66, 0xCD, 0x9B,
  0x33, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0x00, 0x07, 0x07, 0xF3, 0x9C, 0xC3,
  0x30, 0xCC, 0x37, 0x1D, 0x86, 0x61, 0x98, 0x6E, 0x38, 0x0E, 0x1F, 0xDC,
  0x6C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0x7F, 0x9F, 0x00, 0x03, 0x80,
  0xFE, 0x1C, 0x61, 0x86, 0x18, 0x71, 0x86, 0x38, 0x63, 0x0E, 0x31, 0xC3,
  0xF8, 0x7F, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x87, 0xF3,
  0x9D, 0x86, 0xE1, 0xB0, 0x6C, 0x3B, 0x0C, 0xC3, 0x3F, 0xC7, 0xF0, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x07, 0x8F, 0xF3, 0x88, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x00, 0x0F, 0x0F, 0xCC, 0x26, 0x03, 0x81,
  0xF0, 0x3C, 0x06, 0x03, 0x7F, 0xBF, 0x80, 0x04, 0x0C, 0x06, 0x03, 0x0F,
  0xF9, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x07, 0xE1, 0xF0, 0x71,
  0xD8, 0x66, 0x19, 0x86, 0xE3, 0xB0, 0xCC, 0x33, 0x0C, 0xFF, 0x1F, 0xC0,
  0xC1, 0xE1, 0xF0, 0xD8, 0xEE, 0x67, 0x61, 0xB0, 0xF0, 0x70, 0x38, 0x00,
  0xE0, 0x78, 0x0B, 0x33, 0x66, 0x6D, 0xC9, 0xAB, 0x3D, 0x67, 0x38, 0xE7,
  0x18, 0xC0, 0x1C, 0x70, 0xCE, 0x0E, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0D,
  0x81, 0x98, 0x30, 0xCE, 0x0C, 0x18, 0x31, 0x87, 0x1C, 0x61, 0xC6, 0x0C,
  0xC0, 0xCC, 0x0D, 0x80, 0xD8, 0x0F, 0x00, 0x60, 0x0E, 0x09, 0xC0, 0xF8,
  0x0E, 0x00, 0x1F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x7F, 0x9F, 0xF0, 0x01, 0xE0, 0x7C, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x0F, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x00, 0xF8, 0x0F, 0x00, 0x06, 0x0C, 0x38, 0x60,
  0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x87, 0x00, 0x07, 0x01, 0xF0, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x3C, 0x07, 0x81, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x83, 0xF0, 0x78, 0x00, 0x30, 0x9F, 0x3C, 0xFA, 0x1C,
};

const GFXglyph UbuntuSansMono_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 14, 11, 3, -14 },
  { 12, 7, 6, 11, 4, -15 },
  { 18, 12, 14, 11, 0, -14 },
  { 39, 10, 18, 11, 1, -16 },
  { 62, 14, 14, 11, -1, -14 },
  { 87, 10, 14, 11, 0, -14 },
  { 105, 3, 6, 11, 6, -15 },
  { 108, 9, 20, 11, 2, -16 },
  { 131, 9, 20, 11, 0, -16 },
  { 154, 9, 9, 11, 2, -14 },
  { 165, 10, 10, 11, 1, -11 },
  { 178, 6, 6, 11, 1, -3 },
  { 183, 6, 2, 11, 3, -7 },
  { 185, 4, 3, 11, 3, -3 },
  { 187, 13, 20, 11, -1, -16 },
  { 220, 10, 14, 11, 1, -14 },
  { 238, 8, 14, 11, 1, -14 },
  { 252, 11, 14, 11, 0, -14 },
  { 272, 11, 14, 11, 0, -14 },
  { 292, 11, 14, 11, 0, -14 },
  { 312, 12, 14, 11, 0, -14 },
  { 333, 11, 14, 11, 1, -14 },
  { 353, 10, 14, 11, 2, -14 },
  { 371, 10, 14, 11, 1, -14 },
  { 389, 10, 14, 11, 1, -14 },
  { 407, 5, 10, 11, 3, -10 },
  { 414, 7, 13, 11, 1, -10 },
  { 426, 10, 9, 11, 1, -10 },
  { 438, 11, 6, 11, 0, -9 },
  { 447, 10, 9, 11, 0, -10 },
  { 459, 8, 14, 11, 3, -14 },
  { 473, 11, 17, 11, 1, -14 },
  { 497, 11, 14, 11, -1, -14 },
  { 517, 11, 14, 11, 0, -14 },
  { 537, 11, 14, 11, 1, -14 },
  { 557, 11, 14, 11, 0, -14 },
  { 577, 11, 14, 11, 1, -14 },
  { 597, 11, 14, 11, 1, -14 },
  { 617, 11, 14, 11, 1, -14 },
  { 637, 12, 14, 11, 0, -14 },
  { 658, 12, 14, 11, 0, -14 },
  { 679, 12, 14, 11, 0, -14 },
  { 700, 12, 14, 11, 0, -14 },
  { 721, 9, 14, 11, 0, -14 },
  { 737, 13, 14, 11, -1, -14 },
  { 760, 12, 14, 11, 0, -14 },
  { 781, 10, 14, 11, 1, -14 },
  { 799, 11, 14, 11, 0, -14 },
  { 819, 10, 18, 11, 1, -14 },
  { 842, 11, 14, 11, 0, -14 },
  { 862, 11, 14, 11, 0, -14 },
  { 882, 10, 14, 11, 2, -14 },
  { 900, 11, 14, 11, 1, -14 },
  { 920, 11, 14, 11, 2, -14 },
  { 940, 13, 14, 11, 0, -14 },
  { 963, 14, 14, 11, -1, -14 },
  { 988, 11, 14, 11, 2, -14 },
  { 1008, 12, 14, 11, 0, -14 },
  { 1029, 11, 20, 11, 1, -16 },
  { 1057, 4, 20, 11, 4, -16 },
  { 1067, 10, 20, 11, 0, -16 },
  { 1092, 10, 8, 11, 1, -14 },
  { 1102, 11, 2, 11, -2, 2 },
  { 1105, 4, 4, 11, 5, -15 },
  { 1107, 10, 11, 11, 1, -11 },
  { 1121, 10, 16, 11, 0, -16 },
  { 1141, 10, 11, 11, 1, -11 },
  { 1155, 11, 16, 11, 1, -16 },
  { 1177, 10, 11, 11, 1, -11 },
  { 1191, 14, 20, 11, -1, -16 },
  { 1226, 12, 15, 11, -1, -11 },
  { 1249, 10, 16, 11, 0, -16 },
  { 1269, 7, 16, 11, 2, -16 },
  { 1283, 11, 20, 11, -1, -16 },
  { 1311, 12, 16, 11, 0, -16 },
  { 1335, 6, 15, 11, 3, -15 },
  { 1347, 11, 11, 11, 0, -11 },
  { 1363, 10, 11, 11, 0, -11 },
  { 1377, 9, 11, 11, 1, -11 },
  { 1390, 12, 15, 11, -1, -11 },
  { 1413, 10, 15, 11, 1, -11 },
  { 1432, 10, 11, 11, 1, -11 },
  { 1446, 9, 11, 11, 1, -11 },
  { 1459, 9, 14, 11, 2, -14 },
  { 1475, 10, 10, 11, 1, -10 },
  { 1488, 9, 10, 11, 2, -10 },
  { 1500, 11, 10, 11, 1, -10 },
  { 1514, 12, 10, 11, -1, -10 },
  { 1529, 12, 14, 11, -1, -10 },
  { 1550, 11, 10, 11, 0, -10 },
  { 1564, 11, 20, 11, 1, -16 },
  { 1592, 7, 20, 11, 2, -16 },
  { 1610, 11, 20, 11, -1, -16 },
  { 1638, 10, 4, 11, 1, -8 },
};

const GFXfont UbuntuSansMono_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic20pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC20PT7B_H_
