#ifndef _UBUNTUSANSMONO_MEDIUMITALIC30PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x3C, 0x3E, 0x1F, 0x07,
  0x80, 0x71, 0xDC, 0x77, 0x1F, 0xCF, 0xE3, 0xB8, 0xEE, 0x3B, 0x0C, 0xC3,
  0x00, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0C, 0x01, 0xC7,
  0x00, 0xE1, 0xC3, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0xE1, 0x80, 0x38, 0xE0, 0x0C, 0x38, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0x87, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x01, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x1E, 0x02, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x38, 0x40, 0x38, 0x70, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x70, 0xFC, 0x0E, 0x0C, 0xE0,
  0xC1, 0xCE, 0x18, 0x1C, 0xE3, 0x81, 0x8C, 0x70, 0x18, 0xCE, 0x01, 0xDD,
  0xC0, 0x1F, 0xB8, 0x00, 0xF3, 0x00, 0x00, 0x60, 0x00, 0x0E, 0xF0, 0x01,
  0xDF, 0x80, 0x3B, 0xB8, 0x07, 0x31, 0x80, 0x63, 0x18, 0x0C, 0x71, 0x81,
  0xC7, 0x38, 0x38, 0x73, 0x07, 0x03, 0xF0, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x03, 0xFC, 0x07, 0x9C, 0x07, 0x0E, 0x0E, 0x0C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x06, 0x38, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x87, 0x1F, 0xC6, 0x39, 0xCE,
  0x70, 0xEE, 0x70, 0xFC, 0x70, 0x78, 0xF0, 0x78, 0x70, 0x78, 0x79, 0xFC,
  0x7F, 0xDC, 0x3F, 0x1E, 0x7B, 0xBD, 0xEE, 0x73, 0x98, 0xC6, 0x00, 0x00,
  0x10, 0x03, 0x80, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x06, 0x00, 0x20,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x86, 0x17, 0x37, 0xFF, 0xFD, 0xFF,
  0xE0, 0xF0, 0x0F, 0xC0, 0xEF, 0x0F, 0x3C, 0x71, 0xC0, 0x84, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFC, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x0E, 0x1F, 0x3F, 0x1F, 0x1F, 0x0E, 0x1E, 0xFC,
  0xF8, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x3C,
  0x0F, 0x38, 0x0E, 0x79, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0x8E, 0x70,
  0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x70, 0xF0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x07, 0xE1,
  0xFF, 0x0F, 0xB8, 0x33, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x1F, 0xFE,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0x60, 0x70,
  0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x02, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x7C, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x40, 0x3C, 0x79, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xEE, 0x03, 0xCE, 0x07, 0x9E, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C,
  0x38, 0x3C, 0x78, 0x38, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x20, 0x1E, 0x1E, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x0F, 0xF8, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x73, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xE0, 0xE3, 0xE7, 0xC3, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x3F,
  0xFE, 0x7F, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x0F, 0x1E,
  0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1E, 0x0E, 0x0F, 0x3C, 0x0F, 0xF8, 0x0F,
  0xE0, 0x1E, 0xF8, 0x38, 0x78, 0x70, 0x3C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x3C, 0xF0, 0x38, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38,
  0x0F, 0x38, 0x0F, 0x3C, 0x0E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xDE, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x7C, 0xFC, 0xFC, 0x78, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F,
  0xC1, 0xF0, 0x7C, 0x0E, 0x07, 0x8F, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0x80, 0x38,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x06,
  0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x10, 0x00, 0x30, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1E, 0x01, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0xE3,
  0xFF, 0x3F, 0xF2, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xE3,
  0xC1, 0xE0, 0xE1, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x7C, 0xE1, 0xFE, 0x71,
  0xFF, 0x39, 0xE3, 0x98, 0xE3, 0x9C, 0xE1, 0xCE, 0x70, 0xE7, 0x38, 0x73,
  0x9C, 0x39, 0xCE, 0x38, 0xE7, 0x9C, 0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x1E,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1C, 0x07, 0x9C, 0x03, 0xCE, 0x01, 0xEE, 0x00, 0xFF, 0x00, 0x78, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xE0, 0xE0, 0x78, 0x70, 0x38,
  0x38, 0x1C, 0x3C, 0x1E, 0x1C, 0x3E, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0xC3, 0x81, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x1E, 0x38,
  0x1E, 0x1F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0x02, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x10, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x0E, 0x0F,
  0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07,
  0x38, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x3C,
  0x70, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0x21, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0x70, 0x38, 0x3C, 0x1C, 0x1F, 0xBE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80,
  0xE1, 0xE0, 0x78, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70,
  0x1C, 0x1C, 0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xE0, 0x38, 0x00, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x40, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0x80, 0x07,
  0x03, 0xE0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x1C,
  0x78, 0x03, 0x9E, 0x00, 0xF7, 0x80, 0x1D, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0x03, 0x9E, 0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x03, 0xC3,
  0x80, 0x70, 0x78, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x78, 0x0E, 0x0E, 0x01,
  0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x6C, 0x7C,
  0x0D, 0x8D, 0x83, 0xB3, 0xF0, 0x76, 0x6E, 0x0C, 0xD9, 0xC3, 0x9B, 0x30,
  0x73, 0xCE, 0x0E, 0x79, 0xC1, 0x8E, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x0E,
  0x00, 0xE0, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0xF8, 0x1C, 0x3E, 0x0E, 0x0F,
  0x83, 0x83, 0xF0, 0xE1, 0xDC, 0x38, 0x77, 0x0E, 0x1C, 0xC7, 0x07, 0x39,
  0xC3, 0x8E, 0x70, 0xE3, 0x9C, 0x38, 0x6E, 0x0E, 0x1B, 0x87, 0x07, 0xE1,
  0xC1, 0xF8, 0x70, 0x7C, 0x1C, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0,
  0x38, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x0F, 0x1E, 0x0F,
  0x3C, 0x0F, 0x38, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0E,
  0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38,
  0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xE0, 0xF0, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C,
  0x0F, 0x1E, 0x07, 0x8E, 0x07, 0x87, 0x1F, 0x83, 0xFF, 0x83, 0xFF, 0x81,
  0xFC, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x38, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x70,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x38, 0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x20, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xE0, 0xE0, 0x70, 0x70, 0x3C,
  0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x0F, 0x0E, 0x0F, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFE, 0x01, 0xC7, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x0F, 0x1E, 0x03, 0x8F, 0x01, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xC1, 0xE0, 0x20, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x20, 0x1E, 0x1F, 0x7E,
  0x1F, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x3C,
  0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x1F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0x70, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80,
  0x77, 0x80, 0x77, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0xE3, 0x87, 0x3C, 0x60,
  0xE7, 0x9C, 0x1D, 0xF3, 0x83, 0x36, 0x60, 0x6E, 0xCC, 0x1D, 0x9B, 0x83,
  0xF3, 0x70, 0x6C, 0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0x38, 0x1C, 0x0F,
  0x03, 0x80, 0x07, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0xC1, 0xE0, 0x1C, 0x3C,
  0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0x9C, 0x00, 0xF1, 0xC0, 0x0E, 0x1E, 0x01, 0xE0, 0xE0, 0x3C,
  0x0E, 0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0,
  0x1C, 0xE0, 0x38, 0xF0, 0x78, 0x70, 0x70, 0x70, 0xE0, 0x71, 0xE0, 0x79,
  0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xE3,
  0x8E, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x79,
  0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x3F,
  0x01, 0xFC, 0x07, 0x70, 0x39, 0xE1, 0xE3, 0x8F, 0x0E, 0x78, 0x3D, 0xC0,
  0x7E, 0x01, 0xC8, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0xE3,
  0xE1, 0xE1, 0xE0, 0x80, 0x01, 0xFC, 0x0F, 0xFC, 0x7F, 0xF9, 0xF0, 0xF3,
  0xC1, 0xCF, 0x03, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x39, 0xC0, 0x73, 0x80,
  0xE7, 0x03, 0xCF, 0x07, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0x9C, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xF0, 0x71, 0xC0, 0xF3, 0x81, 0xE7, 0x03,
  0xDE, 0x07, 0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x7B, 0xC1, 0xE7, 0x87, 0xCF,
  0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0x87, 0x87,
  0x83, 0x87, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38,
  0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFE,
  0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF3, 0x80, 0xEF, 0x03,
  0xDC, 0x0F, 0x78, 0xFE, 0xFF, 0xF1, 0xFF, 0x83, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0xCE, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x02, 0x7C, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F, 0x07, 0x87,
  0x81, 0xC1, 0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xE0, 0x70, 0x78, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x06, 0x0F, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x03,
  0x40, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xFC, 0x78, 0x78, 0xE0,
  0x71, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x39,
  0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x1E, 0x00, 0x07, 0x80,
  0xF8, 0x1E, 0x03, 0xC0, 0x20, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x1F, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x11, 0xFC, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x30,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x0F,
  0x1E, 0x1E, 0x1C, 0x3C, 0x1C, 0x78, 0x3C, 0xF0, 0x3D, 0xE0, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x7B, 0xC0, 0x71, 0xE0, 0x71, 0xE0, 0x70, 0xF0,
  0xF0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0x7F, 0x9F, 0xCF, 0xF0, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xE0, 0x7D, 0xCF, 0xF3, 0xFC, 0x0F,
  0x9E, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0xE7, 0x38, 0xE7, 0x38, 0xE7, 0x39,
  0xC7, 0x39, 0xC7, 0x71, 0xCE, 0x71, 0xCE, 0x70, 0x0E, 0x70, 0x0E, 0xE0,
  0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x07, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0x0F, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x78, 0x3D, 0xE0,
  0xF7, 0x03, 0x9C, 0x0E, 0xF0, 0x7B, 0xC1, 0xEE, 0x07, 0x38, 0x1C, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF0, 0xE3, 0x81, 0xEF, 0x03, 0xDC, 0x07,
  0xB8, 0x0F, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xCF, 0x07, 0x8F,
  0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x70, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07,
  0x0E, 0x03, 0x87, 0x03, 0xC7, 0x83, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFD, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x1E,
  0x3C, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x38,
  0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0x7D, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0xF0, 0x21, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x03, 0xC4, 0x07, 0x8F, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x1C, 0x0E, 0x38,
  0x1C, 0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x0F, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x8F, 0xFF, 0x1F,
  0xFE, 0x1F, 0x9C, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xE0, 0x73,
  0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x1D, 0xC0,
  0x7F, 0x01, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xB8, 0x01, 0xDC,
  0x01, 0xCE, 0x00, 0xE7, 0x1C, 0x73, 0x8E, 0x31, 0x8F, 0x38, 0xC7, 0x9C,
  0x66, 0xCC, 0x77, 0x6E, 0x3B, 0x37, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0x87,
  0x83, 0xC3, 0xC1, 0xC1, 0xC0, 0x0F, 0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x70,
  0x0E, 0x3C, 0x03, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3C, 0xE0, 0x1E, 0x3C, 0x07, 0x07,
  0x03, 0x81, 0xE3, 0xC0, 0x78, 0x07, 0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x03, 0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x07, 0x00, 0xE1, 0xE0, 0x1C, 0x38,
  0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0F, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x01,
  0x1E, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x03, 0x80, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x7E, 0x0D, 0xFE, 0x3B, 0xBF, 0xEE,
  0x1F, 0x88, 0x1E, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 21, 17, 4, -21 },
  { 25, 10, 9, 17, 6, -23 },
  { 37, 18, 21, 17, 0, -21 },
  { 85, 16, 26, 17, 1, -23 },
  { 137, 20, 21, 17, -1, -21 },
  { 190, 16, 21, 17, 0, -21 },
  { 232, 5, 10, 17, 9, -23 },
  { 239, 13, 30, 17, 4, -24 },
  { 288, 13, 30, 17, 0, -24 },
  { 337, 13, 13, 17, 3, -21 },
  { 359, 15, 15, 17, 1, -16 },
  { 388, 8, 10, 17, 2, -5 },
  { 398, 9, 3, 17, 4, -10 },
  { 402, 6, 5, 17, 4, -5 },
  { 406, 20, 29, 17, -2, -23 },
  { 479, 16, 21, 17, 1, -21 },
  { 521, 13, 21, 17, 1, -21 },
  { 556, 15, 21, 17, 1, -21 },
  { 596, 16, 21, 17, 0, -21 },
  { 638, 16, 21, 17, 0, -21 },
  { 680, 17, 21, 17, 0, -21 },
  { 725, 15, 21, 17, 2, -21 },
  { 765, 16, 21, 17, 3, -21 },
  { 807, 16, 21, 17, 1, -21 },
  { 849, 16, 21, 17, 1, -21 },
  { 891, 8, 16, 17, 4, -16 },
  { 907, 10, 21, 17, 2, -16 },
  { 934, 15, 14, 17, 1, -16 },
  { 961, 16, 9, 17, 1, -13 },
  { 979, 15, 14, 17, 1, -16 },
  { 1006, 12, 21, 17, 4, -21 },
  { 1038, 17, 26, 17, 1, -21 },
  { 1094, 17, 21, 17, -2, -21 },
  { 1139, 17, 21, 17, 0, -21 },
  { 1184, 16, 21, 17, 2, -21 },
  { 1226, 16, 21, 17, 0, -21 },
  { 1268, 17, 21, 17, 1, -21 },
  { 1313, 17, 21, 17, 1, -21 },
  { 1358, 17, 21, 17, 1, -21 },
  { 1403, 18, 21, 17, 0, -21 },
  { 1451, 16, 21, 17, 1, -21 },
  { 1493, 16, 21, 17, 1, -21 },
  { 1535, 19, 21, 17, 0, -21 },
  { 1585, 13, 21, 17, 0, -21 },
  { 1620, 19, 21, 17, -1, -21 },
  { 1670, 18, 21, 17, 0, -21 },
  { 1718, 16, 21, 17, 1, -21 },
  { 1760, 17, 21, 17, 0, -21 },
  { 1805, 16, 27, 17, 1, -21 },
  { 1859, 17, 21, 17, 0, -21 },
  { 1904, 17, 21, 17, 0, -21 },
  { 1949, 15, 21, 17, 4, -21 },
  { 1989, 17, 21, 17, 1, -21 },
  { 2034, 16, 21, 17, 3, -21 },
  { 2076, 19, 21, 17, 0, -21 },
  { 2126, 20, 21, 17, -1, -21 },
  { 2179, 16, 21, 17, 4, -21 },
  { 2221, 18, 21, 17, 0, -21 },
  { 2269, 16, 29, 17, 2, -23 },
  { 2327, 6, 29, 17, 6, -23 },
  { 2349, 16, 29, 17, -1, -23 },
  { 2407, 14, 12, 17, 2, -21 },
  { 2428, 15, 3, 17, -2, 3 },
  { 2434, 7, 6, 17, 7, -23 },
  { 2440, 15, 16, 17, 1, -16 },
  { 2470, 15, 23, 17, 1, -23 },
  { 2514, 15, 16, 17, 1, -16 },
  { 2544, 17, 23, 17, 1, -23 },
  { 2593, 15, 16, 17, 1, -16 },
  { 2623, 21, 29, 17, -2, -23 },
  { 2700, 18, 22, 17, -1, -16 },
  { 2750, 15, 23, 17, 0, -23 },
  { 2794, 11, 23, 17, 3, -23 },
  { 2826, 17, 29, 17, -1, -23 },
  { 2888, 16, 23, 17, 1, -23 },
  { 2934, 10, 23, 17, 4, -23 },
  { 2963, 16, 16, 17, 0, -16 },
  { 2995, 14, 16, 17, 1, -16 },
  { 3023, 15, 16, 17, 1, -16 },
  { 3053, 17, 22, 17, -1, -16 },
  { 3100, 16, 22, 17, 1, -16 },
  { 3144, 15, 16, 17, 1, -16 },
  { 3174, 15, 16, 17, 1, -16 },
  { 3204, 13, 20, 17, 3, -20 },
  { 3237, 15, 16, 17, 1, -16 },
  { 3267, 14, 16, 17, 3, -16 },
  { 3295, 17, 16, 17, 1, -16 },
  { 3329, 18, 16, 17, -1, -16 },
  { 3365, 19, 22, 17, -2, -16 },
  { 3418, 15, 16, 17, 1, -16 },
  { 3448, 16, 29, 17, 2, -23 },
  { 3506, 11, 29, 17, 3, -23 },
  { 3546, 16, 29, 17, -1, -23 },
  { 3604, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC30PT7B_H_
