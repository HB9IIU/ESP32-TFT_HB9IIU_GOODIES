#ifndef _UBUNTUSANSMONO_MEDIUMITALIC56PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x1C, 0x00, 0x3F, 0x07, 0xF3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x01, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x1C, 0x01, 0xFC, 0x00, 0x10, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x01, 0x00, 0x01, 0xFC, 0x06, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0xF8, 0x00, 0x78,
  0x3C, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0xF8,
  0x00, 0x3C, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x3E, 0x00, 0x03, 0xC1,
  0xE1, 0xF0, 0x00, 0x0F, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0x3C, 0x7C, 0x00,
  0x00, 0xF9, 0xF1, 0xF0, 0x00, 0x03, 0xFF, 0x8F, 0x80, 0x00, 0x07, 0xFC,
  0x7C, 0x00, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x00, 0x0E, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x00, 0x1F,
  0x1F, 0xC0, 0x00, 0x00, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0xFE, 0x00,
  0x00, 0x3E, 0x3E, 0x7C, 0x00, 0x01, 0xF1, 0xF1, 0xF0, 0x00, 0x0F, 0x87,
  0x83, 0xC0, 0x00, 0x3E, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x3C, 0x00,
  0x0F, 0x83, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x3C,
  0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x03, 0xC3, 0xE0, 0x03,
  0xE0, 0x0F, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x1C, 0x01, 0xFF, 0x01, 0xF0, 0x7F, 0xF8, 0x1F, 0x0F, 0xFF, 0x83,
  0xF1, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0xE3, 0xE3, 0xF0, 0x7E, 0x7C, 0x7E,
  0x03, 0xF7, 0xC7, 0xC0, 0x3F, 0xF8, 0xFC, 0x01, 0xFF, 0x8F, 0xC0, 0x0F,
  0xF0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xF0, 0xFE, 0x03, 0xFF, 0x0F, 0xF9, 0xFF, 0xF8, 0x7F, 0xFF,
  0xDF, 0x83, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0x0F, 0xC0, 0xFF, 0xC0, 0xFC,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x78,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0xC0, 0xF8, 0x18, 0xF8, 0x7C, 0x3C, 0x7F, 0x3C, 0x7F, 0x3F,
  0xEE, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xE0,
  0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0x7C, 0x0F, 0x80, 0x0E, 0x03, 0x80, 0x02, 0x00, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07,
  0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xC0, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x04, 0x07,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0xC1, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F,
  0x0F, 0x03, 0xF7, 0xE1, 0xF8, 0x7E, 0x7E, 0x1F, 0x87, 0xE7, 0xE3, 0xFC,
  0x7E, 0xFE, 0x3F, 0x87, 0xEF, 0xC3, 0xF8, 0x7E, 0xFC, 0x1F, 0x0F, 0xCF,
  0xC1, 0xE0, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xF8, 0x07, 0xF9, 0xF8,
  0x03, 0xE1, 0xF8, 0x03, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x7F, 0x00, 0x40, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xE0, 0x1F, 0xE0, 0x04, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC2, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0x3F,
  0xE0, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x10, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x20,
  0x00, 0x7F, 0x80, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF1, 0xFE, 0x00, 0x3F, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xCF, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x81,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xBF, 0xF0, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x07, 0xFF,
  0x87, 0xC0, 0x3F, 0xFF, 0x1F, 0x81, 0xFF, 0xFE, 0x3E, 0x07, 0xFF, 0xFC,
  0x7C, 0x1F, 0xFF, 0xF1, 0xF8, 0x3F, 0x03, 0xE3, 0xE0, 0xFC, 0x0F, 0xC7,
  0xC1, 0xF8, 0x1F, 0x8F, 0x87, 0xE0, 0x3F, 0x3F, 0x0F, 0xC0, 0x7C, 0x7C,
  0x1F, 0x01, 0xF8, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0xFC, 0x07, 0xE3, 0xE1,
  0xF8, 0x0F, 0x87, 0xC3, 0xF0, 0x3F, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x0F,
  0xC0, 0xFC, 0x3E, 0x1F, 0x81, 0xF0, 0x7C, 0x3F, 0x87, 0xE0, 0xF8, 0x3F,
  0xCF, 0xC1, 0xF0, 0x7F, 0xFF, 0x83, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0x7F,
  0xFC, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x1E, 0x00, 0xFF, 0x00, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x08, 0x00, 0xFF,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x83,
  0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01,
  0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xC0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0x00, 0xFF, 0x00, 0x0C,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x00,
  0x3F, 0x80, 0x38, 0x00, 0xFE, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xF3, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xEF, 0x83, 0xDF, 0x00, 0x7C, 0xF0,
  0xFB, 0xE0, 0x0F, 0x9E, 0x1E, 0x78, 0x01, 0xF3, 0xC7, 0x9F, 0x00, 0x7C,
  0x78, 0xF3, 0xE0, 0x0F, 0x8F, 0x3C, 0x7C, 0x01, 0xF1, 0xE7, 0x8F, 0x80,
  0x3E, 0x3D, 0xE3, 0xE0, 0x0F, 0x87, 0xFC, 0x7C, 0x01, 0xF0, 0xFF, 0x0F,
  0x80, 0x3E, 0x1F, 0xE1, 0xF0, 0x0F, 0xC3, 0xF8, 0x3E, 0x01, 0xF0, 0x7F,
  0x0F, 0xC0, 0x3E, 0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x3E, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0xFC, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xC0,
  0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0x7D, 0xF0, 0x0F, 0xC0, 0x1F, 0x7C, 0x03, 0xF0, 0x0F,
  0xDF, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x3E, 0x00, 0xF8, 0xF8, 0x1F, 0x80,
  0x3E, 0x3E, 0x07, 0xE0, 0x1F, 0x8F, 0x81, 0xF0, 0x07, 0xE1, 0xE0, 0x7C,
  0x01, 0xF0, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x0F, 0xC0, 0x3F, 0x07, 0xC3,
  0xE0, 0x0F, 0xC0, 0xF0, 0xF8, 0x03, 0xF0, 0x3E, 0x7E, 0x00, 0xF8, 0x0F,
  0x9F, 0x80, 0x3E, 0x03, 0xE7, 0xE0, 0x1F, 0x80, 0xF9, 0xF0, 0x07, 0xE0,
  0x1E, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x3F,
  0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x03, 0xFE, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xF0,
  0x07, 0xC0, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0xFE, 0x00, 0x08, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00, 0x1F, 0xC0,
  0x3E, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F,
  0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x7C, 0x03, 0xE0, 0xFE, 0x1F, 0x80, 0x7C,
  0x3F, 0xC3, 0xE0, 0x0F, 0x87, 0xF8, 0x7C, 0x01, 0xF1, 0xFF, 0x0F, 0x80,
  0x7E, 0x3D, 0xE3, 0xE0, 0x0F, 0x8F, 0x3C, 0x7C, 0x01, 0xF1, 0xE7, 0x8F,
  0x80, 0x3E, 0x78, 0xF1, 0xF0, 0x07, 0xCF, 0x1E, 0x7C, 0x00, 0xF3, 0xC3,
  0xCF, 0x80, 0x3E, 0xF8, 0x79, 0xF0, 0x07, 0xDE, 0x0F, 0x3C, 0x00, 0xFF,
  0xC1, 0xEF, 0x80, 0x1E, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x04, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xE1, 0xFC,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xF3, 0x80, 0x00, 0x70, 0x10, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x0E, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0xFE, 0x07, 0xF8, 0x07, 0xE0,
  0xFF, 0x00, 0x7E, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xBF, 0x00, 0xFF, 0xE1, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F,
  0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x0F,
  0xF0, 0x7E, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x7C, 0x07,
  0xFC, 0x00, 0x40, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x2F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x8F, 0xF0, 0x07,
  0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x9F, 0x80, 0x07, 0xFE, 0x1F, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xE7, 0xE0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x10,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xF8, 0x01, 0xFF,
  0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x10, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x00, 0xFE, 0x00, 0x1E,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x3F, 0x03, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF9, 0xFE, 0x00,
  0x07, 0xE7, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x23, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF1, 0xFC, 0x7E, 0x03, 0xE0, 0xF8,
  0x3F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xE0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x07, 0xC1, 0xF0,
  0x7C, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xE0,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xEE, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xE3, 0xF8,
  0x1F, 0xF0, 0x1F, 0xC1, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0x7E, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xF8, 0x00, 0x40, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0x00, 0xFE, 0x00, 0x20,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0x00, 0x03, 0xF0, 0x38, 0x00, 0xFE,
  0x0F, 0xFB, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x30,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07,
  0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0x3F, 0x01, 0xFF, 0xC3, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x0F,
  0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x03, 0xC0, 0xFC, 0x3E, 0x07, 0xC0, 0xF8, 0x7E, 0x07,
  0xC0, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F,
  0xC1, 0xF0, 0x7C, 0x3F, 0xC3, 0xF0, 0x7C, 0x3F, 0xC3, 0xE0, 0x7C, 0x7F,
  0xC3, 0xE0, 0x7C, 0x7B, 0xE7, 0xC0, 0x7C, 0xFB, 0xE7, 0xC0, 0x7C, 0xF3,
  0xE7, 0xC0, 0x79, 0xF1, 0xEF, 0x80, 0x79, 0xE1, 0xEF, 0x80, 0xFB, 0xE1,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7F, 0x80, 0x0E, 0x0F, 0xFE, 0x01, 0xF1, 0xFF, 0xF0, 0x3F, 0x3F,
  0xFF, 0xC7, 0xE7, 0xFF, 0xFF, 0xFE, 0x7E, 0x3F, 0xFF, 0xCF, 0xC0, 0xFF,
  0xF8, 0xF8, 0x07, 0xFF, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 16, 40, 31, 8, -39 },
  { 81, 20, 17, 31, 11, -43 },
  { 124, 33, 39, 31, 0, -39 },
  { 285, 30, 49, 31, 1, -43 },
  { 469, 38, 41, 31, -2, -40 },
  { 664, 28, 41, 31, 1, -40 },
  { 808, 9, 18, 31, 16, -43 },
  { 829, 24, 55, 31, 7, -44 },
  { 994, 24, 55, 31, 1, -44 },
  { 1159, 25, 24, 31, 6, -39 },
  { 1234, 26, 27, 31, 3, -30 },
  { 1322, 14, 18, 31, 4, -9 },
  { 1354, 16, 6, 31, 8, -19 },
  { 1366, 10, 11, 31, 8, -10 },
  { 1380, 36, 54, 31, -3, -44 },
  { 1623, 28, 41, 31, 3, -40 },
  { 1767, 24, 39, 31, 3, -39 },
  { 1884, 30, 40, 31, 1, -40 },
  { 2034, 29, 41, 31, 1, -40 },
  { 2183, 31, 39, 31, 0, -39 },
  { 2335, 31, 40, 31, 1, -39 },
  { 2490, 29, 40, 31, 3, -39 },
  { 2635, 29, 39, 31, 6, -39 },
  { 2777, 29, 41, 31, 2, -40 },
  { 2926, 29, 40, 31, 2, -40 },
  { 3071, 15, 31, 31, 8, -30 },
  { 3130, 19, 39, 31, 4, -30 },
  { 3223, 28, 26, 31, 3, -29 },
  { 3314, 30, 17, 31, 1, -25 },
  { 3378, 28, 26, 31, 1, -29 },
  { 3469, 22, 41, 31, 8, -40 },
  { 3582, 31, 48, 31, 2, -40 },
  { 3768, 30, 39, 31, -3, -39 },
  { 3915, 31, 39, 31, 0, -39 },
  { 4067, 31, 41, 31, 3, -40 },
  { 4226, 31, 39, 31, 0, -39 },
  { 4378, 31, 39, 31, 2, -39 },
  { 4530, 32, 39, 31, 2, -39 },
  { 4686, 30, 41, 31, 3, -40 },
  { 4840, 34, 39, 31, 0, -39 },
  { 5006, 31, 39, 31, 1, -39 },
  { 5158, 31, 40, 31, 1, -39 },
  { 5313, 35, 39, 31, 0, -39 },
  { 5484, 24, 39, 31, 1, -39 },
  { 5601, 35, 39, 31, -2, -39 },
  { 5772, 34, 39, 31, 0, -39 },
  { 5938, 30, 41, 31, 2, -40 },
  { 6092, 31, 39, 31, 1, -39 },
  { 6244, 30, 50, 31, 2, -40 },
  { 6432, 31, 39, 31, 0, -39 },
  { 6584, 32, 41, 31, 0, -40 },
  { 6748, 28, 39, 31, 7, -39 },
  { 6885, 32, 40, 31, 2, -39 },
  { 7045, 30, 39, 31, 6, -39 },
  { 7192, 35, 39, 31, 1, -39 },
  { 7363, 38, 39, 31, -2, -39 },
  { 7549, 30, 39, 31, 7, -39 },
  { 7696, 33, 39, 31, 0, -39 },
  { 7857, 29, 54, 31, 4, -44 },
  { 8053, 11, 54, 31, 11, -44 },
  { 8128, 29, 54, 31, -1, -44 },
  { 8324, 27, 22, 31, 4, -39 },
  { 8399, 29, 5, 31, -4, 5 },
  { 8418, 12, 11, 31, 13, -43 },
  { 8435, 28, 31, 31, 2, -30 },
  { 8544, 28, 45, 31, 1, -44 },
  { 8702, 28, 31, 31, 2, -30 },
  { 8811, 32, 45, 31, 2, -44 },
  { 8991, 28, 31, 31, 2, -30 },
  { 9100, 38, 54, 31, -3, -43 },
  { 9357, 33, 41, 31, -2, -30 },
  { 9527, 28, 44, 31, 0, -44 },
  { 9681, 20, 43, 31, 5, -43 },
  { 9789, 31, 54, 31, -2, -43 },
  { 9999, 31, 44, 31, 1, -44 },
  { 10170, 18, 44, 31, 8, -43 },
  { 10269, 32, 30, 31, -1, -30 },
  { 10389, 28, 30, 31, 1, -30 },
  { 10494, 27, 31, 31, 2, -30 },
  { 10599, 31, 40, 31, -2, -30 },
  { 10754, 29, 40, 31, 2, -30 },
  { 10899, 28, 30, 31, 3, -30 },
  { 11004, 27, 31, 31, 2, -30 },
  { 11109, 24, 39, 31, 6, -38 },
  { 11226, 27, 30, 31, 3, -29 },
  { 11328, 27, 29, 31, 5, -29 },
  { 11426, 32, 29, 31, 2, -29 },
  { 11542, 33, 29, 31, -1, -29 },
  { 11662, 36, 40, 31, -4, -29 },
  { 11842, 29, 29, 31, 1, -29 },
  { 11948, 30, 54, 31, 4, -44 },
  { 12151, 20, 54, 31, 6, -44 },
  { 12286, 30, 54, 31, -2, -44 },
  { 12489, 28, 11, 31, 2, -22 },
};

const GFXfont UbuntuSansMono_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic56pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC56PT7B_H_
