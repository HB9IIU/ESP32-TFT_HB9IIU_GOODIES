#ifndef _UBUNTUSANSMONO_MEDIUMITALIC11PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x25, 0x24, 0xDA, 0xA0, 0x16, 0x29, 0xF9, 0x46, 0x9F, 0x94,
  0x58, 0x08, 0x23, 0xD8, 0x20, 0x60, 0xA2, 0x70, 0x80, 0x22, 0xA9, 0xA3,
  0x81, 0x86, 0x95, 0x4C, 0x18, 0xA2, 0x8C, 0x76, 0x69, 0x9E, 0xE8, 0x08,
  0xC8, 0xC4, 0x62, 0x10, 0xC2, 0x08, 0x11, 0x86, 0x10, 0x84, 0x62, 0x33,
  0x20, 0x25, 0x7E, 0xE5, 0x00, 0x10, 0x47, 0xEC, 0x20, 0x80, 0x4D, 0x40,
  0xE0, 0xB0, 0x02, 0x04, 0x10, 0x20, 0x83, 0x04, 0x18, 0x20, 0x83, 0x00,
  0x18, 0x94, 0x55, 0x57, 0x24, 0x9C, 0x13, 0x72, 0x22, 0x2F, 0x18, 0x90,
  0x43, 0x18, 0x84, 0x3E, 0x38, 0xB0, 0x4E, 0x18, 0x20, 0xBE, 0x04, 0x31,
  0x8A, 0x4B, 0xF1, 0x84, 0x1C, 0x82, 0x0C, 0x58, 0x20, 0xBC, 0x09, 0x91,
  0xE9, 0xCE, 0x5E, 0x7C, 0x21, 0x8C, 0x21, 0x04, 0x30, 0x18, 0x96, 0x4B,
  0x79, 0x2C, 0x9E, 0x18, 0x94, 0x51, 0x3C, 0x21, 0xB8, 0x4C, 0x09, 0x80,
  0x23, 0x00, 0x46, 0x48, 0x04, 0x76, 0x38, 0x18, 0x7C, 0x0F, 0xC0, 0x41,
  0xC0, 0xCE, 0xE0, 0x32, 0x42, 0x66, 0x01, 0x18, 0x1C, 0x94, 0x57, 0xE6,
  0x9B, 0xB2, 0x40, 0xC0, 0x0C, 0x31, 0x45, 0x24, 0xF4, 0x71, 0x38, 0xB6,
  0x56, 0x79, 0x3C, 0xBC, 0x3D, 0xAC, 0x20, 0x82, 0x08, 0x3C, 0x39, 0xB4,
  0x51, 0x45, 0x3D, 0xBC, 0x3E, 0x40, 0x83, 0xC7, 0x88, 0x10, 0x7C, 0x3E,
  0x40, 0x83, 0x07, 0x88, 0x10, 0x60, 0x3B, 0x71, 0x09, 0xCA, 0x5E, 0x26,
  0xC9, 0x13, 0xE7, 0xC9, 0x32, 0x44, 0x3C, 0x61, 0x04, 0x10, 0xC2, 0x3E,
  0x1C, 0x90, 0x43, 0x08, 0x28, 0xBC, 0x26, 0x59, 0xE3, 0x87, 0x0A, 0x36,
  0x44, 0x21, 0x18, 0x84, 0x21, 0x1F, 0x26, 0x49, 0xB3, 0x65, 0x50, 0xA2,
  0x44, 0x22, 0x49, 0x52, 0xA5, 0x4B, 0x22, 0x44, 0x18, 0x94, 0x51, 0x47,
  0x34, 0x9C, 0x38, 0x96, 0x51, 0x79, 0x0C, 0x20, 0x18, 0x94, 0x51, 0x47,
  0x34, 0x9C, 0x20, 0xE0, 0x38, 0xB6, 0x53, 0x79, 0x4C, 0xA2, 0x1C, 0x96,
  0x0C, 0x18, 0x20, 0xBE, 0xFC, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x26, 0xC9,
  0x12, 0x24, 0xC9, 0x32, 0x38, 0x86, 0x38, 0xB6, 0xD3, 0xC6, 0x10, 0x62,
  0x85, 0x12, 0xA7, 0x56, 0xB6, 0x64, 0x22, 0x48, 0xE0, 0xC3, 0x05, 0x12,
  0x44, 0xC5, 0x25, 0x94, 0x61, 0x84, 0x10, 0x3E, 0x08, 0x20, 0x83, 0x0C,
  0x10, 0x7C, 0x39, 0x08, 0x44, 0x21, 0x08, 0x84, 0x38, 0xAF, 0x55, 0x54,
  0x3C, 0x20, 0x82, 0x18, 0x41, 0x04, 0x30, 0x8E, 0x00, 0x11, 0x95, 0x98,
  0x80, 0xFC, 0xA4, 0x3D, 0xB4, 0xB2, 0xC9, 0xE0, 0x10, 0x82, 0x1E, 0x4D,
  0x14, 0xD2, 0xF0, 0x3D, 0x84, 0x30, 0x41, 0xE0, 0x02, 0x08, 0x10, 0xE6,
  0x49, 0x32, 0x64, 0x78, 0x39, 0x94, 0xFC, 0x41, 0xE0, 0x02, 0x0F, 0x08,
  0x3E, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0xE0, 0x1D, 0x94, 0xD2, 0x59,
  0xA1, 0xBC, 0x10, 0x82, 0x1E, 0x4D, 0x24, 0xB2, 0x98, 0x23, 0x0E, 0x26,
  0x44, 0x70, 0x08, 0x30, 0x0E, 0x08, 0x21, 0x84, 0x10, 0x4E, 0x00, 0x10,
  0x82, 0x09, 0x69, 0xC5, 0x16, 0xC8, 0xE9, 0x69, 0x27, 0x7D, 0x55, 0x7D,
  0x8A, 0x20, 0x39, 0xB4, 0xD2, 0x4B, 0x20, 0x39, 0xB4, 0x73, 0xC9, 0xC0,
  0x79, 0x34, 0x53, 0x4B, 0xC8, 0x20, 0x1D, 0x94, 0xF2, 0x49, 0xE1, 0x84,
  0x7A, 0x31, 0x08, 0x40, 0x3D, 0x82, 0x06, 0x0B, 0xE0, 0x27, 0xD0, 0x84,
  0x21, 0xC0, 0xCC, 0xE5, 0x29, 0x78, 0x8C, 0xE5, 0xE6, 0x20, 0x46, 0x89,
  0x53, 0xAD, 0x9B, 0x00, 0x64, 0xA3, 0x0C, 0x7B, 0x20, 0x22, 0x44, 0xD1,
  0xA1, 0x83, 0x04, 0x70, 0x3D, 0x21, 0x08, 0x43, 0xE0, 0x1C, 0xC2, 0x08,
  0x23, 0x04, 0x10, 0x43, 0x06, 0x00, 0x11, 0x32, 0x22, 0x64, 0x44, 0xC0,
  0x30, 0x42, 0x21, 0x0C, 0x46, 0x21, 0x30, 0x76, 0x60,
};

const GFXglyph UbuntuSansMono_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 8, 6, 2, -8 },
  { 4, 4, 3, 6, 2, -8 },
  { 6, 7, 8, 6, 0, -8 },
  { 13, 6, 10, 6, 0, -9 },
  { 21, 7, 8, 6, 0, -8 },
  { 28, 6, 8, 6, 0, -8 },
  { 34, 2, 3, 6, 3, -8 },
  { 35, 5, 11, 6, 1, -9 },
  { 42, 5, 11, 6, 0, -9 },
  { 49, 5, 5, 6, 1, -8 },
  { 53, 6, 6, 6, 0, -6 },
  { 58, 3, 4, 6, 1, -2 },
  { 60, 3, 1, 6, 2, -4 },
  { 61, 2, 2, 6, 2, -2 },
  { 62, 7, 11, 6, -1, -9 },
  { 72, 6, 8, 6, 0, -8 },
  { 78, 4, 8, 6, 1, -8 },
  { 82, 6, 8, 6, 0, -8 },
  { 88, 6, 8, 6, 0, -8 },
  { 94, 6, 8, 6, 0, -8 },
  { 100, 6, 8, 6, 0, -8 },
  { 106, 5, 8, 6, 1, -8 },
  { 111, 6, 8, 6, 1, -8 },
  { 117, 6, 8, 6, 0, -8 },
  { 123, 6, 8, 6, 0, -8 },
  { 129, 3, 6, 6, 2, -6 },
  { 132, 4, 8, 6, 1, -6 },
  { 136, 6, 5, 6, 0, -6 },
  { 140, 6, 3, 6, 0, -5 },
  { 143, 6, 5, 6, 0, -6 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 6, 10, 6, 0, -8 },
  { 160, 6, 8, 6, -1, -8 },
  { 166, 6, 8, 6, 0, -8 },
  { 172, 6, 8, 6, 1, -8 },
  { 178, 6, 8, 6, 0, -8 },
  { 184, 7, 8, 6, 0, -8 },
  { 191, 7, 8, 6, 0, -8 },
  { 198, 5, 8, 6, 1, -8 },
  { 203, 7, 8, 6, 0, -8 },
  { 210, 6, 8, 6, 0, -8 },
  { 216, 6, 8, 6, 0, -8 },
  { 222, 7, 8, 6, 0, -8 },
  { 229, 5, 8, 6, 0, -8 },
  { 234, 7, 8, 6, 0, -8 },
  { 241, 7, 8, 6, 0, -8 },
  { 248, 6, 8, 6, 0, -8 },
  { 254, 6, 8, 6, 0, -8 },
  { 260, 6, 10, 6, 0, -8 },
  { 268, 6, 8, 6, 0, -8 },
  { 274, 6, 8, 6, 0, -8 },
  { 280, 6, 8, 6, 1, -8 },
  { 286, 7, 8, 6, 0, -8 },
  { 293, 6, 8, 6, 1, -8 },
  { 299, 7, 8, 6, 0, -8 },
  { 306, 7, 8, 6, 0, -8 },
  { 313, 6, 8, 6, 1, -8 },
  { 319, 7, 8, 6, 0, -8 },
  { 326, 5, 11, 6, 1, -9 },
  { 333, 2, 11, 6, 2, -9 },
  { 336, 6, 11, 6, 0, -9 },
  { 345, 5, 5, 6, 1, -8 },
  { 349, 6, 1, 6, -1, 1 },
  { 350, 2, 3, 6, 3, -9 },
  { 351, 6, 6, 6, 0, -6 },
  { 356, 6, 9, 6, 0, -9 },
  { 363, 6, 6, 6, 0, -6 },
  { 368, 7, 9, 6, 0, -9 },
  { 376, 6, 6, 6, 0, -6 },
  { 381, 8, 11, 6, -1, -9 },
  { 392, 6, 8, 6, 0, -6 },
  { 398, 6, 9, 6, 0, -9 },
  { 405, 4, 9, 6, 1, -9 },
  { 410, 6, 11, 6, 0, -9 },
  { 419, 6, 9, 6, 0, -9 },
  { 426, 3, 8, 6, 2, -8 },
  { 429, 6, 6, 6, 0, -6 },
  { 434, 6, 6, 6, 0, -6 },
  { 439, 6, 6, 6, 0, -6 },
  { 444, 6, 8, 6, 0, -6 },
  { 450, 6, 8, 6, 0, -6 },
  { 456, 5, 6, 6, 1, -6 },
  { 460, 6, 6, 6, 0, -6 },
  { 465, 5, 7, 6, 1, -7 },
  { 470, 5, 6, 6, 1, -6 },
  { 474, 5, 6, 6, 1, -6 },
  { 478, 7, 6, 6, 0, -6 },
  { 484, 6, 6, 6, 0, -6 },
  { 489, 7, 8, 6, -1, -6 },
  { 496, 6, 6, 6, 0, -6 },
  { 501, 6, 11, 6, 1, -9 },
  { 510, 4, 11, 6, 1, -9 },
  { 516, 5, 11, 6, 0, -9 },
  { 523, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC11PT7B_H_
