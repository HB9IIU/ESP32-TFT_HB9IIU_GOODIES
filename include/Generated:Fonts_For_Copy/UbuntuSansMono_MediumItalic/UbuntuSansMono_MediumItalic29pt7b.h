#ifndef _UBUNTUSANSMONO_MEDIUMITALIC29PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x3E, 0x0E, 0x00,
  0x71, 0xDC, 0xFE, 0x3B, 0x8E, 0xE3, 0xB8, 0xCC, 0x33, 0x1C, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0xE1, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x07,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x71, 0xC0, 0x71, 0xC0, 0x38, 0xE0,
  0x18, 0x60, 0x1C, 0x70, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x3F, 0xC1, 0xFF, 0xC3, 0xC3, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE3, 0x07, 0x8F, 0xFF, 0x0F, 0xF8, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x1C, 0x3F,
  0x03, 0x06, 0x60, 0xC1, 0xCC, 0x30, 0x31, 0x8E, 0x06, 0x33, 0x80, 0xCE,
  0xE0, 0x1F, 0xB8, 0x01, 0xE6, 0x00, 0x11, 0x80, 0x00, 0x72, 0x00, 0x1D,
  0xF0, 0x07, 0x76, 0x01, 0xCC, 0xE0, 0x33, 0x98, 0x0C, 0x63, 0x03, 0x0C,
  0x60, 0xE1, 0x9C, 0x38, 0x3F, 0x0E, 0x03, 0xC0, 0x00, 0x60, 0x03, 0xF0,
  0x0F, 0xF0, 0x38, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x86, 0x07, 0x1C, 0x06,
  0xF0, 0x0F, 0xC0, 0x1E, 0x18, 0xFC, 0x73, 0xDC, 0xEE, 0x3F, 0x9C, 0x3F,
  0x38, 0x3C, 0xF0, 0x71, 0xE0, 0xF1, 0xE7, 0xE3, 0xFF, 0xE3, 0xF1, 0xC0,
  0x3B, 0xDC, 0xE7, 0x3B, 0x9C, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x18, 0x00, 0x00, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xCE, 0x6F, 0xAF, 0xFF, 0xFC,
  0x3E, 0x01, 0xF0, 0x1D, 0xC1, 0xEF, 0x0E, 0x38, 0x31, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x07, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x0E, 0x1E, 0x3F, 0x3E, 0x1E, 0x0E, 0x1C, 0xF8, 0xF0, 0xC0, 0x7F,
  0xFF, 0xBF, 0xC0, 0x3B, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x40, 0x07, 0xF0, 0x1F, 0xF0, 0x78, 0xE1, 0xE1, 0xE3,
  0x81, 0xCF, 0x03, 0x9C, 0x07, 0x79, 0x0E, 0xE7, 0x9D, 0xCF, 0x7B, 0x9C,
  0xE7, 0x11, 0xDE, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x70, 0xE1, 0xE1,
  0xE7, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x07, 0x80, 0x7C, 0x1F,
  0xE1, 0xFF, 0x0F, 0x70, 0x43, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0x9F,
  0xFD, 0xFF, 0xE0, 0x00, 0x40, 0x0F, 0xF0, 0x7F, 0xF0, 0x79, 0xF0, 0x81,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x07,
  0xFE, 0x07, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x3C, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x71, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x01,
  0xDC, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x3C, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x80, 0x7F, 0xE1, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xE3, 0xC1, 0xFF, 0x81,
  0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x60, 0x07, 0xF8, 0x1F, 0xF8, 0x78, 0xF1,
  0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1E, 0x1C, 0x1E, 0xF0, 0x1F,
  0xC0, 0xFF, 0x83, 0xC7, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x39,
  0xC0, 0xF3, 0xC3, 0xC3, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x40, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF0, 0xF1, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFD, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x78,
  0xF8, 0xF8, 0x78, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x3F, 0x0F, 0x81, 0xE0, 0x38, 0x1C,
  0x3E, 0x0F, 0x03, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0x00, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0xFF, 0xF8, 0x10, 0x00,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x3F,
  0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x3E, 0x00, 0xC0, 0x00, 0x02, 0x03, 0xFC,
  0x3F, 0xE3, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xFE, 0x0F,
  0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x7F, 0x71, 0xFE, 0x73,
  0xEE, 0x63, 0x8E, 0xE7, 0x0E, 0xE7, 0x0E, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7,
  0x1C, 0xE7, 0x1C, 0xE7, 0xF8, 0xE3, 0xF8, 0xE0, 0xE0, 0xF0, 0x00, 0x70,
  0x00, 0x7C, 0x20, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0xE6, 0x01, 0xC6, 0x01, 0xC7, 0x03,
  0x87, 0x03, 0x87, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x07,
  0xFC, 0x0F, 0xFE, 0x0F, 0x3F, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C,
  0x0E, 0x1C, 0x1E, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x38, 0x1C, 0x38,
  0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0xFC, 0x1F, 0xF8, 0x7C, 0x71, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x21, 0xF7, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0x7E, 0x0E, 0x1E, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x70,
  0x3C, 0x70, 0x3C, 0x70, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0x8E, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x1C, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0x70, 0x38, 0x78, 0x78, 0x7E, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x38,
  0x0E, 0x0E, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x1E, 0x07, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x3C, 0x3C, 0x0E, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x40, 0xF0, 0xF3, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0x03, 0xC3,
  0xC1, 0xE0, 0xE0, 0xF0, 0x38, 0x78, 0x0E, 0x3C, 0x03, 0x9E, 0x01, 0xEF,
  0x00, 0x77, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xEF, 0x00,
  0x39, 0xE0, 0x0E, 0x38, 0x07, 0x8F, 0x01, 0xC1, 0xC0, 0x70, 0x78, 0x1C,
  0x0E, 0x0F, 0x03, 0xC3, 0x80, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F,
  0x07, 0xC7, 0xC3, 0xF3, 0x60, 0xEC, 0xD8, 0x33, 0x6E, 0x1C, 0xDB, 0x87,
  0x3C, 0xE1, 0xCF, 0x38, 0x63, 0x8C, 0x38, 0xE7, 0x0E, 0x01, 0xC3, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x38,
  0x07, 0x01, 0xC3, 0xC0, 0xE0, 0xF0, 0x38, 0x3E, 0x0E, 0x0F, 0x83, 0x87,
  0x61, 0xC1, 0xDC, 0x70, 0x77, 0x1C, 0x1C, 0xC7, 0x0E, 0x33, 0x83, 0x8E,
  0xE0, 0xE3, 0xB8, 0x38, 0xEE, 0x1C, 0x1B, 0x07, 0x07, 0xC1, 0xC1, 0xF0,
  0x70, 0x7C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0x00, 0x40, 0x07,
  0xF0, 0x1F, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xB8,
  0x07, 0x70, 0x1C, 0xF0, 0x79, 0xE0, 0xE1, 0xE7, 0xC3, 0xFF, 0x03, 0xF8,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xCF, 0xC1, 0xE0, 0xE0, 0xE0, 0x78,
  0x70, 0x3C, 0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x0F, 0x0E, 0x0F, 0x07, 0xFF,
  0x07, 0xFF, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF0,
  0x1F, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x78,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xB8, 0x07,
  0x70, 0x1C, 0xF0, 0x79, 0xE0, 0xE1, 0xE7, 0xC3, 0xFF, 0x03, 0xF8, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F,
  0xFE, 0x0F, 0x3F, 0x0E, 0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C,
  0x0E, 0x1C, 0x1E, 0x1C, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x38, 0xE0, 0x38,
  0xF0, 0x78, 0x70, 0x70, 0x70, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0,
  0x3C, 0x00, 0x18, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0x87, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x40,
  0x3C, 0x7C, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x8E,
  0x03, 0x87, 0x01, 0xC3, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0x70, 0x3C, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03,
  0xC7, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x3C, 0xF8, 0x1F,
  0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xE0,
  0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0x73, 0x80, 0x77, 0x00, 0x77, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xC3, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38,
  0xE3, 0x9C, 0x39, 0xE7, 0x0E, 0x79, 0xC3, 0xBE, 0x60, 0xCD, 0xB8, 0x36,
  0x6E, 0x1D, 0x9B, 0x07, 0xC6, 0xC1, 0xB1, 0xF0, 0x78, 0x7C, 0x1E, 0x1E,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0x07, 0x80, 0xF0, 0x38, 0x1C, 0x03, 0x83,
  0xC0, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1E, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7B, 0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x03,
  0xC1, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x1F, 0xC0, 0x7B, 0x80,
  0xE7, 0x03, 0xCE, 0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xF7, 0xBC, 0xE7,
  0x39, 0xCE, 0x70, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x0F, 0x70, 0x79, 0xC3, 0xC3, 0x8E,
  0x0E, 0x70, 0x3B, 0xC0, 0xF6, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x63,
  0xC7, 0x8F, 0x1C, 0x20, 0x07, 0xFE, 0x1F, 0xF8, 0x7C, 0x71, 0xE0, 0xE7,
  0x83, 0xCE, 0x07, 0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0x81,
  0xC7, 0x83, 0x8F, 0xBF, 0x0F, 0xFE, 0x0F, 0xCE, 0x00, 0x01, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1F,
  0xF0, 0x7F, 0xE3, 0xE7, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x81, 0xDC,
  0x07, 0x70, 0x3D, 0xC0, 0xEF, 0x07, 0xB8, 0x3C, 0xF7, 0xE3, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x3F, 0xF0, 0xF8, 0x63, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0xDE, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xC7, 0x07, 0x83, 0x87, 0x81, 0xC3,
  0x81, 0xE1, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x1C,
  0x1E, 0x0E, 0x07, 0xBF, 0x03, 0xFF, 0xC0, 0xFC, 0xE0, 0x00, 0x40, 0x1F,
  0xE0, 0xFF, 0xC7, 0x87, 0x3C, 0x1D, 0xE0, 0x77, 0x03, 0xDC, 0x3E, 0xFF,
  0xF3, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF1, 0xC3, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x01, 0xE2, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x04, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x38,
  0x70, 0x3C, 0x38, 0x1C, 0x3C, 0x0E, 0x1E, 0x07, 0x0F, 0x07, 0x83, 0xEF,
  0x81, 0xFF, 0xC0, 0x7E, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x38,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xF8, 0x3F,
  0xF8, 0x78, 0xF0, 0xE0, 0xE1, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x79, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x3C,
  0x1C, 0x00, 0x02, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x3F, 0xCF, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x1F, 0xC7, 0xF0, 0xFC, 0x00, 0x02, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x73, 0xE0, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x1F, 0x1C, 0x3C, 0x1C,
  0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x3B, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x7B,
  0x80, 0x73, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0xF0, 0xF0, 0xE0, 0x70, 0xE0,
  0x78, 0x7F, 0x7F, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0F, 0xB7,
  0xF9, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x18, 0xE7, 0x38, 0xC7, 0x39, 0xC7,
  0x39, 0xC6, 0x31, 0xCE, 0x71, 0xCE, 0x73, 0x8E, 0x70, 0x0C, 0x70, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x1F, 0xF0, 0x7F, 0xE1,
  0xC7, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xDE, 0x0E, 0x70, 0x39,
  0xC0, 0xE7, 0x07, 0xBC, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x00, 0x00,
  0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x3C, 0x1D, 0xE0, 0x77, 0x01, 0xDC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xBC, 0x1E, 0xF0, 0x71, 0xFF, 0xC7,
  0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0x1F, 0x0E, 0x07, 0x0E,
  0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C,
  0x1E, 0x38, 0x3C, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x7C,
  0x71, 0xE0, 0xE3, 0x81, 0xCE, 0x07, 0x9C, 0x0E, 0x78, 0x1C, 0xF0, 0x39,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x87, 0x9F, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x7F, 0x70, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0xC7, 0x86, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x40,
  0x71, 0xC7, 0xCF, 0xFE, 0x1F, 0xF0, 0x03, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFE, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0xEE, 0x0F,
  0xF0, 0x3F, 0x80, 0x1C, 0x1E, 0x78, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x83,
  0xCF, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x79, 0xE0, 0xE3, 0xC1, 0xC7,
  0x87, 0x87, 0xBF, 0x0F, 0xFE, 0x0F, 0xCE, 0x00, 0xE0, 0x3F, 0x03, 0xF8,
  0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0x1E, 0x38, 0x73, 0x83, 0xBC,
  0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0xB8,
  0x03, 0x9C, 0x01, 0xCE, 0x30, 0xC7, 0x38, 0xE3, 0x1C, 0x71, 0x9E, 0x31,
  0xCF, 0xB8, 0xEF, 0xD8, 0x76, 0x6C, 0x3F, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x03, 0x83, 0x80, 0x0F, 0x03, 0xC1, 0xC1, 0xC0, 0x78, 0xE0,
  0x0E, 0x78, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x80, 0x38, 0xE0, 0x1C, 0x3C, 0x0E, 0x07,
  0x0F, 0x01, 0xE0, 0x07, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x87, 0x81, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE7, 0x00, 0x3D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x13, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x1E, 0x0E, 0xFF, 0x19, 0xFF, 0xF7, 0x1F, 0xC4, 0x0F, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 20, 16, 4, -20 },
  { 24, 10, 8, 16, 6, -22 },
  { 34, 17, 20, 16, 0, -20 },
  { 77, 15, 26, 16, 1, -23 },
  { 126, 19, 21, 16, -1, -21 },
  { 176, 15, 21, 16, 0, -21 },
  { 216, 5, 9, 16, 8, -22 },
  { 222, 13, 28, 16, 3, -23 },
  { 268, 13, 28, 16, 0, -23 },
  { 314, 13, 12, 16, 3, -20 },
  { 334, 14, 15, 16, 1, -16 },
  { 361, 8, 10, 16, 2, -5 },
  { 371, 9, 3, 16, 4, -10 },
  { 375, 5, 5, 16, 4, -5 },
  { 379, 19, 28, 16, -2, -23 },
  { 446, 15, 21, 16, 1, -21 },
  { 486, 13, 20, 16, 1, -20 },
  { 519, 15, 21, 16, 1, -21 },
  { 559, 16, 21, 16, 0, -21 },
  { 601, 16, 20, 16, 0, -20 },
  { 641, 17, 20, 16, 0, -20 },
  { 684, 15, 20, 16, 2, -20 },
  { 722, 15, 20, 16, 3, -20 },
  { 760, 15, 21, 16, 1, -21 },
  { 800, 15, 21, 16, 1, -21 },
  { 840, 8, 15, 16, 4, -15 },
  { 855, 10, 20, 16, 2, -15 },
  { 880, 15, 13, 16, 1, -15 },
  { 905, 15, 9, 16, 1, -13 },
  { 922, 14, 13, 16, 1, -15 },
  { 945, 12, 21, 16, 4, -21 },
  { 977, 16, 25, 16, 1, -21 },
  { 1027, 16, 20, 16, -2, -20 },
  { 1067, 16, 20, 16, 0, -20 },
  { 1107, 15, 21, 16, 2, -21 },
  { 1147, 16, 20, 16, 0, -20 },
  { 1187, 16, 20, 16, 1, -20 },
  { 1227, 17, 20, 16, 1, -20 },
  { 1270, 16, 21, 16, 1, -21 },
  { 1312, 18, 20, 16, 0, -20 },
  { 1357, 16, 20, 16, 1, -20 },
  { 1397, 16, 20, 16, 1, -20 },
  { 1437, 18, 20, 16, 0, -20 },
  { 1482, 13, 20, 16, 0, -20 },
  { 1515, 18, 20, 16, -1, -20 },
  { 1560, 18, 20, 16, 0, -20 },
  { 1605, 15, 21, 16, 1, -21 },
  { 1645, 17, 20, 16, 0, -20 },
  { 1688, 15, 26, 16, 1, -21 },
  { 1737, 16, 20, 16, 0, -20 },
  { 1777, 16, 21, 16, 0, -21 },
  { 1819, 15, 20, 16, 3, -20 },
  { 1857, 17, 20, 16, 1, -20 },
  { 1900, 16, 20, 16, 3, -20 },
  { 1940, 18, 20, 16, 0, -20 },
  { 1985, 20, 20, 16, -1, -20 },
  { 2035, 15, 20, 16, 4, -20 },
  { 2073, 17, 20, 16, 0, -20 },
  { 2116, 15, 28, 16, 2, -23 },
  { 2169, 5, 28, 16, 6, -23 },
  { 2187, 16, 28, 16, -1, -23 },
  { 2243, 14, 11, 16, 2, -20 },
  { 2263, 15, 2, 16, -2, 3 },
  { 2267, 6, 6, 16, 7, -22 },
  { 2272, 15, 15, 16, 1, -15 },
  { 2301, 14, 23, 16, 1, -23 },
  { 2342, 15, 16, 16, 1, -16 },
  { 2372, 17, 23, 16, 1, -23 },
  { 2421, 14, 16, 16, 1, -16 },
  { 2449, 20, 28, 16, -2, -23 },
  { 2519, 17, 20, 16, -1, -15 },
  { 2562, 15, 23, 16, 0, -23 },
  { 2606, 10, 23, 16, 3, -23 },
  { 2635, 16, 28, 16, -1, -23 },
  { 2691, 16, 23, 16, 1, -23 },
  { 2737, 9, 22, 16, 4, -22 },
  { 2762, 16, 15, 16, 0, -15 },
  { 2792, 14, 15, 16, 1, -15 },
  { 2819, 14, 16, 16, 1, -16 },
  { 2847, 16, 20, 16, -1, -15 },
  { 2887, 15, 20, 16, 1, -15 },
  { 2925, 15, 15, 16, 1, -15 },
  { 2954, 14, 16, 16, 1, -16 },
  { 2982, 13, 20, 16, 3, -20 },
  { 3015, 15, 15, 16, 1, -15 },
  { 3044, 13, 15, 16, 3, -15 },
  { 3069, 17, 15, 16, 1, -15 },
  { 3101, 18, 15, 16, -1, -15 },
  { 3135, 18, 20, 16, -2, -15 },
  { 3180, 15, 15, 16, 1, -15 },
  { 3209, 15, 28, 16, 2, -23 },
  { 3262, 10, 28, 16, 3, -23 },
  { 3297, 15, 28, 16, -1, -23 },
  { 3350, 15, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic29pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC29PT7B_H_
