#ifndef _UBUNTUSANSMONO_MEDIUMITALIC35PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x0E, 0xF1, 0xEF, 0x1E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x18, 0xC1, 0x80,
  0x00, 0x38, 0x78, 0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x0F,
  0x1E, 0x00, 0x70, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x87,
  0x00, 0x38, 0x78, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80,
  0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7C, 0x04, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x18, 0x07, 0x83, 0xFF, 0xF0,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x1C, 0x1F,
  0xC0, 0x70, 0x71, 0x81, 0xC0, 0xE3, 0x07, 0x01, 0x86, 0x1C, 0x07, 0x1C,
  0x70, 0x0E, 0x39, 0xE0, 0x1C, 0x73, 0x80, 0x39, 0xCE, 0x00, 0x3F, 0x38,
  0x00, 0x7C, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x1D, 0xF8,
  0x00, 0x77, 0xF0, 0x01, 0xCE, 0x70, 0x07, 0x38, 0xE0, 0x1C, 0x71, 0xC0,
  0x70, 0xE3, 0x81, 0xE1, 0x86, 0x03, 0x83, 0x1C, 0x0E, 0x07, 0x38, 0x38,
  0x0F, 0xE0, 0xE0, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xF9, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1C,
  0x1C, 0x0F, 0x1E, 0x07, 0x9E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x38,
  0xFE, 0x1C, 0xF7, 0x9E, 0xF1, 0xCE, 0xF0, 0xFF, 0x78, 0x3F, 0x38, 0x1F,
  0x9C, 0x07, 0x8E, 0x03, 0xC7, 0x87, 0xF3, 0xFF, 0xF8, 0xFF, 0x9C, 0x3F,
  0x8F, 0x00, 0x3D, 0xF7, 0x9E, 0x79, 0xCF, 0x3C, 0xE3, 0x8E, 0x00, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x40, 0x01, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x00, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x02, 0x1C, 0x2F, 0x39, 0xDF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xF8, 0x07, 0xC0, 0x1D, 0xC0, 0x7B, 0xC1, 0xE3, 0xC7, 0xC7, 0x83,
  0x06, 0x02, 0x08, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F, 0x1F, 0x0F, 0x0E, 0x3E, 0xFC,
  0xF0, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0x78, 0xF0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x71, 0xFE, 0x7C,
  0xFF, 0x3E, 0x7F, 0x9F, 0x3F, 0xC7, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0x70,
  0x0F, 0x38, 0x07, 0x9E, 0x07, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0x9E, 0x04, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x07, 0x03, 0xC1, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x10,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0xC0, 0x3E, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3C, 0xE0, 0x0F, 0x3C, 0x03, 0xC7,
  0x80, 0xF0, 0xF0, 0x3C, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x1E,
  0x1E, 0x03, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x60, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x7E, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0xFC, 0x1F, 0x3C, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78,
  0x78, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x02, 0x00, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xF3, 0xE0, 0x78, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70,
  0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xF8, 0x07, 0x8F, 0x81, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x00,
  0xE3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x3E, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0x70, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x0F, 0x01,
  0xE1, 0xFB, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0E, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xE3,
  0xF1, 0xF8, 0xFC, 0x3C, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x3C, 0x07, 0x03, 0xE1, 0xF8, 0x3C,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x10,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF0, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7F, 0xC1, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0x00, 0x00, 0x07,
  0xE0, 0xFF, 0xE3, 0xFF, 0x8F, 0x3F, 0x20, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xF0, 0xF0, 0x78, 0x0E, 0x1E, 0x01, 0xC7, 0x80, 0x38,
  0xE0, 0x07, 0x3C, 0x1F, 0xE7, 0x0F, 0xFD, 0xE3, 0xFF, 0xBC, 0x78, 0xF7,
  0x1E, 0x1C, 0xE3, 0x83, 0xBC, 0xF0, 0xF7, 0x9E, 0x1E, 0xE3, 0x83, 0x9C,
  0x70, 0x73, 0x8E, 0x1E, 0x71, 0xE3, 0xCE, 0x3F, 0xF1, 0xC3, 0xFE, 0x3C,
  0x3F, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x1E, 0x70,
  0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x81, 0xE0, 0xF0,
  0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0x7F, 0x80, 0x0F, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x78, 0x38, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFF, 0x07, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0,
  0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0xFF, 0xC7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xF8, 0x0C, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x18, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x7C, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x38, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00,
  0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x83, 0xF0, 0xF1, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x01, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0x08, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x81, 0xE1, 0xF8, 0x78, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x40, 0x00, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x70, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x20, 0x1E, 0x07, 0x07, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x3E,
  0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3B, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x73, 0xC0, 0x03, 0xCF,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x81, 0xE0,
  0x1E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x01, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x1D, 0x87, 0xE0, 0x76, 0x3B, 0x81, 0xD8, 0xEE,
  0x0F, 0x77, 0x70, 0x39, 0xD9, 0xC0, 0xE7, 0xE7, 0x03, 0x9F, 0x1C, 0x1E,
  0x7C, 0xF0, 0x71, 0xE3, 0xC1, 0xC7, 0x8E, 0x0F, 0x00, 0x38, 0x3C, 0x01,
  0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x3E,
  0x03, 0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xE0, 0x7E, 0x07, 0x07, 0xF0, 0x78,
  0x3F, 0x83, 0xC1, 0xDE, 0x1C, 0x0E, 0x70, 0xE0, 0xF3, 0x8F, 0x07, 0x9C,
  0x78, 0x38, 0xF3, 0xC1, 0xC3, 0x9C, 0x1E, 0x1C, 0xE0, 0xF0, 0xEF, 0x07,
  0x07, 0x78, 0x38, 0x1B, 0x83, 0xC0, 0xFC, 0x1E, 0x07, 0xE0, 0xE0, 0x3F,
  0x07, 0x01, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x1E,
  0x07, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0,
  0x07, 0xBC, 0x00, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80,
  0x1E, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x3C, 0x07, 0x87, 0x81,
  0xE0, 0xF8, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0x81, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x1E, 0x0F, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x07, 0xBC, 0x00, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF8, 0x7C, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x0F, 0x0F, 0x03,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0x40, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x87, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x70,
  0x0F, 0x0F, 0x00, 0xF0, 0x70, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x03,
  0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0x8F, 0x00,
  0x73, 0xC0, 0x0E, 0x78, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0,
  0x03, 0x87, 0x80, 0x1C, 0x38, 0x01, 0xE1, 0xC7, 0x8E, 0x0E, 0x3C, 0x70,
  0xF3, 0xE3, 0x87, 0x1F, 0x3C, 0x39, 0xD9, 0xC1, 0xCC, 0xCE, 0x0E, 0xE6,
  0x70, 0x7E, 0x37, 0x07, 0x71, 0xB8, 0x3F, 0x0D, 0xC1, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x0F, 0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xFE, 0x00, 0x79,
  0xC0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x01,
  0xC1, 0xE0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x0E, 0x1E, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x3E,
  0x38, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x9E, 0x01, 0xFF, 0x00, 0xF3,
  0x00, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x20, 0x70,
  0xF8, 0x3C, 0x1E, 0x0F, 0x06, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x1C, 0x78,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE1, 0xE0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFC, 0xF0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x38, 0x07, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF3, 0xC0, 0xF9, 0xC0,
  0xF9, 0xE0, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x80, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x18, 0x3F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0x07, 0x83, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x07, 0x83, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xCF,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x7E, 0x1F, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x39, 0xE0, 0x1E, 0x78, 0x1F, 0x9F, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x18, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC2, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0,
  0x38, 0x1F, 0x0F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x06, 0x03, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xBC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x07,
  0x87, 0x81, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x1F, 0xF1, 0xFF, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE1, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0xC1, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x3C, 0x1E, 0x07, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0xF8, 0x07, 0xBE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8,
  0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x1E, 0x1F, 0x03, 0xC1, 0xE0, 0xF0, 0x3E,
  0x1E, 0x03, 0xC3, 0xC0, 0x7C, 0x00, 0x7F, 0xDF, 0xFB, 0xFE, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC1, 0x7F, 0xE7, 0xFC, 0xFF, 0x80, 0x01, 0x81, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0x7E, 0xF1, 0xC7, 0x8E, 0x38, 0xF1, 0xC7, 0x1C,
  0x79, 0xE3, 0x8F, 0x38, 0x71, 0xC7, 0x1E, 0x38, 0xE3, 0x8F, 0x3C, 0x71,
  0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x07, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xF1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71,
  0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0x79, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x78, 0xF8, 0x7C, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x87, 0x03, 0xE1, 0xE1, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xF3, 0xF0, 0x79, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78,
  0x0F, 0x3C, 0x07, 0x9C, 0x03, 0xCE, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0,
  0xF0, 0x10, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xC0,
  0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x08, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x3C, 0x07, 0x9E, 0x03,
  0x8F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x78, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xCE, 0x00, 0xF0,
  0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xCE, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C,
  0x03, 0xBC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x0E,
  0x78, 0xE1, 0xE7, 0x0F, 0x1C, 0x71, 0xF1, 0xC7, 0x1F, 0x3C, 0x73, 0xF3,
  0x87, 0x3F, 0x38, 0x77, 0x77, 0x07, 0x77, 0x70, 0x7E, 0x7F, 0x06, 0xC7,
  0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0x0F,
  0x80, 0xF8, 0x3C, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x1E, 0x78,
  0x00, 0xF7, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xE0, 0x07, 0xC7, 0x80,
  0x7C, 0x3C, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x00, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x78,
  0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x23, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x07, 0xE0, 0x73, 0xFE, 0x3D, 0xFF,
  0xFE, 0x71, 0xFF, 0x38, 0x1F, 0x82, 0x03, 0xC0,
};

const GFXglyph UbuntuSansMono_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 10, 24, 20, 5, -24 },
  { 31, 12, 11, 20, 7, -27 },
  { 48, 21, 24, 20, 0, -24 },
  { 111, 19, 31, 20, 1, -27 },
  { 185, 23, 26, 20, -1, -25 },
  { 260, 17, 25, 20, 1, -25 },
  { 314, 6, 11, 20, 10, -27 },
  { 323, 15, 35, 20, 4, -28 },
  { 389, 15, 35, 20, 1, -28 },
  { 455, 15, 15, 20, 4, -24 },
  { 484, 16, 17, 20, 2, -19 },
  { 518, 8, 12, 20, 3, -6 },
  { 530, 10, 4, 20, 5, -12 },
  { 535, 6, 6, 20, 5, -6 },
  { 540, 23, 33, 20, -2, -27 },
  { 635, 17, 26, 20, 2, -25 },
  { 691, 15, 24, 20, 2, -24 },
  { 736, 18, 25, 20, 1, -25 },
  { 793, 19, 26, 20, 0, -25 },
  { 855, 19, 24, 20, 0, -24 },
  { 912, 20, 25, 20, 0, -24 },
  { 975, 18, 25, 20, 2, -24 },
  { 1032, 18, 24, 20, 4, -24 },
  { 1086, 19, 26, 20, 1, -25 },
  { 1148, 19, 25, 20, 1, -25 },
  { 1208, 9, 18, 20, 5, -18 },
  { 1229, 11, 24, 20, 3, -18 },
  { 1262, 17, 16, 20, 2, -18 },
  { 1296, 18, 11, 20, 1, -16 },
  { 1321, 17, 16, 20, 1, -18 },
  { 1355, 14, 25, 20, 5, -25 },
  { 1399, 19, 30, 20, 1, -25 },
  { 1471, 19, 24, 20, -2, -24 },
  { 1528, 19, 25, 20, 0, -25 },
  { 1588, 19, 26, 20, 2, -25 },
  { 1650, 19, 25, 20, 0, -25 },
  { 1710, 20, 24, 20, 1, -24 },
  { 1770, 20, 24, 20, 1, -24 },
  { 1830, 19, 26, 20, 2, -25 },
  { 1892, 21, 24, 20, 0, -24 },
  { 1955, 19, 24, 20, 1, -24 },
  { 2012, 19, 25, 20, 1, -24 },
  { 2072, 22, 24, 20, 0, -24 },
  { 2138, 16, 24, 20, 0, -24 },
  { 2186, 22, 24, 20, -1, -24 },
  { 2252, 21, 24, 20, 0, -24 },
  { 2315, 19, 26, 20, 1, -25 },
  { 2377, 20, 25, 20, 0, -25 },
  { 2440, 19, 32, 20, 1, -25 },
  { 2516, 19, 25, 20, 0, -25 },
  { 2576, 20, 26, 20, 0, -25 },
  { 2641, 18, 24, 20, 4, -24 },
  { 2695, 20, 25, 20, 1, -24 },
  { 2758, 19, 24, 20, 4, -24 },
  { 2815, 21, 24, 20, 1, -24 },
  { 2878, 23, 24, 20, -1, -24 },
  { 2947, 19, 24, 20, 4, -24 },
  { 3004, 21, 24, 20, 0, -24 },
  { 3067, 18, 33, 20, 2, -27 },
  { 3142, 7, 33, 20, 7, -27 },
  { 3171, 19, 33, 20, -1, -27 },
  { 3250, 17, 13, 20, 2, -24 },
  { 3278, 19, 3, 20, -3, 3 },
  { 3286, 8, 7, 20, 8, -27 },
  { 3293, 18, 19, 20, 1, -19 },
  { 3336, 17, 27, 20, 1, -27 },
  { 3394, 18, 19, 20, 1, -19 },
  { 3437, 20, 27, 20, 1, -27 },
  { 3505, 18, 19, 20, 1, -19 },
  { 3548, 24, 34, 20, -2, -27 },
  { 3650, 20, 26, 20, -1, -19 },
  { 3715, 18, 27, 20, 0, -27 },
  { 3776, 13, 27, 20, 3, -27 },
  { 3820, 19, 34, 20, -1, -27 },
  { 3901, 19, 27, 20, 1, -27 },
  { 3966, 11, 27, 20, 5, -27 },
  { 4004, 19, 19, 20, 0, -19 },
  { 4050, 17, 19, 20, 1, -19 },
  { 4091, 17, 19, 20, 1, -19 },
  { 4132, 19, 25, 20, -1, -19 },
  { 4192, 17, 25, 20, 2, -19 },
  { 4246, 17, 19, 20, 2, -19 },
  { 4287, 17, 19, 20, 1, -19 },
  { 4328, 16, 24, 20, 3, -24 },
  { 4376, 17, 18, 20, 2, -18 },
  { 4415, 17, 18, 20, 3, -18 },
  { 4454, 20, 18, 20, 1, -18 },
  { 4499, 21, 18, 20, -1, -18 },
  { 4547, 23, 25, 20, -3, -18 },
  { 4619, 18, 18, 20, 1, -18 },
  { 4660, 19, 33, 20, 2, -27 },
  { 4739, 12, 33, 20, 4, -27 },
  { 4789, 18, 33, 20, -1, -27 },
  { 4864, 18, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC35PT7B_H_
