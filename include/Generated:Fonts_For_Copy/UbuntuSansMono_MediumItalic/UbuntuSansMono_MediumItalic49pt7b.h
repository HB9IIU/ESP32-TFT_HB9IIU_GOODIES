#ifndef _UBUNTUSANSMONO_MEDIUMITALIC49PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xF8,
  0x01, 0x80, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x1F, 0x9F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xC0, 0xF0, 0x70, 0x3C, 0x3C, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xC0, 0x38, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xE0, 0x03, 0xF0, 0x3F,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x3F, 0xE0, 0x03, 0xC0,
  0x3F, 0xF8, 0x03, 0xC0, 0x1E, 0x3C, 0x03, 0xC0, 0x1E, 0x1E, 0x03, 0xC0,
  0x0F, 0x0F, 0x03, 0xE0, 0x07, 0x87, 0x83, 0xE0, 0x03, 0x83, 0xC1, 0xE0,
  0x03, 0xC1, 0xC1, 0xE0, 0x01, 0xE1, 0xE1, 0xE0, 0x00, 0xF0, 0xF1, 0xE0,
  0x00, 0x78, 0x79, 0xF0, 0x00, 0x3E, 0x79, 0xF0, 0x00, 0x0F, 0xF8, 0xF0,
  0x00, 0x07, 0xF8, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xF9,
  0xFE, 0x00, 0x00, 0x79, 0xFF, 0x80, 0x00, 0x79, 0xF3, 0xC0, 0x00, 0x78,
  0xF1, 0xE0, 0x00, 0x78, 0x70, 0xF0, 0x00, 0x7C, 0x78, 0x78, 0x00, 0x7C,
  0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x1E, 0x00, 0x3C, 0x0E, 0x0F, 0x00, 0x3C,
  0x07, 0x07, 0x00, 0x3C, 0x03, 0x87, 0x80, 0x3E, 0x01, 0xE3, 0xC0, 0x3E,
  0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x0F, 0xC1, 0xF0, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x1F, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xC1, 0xFF, 0x03, 0xC1, 0xFF, 0xC3, 0xE1, 0xF3, 0xF1, 0xF1, 0xF0, 0xF8,
  0xF1, 0xF0, 0x7E, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x07, 0xFC, 0x7C, 0x03,
  0xFC, 0x3E, 0x00, 0xFE, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xE0,
  0x3F, 0xC3, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x7C, 0x1F,
  0xFE, 0x3E, 0x07, 0xFC, 0x1F, 0x80, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xC1,
  0xE0, 0xC7, 0xC7, 0x8F, 0x9F, 0xDE, 0xFE, 0x7F, 0xB7, 0xFB, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x80, 0xF8,
  0x3C, 0x01, 0xC0, 0xE0, 0x02, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xE0,
  0x3E, 0x07, 0xC1, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0E, 0x00, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE1, 0xF8, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC7,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C,
  0xF8, 0x78, 0x7E, 0x7C, 0x7E, 0x3F, 0x7E, 0x3F, 0x1F, 0x3E, 0x1F, 0x8F,
  0x9F, 0x0F, 0xC7, 0xCF, 0x87, 0xC3, 0xE7, 0xC1, 0xC3, 0xF7, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x03, 0xE0,
  0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFB, 0xE0, 0x3F, 0x3F, 0x00,
  0xE1, 0xF8, 0x04, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x1E,
  0x00, 0xFC, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0x81, 0xFC, 0x02, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC2, 0x00, 0x0F, 0xE1, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x20,
  0x00, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF1, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x3E, 0x00, 0xF8,
  0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0x7F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x87, 0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xF1, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0,
  0xFC, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x1F, 0x01, 0xFF, 0xE1,
  0xF0, 0x7F, 0xFE, 0x3E, 0x0F, 0xFF, 0xE3, 0xE1, 0xFE, 0x7C, 0x3E, 0x1F,
  0x87, 0xC3, 0xC3, 0xF0, 0x7C, 0x7C, 0x3E, 0x07, 0xC7, 0xC7, 0xC0, 0x7C,
  0x7C, 0x7C, 0x0F, 0x87, 0x87, 0xC0, 0xF8, 0x78, 0x7C, 0x0F, 0x87, 0x87,
  0xC0, 0xF8, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7F, 0xBE, 0x07, 0x83, 0xFF, 0xE0, 0x78,
  0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xE0, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0x83, 0xFE, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x87, 0xE0,
  0x0F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0x81, 0xE0, 0x3F, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x08, 0x07, 0xF8, 0x1E, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x9F, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x07, 0xC0, 0x7F, 0x80, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFC, 0x07, 0x00, 0xFE, 0x00, 0x20, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x10, 0x01, 0xFC,
  0x03, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3E, 0x03, 0xF8,
  0x00, 0x7C, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7B, 0x81,
  0xFE, 0x01, 0xEF, 0x0F, 0x78, 0x07, 0xBC, 0x3D, 0xE0, 0x3E, 0xF1, 0xEF,
  0x80, 0xF3, 0xC7, 0x3C, 0x03, 0xCF, 0x3C, 0xF0, 0x0F, 0x3C, 0xE3, 0xC0,
  0x7C, 0xF7, 0x9F, 0x01, 0xE3, 0xDC, 0x7C, 0x07, 0x8F, 0xF1, 0xE0, 0x3E,
  0x1F, 0x87, 0x80, 0xF8, 0x7E, 0x3E, 0x03, 0xC1, 0xF0, 0xF8, 0x1F, 0x07,
  0xC3, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0xF8, 0x07, 0xF8,
  0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x01,
  0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x7C, 0xF0, 0x3E, 0x01, 0xF3, 0xC0, 0xF8,
  0x07, 0xCF, 0x83, 0xE0, 0x1F, 0x3E, 0x0F, 0x80, 0x78, 0x78, 0x3C, 0x03,
  0xE1, 0xE1, 0xF0, 0x0F, 0x87, 0xC7, 0xC0, 0x3E, 0x1F, 0x1F, 0x00, 0xF0,
  0x3C, 0x78, 0x07, 0xC0, 0xF3, 0xE0, 0x1F, 0x03, 0xCF, 0x80, 0x7C, 0x0F,
  0xBE, 0x01, 0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x3E, 0x01, 0xFF,
  0x00, 0xF8, 0x07, 0xFC, 0x03, 0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0x3F, 0x80,
  0x7C, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x3E,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F,
  0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C,
  0x01, 0xFC, 0x0F, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x7F,
  0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x83, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x7C,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x3F,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1C, 0x01, 0xF8, 0x00, 0x40, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x03, 0x00, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x0F,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0,
  0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x3E, 0x0F, 0x01, 0xE1, 0xF8, 0x7C, 0x07, 0x87, 0xE1, 0xF0,
  0x3E, 0x3F, 0x87, 0x80, 0xF8, 0xFE, 0x1E, 0x03, 0xC7, 0xB8, 0xF8, 0x0F,
  0x1E, 0xE3, 0xC0, 0x3C, 0xF3, 0x8F, 0x00, 0xF3, 0xCE, 0x3C, 0x07, 0xDE,
  0x3D, 0xF0, 0x1E, 0x70, 0xF7, 0x80, 0x7B, 0xC3, 0xDE, 0x01, 0xEE, 0x0F,
  0x78, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xF9, 0xF8, 0x01,
  0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0x38, 0x00, 0x3C, 0x08, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x80, 0x10, 0x0E, 0x07, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0x80, 0x40, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0x0F, 0xE0, 0x3E, 0x1F, 0xC0, 0x3E, 0x3F,
  0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xF8, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0xFC, 0x03, 0xF8, 0x7C, 0x03, 0xF8, 0x3E, 0x0F, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0x3E, 0x0F, 0xF0, 0x02, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x10, 0x7F, 0x80, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0x00, 0xFF, 0x03,
  0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x7C, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7F, 0x80, 0x70, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xC7, 0xE0, 0x1F, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x38, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x06, 0x00, 0x3F, 0x00, 0x7E, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0xF8,
  0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x00, 0xFE, 0x00, 0x3F, 0x7F,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x0F, 0xE0, 0x03, 0xE3, 0xF8, 0x00,
  0xFC, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x06, 0x3F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x3F,
  0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xE7, 0xF3,
  0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3C, 0x1E, 0x07,
  0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1,
  0xF0, 0xF8, 0x7C, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x7F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x03, 0xF8, 0x0F, 0x80, 0xFF, 0x00, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xF0,
  0x7F, 0x81, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xC0,
  0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFD, 0xF0, 0x00, 0x21, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xCF, 0xC0, 0xFC,
  0x00, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x86, 0x00, 0x3F, 0x0F, 0x00, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0,
  0xFC, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFC, 0xF8, 0x1F, 0xF8, 0xF8, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F,
  0x00, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83,
  0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x0E, 0x07,
  0xC7, 0xC1, 0xF0, 0x78, 0x7C, 0x3F, 0x0F, 0x87, 0x83, 0xF0, 0xF8, 0x78,
  0x7F, 0x0F, 0x07, 0x87, 0xF1, 0xF0, 0x78, 0xFF, 0x1E, 0x07, 0x8F, 0xF1,
  0xE0, 0xF9, 0xEF, 0x3E, 0x0F, 0x9E, 0xF3, 0xC0, 0xFB, 0xCF, 0x3C, 0x0F,
  0x3C, 0xF7, 0xC0, 0xF7, 0x87, 0x78, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x02, 0x01, 0xFE, 0x01, 0xF0, 0xFF, 0xE0, 0x78, 0x7F, 0xFC, 0x3E, 0x3F,
  0xFF, 0xFF, 0x1F, 0x8F, 0xFF, 0xC7, 0xC0, 0xFF, 0xE3, 0xE0, 0x1F, 0xF0,
  0x10, 0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 14, 35, 27, 7, -34 },
  { 63, 18, 14, 27, 9, -37 },
  { 95, 29, 34, 27, 0, -34 },
  { 219, 26, 43, 27, 1, -38 },
  { 359, 33, 36, 27, -2, -35 },
  { 508, 25, 35, 27, 1, -35 },
  { 618, 8, 15, 27, 14, -37 },
  { 633, 21, 48, 27, 6, -39 },
  { 759, 21, 48, 27, 1, -39 },
  { 885, 22, 21, 27, 5, -34 },
  { 943, 24, 25, 27, 2, -27 },
  { 1018, 12, 16, 27, 4, -8 },
  { 1042, 14, 6, 27, 7, -17 },
  { 1053, 9, 9, 27, 7, -8 },
  { 1064, 32, 47, 27, -3, -38 },
  { 1252, 25, 36, 27, 2, -35 },
  { 1365, 21, 34, 27, 2, -34 },
  { 1455, 26, 35, 27, 1, -35 },
  { 1569, 25, 36, 27, 1, -35 },
  { 1682, 27, 34, 27, 0, -34 },
  { 1797, 28, 35, 27, 0, -34 },
  { 1920, 25, 35, 27, 3, -34 },
  { 2030, 25, 34, 27, 5, -34 },
  { 2137, 26, 36, 27, 2, -35 },
  { 2254, 25, 35, 27, 2, -35 },
  { 2364, 13, 26, 27, 7, -25 },
  { 2407, 16, 33, 27, 4, -25 },
  { 2473, 25, 22, 27, 2, -25 },
  { 2542, 26, 15, 27, 1, -22 },
  { 2591, 25, 22, 27, 1, -25 },
  { 2660, 20, 36, 27, 7, -35 },
  { 2750, 28, 42, 27, 1, -35 },
  { 2897, 27, 34, 27, -3, -34 },
  { 3012, 27, 34, 27, 0, -34 },
  { 3127, 26, 36, 27, 3, -35 },
  { 3244, 27, 34, 27, 0, -34 },
  { 3359, 28, 34, 27, 1, -34 },
  { 3478, 28, 34, 27, 2, -34 },
  { 3597, 27, 36, 27, 2, -35 },
  { 3719, 30, 34, 27, 0, -34 },
  { 3847, 27, 34, 27, 1, -34 },
  { 3962, 27, 35, 27, 1, -34 },
  { 4081, 31, 34, 27, 0, -34 },
  { 4213, 21, 34, 27, 1, -34 },
  { 4303, 30, 34, 27, -1, -34 },
  { 4431, 30, 34, 27, 0, -34 },
  { 4559, 26, 36, 27, 2, -35 },
  { 4676, 27, 34, 27, 1, -34 },
  { 4791, 26, 44, 27, 2, -35 },
  { 4934, 27, 34, 27, 0, -34 },
  { 5049, 28, 36, 27, 0, -35 },
  { 5175, 25, 34, 27, 6, -34 },
  { 5282, 28, 35, 27, 2, -34 },
  { 5405, 27, 34, 27, 5, -34 },
  { 5520, 30, 34, 27, 1, -34 },
  { 5648, 33, 34, 27, -2, -34 },
  { 5789, 26, 34, 27, 6, -34 },
  { 5900, 29, 34, 27, 0, -34 },
  { 6024, 26, 47, 27, 3, -38 },
  { 6177, 9, 47, 27, 10, -38 },
  { 6230, 26, 47, 27, -1, -38 },
  { 6383, 24, 19, 27, 3, -34 },
  { 6440, 26, 5, 27, -4, 4 },
  { 6457, 10, 10, 27, 12, -38 },
  { 6470, 24, 27, 27, 2, -26 },
  { 6551, 25, 39, 27, 1, -38 },
  { 6673, 24, 27, 27, 2, -26 },
  { 6754, 28, 39, 27, 2, -38 },
  { 6891, 24, 27, 27, 2, -26 },
  { 6972, 34, 47, 27, -3, -38 },
  { 7172, 28, 35, 27, -1, -26 },
  { 7295, 25, 38, 27, 0, -38 },
  { 7414, 17, 38, 27, 5, -38 },
  { 7495, 28, 47, 27, -2, -38 },
  { 7660, 27, 38, 27, 1, -38 },
  { 7789, 16, 39, 27, 7, -38 },
  { 7867, 28, 26, 27, -1, -26 },
  { 7958, 24, 26, 27, 1, -26 },
  { 8036, 24, 27, 27, 2, -26 },
  { 8117, 28, 35, 27, -2, -26 },
  { 8240, 25, 35, 27, 2, -26 },
  { 8350, 25, 26, 27, 2, -26 },
  { 8432, 23, 27, 27, 2, -26 },
  { 8510, 22, 34, 27, 5, -33 },
  { 8604, 24, 27, 27, 2, -26 },
  { 8685, 23, 26, 27, 5, -26 },
  { 8760, 28, 26, 27, 2, -26 },
  { 8851, 29, 26, 27, -1, -26 },
  { 8946, 32, 35, 27, -4, -26 },
  { 9086, 25, 26, 27, 1, -26 },
  { 9168, 27, 47, 27, 3, -38 },
  { 9327, 16, 47, 27, 6, -38 },
  { 9421, 26, 47, 27, -2, -38 },
  { 9574, 26, 9, 27, 1, -19 },
};

const GFXfont UbuntuSansMono_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic49pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC49PT7B_H_
