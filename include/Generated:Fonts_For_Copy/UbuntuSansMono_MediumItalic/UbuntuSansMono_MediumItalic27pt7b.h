#ifndef _UBUNTUSANSMONO_MEDIUMITALIC27PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x71, 0xDC, 0x77, 0x39,
  0xCE, 0x63, 0xB8, 0xCE, 0x33, 0x0C, 0x00, 0xC7, 0x01, 0xC6, 0x01, 0x8E,
  0x03, 0x8E, 0x03, 0x8C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x0E, 0x38,
  0x0E, 0x30, 0x0C, 0x70, 0x1C, 0x60, 0xFF, 0xFC, 0xFF, 0xFC, 0x31, 0xC0,
  0x71, 0xC0, 0x71, 0x80, 0x63, 0x80, 0xE3, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0xFE, 0x0F, 0xFC, 0x7C, 0xE1, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x71, 0x03, 0xCF, 0xFE, 0x3F, 0xF0, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x07, 0x80, 0xC3, 0xF0, 0x60, 0xCC, 0x30, 0x63, 0x18, 0x18,
  0xCE, 0x06, 0x67, 0x01, 0x99, 0x80, 0x7C, 0xC0, 0x0F, 0x60, 0x00, 0x30,
  0x00, 0x1D, 0xC0, 0x0E, 0xF8, 0x07, 0x76, 0x01, 0x99, 0x80, 0xC6, 0x60,
  0x63, 0x98, 0x38, 0xE6, 0x1C, 0x1F, 0x0E, 0x07, 0x80, 0x01, 0xF0, 0x1F,
  0xE0, 0x73, 0x83, 0x86, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x03, 0xB8, 0x07,
  0xC0, 0x3C, 0x31, 0xF9, 0xCE, 0xF6, 0x71, 0xF9, 0x83, 0xCE, 0x0F, 0x38,
  0x3C, 0x71, 0xF1, 0xFE, 0xE3, 0xF3, 0x80, 0x77, 0x7E, 0xEE, 0xCC, 0xC0,
  0x00, 0x60, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0x80, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0,
  0x3C, 0x0F, 0x80, 0x70, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x06, 0x04, 0x66,
  0xF6, 0xEF, 0xFF, 0x0E, 0x01, 0xF0, 0x3B, 0x87, 0x9C, 0x31, 0xC1, 0x08,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x08,
  0x78, 0xF9, 0xF3, 0xE1, 0x87, 0x7C, 0xE0, 0xFF, 0xFE, 0xFE, 0x27, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0x87, 0x3C, 0x1C, 0xE0, 0x73,
  0x81, 0xDC, 0x47, 0x73, 0x9D, 0xDE, 0x66, 0x73, 0xB8, 0x0E, 0xE0, 0x3B,
  0x81, 0xCE, 0x07, 0x38, 0x38, 0x71, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x00,
  0x70, 0x0F, 0x03, 0xE0, 0xFE, 0x1F, 0xE1, 0xCE, 0x11, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x7F,
  0xF7, 0xFE, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0xE1, 0xF7, 0x82, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1C, 0xF0, 0x20, 0xE0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x60, 0xF0, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1D, 0xC0,
  0x73, 0x01, 0xCE, 0x07, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0xE1, 0xC3, 0x83,
  0x87, 0xFF, 0xDF, 0xFF, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x61, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3C, 0x07, 0xE0, 0x7F, 0x83, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0xE0, 0xFF, 0xE3, 0xFF, 0x8E, 0x0F, 0x38,
  0x1C, 0xC0, 0x73, 0x01, 0xCC, 0x07, 0x38, 0x38, 0xF1, 0xE1, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xE0, 0xF3, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1,
  0xC7, 0x0E, 0x0F, 0xF0, 0x3F, 0x03, 0xDE, 0x1E, 0x3C, 0x70, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xF0, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x03, 0xE0,
  0x3F, 0xE1, 0xE7, 0x8F, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x1C, 0xFF, 0xF1, 0xFF, 0x81, 0xCE, 0x00, 0x70, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0x80, 0x00, 0x0C, 0x3C, 0xF9, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x87, 0xCF, 0x9F, 0x3C, 0x00, 0x03, 0x03,
  0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0x83,
  0xE1, 0xF0, 0xF8, 0x18, 0x1C, 0x7C, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xF0,
  0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xF0, 0x0F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x18, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x2F, 0xFF, 0x3F, 0xFC, 0x30, 0x01, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x7F, 0x1F, 0xC7, 0xF0, 0x3E,
  0x01, 0x80, 0x00, 0x3F, 0x8F, 0xF8, 0xCF, 0x80, 0xF0, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x18, 0x04, 0x00, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3C, 0x70,
  0xE0, 0x73, 0x80, 0xE7, 0x01, 0xDC, 0x3F, 0xB9, 0xFE, 0x63, 0x9D, 0xCE,
  0x3B, 0x98, 0x77, 0x70, 0xCC, 0xE3, 0x99, 0xC7, 0x33, 0x8E, 0x63, 0xF8,
  0xE7, 0xF1, 0xC3, 0xC3, 0x80, 0x03, 0x80, 0x07, 0xC4, 0x07, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0xD8, 0x0E,
  0x60, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x07, 0x1F,
  0xFC, 0xFF, 0xF3, 0x81, 0xDC, 0x07, 0x70, 0x1F, 0x80, 0x7E, 0x01, 0xC0,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x70, 0xC0, 0xE3, 0x81, 0xC7,
  0x07, 0x0E, 0x1E, 0x1F, 0xF0, 0x7F, 0xE0, 0xE3, 0xE1, 0xC1, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x71, 0xF9, 0xFF, 0xC3, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xC7, 0x02, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF8, 0xC1, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x70, 0xE1, 0xC1, 0xC3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE7, 0x03, 0xCE, 0x07,
  0x1C, 0x1E, 0x38, 0x78, 0xF7, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x21, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E,
  0x3C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x7F, 0xC0, 0x7F, 0x80, 0x0E, 0x07,
  0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x1C, 0x0E, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70,
  0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x20, 0xF0, 0xE3, 0xC1, 0xFF, 0x81, 0xFC, 0x00,
  0x0F, 0x07, 0x87, 0x07, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE3, 0x80, 0xE3,
  0x80, 0x73, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0E, 0xE0, 0x07,
  0x78, 0x03, 0x9C, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x3C, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x03, 0x83,
  0x83, 0xC1, 0xC1, 0xE1, 0xE0, 0xF1, 0xF0, 0xF8, 0xF0, 0x6C, 0xD8, 0x36,
  0x6C, 0x1B, 0x66, 0x1D, 0xB7, 0x0C, 0xF3, 0x86, 0x79, 0x87, 0x38, 0xC3,
  0x80, 0xE1, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x30, 0x0E,
  0x38, 0x07, 0x00, 0x0E, 0x03, 0x0E, 0x07, 0x0F, 0x07, 0x0F, 0x07, 0x1F,
  0x06, 0x1F, 0x86, 0x1D, 0x8E, 0x19, 0x8E, 0x39, 0x8C, 0x39, 0xCC, 0x38,
  0xDC, 0x30, 0xDC, 0x70, 0xDC, 0x70, 0xD8, 0x70, 0xF8, 0x60, 0x78, 0x60,
  0x78, 0xE0, 0x70, 0xE0, 0x70, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x07,
  0x3C, 0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x7E, 0x01,
  0xF8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x3C, 0x71, 0xE1, 0xFF,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x70, 0xE0,
  0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0xF8, 0xFF, 0xE1,
  0xFF, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x07, 0x3C, 0x1C,
  0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xF8, 0x0E,
  0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x3C, 0x71, 0xE1, 0xFF, 0x03, 0xF8,
  0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x07, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x70, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E,
  0x1C, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0x8E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x80, 0xE0, 0x01, 0xFC, 0x0F,
  0xFC, 0x3E, 0x78, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x70, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x39, 0xE0, 0x73, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x70, 0xF1, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87,
  0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x01, 0x9C, 0x06, 0xE0, 0x1B, 0x80, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x73, 0x9C, 0x39, 0xCE,
  0x19, 0xE6, 0x0C, 0xF3, 0x0E, 0xDB, 0x87, 0x6D, 0xC3, 0x66, 0xC1, 0xF3,
  0x60, 0xF1, 0xF0, 0x78, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x00, 0x07, 0x01,
  0xC1, 0xC0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0xCE, 0x00, 0x77, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xB8, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x38, 0x1C,
  0x1E, 0x07, 0x0F, 0x01, 0xC0, 0xE0, 0x1F, 0xC0, 0x39, 0xC0, 0xE3, 0x83,
  0xC7, 0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x7E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7F, 0x81,
  0xFE, 0x00, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0xC0, 0xEE, 0x0E, 0x70,
  0xE1, 0xCF, 0x0E, 0xF0, 0x77, 0x01, 0xD0, 0x08, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x21, 0xCF, 0x8F, 0x1C, 0x20, 0x07, 0xFC, 0x7F, 0xE3, 0xE3,
  0x8E, 0x0E, 0x70, 0x39, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83,
  0x8E, 0x0E, 0x3C, 0x78, 0x7F, 0xE0, 0xFD, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFC, 0x1F, 0xF8,
  0x78, 0xF1, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E,
  0x70, 0x39, 0xC1, 0xC7, 0x1F, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xE3, 0xE0, 0x8E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0x18, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x03,
  0xFE, 0x0F, 0xF8, 0x3C, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0xC7, 0x83, 0xFF, 0x83,
  0xF7, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0x0E, 0xF0, 0x77, 0x03, 0xB8, 0x3F,
  0xFF, 0xDF, 0xFC, 0xFE, 0x07, 0x00, 0x38, 0x00, 0xF0, 0xC7, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0x8E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E,
  0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x78, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x71, 0xE1, 0xC3, 0xCF, 0x0F, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0xE0, 0xE0, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0xFE, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0xA3, 0xF1, 0xF8, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x10, 0x70, 0x3F, 0xE0,
  0xFF, 0x80, 0xFE, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x8E, 0x0E, 0x1C, 0x78, 0x71, 0xE0, 0xE7,
  0x81, 0xDE, 0x03, 0xF0, 0x0F, 0xC0, 0x1D, 0xC0, 0x39, 0xC0, 0x73, 0xC1,
  0xE3, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x0F, 0x00, 0xFE, 0xFE, 0xFE, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x79, 0x7F, 0x3F, 0x1F, 0xFC, 0x3F, 0xFC, 0xE7, 0x39, 0xCE,
  0x73, 0x98, 0xC6, 0x31, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x98, 0xC0, 0x31,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x06, 0x00, 0x1F, 0xE0, 0xFF, 0x8E,
  0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x70, 0x70, 0x07, 0xE0, 0xFF, 0x8F, 0x1E,
  0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0xB8,
  0x3D, 0xE3, 0xC7, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xF8, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x70,
  0x38, 0xE0, 0xF1, 0xCF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xF1, 0xE3, 0x8E,
  0x0E, 0x78, 0x39, 0xC0, 0xEF, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE,
  0x0E, 0x1C, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x7F, 0xE1, 0xF0, 0x87, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0xC7, 0x04, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x38, 0xC3,
  0xCF, 0xFC, 0x3F, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xFF, 0xFF,
  0xFE, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x88, 0x7F, 0x83, 0xF8, 0x38, 0x3C, 0xE0, 0xE3, 0x83,
  0x8E, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0xF3, 0x83,
  0x8E, 0x0E, 0x3C, 0xF8, 0x7F, 0xE0, 0xFD, 0xC0, 0xE0, 0x7E, 0x07, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x06, 0xE0, 0x7E,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x33, 0x1C,
  0x66, 0x39, 0xCC, 0xF3, 0x39, 0xE6, 0x76, 0xDC, 0xED, 0xB1, 0xF3, 0xE3,
  0x67, 0x87, 0x8F, 0x0E, 0x1E, 0x1C, 0x38, 0x00, 0x0E, 0x07, 0x0F, 0x0E,
  0x07, 0x1C, 0x07, 0xB8, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x38, 0x38, 0xF0, 0x3C,
  0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0x38,
  0x70, 0x1C, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x47, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xF0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x3E, 0x1D, 0xFE, 0xEE,
  0x7F, 0xB0, 0xFC,
};

const GFXglyph UbuntuSansMono_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 19, 15, 4, -19 },
  { 20, 10, 8, 15, 5, -21 },
  { 30, 16, 19, 15, 0, -19 },
  { 68, 14, 24, 15, 1, -21 },
  { 110, 18, 19, 15, -1, -19 },
  { 153, 14, 19, 15, 0, -19 },
  { 187, 4, 9, 15, 8, -21 },
  { 192, 12, 26, 15, 3, -21 },
  { 231, 12, 26, 15, 0, -21 },
  { 270, 12, 12, 15, 3, -19 },
  { 288, 13, 14, 15, 1, -15 },
  { 311, 7, 9, 15, 2, -5 },
  { 319, 8, 3, 15, 4, -9 },
  { 322, 5, 5, 15, 4, -5 },
  { 326, 18, 26, 15, -2, -21 },
  { 385, 14, 19, 15, 1, -19 },
  { 419, 12, 19, 15, 1, -19 },
  { 448, 14, 19, 15, 1, -19 },
  { 482, 15, 19, 15, 0, -19 },
  { 518, 15, 19, 15, 0, -19 },
  { 554, 16, 19, 15, 0, -19 },
  { 592, 14, 19, 15, 2, -19 },
  { 626, 14, 19, 15, 3, -19 },
  { 660, 14, 19, 15, 1, -19 },
  { 694, 14, 19, 15, 1, -19 },
  { 728, 7, 15, 15, 4, -15 },
  { 742, 9, 19, 15, 2, -15 },
  { 764, 14, 12, 15, 1, -14 },
  { 785, 14, 8, 15, 1, -12 },
  { 799, 13, 12, 15, 1, -14 },
  { 819, 11, 19, 15, 4, -19 },
  { 846, 15, 23, 15, 1, -19 },
  { 890, 14, 19, 15, -1, -19 },
  { 924, 15, 19, 15, 0, -19 },
  { 960, 14, 19, 15, 2, -19 },
  { 994, 15, 19, 15, 0, -19 },
  { 1030, 15, 19, 15, 1, -19 },
  { 1066, 15, 19, 15, 1, -19 },
  { 1102, 15, 19, 15, 1, -19 },
  { 1138, 16, 19, 15, 0, -19 },
  { 1176, 15, 19, 15, 1, -19 },
  { 1212, 15, 19, 15, 1, -19 },
  { 1248, 17, 19, 15, 0, -19 },
  { 1289, 12, 19, 15, 0, -19 },
  { 1318, 17, 19, 15, -1, -19 },
  { 1359, 16, 19, 15, 0, -19 },
  { 1397, 14, 19, 15, 1, -19 },
  { 1431, 15, 19, 15, 0, -19 },
  { 1467, 14, 24, 15, 1, -19 },
  { 1509, 15, 19, 15, 0, -19 },
  { 1545, 15, 19, 15, 0, -19 },
  { 1581, 14, 19, 15, 3, -19 },
  { 1615, 15, 19, 15, 1, -19 },
  { 1651, 14, 19, 15, 3, -19 },
  { 1685, 17, 19, 15, 0, -19 },
  { 1726, 18, 19, 15, -1, -19 },
  { 1769, 15, 19, 15, 3, -19 },
  { 1805, 16, 19, 15, 0, -19 },
  { 1843, 14, 26, 15, 2, -21 },
  { 1889, 6, 26, 15, 5, -21 },
  { 1909, 15, 26, 15, -1, -21 },
  { 1958, 13, 11, 15, 2, -19 },
  { 1976, 14, 3, 15, -2, 2 },
  { 1982, 6, 6, 15, 6, -21 },
  { 1987, 14, 14, 15, 1, -14 },
  { 2012, 14, 21, 15, 0, -21 },
  { 2049, 14, 14, 15, 1, -14 },
  { 2074, 15, 21, 15, 1, -21 },
  { 2114, 13, 14, 15, 1, -14 },
  { 2137, 18, 26, 15, -1, -21 },
  { 2196, 16, 19, 15, -1, -14 },
  { 2234, 14, 21, 15, 0, -21 },
  { 2271, 9, 21, 15, 3, -21 },
  { 2295, 15, 26, 15, -1, -21 },
  { 2344, 15, 21, 15, 1, -21 },
  { 2384, 8, 21, 15, 4, -21 },
  { 2405, 15, 14, 15, 0, -14 },
  { 2432, 13, 14, 15, 1, -14 },
  { 2455, 13, 14, 15, 1, -14 },
  { 2478, 15, 19, 15, -1, -14 },
  { 2514, 14, 19, 15, 1, -14 },
  { 2548, 14, 14, 15, 1, -14 },
  { 2573, 13, 14, 15, 1, -14 },
  { 2596, 12, 18, 15, 3, -18 },
  { 2623, 14, 14, 15, 1, -14 },
  { 2648, 12, 14, 15, 3, -14 },
  { 2669, 15, 14, 15, 1, -14 },
  { 2696, 16, 14, 15, -1, -14 },
  { 2724, 17, 19, 15, -2, -14 },
  { 2765, 14, 14, 15, 1, -14 },
  { 2790, 14, 26, 15, 2, -21 },
  { 2836, 9, 26, 15, 3, -21 },
  { 2866, 14, 26, 15, -1, -21 },
  { 2912, 14, 4, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC27PT7B_H_
