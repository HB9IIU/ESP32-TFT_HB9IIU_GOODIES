#ifndef _UBUNTUSANSMONO_MEDIUMITALIC14PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x40, 0xCC, 0xDE, 0xA5, 0x60, 0x09, 0x0B, 0x12,
  0x7F, 0x36, 0x24, 0xFE, 0xFE, 0x48, 0xD0, 0x04, 0x04, 0x1F, 0x30, 0x30,
  0x38, 0x1C, 0x06, 0x06, 0xFC, 0x78, 0x30, 0x20, 0x18, 0x4B, 0x22, 0x90,
  0xA8, 0x34, 0x03, 0xC1, 0xF0, 0x54, 0x25, 0x31, 0xC0, 0x1C, 0x6C, 0x99,
  0x23, 0x8F, 0x53, 0xE6, 0xCC, 0xEC, 0x7E, 0x80, 0x0C, 0x63, 0x18, 0x43,
  0x08, 0x20, 0x82, 0x08, 0x30, 0x61, 0x00, 0x18, 0x20, 0xC1, 0x04, 0x10,
  0x43, 0x0C, 0x61, 0x0C, 0xC2, 0x00, 0x10, 0x21, 0xFC, 0xC2, 0x8D, 0x80,
  0x18, 0x41, 0x3F, 0xFC, 0x86, 0x00, 0x77, 0x2C, 0xFF, 0xF8, 0x01, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x04,
  0x06, 0x00, 0x1C, 0xE9, 0x1E, 0x3F, 0x76, 0xA1, 0x46, 0x99, 0xE0, 0x0C,
  0x66, 0x96, 0x18, 0x41, 0x0C, 0x33, 0xE0, 0x1E, 0x37, 0x03, 0x02, 0x06,
  0x0C, 0x30, 0x60, 0x42, 0xFC, 0x1E, 0x36, 0x03, 0x02, 0x1C, 0x0C, 0x06,
  0x06, 0x8C, 0xFC, 0x03, 0x06, 0x0A, 0x16, 0x26, 0x64, 0xFE, 0xFE, 0x0C,
  0x08, 0x1F, 0x1F, 0x10, 0x30, 0x38, 0x0E, 0x06, 0x06, 0x8C, 0xF8, 0x06,
  0x3D, 0x82, 0x0F, 0x99, 0xA1, 0x42, 0xCC, 0xF0, 0x7F, 0x7E, 0x04, 0x0C,
  0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0x3C, 0xCD, 0x1A, 0x37, 0xCF, 0x23,
  0x46, 0x8D, 0xF0, 0x1E, 0x32, 0x23, 0x63, 0x63, 0x3E, 0x06, 0x04, 0x18,
  0xF0, 0x77, 0x00, 0x0E, 0xC0, 0x39, 0xC0, 0x00, 0x39, 0xC4, 0xC0, 0x06,
  0x7B, 0x86, 0x07, 0x81, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x60, 0x78, 0x18,
  0x77, 0x98, 0x00, 0x79, 0x30, 0xC6, 0x31, 0x84, 0x00, 0xC3, 0x00, 0x0E,
  0x1B, 0x21, 0x67, 0x5B, 0x53, 0xD2, 0xD2, 0xDE, 0x40, 0x60, 0x3C, 0x06,
  0x06, 0x0E, 0x0B, 0x13, 0x13, 0x3F, 0x7F, 0x63, 0xC3, 0x3E, 0x3F, 0x23,
  0x22, 0x7E, 0x7E, 0x42, 0x46, 0xCE, 0xF8, 0x1E, 0x6D, 0x86, 0x0C, 0x10,
  0x20, 0x40, 0xC4, 0xF8, 0x3C, 0x3E, 0x23, 0x63, 0x63, 0x62, 0x42, 0x46,
  0xCC, 0xF8, 0x1F, 0x3F, 0x30, 0x30, 0x3E, 0x3E, 0x60, 0x60, 0x40, 0xFE,
  0x1F, 0x3F, 0x30, 0x30, 0x3E, 0x3E, 0x60, 0x60, 0x40, 0xC0, 0x1E, 0x6D,
  0x86, 0x0C, 0x10, 0xA3, 0x46, 0xCC, 0xF0, 0x31, 0x98, 0x88, 0xCC, 0x67,
  0xF3, 0xF1, 0x18, 0x8C, 0xC6, 0x62, 0x00, 0x1F, 0x3F, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0xFC, 0x1F, 0x1F, 0x03, 0x02, 0x02, 0x06, 0x06,
  0x04, 0x4C, 0xF8, 0x31, 0x99, 0x89, 0x85, 0x87, 0x83, 0xC1, 0x20, 0x98,
  0xC4, 0x63, 0x00, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x10, 0x43, 0xF0, 0x31,
  0x33, 0x33, 0x75, 0x57, 0x5A, 0x42, 0xC2, 0x86, 0x86, 0x31, 0x98, 0x8C,
  0x47, 0x66, 0xB2, 0x51, 0x28, 0x9C, 0xC6, 0x42, 0x00, 0x1C, 0xED, 0x1E,
  0x38, 0x70, 0xE1, 0x46, 0xD9, 0xE0, 0x3E, 0x3F, 0x33, 0x23, 0x63, 0x7E,
  0x70, 0x40, 0x40, 0xC0, 0x1C, 0xED, 0x1E, 0x38, 0x70, 0xE1, 0x46, 0xD9,
  0xE1, 0x81, 0xC0, 0x80, 0x3C, 0x36, 0x23, 0x23, 0x66, 0x7C, 0x48, 0x4C,
  0xC4, 0xC6, 0x1F, 0x33, 0x20, 0x30, 0x38, 0x0C, 0x06, 0x06, 0x84, 0xFC,
  0xFF, 0xF8, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x41, 0x80, 0x62, 0x85, 0x1E,
  0x3C, 0x58, 0xA3, 0x46, 0x89, 0xF0, 0x87, 0x0A, 0x34, 0x49, 0x92, 0x2C,
  0x50, 0xE1, 0x80, 0x21, 0x90, 0xD8, 0x4C, 0x24, 0xB2, 0xD1, 0xE8, 0xD4,
  0xCC, 0x66, 0x00, 0x31, 0x99, 0x84, 0x83, 0xC0, 0xC0, 0xE0, 0xF0, 0x48,
  0x46, 0x63, 0x00, 0x87, 0x0B, 0x36, 0xC5, 0x0C, 0x18, 0x20, 0x41, 0x80,
  0x3F, 0x3F, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60, 0xC2, 0xFC, 0x1E, 0x20,
  0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0F, 0x1E, 0x00, 0xAB,
  0xFF, 0xD5, 0x50, 0x1E, 0x0C, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x18, 0x30,
  0x40, 0x8F, 0x1E, 0x00, 0x08, 0x30, 0xF3, 0x2C, 0x70, 0x80, 0xFF, 0xFC,
  0x5C, 0x80, 0x3F, 0x62, 0x46, 0x46, 0xC4, 0x4C, 0x7E, 0x10, 0x60, 0xC1,
  0x83, 0xE4, 0x58, 0xB1, 0x46, 0x9B, 0xE0, 0x7F, 0x83, 0x04, 0x08, 0x18,
  0x9E, 0x00, 0x03, 0x02, 0x06, 0x06, 0x7C, 0xC4, 0xCC, 0x8C, 0x8C, 0x98,
  0xFC, 0x7F, 0x18, 0xFE, 0x83, 0x1F, 0x80, 0x03, 0xC1, 0xE0, 0x40, 0x10,
  0x1F, 0x83, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x70, 0x38,
  0x00, 0x3F, 0x22, 0x62, 0x46, 0x46, 0x7C, 0x34, 0x0C, 0xF8, 0x60, 0x10,
  0x60, 0xC1, 0x03, 0xEC, 0xD9, 0xB3, 0x45, 0x8B, 0x30, 0x18, 0xC0, 0x0F,
  0x18, 0xC4, 0x21, 0x0E, 0x06, 0x0C, 0x00, 0x03, 0xE0, 0x81, 0x06, 0x0C,
  0x10, 0x20, 0xCF, 0x0C, 0x00, 0x18, 0x10, 0x30, 0x30, 0x27, 0x2C, 0x78,
  0x78, 0x48, 0x4C, 0xC6, 0xFF, 0x22, 0x66, 0x44, 0xCD, 0x70, 0x7F, 0x4B,
  0x5A, 0x5A, 0xC2, 0xC6, 0x84, 0x3E, 0x45, 0x8B, 0x34, 0x68, 0xB3, 0x00,
  0x7F, 0x1C, 0x61, 0x8E, 0x6F, 0x00, 0x3E, 0x45, 0x8B, 0x14, 0x69, 0xBE,
  0x60, 0x81, 0x00, 0x7E, 0x8B, 0x14, 0x68, 0xD1, 0x3E, 0x0C, 0x18, 0x20,
  0x7E, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x00, 0x3E, 0x40, 0xC0, 0xE0, 0x48,
  0xBF, 0x00, 0x08, 0x60, 0xCF, 0xE2, 0x04, 0x18, 0x30, 0x64, 0xF0, 0x47,
  0x8B, 0x34, 0x68, 0x93, 0x3F, 0x00, 0xC7, 0x89, 0x32, 0x45, 0x8E, 0x18,
  0x00, 0xC3, 0x26, 0xDD, 0xAD, 0x5B, 0x26, 0x00, 0x63, 0x34, 0x1C, 0x18,
  0x3C, 0x6C, 0xC6, 0x31, 0x88, 0x84, 0xC2, 0x41, 0xE0, 0xE0, 0x30, 0x30,
  0xF0, 0x60, 0x00, 0x3F, 0x06, 0x08, 0x10, 0x30, 0x60, 0xFC, 0x0E, 0x30,
  0x40, 0x83, 0x06, 0x38, 0x30, 0x60, 0xC1, 0x02, 0x07, 0x86, 0x00, 0x11,
  0x33, 0x22, 0x66, 0x44, 0xCC, 0x88, 0x1E, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x07, 0x06, 0x0C, 0x08, 0x08, 0x18, 0x70, 0xE0, 0x7B, 0xCE,
};

const GFXglyph UbuntuSansMono_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 5, 4, 8, 3, -11 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 8, 13, 8, 0, -11 },
  { 32, 10, 10, 8, -1, -10 },
  { 45, 7, 10, 8, 0, -10 },
  { 54, 2, 5, 8, 4, -11 },
  { 56, 6, 14, 8, 2, -11 },
  { 67, 6, 14, 8, 0, -11 },
  { 78, 7, 6, 8, 1, -10 },
  { 84, 6, 7, 8, 1, -8 },
  { 90, 4, 4, 8, 1, -2 },
  { 92, 4, 2, 8, 2, -5 },
  { 93, 3, 2, 8, 2, -2 },
  { 94, 9, 14, 8, -1, -11 },
  { 110, 7, 10, 8, 1, -10 },
  { 119, 6, 10, 8, 1, -10 },
  { 127, 8, 10, 8, 0, -10 },
  { 137, 8, 10, 8, 0, -10 },
  { 147, 8, 10, 8, 0, -10 },
  { 157, 8, 10, 8, 0, -10 },
  { 167, 7, 10, 8, 1, -10 },
  { 176, 8, 10, 8, 1, -10 },
  { 186, 7, 10, 8, 1, -10 },
  { 195, 8, 10, 8, 0, -10 },
  { 205, 4, 7, 8, 2, -7 },
  { 209, 5, 9, 8, 1, -7 },
  { 215, 7, 6, 8, 1, -7 },
  { 221, 8, 4, 8, 0, -6 },
  { 225, 7, 6, 8, 0, -7 },
  { 231, 6, 10, 8, 2, -10 },
  { 239, 8, 12, 8, 0, -10 },
  { 251, 8, 10, 8, -1, -10 },
  { 261, 8, 10, 8, 0, -10 },
  { 271, 7, 10, 8, 1, -10 },
  { 280, 8, 10, 8, 0, -10 },
  { 290, 8, 10, 8, 0, -10 },
  { 300, 8, 10, 8, 0, -10 },
  { 310, 7, 10, 8, 1, -10 },
  { 319, 9, 10, 8, 0, -10 },
  { 331, 8, 10, 8, 0, -10 },
  { 341, 8, 10, 8, 0, -10 },
  { 351, 9, 10, 8, 0, -10 },
  { 363, 6, 10, 8, 0, -10 },
  { 371, 8, 10, 8, 0, -10 },
  { 381, 9, 10, 8, 0, -10 },
  { 393, 7, 10, 8, 1, -10 },
  { 402, 8, 10, 8, 0, -10 },
  { 412, 7, 13, 8, 1, -10 },
  { 424, 8, 10, 8, 0, -10 },
  { 434, 8, 10, 8, 0, -10 },
  { 444, 7, 10, 8, 2, -10 },
  { 453, 7, 10, 8, 1, -10 },
  { 462, 7, 10, 8, 2, -10 },
  { 471, 9, 10, 8, 0, -10 },
  { 483, 9, 10, 8, 0, -10 },
  { 495, 7, 10, 8, 2, -10 },
  { 504, 8, 10, 8, 0, -10 },
  { 514, 7, 14, 8, 1, -11 },
  { 527, 2, 14, 8, 3, -11 },
  { 531, 7, 14, 8, 0, -11 },
  { 544, 7, 6, 8, 1, -10 },
  { 550, 7, 2, 8, -1, 1 },
  { 552, 3, 3, 8, 3, -11 },
  { 554, 8, 7, 8, 0, -7 },
  { 561, 7, 11, 8, 0, -11 },
  { 571, 7, 7, 8, 1, -7 },
  { 578, 8, 11, 8, 1, -11 },
  { 589, 6, 7, 8, 1, -7 },
  { 595, 10, 14, 8, -1, -11 },
  { 613, 8, 10, 8, 0, -7 },
  { 623, 7, 11, 8, 0, -11 },
  { 633, 5, 11, 8, 1, -11 },
  { 640, 7, 14, 8, 0, -11 },
  { 653, 8, 11, 8, 0, -11 },
  { 664, 4, 11, 8, 2, -11 },
  { 670, 8, 7, 8, 0, -7 },
  { 677, 7, 7, 8, 0, -7 },
  { 684, 6, 7, 8, 1, -7 },
  { 690, 7, 10, 8, 0, -7 },
  { 699, 7, 10, 8, 1, -7 },
  { 708, 7, 7, 8, 1, -7 },
  { 715, 7, 7, 8, 0, -7 },
  { 722, 7, 10, 8, 1, -10 },
  { 731, 7, 7, 8, 1, -7 },
  { 738, 7, 7, 8, 1, -7 },
  { 745, 7, 7, 8, 1, -7 },
  { 752, 8, 7, 8, 0, -7 },
  { 759, 9, 10, 8, -1, -7 },
  { 771, 8, 7, 8, 0, -7 },
  { 778, 7, 14, 8, 1, -11 },
  { 791, 4, 14, 8, 2, -11 },
  { 798, 8, 14, 8, -1, -11 },
  { 812, 8, 2, 8, 0, -5 },
};

const GFXfont UbuntuSansMono_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC14PT7B_H_
