#ifndef _UBUNTUSANSMONO_MEDIUMITALIC65PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC1, 0xFE,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0xC0, 0x0F, 0xF0, 0x00, 0x10, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00, 0x07, 0xF8, 0x0F, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x7E, 0x00, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x7C, 0x00,
  0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC7, 0xE0, 0x00, 0x00,
  0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0x1F, 0x80, 0x00, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF8,
  0x00, 0x00, 0x03, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC7, 0xE3, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87,
  0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x3F,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x03, 0xFF, 0xF0,
  0x3F, 0x03, 0xFF, 0xF8, 0x1F, 0x83, 0xFC, 0xFE, 0x0F, 0xC3, 0xFC, 0x7F,
  0x8F, 0xC1, 0xF8, 0x1F, 0xC7, 0xE1, 0xFC, 0x07, 0xF7, 0xF0, 0xFC, 0x03,
  0xFB, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0xF8, 0x7F, 0x00,
  0x1F, 0xF8, 0x3F, 0x80, 0x07, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xC1, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xFC, 0x1F, 0xC0,
  0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFE, 0x3F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x7E, 0x00, 0x87, 0x01, 0xF0, 0x3C,
  0x7E, 0x0F, 0x87, 0xE3, 0xFC, 0x7C, 0xFF, 0x9F, 0xFB, 0xCF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x1F, 0x07, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF9, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x78, 0x0F, 0xC7, 0xF0, 0x7E, 0x0F,
  0xE3, 0xF8, 0x7F, 0x87, 0xF3, 0xFC, 0x3F, 0xC3, 0xF9, 0xFC, 0x3F, 0xE1,
  0xFC, 0xFE, 0x1F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8,
  0x7F, 0x3F, 0xC1, 0xF8, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0x80, 0x1F, 0xF3, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0x07, 0xF8, 0x01, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x06, 0x00,
  0x03, 0xFC, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x70,
  0x01, 0xFF, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x02, 0x00, 0x00,
  0xFF, 0x80, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x10, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xF9, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xCF, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFC, 0x00, 0x01, 0x80, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x78, 0x07, 0xFC, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF,
  0xFF, 0x0F, 0xC0, 0x3F, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0x80,
  0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0x03, 0xFE, 0x0F, 0xC3,
  0xF0, 0x7F, 0x80, 0xFC, 0x7F, 0x07, 0xF0, 0x1F, 0xC7, 0xE0, 0xFE, 0x01,
  0xFC, 0x7E, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x0F,
  0xC0, 0x3F, 0x8F, 0xE1, 0xFC, 0x03, 0xF8, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC1, 0xF8, 0x07,
  0xF0, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0x00,
  0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x10, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xE0, 0x07, 0xFE,
  0x00, 0x3C, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x20, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xFC,
  0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0x1C,
  0x01, 0xFF, 0x80, 0x01, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x80, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xF0,
  0x00, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00, 0x03, 0xF9,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x0F, 0x7E, 0x00, 0x3E, 0xF8, 0x1F, 0x7E,
  0x00, 0x7E, 0x78, 0x3E, 0x7E, 0x00, 0x7E, 0x78, 0x3E, 0x7C, 0x00, 0x7C,
  0x7C, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x7C, 0xFC, 0x00, 0xFC, 0x7C, 0xF8,
  0xFC, 0x00, 0xFC, 0x7C, 0xF8, 0xFC, 0x01, 0xF8, 0x7D, 0xF0, 0xF8, 0x01,
  0xF8, 0x7D, 0xF1, 0xF8, 0x01, 0xF8, 0x7F, 0xE1, 0xF8, 0x01, 0xF8, 0x7F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x83, 0xF8,
  0x03, 0xF0, 0x7F, 0x83, 0xF0, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF8, 0x00,
  0xFD, 0xF8, 0x03, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF8, 0x01, 0xFD, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0xFC, 0x07, 0xF0,
  0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0xBF, 0x80, 0x0F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xC0,
  0x0F, 0xBF, 0x00, 0x1F, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x18, 0x00, 0xFF,
  0x00, 0x00, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x30, 0x00, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xFE, 0x07, 0xE0,
  0x0F, 0xC1, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xFE, 0x0F, 0xC0, 0x1F, 0x83,
  0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xFE, 0x0F, 0x80, 0x1F, 0x87, 0xDE, 0x1F,
  0x80, 0x1F, 0x8F, 0x9E, 0x1F, 0x80, 0x1F, 0x0F, 0x9E, 0x1F, 0x80, 0x1F,
  0x1F, 0x1E, 0x1F, 0x00, 0x3F, 0x3F, 0x1E, 0x3F, 0x00, 0x3F, 0x3E, 0x1F,
  0x3F, 0x00, 0x3F, 0x7C, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x1F, 0x7E, 0x00,
  0x3E, 0xF8, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x1F, 0x7C, 0x00, 0x7F, 0xF0,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC,
  0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x00,
  0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x18, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE7, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x07,
  0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF1, 0xF8, 0x00, 0xFF,
  0xE0, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x7F, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFE,
  0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xFC, 0x07, 0xFF,
  0x00, 0x04, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF1,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0xE1,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xFE, 0xFE, 0x01, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0C, 0x0F,
  0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x06, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0x80, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x10, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x07, 0xF3, 0xFE, 0x00,
  0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x23,
  0xFF, 0x9F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x04, 0x00, 0x03,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x3F,
  0xC7, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFD, 0xF4, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC7,
  0xFC, 0x07, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xE0, 0x00, 0x0E, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0xFC, 0x01, 0xFE, 0x00, 0x08, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x10,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x1F, 0xE0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x81, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x01, 0x80, 0x3F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x3F, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xC1,
  0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xC3, 0xEF, 0x8F, 0xC0,
  0xFC, 0x3E, 0xF8, 0xFC, 0x0F, 0xC7, 0xCF, 0x8F, 0x80, 0xFC, 0xFC, 0xF9,
  0xF8, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0xFD, 0xF8, 0xF9, 0xF0, 0x0F, 0x9F,
  0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0xFB, 0xE0, 0x0F, 0xBE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x01,
  0xFF, 0x80, 0x07, 0xC1, 0xFF, 0xF0, 0x07, 0xE1, 0xFF, 0xFC, 0x07, 0xF1,
  0xFF, 0xFF, 0x87, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xF8,
  0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 18, 46, 36, 10, -45 },
  { 105, 23, 19, 36, 13, -49 },
  { 160, 38, 45, 36, 0, -45 },
  { 374, 34, 57, 36, 2, -50 },
  { 617, 43, 47, 36, -2, -46 },
  { 870, 33, 47, 36, 1, -46 },
  { 1064, 10, 20, 36, 19, -49 },
  { 1089, 28, 63, 36, 8, -51 },
  { 1310, 28, 63, 36, 1, -51 },
  { 1531, 29, 27, 36, 7, -45 },
  { 1629, 31, 32, 36, 3, -35 },
  { 1753, 16, 22, 36, 5, -11 },
  { 1797, 19, 7, 36, 9, -22 },
  { 1814, 11, 12, 36, 10, -11 },
  { 1831, 42, 63, 36, -4, -51 },
  { 2162, 33, 47, 36, 3, -46 },
  { 2356, 28, 45, 36, 3, -45 },
  { 2514, 35, 46, 36, 1, -46 },
  { 2716, 34, 47, 36, 1, -46 },
  { 2916, 34, 45, 36, 1, -45 },
  { 3108, 37, 46, 36, 1, -45 },
  { 3321, 34, 46, 36, 4, -45 },
  { 3517, 33, 45, 36, 7, -45 },
  { 3703, 35, 47, 36, 2, -46 },
  { 3909, 34, 46, 36, 2, -46 },
  { 4105, 17, 35, 36, 10, -34 },
  { 4180, 22, 45, 36, 5, -34 },
  { 4304, 32, 30, 36, 3, -34 },
  { 4424, 35, 20, 36, 1, -29 },
  { 4512, 33, 30, 36, 1, -34 },
  { 4636, 26, 47, 36, 9, -46 },
  { 4789, 36, 56, 36, 2, -46 },
  { 5041, 36, 45, 36, -4, -45 },
  { 5244, 36, 46, 36, 0, -46 },
  { 5451, 35, 47, 36, 4, -46 },
  { 5657, 35, 46, 36, 0, -46 },
  { 5859, 37, 45, 36, 2, -45 },
  { 6068, 37, 45, 36, 2, -45 },
  { 6277, 35, 47, 36, 3, -46 },
  { 6483, 40, 45, 36, 0, -45 },
  { 6708, 37, 45, 36, 1, -45 },
  { 6917, 37, 46, 36, 1, -45 },
  { 7130, 41, 45, 36, 0, -45 },
  { 7361, 28, 45, 36, 1, -45 },
  { 7519, 40, 45, 36, -2, -45 },
  { 7744, 40, 45, 36, 0, -45 },
  { 7969, 34, 47, 36, 3, -46 },
  { 8169, 36, 46, 36, 1, -46 },
  { 8376, 34, 58, 36, 3, -46 },
  { 8623, 36, 46, 36, 0, -46 },
  { 8830, 36, 47, 36, 1, -46 },
  { 9042, 33, 45, 36, 8, -45 },
  { 9228, 36, 46, 36, 3, -45 },
  { 9435, 35, 45, 36, 7, -45 },
  { 9632, 40, 45, 36, 1, -45 },
  { 9857, 44, 45, 36, -2, -45 },
  { 10105, 34, 45, 36, 8, -45 },
  { 10297, 39, 45, 36, 0, -45 },
  { 10517, 34, 63, 36, 4, -51 },
  { 10785, 12, 63, 36, 13, -51 },
  { 10880, 34, 63, 36, -1, -51 },
  { 11148, 31, 25, 36, 4, -45 },
  { 11245, 34, 6, 36, -5, 6 },
  { 11271, 14, 13, 36, 16, -50 },
  { 11294, 33, 36, 36, 2, -35 },
  { 11443, 33, 52, 36, 1, -51 },
  { 11658, 32, 36, 36, 3, -35 },
  { 11802, 37, 52, 36, 3, -51 },
  { 12043, 31, 36, 36, 3, -35 },
  { 12183, 44, 62, 36, -3, -50 },
  { 12524, 38, 47, 36, -2, -35 },
  { 12748, 33, 51, 36, 0, -51 },
  { 12959, 23, 50, 36, 6, -50 },
  { 13103, 36, 62, 36, -2, -50 },
  { 13382, 36, 51, 36, 2, -51 },
  { 13612, 21, 51, 36, 9, -50 },
  { 13746, 36, 35, 36, -1, -35 },
  { 13904, 32, 35, 36, 1, -35 },
  { 14044, 31, 36, 36, 3, -35 },
  { 14184, 36, 47, 36, -2, -35 },
  { 14396, 33, 47, 36, 3, -35 },
  { 14590, 33, 35, 36, 3, -35 },
  { 14735, 32, 36, 36, 2, -35 },
  { 14879, 29, 45, 36, 6, -44 },
  { 15043, 32, 35, 36, 3, -34 },
  { 15183, 31, 34, 36, 6, -34 },
  { 15315, 36, 34, 36, 3, -34 },
  { 15468, 39, 34, 36, -2, -34 },
  { 15634, 42, 46, 36, -5, -34 },
  { 15876, 34, 34, 36, 1, -34 },
  { 16021, 35, 63, 36, 4, -51 },
  { 16297, 22, 63, 36, 8, -51 },
  { 16471, 35, 63, 36, -3, -51 },
  { 16747, 33, 12, 36, 2, -25 },
};

const GFXfont UbuntuSansMono_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic65pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC65PT7B_H_
