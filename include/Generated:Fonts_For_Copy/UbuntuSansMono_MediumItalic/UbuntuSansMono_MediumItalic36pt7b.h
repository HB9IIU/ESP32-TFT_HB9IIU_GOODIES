#ifndef _UBUNTUSANSMONO_MEDIUMITALIC36PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00,
  0x7C, 0x7B, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E, 0x78, 0x73, 0xC7, 0x9C,
  0x38, 0xE1, 0xC6, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x1E,
  0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0x07, 0x0F,
  0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x3C, 0x38, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x78, 0x70, 0x03, 0x87, 0x80,
  0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x0E, 0x0F, 0x80, 0x41, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x0F, 0x07, 0xF0, 0x0E,
  0x07, 0x38, 0x1C, 0x0E, 0x38, 0x38, 0x0E, 0x38, 0x70, 0x0C, 0x38, 0xE0,
  0x1C, 0x31, 0xE0, 0x1C, 0x73, 0xC0, 0x1C, 0x73, 0x80, 0x0F, 0xE7, 0x00,
  0x0F, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x77, 0xF0, 0x00, 0xE7, 0xF0, 0x01, 0xCE, 0x70, 0x03, 0x8C, 0x30,
  0x07, 0x1C, 0x70, 0x0F, 0x1C, 0x70, 0x1E, 0x1C, 0x70, 0x1C, 0x1C, 0x60,
  0x38, 0x1C, 0xE0, 0x70, 0x1F, 0xC0, 0xE0, 0x0F, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0x87, 0x81,
  0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0x77,
  0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0xF1, 0xFE, 0x38, 0xF7, 0x8E,
  0x78, 0xF7, 0xBC, 0x1F, 0xCF, 0x07, 0xF3, 0x80, 0xF8, 0xE0, 0x3C, 0x3C,
  0x0F, 0x8F, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0xEF, 0x0F, 0xE3, 0xC0, 0x3C,
  0xF7, 0xDE, 0x79, 0xE7, 0x1C, 0xF3, 0x8E, 0x00, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x63, 0x8E, 0xF9, 0xBE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x1E, 0x78,
  0x3E, 0x7C, 0x3C, 0x38, 0x08, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x8F,
  0xE7, 0xF3, 0xF8, 0xF8, 0x1C, 0x1E, 0x3E, 0x7E, 0x3C, 0x18, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x3C, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0xFE, 0x0F, 0x87, 0x87, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xDE, 0x00, 0xF7, 0x8C, 0x3D, 0xE7, 0x8F, 0xF1, 0xE3, 0xBC, 0xF9, 0xEF,
  0x1E, 0x7B, 0xC6, 0x1E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x8F, 0x81, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x87, 0xDF, 0x06, 0x3C, 0x10, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE0, 0x78, 0x3C, 0x0C, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x18, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x1C, 0x07,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x38,
  0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x07, 0x80, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x18, 0x1F, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x84, 0x01, 0xEF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01,
  0xF0, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x20,
  0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7C, 0x1E, 0x1F, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3E, 0x1F,
  0x03, 0xE7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xF0, 0xF8,
  0x3C, 0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x1E, 0x1E, 0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xF8, 0x3C, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xDE, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC3,
  0xF8, 0xFE, 0x3F, 0x07, 0xC0, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x1F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x00, 0x70, 0x0F,
  0x03, 0xE0, 0xFC, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0xE0,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x0F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0x71, 0xE0,
  0x07, 0x1C, 0x03, 0xF3, 0xC3, 0xFF, 0x38, 0x7F, 0xE7, 0x8F, 0xFE, 0x78,
  0xF1, 0xE7, 0x1E, 0x1E, 0x71, 0xC1, 0xEF, 0x3C, 0x1C, 0xF3, 0xC3, 0xCF,
  0x3C, 0x3C, 0xE3, 0xC3, 0xCE, 0x3C, 0x38, 0xE3, 0xC7, 0x8F, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x07, 0xF0, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1D, 0xC0,
  0x03, 0xDE, 0x00, 0x39, 0xE0, 0x07, 0x9E, 0x00, 0x71, 0xE0, 0x0F, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xE0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0,
  0x01, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x3F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01,
  0xE0, 0xF0, 0x3C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1E, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x83, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x0C, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x78, 0x7C, 0x07,
  0x83, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x78, 0x07,
  0x87, 0x80, 0xF8, 0x78, 0x3F, 0x07, 0x8F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFC,
  0x0C, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xC0, 0x3C, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x40, 0x3E, 0x07, 0x07,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x03,
  0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x83,
  0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x0F, 0x3E, 0x00,
  0x3D, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xEF, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xF0,
  0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0x70, 0x77, 0x1F, 0x81, 0xDC, 0x6E, 0x07, 0x73, 0xB8, 0x3D,
  0xDC, 0xE0, 0xE7, 0x73, 0x83, 0x9F, 0x9E, 0x0E, 0x7E, 0x70, 0x78, 0xF1,
  0xC1, 0xC3, 0xC7, 0x07, 0x0E, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00,
  0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0xF0, 0x7C, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0,
  0xFE, 0x07, 0x03, 0xDC, 0x1C, 0x0E, 0x70, 0xF0, 0x39, 0xC3, 0xC1, 0xE7,
  0x0E, 0x07, 0x8E, 0x38, 0x1C, 0x39, 0xE0, 0x70, 0xE7, 0x83, 0xC3, 0x9C,
  0x0F, 0x07, 0x70, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1E,
  0x07, 0xE0, 0x78, 0x0F, 0x81, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0xFE, 0x0F, 0x87, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x00, 0x20, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0x87, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xE0,
  0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x07,
  0xC1, 0xE3, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0x87, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F,
  0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00,
  0x30, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x3E,
  0x07, 0x81, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C,
  0x1E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F,
  0x00, 0x78, 0xF0, 0x07, 0x80, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xE0, 0x60, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x82, 0x00, 0x78,
  0x70, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x20, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03,
  0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x1C, 0x3C, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x01, 0xEF, 0x00,
  0x3D, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xE0, 0xE1, 0xC3, 0x83, 0x8F, 0x1E, 0x0E, 0x3C, 0x78,
  0x79, 0xF1, 0xC1, 0xE6, 0xC7, 0x07, 0x3B, 0x3C, 0x1C, 0xCE, 0xE0, 0x77,
  0x3B, 0x81, 0xF8, 0xEE, 0x0E, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x7C,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x87, 0x80,
  0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xC0,
  0xF8, 0x03, 0xE0, 0xF0, 0x01, 0xF7, 0x00, 0x3E, 0x78, 0x03, 0xC7, 0x80,
  0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0xC3, 0xE0, 0x3C,
  0x3C, 0x03, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF7, 0x80,
  0x78, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0x81, 0xE3, 0xC0, 0x79, 0xE0,
  0x1E, 0xF0, 0x03, 0xC4, 0x00, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0xC3, 0xC7, 0xC3, 0xC3, 0xC3, 0x02, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x0F, 0x1F, 0x03, 0xCF, 0x81,
  0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x8F, 0x87,
  0x81, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0xF8,
  0xF0, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x02, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x18, 0x3F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFC, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x0E, 0x07, 0x80, 0xF0, 0x7C, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78,
  0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x3F, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0x9E, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x1F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x1E,
  0x78, 0x3F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x18, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xE1, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x3F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xBC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x20, 0x1F,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0x78, 0x00, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x88, 0x7F, 0xC1, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x40, 0x78, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x01, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x80,
  0x78, 0x7C, 0x07, 0x83, 0xC0, 0x78, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F,
  0x0F, 0x00, 0xF0, 0x7F, 0xC7, 0xFC, 0xFF, 0xCF, 0xFC, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7C, 0x27, 0xFE, 0x3F, 0xF1, 0xFE, 0x07, 0xE7, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xE7, 0x8F, 0x1C, 0x38, 0xF1, 0xC7, 0x8E,
  0x1C, 0x78, 0xE3, 0xC7, 0x0E, 0x3C, 0x71, 0xE3, 0x8F, 0x1E, 0x38, 0xF1,
  0xC7, 0x8E, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00,
  0x38, 0xF0, 0x07, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x1E,
  0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xC7, 0x81, 0xF1,
  0xF0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xF0, 0x78, 0x0F,
  0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C, 0x1E, 0x0F, 0xC3, 0xC3,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0x1E, 0x3E,
  0x07, 0x9F, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC3,
  0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0x8C, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3E, 0x06, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE1, 0xC0, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x83, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF0, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xE7, 0x80, 0xF8, 0x07, 0xFC,
  0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x87, 0x0E, 0x3C, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1E, 0x38, 0x71,
  0xF1, 0xC3, 0x9F, 0x9E, 0x1C, 0xFC, 0xE0, 0xEE, 0x67, 0x07, 0x73, 0x70,
  0x3F, 0x1B, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1,
  0xE0, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x7C,
  0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xF0, 0x3E, 0x07,
  0x83, 0xE0, 0x3C, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x38, 0x01, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x83, 0xF8, 0x3C, 0xFF, 0x8F, 0x3F, 0xFF, 0xC7, 0x0F,
  0xF9, 0xC0, 0xFE, 0x08, 0x06, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 11, 25, 20, 5, -25 },
  { 36, 13, 10, 20, 7, -27 },
  { 53, 21, 25, 20, 0, -25 },
  { 119, 19, 32, 20, 1, -28 },
  { 195, 24, 27, 20, -1, -26 },
  { 276, 18, 26, 20, 1, -26 },
  { 335, 6, 11, 20, 10, -27 },
  { 344, 16, 35, 20, 4, -28 },
  { 414, 15, 35, 20, 1, -28 },
  { 480, 16, 15, 20, 4, -25 },
  { 510, 17, 18, 20, 2, -20 },
  { 549, 9, 12, 20, 3, -6 },
  { 563, 11, 4, 20, 5, -12 },
  { 569, 7, 6, 20, 5, -6 },
  { 575, 23, 35, 20, -2, -28 },
  { 676, 18, 27, 20, 2, -26 },
  { 737, 15, 25, 20, 2, -25 },
  { 784, 19, 26, 20, 1, -26 },
  { 846, 19, 27, 20, 0, -26 },
  { 911, 20, 25, 20, 0, -25 },
  { 974, 21, 26, 20, 0, -25 },
  { 1043, 19, 26, 20, 2, -25 },
  { 1105, 18, 25, 20, 4, -25 },
  { 1162, 19, 27, 20, 1, -26 },
  { 1227, 19, 26, 20, 1, -26 },
  { 1289, 10, 19, 20, 5, -19 },
  { 1313, 12, 25, 20, 3, -19 },
  { 1351, 18, 17, 20, 2, -19 },
  { 1390, 19, 11, 20, 1, -16 },
  { 1417, 18, 17, 20, 1, -19 },
  { 1456, 15, 26, 20, 5, -26 },
  { 1505, 20, 31, 20, 1, -26 },
  { 1583, 20, 25, 20, -2, -25 },
  { 1646, 20, 25, 20, 0, -25 },
  { 1709, 20, 27, 20, 2, -26 },
  { 1777, 20, 25, 20, 0, -25 },
  { 1840, 20, 25, 20, 1, -25 },
  { 1903, 21, 25, 20, 1, -25 },
  { 1969, 19, 27, 20, 2, -26 },
  { 2034, 22, 25, 20, 0, -25 },
  { 2103, 20, 25, 20, 1, -25 },
  { 2166, 20, 26, 20, 1, -25 },
  { 2231, 22, 25, 20, 0, -25 },
  { 2300, 16, 25, 20, 0, -25 },
  { 2350, 22, 25, 20, -1, -25 },
  { 2419, 22, 25, 20, 0, -25 },
  { 2488, 18, 27, 20, 2, -26 },
  { 2549, 21, 25, 20, 0, -25 },
  { 2615, 18, 33, 20, 2, -26 },
  { 2690, 20, 25, 20, 0, -25 },
  { 2753, 20, 27, 20, 0, -26 },
  { 2821, 18, 25, 20, 4, -25 },
  { 2878, 20, 26, 20, 2, -25 },
  { 2943, 19, 25, 20, 4, -25 },
  { 3003, 22, 25, 20, 1, -25 },
  { 3072, 24, 25, 20, -1, -25 },
  { 3147, 20, 25, 20, 4, -25 },
  { 3210, 22, 25, 20, 0, -25 },
  { 3279, 19, 35, 20, 2, -28 },
  { 3363, 7, 35, 20, 7, -28 },
  { 3394, 19, 35, 20, -1, -28 },
  { 3478, 18, 14, 20, 2, -25 },
  { 3510, 19, 4, 20, -3, 3 },
  { 3520, 7, 8, 20, 9, -28 },
  { 3527, 18, 19, 20, 1, -19 },
  { 3570, 18, 28, 20, 1, -28 },
  { 3633, 18, 19, 20, 1, -19 },
  { 3676, 21, 28, 20, 1, -28 },
  { 3750, 18, 19, 20, 1, -19 },
  { 3793, 25, 35, 20, -2, -28 },
  { 3903, 21, 26, 20, -1, -19 },
  { 3972, 18, 28, 20, 0, -28 },
  { 4035, 13, 28, 20, 3, -28 },
  { 4081, 20, 35, 20, -1, -28 },
  { 4169, 20, 28, 20, 1, -28 },
  { 4239, 12, 28, 20, 5, -28 },
  { 4281, 20, 19, 20, 0, -19 },
  { 4329, 17, 19, 20, 1, -19 },
  { 4370, 18, 19, 20, 1, -19 },
  { 4413, 20, 26, 20, -1, -19 },
  { 4478, 18, 26, 20, 2, -19 },
  { 4537, 18, 19, 20, 2, -19 },
  { 4580, 18, 20, 20, 1, -19 },
  { 4625, 15, 25, 20, 4, -25 },
  { 4672, 17, 19, 20, 2, -19 },
  { 4713, 17, 19, 20, 3, -19 },
  { 4754, 21, 19, 20, 1, -19 },
  { 4804, 21, 19, 20, -1, -19 },
  { 4854, 23, 26, 20, -3, -19 },
  { 4929, 18, 19, 20, 1, -19 },
  { 4972, 20, 35, 20, 2, -28 },
  { 5060, 12, 35, 20, 4, -28 },
  { 5113, 19, 35, 20, -1, -28 },
  { 5197, 19, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC36PT7B_H_
