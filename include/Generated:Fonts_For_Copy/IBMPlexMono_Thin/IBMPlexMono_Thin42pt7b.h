#ifndef _IBMPLEXMONO_THIN42PT7B_H_
#define _IBMPLEXMONO_THIN42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x03, 0xFE,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x02, 0x02, 0x00, 0x04, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x80, 0x80,
  0x01, 0x01, 0x01, 0xFE, 0x03, 0xF8, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x01, 0x02, 0x00, 0x02,
  0x04, 0x03, 0xFC, 0x0F, 0xF0, 0x08, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40,
  0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x08, 0x08,
  0x00, 0x10, 0x10, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x38, 0x8E,
  0x0C, 0x10, 0x22, 0x02, 0x02, 0x40, 0x40, 0x68, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x01, 0x02, 0x00,
  0x18, 0x40, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x21, 0x80, 0x04, 0x08,
  0x00, 0x80, 0x80, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x02, 0x80, 0x80, 0x8C, 0x10, 0x20,
  0x62, 0x18, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x0F, 0x80, 0x02, 0x61, 0x80, 0x08, 0x80, 0x80, 0x12, 0x01,
  0x00, 0x44, 0x01, 0x01, 0x10, 0x02, 0x02, 0x20, 0x04, 0x08, 0x40, 0x08,
  0x10, 0x80, 0x10, 0x40, 0x80, 0x21, 0x01, 0x00, 0x82, 0x01, 0x01, 0x08,
  0x03, 0x0C, 0x10, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x86, 0x18, 0x02, 0x10, 0x08, 0x08, 0x20, 0x10, 0x10, 0x80, 0x20,
  0x41, 0x00, 0x20, 0x82, 0x00, 0x42, 0x04, 0x00, 0x88, 0x08, 0x01, 0x10,
  0x10, 0x04, 0x40, 0x10, 0x08, 0x80, 0x20, 0x12, 0x00, 0x30, 0xC8, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x40, 0x02, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x64, 0x01, 0xE4, 0x10, 0x10, 0x40, 0x40, 0x82, 0x01,
  0x04, 0x20, 0x0C, 0x21, 0x00, 0x31, 0x08, 0x00, 0xC8, 0x40, 0x03, 0x42,
  0x00, 0x0C, 0x10, 0x00, 0x20, 0x80, 0x02, 0x82, 0x00, 0x12, 0x18, 0x01,
  0x08, 0x70, 0x30, 0x60, 0xFE, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x70, 0x20, 0x30, 0x71, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x02, 0x02,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x10, 0x01, 0x01, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x32, 0x66, 0x44, 0xC8, 0x88, 0xFF, 0xE0,
  0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0x42, 0x00, 0x08, 0x80,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x86, 0x00,
  0x10, 0x60, 0x0C, 0x07, 0x03, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x09, 0x00, 0x02, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80, 0x18, 0x10,
  0x06, 0x02, 0x00, 0x80, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x06, 0x07, 0x02, 0x00, 0x61,
  0x00, 0x08, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x04, 0x40, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x42, 0x00, 0x30,
  0x60, 0x30, 0x07, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x20, 0x00, 0x41, 0x00, 0x04, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x00, 0x20, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x10,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x10,
  0x7F, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0xFE, 0x05,
  0x80, 0xC3, 0x00, 0x11, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x01, 0x60, 0x01, 0x98, 0x01, 0x83, 0x01, 0x80, 0x7F, 0x00,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x7E, 0x04, 0xC0, 0xC5, 0x00, 0x13, 0x00, 0x05, 0x80, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x40, 0x01, 0x20, 0x00, 0x8C, 0x00, 0x83, 0x81, 0x80,
  0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48,
  0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x03,
  0xF8, 0x01, 0x80, 0xC0, 0x40, 0x06, 0x10, 0x00, 0x44, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x08, 0x80,
  0x02, 0x08, 0x00, 0x80, 0xC0, 0x60, 0x07, 0xF0, 0x03, 0x01, 0x81, 0x80,
  0x0C, 0x60, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x40, 0x00, 0x4C, 0x00,
  0x08, 0xC0, 0x06, 0x0E, 0x03, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0x03,
  0x03, 0x00, 0x21, 0x80, 0x04, 0x40, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xD0, 0x00, 0x26, 0x00, 0x18, 0xC0, 0x0A, 0x1C, 0x0C, 0x81, 0xFC,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x77,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x26, 0x64, 0x4C,
  0x88, 0x80, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x0C, 0x00, 0x84, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x07, 0xC0, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x01, 0x84, 0x00,
  0x42, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x00, 0xC0,
  0x3E, 0x60, 0x60, 0xB0, 0x60, 0x38, 0x20, 0x1C, 0x10, 0x06, 0x10, 0x03,
  0x08, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x61, 0x00, 0x30, 0x80, 0x18, 0x20,
  0x0C, 0x10, 0x06, 0x08, 0x07, 0x02, 0x05, 0x80, 0xFC, 0xA0, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00,
  0xA0, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x20, 0x80,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x00, 0x80,
  0x40, 0x04, 0x03, 0xFF, 0xE0, 0x20, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00,
  0x20, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0x20, 0x03,
  0x08, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x03, 0x0F, 0xFF, 0x82, 0x00, 0x18, 0x80, 0x01, 0x20, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x18, 0xFF,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0xC0, 0x20, 0x06, 0x08, 0x00, 0x42,
  0x00, 0x04, 0x40, 0x00, 0x50, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x01, 0x20,
  0x00, 0x42, 0x00, 0x10, 0x20, 0x06, 0x03, 0x01, 0x80, 0x1F, 0xC0, 0xFF,
  0xE0, 0x40, 0x1C, 0x20, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x02, 0x40, 0x03, 0x20, 0x03, 0x10, 0x07, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFD, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFD, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x60, 0x04,
  0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x00, 0x90, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x19,
  0x00, 0x03, 0x20, 0x00, 0xA2, 0x00, 0x14, 0x60, 0x04, 0x83, 0x03, 0x10,
  0x1F, 0x82, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x08, 0x80, 0x30, 0xC0, 0xC0, 0x7E,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x08, 0x80, 0x04,
  0x20, 0x02, 0x08, 0x01, 0x02, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x08,
  0x10, 0x02, 0x08, 0x00, 0x86, 0x00, 0x23, 0x40, 0x08, 0x90, 0x02, 0x42,
  0x00, 0xA0, 0x40, 0x30, 0x10, 0x08, 0x02, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0x40, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x5C, 0x00, 0x16,
  0x80, 0x09, 0xA0, 0x02, 0x68, 0x00, 0x99, 0x00, 0x46, 0x40, 0x11, 0x88,
  0x08, 0x62, 0x02, 0x18, 0x41, 0x06, 0x10, 0x41, 0x82, 0x20, 0x60, 0x88,
  0x18, 0x12, 0x06, 0x05, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x08, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0xE0, 0x00, 0x68, 0x00, 0x34, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x06,
  0x20, 0x03, 0x10, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x20,
  0x18, 0x10, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00, 0x81, 0x80, 0x40, 0xC0,
  0x10, 0x60, 0x08, 0x30, 0x02, 0x18, 0x01, 0x0C, 0x00, 0x46, 0x00, 0x23,
  0x00, 0x09, 0x80, 0x04, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x38, 0x00,
  0x18, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0x42, 0x00,
  0x08, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00,
  0x86, 0x00, 0x10, 0x60, 0x0C, 0x07, 0x03, 0x00, 0x3F, 0x80, 0xFF, 0xF8,
  0x40, 0x07, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x14, 0x00, 0x1A, 0x00, 0x19, 0xFF, 0xF0, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0x42, 0x00, 0x08,
  0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x86,
  0x00, 0x10, 0x60, 0x0C, 0x07, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xF0, 0xFF, 0xF8, 0x40,
  0x07, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x14, 0x00, 0x1A, 0x00, 0x19, 0xFF, 0xF0, 0x81, 0x00, 0x40, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x02, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x10,
  0x80, 0x04, 0x40, 0x02, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x18, 0x03,
  0xFC, 0x03, 0x80, 0xE0, 0xC0, 0x02, 0x30, 0x00, 0x24, 0x00, 0x06, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00,
  0x08, 0xC0, 0x02, 0x06, 0x01, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00, 0x83, 0x01,
  0x80, 0x7F, 0x00, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x22, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x08,
  0x10, 0x00, 0x40, 0x80, 0x02, 0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x02, 0x02, 0x00,
  0x10, 0x10, 0x00, 0x80, 0x80, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x02, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09,
  0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x01, 0x00, 0x90, 0x14,
  0x04, 0x80, 0xA0, 0x22, 0x05, 0x01, 0x10, 0x24, 0x10, 0x82, 0x20, 0x84,
  0x11, 0x04, 0x20, 0x88, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08,
  0x42, 0x20, 0x22, 0x11, 0x01, 0x10, 0x48, 0x08, 0x82, 0x40, 0x28, 0x14,
  0x01, 0x40, 0xA0, 0x0A, 0x05, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x00, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x88, 0x00, 0x08, 0x20, 0x00, 0x81,
  0x80, 0x04, 0x04, 0x00, 0x40, 0x10, 0x04, 0x00, 0xC0, 0x20, 0x02, 0x02,
  0x00, 0x08, 0x20, 0x00, 0x61, 0x00, 0x01, 0x10, 0x00, 0x05, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x48, 0x00, 0x04, 0x40,
  0x00, 0x41, 0x00, 0x02, 0x04, 0x00, 0x20, 0x20, 0x02, 0x00, 0x80, 0x30,
  0x02, 0x01, 0x00, 0x10, 0x10, 0x00, 0x41, 0x80, 0x01, 0x08, 0x00, 0x08,
  0x80, 0x00, 0x2C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x41, 0x00, 0x01, 0x01, 0x00, 0x04, 0x02,
  0x00, 0x08, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x08, 0x80, 0x00, 0x09,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0xFF, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F, 0xF0, 0x00, 0x40, 0x00, 0x14,
  0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x01,
  0x00, 0x20, 0x10, 0x08, 0x02, 0x02, 0x00, 0x20, 0x40, 0x04, 0x10, 0x00,
  0x42, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x43, 0x02, 0x04, 0x10, 0x20, 0x40, 0x07, 0xF0, 0x03, 0x03, 0x00,
  0x80, 0x10, 0x20, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x3F, 0xFC, 0x1C, 0x00, 0x86,
  0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10,
  0x00, 0x61, 0x00, 0x14, 0x20, 0x02, 0x83, 0x01, 0x90, 0x1F, 0xC3, 0xC0,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x43, 0xF0, 0x26, 0x06, 0x14,
  0x00, 0x8C, 0x00, 0x26, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x40, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x4A,
  0x00, 0x44, 0xC0, 0xC2, 0x1F, 0x80, 0x07, 0xF0, 0x18, 0x18, 0x30, 0x04,
  0x60, 0x02, 0x40, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x01, 0x60, 0x02, 0x30, 0x04, 0x1C, 0x18,
  0x07, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x81, 0xF8, 0x43,
  0x03, 0x22, 0x00, 0x52, 0x00, 0x19, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x31, 0x00, 0x28, 0x60, 0x64, 0x0F, 0xC2, 0x07, 0xF0, 0x0E, 0x06,
  0x0C, 0x00, 0x84, 0x00, 0x24, 0x00, 0x12, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0xA0, 0x00, 0x48, 0x00,
  0x46, 0x00, 0x40, 0xC0, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x0F, 0xD0,
  0x06, 0x06, 0x01, 0x00, 0x60, 0x40, 0x04, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x20,
  0x20, 0x0C, 0x03, 0x03, 0x00, 0x3F, 0x80, 0x18, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFE, 0x0C, 0x00, 0x62,
  0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x04, 0x80, 0x01, 0x0C, 0x00, 0xC0, 0x7F, 0xE0, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x0F, 0xC2, 0x60, 0x65, 0x00, 0x6C, 0x00, 0x58, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x9F, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x48, 0x00, 0x62, 0x00, 0x30, 0x80, 0x10, 0x20, 0x08, 0x08,
  0x04, 0x02, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0xE0, 0x02, 0x64,
  0x00, 0xA0, 0x80, 0x30, 0x10, 0x08, 0x06, 0x02, 0x00, 0x80, 0x80, 0x10,
  0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x03, 0x20, 0x00, 0x48,
  0x00, 0x0C, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x03, 0xFF, 0xFE, 0x9F, 0x0F, 0x94, 0x33,
  0x0B, 0x02, 0x80, 0xE0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x40, 0x87, 0xE1, 0x30, 0x32, 0x80, 0x36, 0x00, 0x2C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x07, 0xF0, 0x0E, 0x06, 0x0C,
  0x01, 0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x88, 0x00, 0xC6,
  0x00, 0xC1, 0xC0, 0xC0, 0x3F, 0x80, 0x87, 0xE0, 0x4C, 0x0C, 0x28, 0x01,
  0x18, 0x00, 0x4C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x02, 0x80, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x94, 0x00,
  0x89, 0x81, 0x84, 0x3F, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0,
  0x86, 0x06, 0x44, 0x00, 0xA4, 0x00, 0x32, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x62, 0x00, 0x50, 0xC0, 0xC8, 0x1F, 0x84, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0xFF, 0x87, 0xF0, 0x09, 0x80, 0x00, 0xA0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x06,
  0x03, 0x02, 0x00, 0x31, 0x00, 0x02, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x08, 0x80, 0x04, 0x18, 0x06, 0x01, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xF0,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x1B,
  0x00, 0x53, 0x03, 0x21, 0xF8, 0x40, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x20, 0x04, 0x10,
  0x04, 0x08, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x20, 0x80,
  0x10, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x04, 0x00, 0x80, 0x20, 0x06, 0x01, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x20, 0x24, 0x08, 0x81,
  0x10, 0x22, 0x04, 0x40, 0x88, 0x11, 0x04, 0x10, 0x44, 0x10, 0x41, 0x08,
  0x41, 0x08, 0x21, 0x02, 0x20, 0x88, 0x08, 0x82, 0x20, 0x22, 0x08, 0x80,
  0x88, 0x12, 0x01, 0x20, 0x50, 0x05, 0x01, 0x40, 0x14, 0x05, 0x00, 0x50,
  0x18, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x88, 0x00,
  0x86, 0x00, 0x41, 0x00, 0x40, 0x40, 0x40, 0x10, 0x60, 0x0C, 0x20, 0x02,
  0x20, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x11, 0x00,
  0x18, 0x40, 0x08, 0x30, 0x08, 0x08, 0x08, 0x02, 0x08, 0x00, 0x84, 0x00,
  0x64, 0x00, 0x14, 0x00, 0x04, 0xC0, 0x00, 0x28, 0x00, 0x09, 0x00, 0x01,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x40, 0x08,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x10, 0x02, 0x02, 0x00, 0x20, 0x40,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x03, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x08,
  0x8C, 0x00, 0x88, 0x10, 0x04, 0x80, 0x40, 0x24, 0x01, 0x02, 0x20, 0x06,
  0x32, 0x00, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 3, 29, 25, 11, -29 },
  { 12, 7, 11, 25, 9, -31 },
  { 22, 23, 29, 25, 1, -29 },
  { 106, 19, 37, 25, 3, -33 },
  { 194, 23, 29, 25, 1, -29 },
  { 278, 21, 29, 25, 2, -29 },
  { 355, 1, 11, 25, 12, -31 },
  { 357, 10, 38, 25, 10, -32 },
  { 405, 9, 38, 25, 6, -32 },
  { 448, 21, 21, 25, 2, -23 },
  { 504, 20, 21, 25, 3, -23 },
  { 557, 4, 10, 25, 10, -3 },
  { 562, 11, 1, 25, 7, -13 },
  { 564, 3, 3, 25, 11, -3 },
  { 566, 17, 38, 25, 4, -32 },
  { 647, 19, 29, 25, 3, -29 },
  { 716, 19, 29, 25, 4, -29 },
  { 785, 18, 29, 25, 4, -29 },
  { 851, 18, 29, 25, 3, -29 },
  { 917, 21, 29, 25, 2, -29 },
  { 994, 17, 29, 25, 4, -29 },
  { 1056, 17, 29, 25, 4, -29 },
  { 1118, 19, 29, 25, 3, -29 },
  { 1187, 19, 29, 25, 3, -29 },
  { 1256, 18, 29, 25, 4, -29 },
  { 1322, 3, 22, 25, 11, -22 },
  { 1331, 4, 29, 25, 10, -22 },
  { 1346, 18, 22, 25, 4, -24 },
  { 1396, 20, 8, 25, 3, -17 },
  { 1416, 18, 22, 25, 4, -24 },
  { 1466, 17, 29, 25, 4, -29 },
  { 1528, 17, 33, 25, 4, -29 },
  { 1599, 21, 29, 25, 2, -29 },
  { 1676, 18, 29, 25, 4, -29 },
  { 1742, 19, 29, 25, 3, -29 },
  { 1811, 17, 29, 25, 5, -29 },
  { 1873, 17, 29, 25, 5, -29 },
  { 1935, 17, 29, 25, 5, -29 },
  { 1997, 19, 29, 25, 3, -29 },
  { 2066, 17, 29, 25, 4, -29 },
  { 2128, 17, 29, 25, 4, -29 },
  { 2190, 15, 29, 25, 4, -29 },
  { 2245, 18, 29, 25, 5, -29 },
  { 2311, 16, 29, 25, 6, -29 },
  { 2369, 18, 29, 25, 4, -29 },
  { 2435, 17, 29, 25, 4, -29 },
  { 2497, 19, 29, 25, 3, -29 },
  { 2566, 17, 29, 25, 5, -29 },
  { 2628, 19, 34, 25, 3, -29 },
  { 2709, 17, 29, 25, 5, -29 },
  { 2771, 19, 29, 25, 3, -29 },
  { 2840, 21, 29, 25, 2, -29 },
  { 2917, 17, 29, 25, 4, -29 },
  { 2979, 21, 29, 25, 2, -29 },
  { 3056, 21, 29, 25, 2, -29 },
  { 3133, 21, 29, 25, 2, -29 },
  { 3210, 23, 29, 25, 1, -29 },
  { 3294, 21, 29, 25, 2, -29 },
  { 3371, 10, 38, 25, 11, -32 },
  { 3419, 17, 38, 25, 4, -32 },
  { 3500, 10, 38, 25, 4, -32 },
  { 3548, 19, 16, 25, 3, -29 },
  { 3586, 20, 1, 25, 3, 5 },
  { 3589, 6, 7, 25, 8, -32 },
  { 3595, 19, 22, 25, 3, -22 },
  { 3648, 17, 31, 25, 5, -31 },
  { 3714, 16, 22, 25, 5, -22 },
  { 3758, 17, 31, 25, 3, -31 },
  { 3824, 17, 22, 25, 4, -22 },
  { 3871, 18, 31, 25, 4, -31 },
  { 3941, 19, 32, 25, 4, -24 },
  { 4017, 15, 31, 25, 5, -31 },
  { 4076, 17, 31, 25, 5, -31 },
  { 4142, 15, 39, 25, 4, -31 },
  { 4216, 18, 31, 25, 6, -31 },
  { 4286, 17, 31, 25, 4, -31 },
  { 4352, 19, 22, 25, 3, -22 },
  { 4405, 15, 22, 25, 5, -22 },
  { 4447, 17, 22, 25, 4, -22 },
  { 4494, 17, 30, 25, 5, -22 },
  { 4558, 17, 30, 25, 3, -22 },
  { 4622, 20, 22, 25, 3, -22 },
  { 4677, 18, 22, 25, 4, -22 },
  { 4727, 20, 29, 25, 2, -29 },
  { 4800, 15, 22, 25, 5, -22 },
  { 4842, 17, 22, 25, 4, -22 },
  { 4889, 22, 22, 25, 2, -22 },
  { 4950, 17, 22, 25, 4, -22 },
  { 4997, 19, 30, 25, 3, -22 },
  { 5069, 17, 22, 25, 4, -22 },
  { 5116, 15, 38, 25, 5, -32 },
  { 5188, 1, 38, 25, 12, -32 },
  { 5193, 15, 38, 25, 5, -32 },
  { 5265, 21, 7, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Thin42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_THIN42PT7B_H_
