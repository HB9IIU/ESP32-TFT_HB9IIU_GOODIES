#ifndef _IBMPLEXMONO_THIN40PT7B_H_
#define _IBMPLEXMONO_THIN40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x0F, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x40, 0x00, 0x81, 0x01, 0xFE, 0x07, 0xF0, 0x08, 0x20, 0x00, 0x40,
  0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80,
  0x01, 0x02, 0x00, 0x08, 0x10, 0x0F, 0xE0, 0x7F, 0x80, 0x81, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x06, 0x11, 0x82, 0x04,
  0x11, 0x01, 0x02, 0x40, 0x40, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x10, 0x04, 0x04, 0x00, 0x81, 0x00, 0x1C, 0x40, 0x01,
  0xF8, 0x00, 0x05, 0xE0, 0x01, 0x0C, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04,
  0x04, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04, 0x06, 0x01, 0x01,
  0x40, 0x40, 0x88, 0x10, 0x41, 0xC4, 0x60, 0x0F, 0xE0, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x04, 0xC3, 0x00, 0x24,
  0x06, 0x01, 0x10, 0x08, 0x04, 0x80, 0x20, 0x22, 0x00, 0x80, 0x88, 0x02,
  0x04, 0x20, 0x08, 0x20, 0x80, 0x20, 0x81, 0x00, 0x84, 0x04, 0x06, 0x10,
  0x0C, 0x30, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0x0C, 0x30, 0x08, 0x60, 0x20, 0x21, 0x00, 0x81, 0x04,
  0x02, 0x08, 0x20, 0x04, 0x20, 0x80, 0x11, 0x02, 0x00, 0x44, 0x04, 0x02,
  0x20, 0x10, 0x09, 0x00, 0x60, 0x24, 0x00, 0xC3, 0x20, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x02, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xA0, 0x0F, 0x31, 0x01,
  0x06, 0x08, 0x10, 0x40, 0x41, 0x08, 0x06, 0x10, 0x80, 0x31, 0x08, 0x01,
  0x90, 0x80, 0x0D, 0x08, 0x00, 0x50, 0x80, 0x02, 0x08, 0x00, 0x30, 0x40,
  0x04, 0x86, 0x00, 0x84, 0x30, 0x30, 0x40, 0xFC, 0x03, 0xFF, 0xC0, 0x01,
  0x81, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x30, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x0C, 0x04, 0x01, 0x38, 0x41, 0xE0, 0x74, 0xE0, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x90, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20,
  0x40, 0x04, 0x02, 0x00, 0x80, 0x10, 0x08, 0x01, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x33,
  0x22, 0x64, 0x44, 0x88, 0xFF, 0xC0, 0xF0, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01,
  0x00, 0x20, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x24, 0x00, 0x0A, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09, 0x80,
  0x04, 0x20, 0x01, 0x04, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0x34, 0x00, 0x0C, 0x80, 0x03, 0x10, 0x00, 0xC2, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x06, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x20,
  0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x0C, 0x0E,
  0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x7F, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x05, 0x00, 0x02, 0xC0,
  0x03, 0x30, 0x03, 0x06, 0x07, 0x00, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0A, 0x00, 0x00, 0xA0, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x02, 0x00,
  0x20, 0x20, 0x02, 0x02, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02,
  0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x7E, 0x04, 0xC0, 0xC2, 0x80, 0x10,
  0x80, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x02, 0x40, 0x01, 0x10,
  0x01, 0x06, 0x03, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x7E, 0x04, 0xC0, 0xC2, 0x80, 0x11,
  0x80, 0x04, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x20, 0x01, 0x08,
  0x01, 0x03, 0x03, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x28, 0x00, 0x14, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x07, 0x03, 0x03, 0x00,
  0x30, 0x80, 0x04, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x22, 0x00, 0x10, 0xC0, 0x0C, 0x0C, 0x0C, 0x00,
  0xFC, 0x01, 0xC0, 0xE0, 0x80, 0x04, 0x40, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x40, 0x00, 0x88, 0x00, 0x41, 0x80, 0x60, 0x1F, 0xE0, 0x07, 0xE0, 0x0C,
  0x0C, 0x08, 0x01, 0x08, 0x00, 0x48, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x12, 0x00, 0x18, 0x80, 0x14, 0x30, 0x32, 0x07, 0xE2, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x33, 0x22, 0x64, 0x44, 0x88, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x01, 0xE0, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x18,
  0x18, 0x30, 0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x01, 0x80, 0xF9, 0x81, 0x05, 0x82, 0x03, 0x84, 0x01, 0x84, 0x01, 0x84,
  0x01, 0x84, 0x01, 0x84, 0x01, 0x84, 0x01, 0x84, 0x01, 0x84, 0x01, 0x84,
  0x01, 0x84, 0x01, 0x82, 0x03, 0x83, 0x05, 0x81, 0xF9, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0xFE, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00,
  0x90, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00,
  0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04, 0x02, 0x00, 0x40, 0x20,
  0x04, 0x02, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x1F, 0xFF,
  0x81, 0x00, 0x08, 0x10, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x01, 0xFF,
  0xF0, 0x40, 0x0C, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x88, 0x01, 0x87, 0xFF, 0x82, 0x00, 0x31, 0x00, 0x04, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x03, 0x1F, 0xFF, 0x00, 0x01,
  0xF8, 0x01, 0x81, 0x81, 0x80, 0x10, 0x40, 0x02, 0x20, 0x00, 0x90, 0x00,
  0x14, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x04, 0x80, 0x02, 0x10, 0x00, 0x86, 0x00, 0x40, 0xE0, 0x60,
  0x07, 0xE0, 0xFF, 0xE0, 0x40, 0x0C, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x06, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xFA, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xFA, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x20, 0xC0, 0x04, 0x20,
  0x00, 0x90, 0x00, 0x24, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x34, 0x00, 0x0C, 0x80, 0x05, 0x20, 0x01, 0x46, 0x00,
  0x90, 0xC0, 0xC4, 0x0F, 0xE1, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x3F, 0xFC, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x40, 0x0D, 0x00, 0x23, 0x03, 0x03, 0xF0, 0x80, 0x00,
  0xE0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x04, 0x20, 0x02, 0x08,
  0x01, 0x02, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x08, 0x10, 0x02, 0x0C,
  0x00, 0x83, 0x00, 0x21, 0x40, 0x08, 0x88, 0x02, 0x41, 0x00, 0xA0, 0x40,
  0x30, 0x08, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x0A, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x07, 0xFF, 0xF0, 0xC0, 0x00, 0xF0, 0x00, 0x5A, 0x00,
  0x16, 0x80, 0x05, 0x90, 0x02, 0x64, 0x00, 0x98, 0x80, 0x46, 0x20, 0x11,
  0x84, 0x08, 0x61, 0x02, 0x18, 0x41, 0x06, 0x08, 0x41, 0x82, 0x20, 0x60,
  0x48, 0x18, 0x12, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xA0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x90, 0x01, 0x88, 0x01, 0x88,
  0x01, 0x84, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x01, 0x81, 0x01, 0x81,
  0x01, 0x80, 0x81, 0x80, 0x81, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21, 0x80,
  0x21, 0x80, 0x11, 0x80, 0x11, 0x80, 0x09, 0x80, 0x09, 0x80, 0x05, 0x80,
  0x05, 0x80, 0x03, 0x80, 0x01, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x20,
  0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09, 0x80, 0x04, 0x20,
  0x01, 0x04, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xC0, 0xFF, 0xF8, 0x40, 0x03,
  0x20, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x34,
  0x00, 0x33, 0xFF, 0xE1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x03,
  0x01, 0x00, 0x20, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x24, 0x00, 0x0A,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09,
  0x80, 0x04, 0x20, 0x01, 0x04, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xC0, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xF8, 0x40, 0x03, 0x20, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x28, 0x00, 0x34, 0x00, 0x33, 0xFF, 0xE1, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x08, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x50, 0x00, 0x20, 0x07,
  0xF8, 0x06, 0x01, 0x82, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x88, 0x00, 0x41, 0x80, 0x60,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02,
  0x40, 0x02, 0x20, 0x04, 0x30, 0x1C, 0x0F, 0xF0, 0x80, 0x00, 0x14, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20,
  0x00, 0x41, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x08, 0x01, 0x00,
  0x80, 0x10, 0x08, 0x01, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20,
  0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x0A,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x28, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x06, 0x02, 0x40, 0x60, 0x24, 0x06, 0x02,
  0x40, 0x90, 0x44, 0x09, 0x04, 0x20, 0x90, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x22, 0x08, 0x42, 0x20, 0x44, 0x22, 0x04, 0x42, 0x20,
  0x44, 0x24, 0x02, 0x42, 0x40, 0x28, 0x14, 0x02, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x80, 0x18, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x20, 0x00, 0x41,
  0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x10, 0x04, 0x02, 0x00, 0x40, 0x20,
  0x02, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x09, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x10,
  0x80, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04, 0x02, 0x00, 0x80, 0x10, 0x08,
  0x01, 0x01, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0x28,
  0x00, 0x01, 0x80, 0x00, 0x05, 0x00, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x04, 0x01, 0x00, 0x20,
  0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x10, 0x20, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x20, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xF0, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x12, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x01, 0x02, 0x00, 0x40, 0x80, 0x20, 0x10, 0x10, 0x02, 0x04,
  0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x40, 0x00, 0xA0, 0x00, 0x18, 0x00,
  0x04, 0xFF, 0xFF, 0xF0, 0x82, 0x10, 0x41, 0x0C, 0x20, 0x07, 0xE0, 0x06,
  0x06, 0x02, 0x00, 0xC1, 0x00, 0x10, 0x40, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0xFF, 0xE0, 0xC0, 0x08,
  0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x01, 0x84, 0x00, 0xA0, 0xC0, 0xC8, 0x1F, 0xC3, 0xC0, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x87, 0xE0, 0x98, 0x30, 0xA0, 0x08, 0xC0, 0x04, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0xC0, 0x04, 0xA0, 0x08, 0x98, 0x30, 0x8F, 0xC0, 0x03, 0xF0, 0x0C,
  0x0C, 0x10, 0x06, 0x20, 0x02, 0x40, 0x01, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x01, 0x20, 0x02, 0x10, 0x06, 0x0C,
  0x08, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x07, 0xE1, 0x0C,
  0x19, 0x30, 0x05, 0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x03, 0x30, 0x05, 0x0C,
  0x19, 0x07, 0xE1, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x01, 0x40, 0x02, 0x20, 0x06, 0x18, 0x0C, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x02, 0x00, 0x7E, 0x80,
  0x60, 0x60, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x20, 0x80, 0x08, 0x20, 0x04, 0x04, 0x01,
  0x00, 0x81, 0x80, 0x3F, 0x80, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x86, 0x00, 0x1B, 0x00, 0x02, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0xC0, 0x01, 0x9C, 0x01,
  0x80, 0xFF, 0x80, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x3F, 0x09, 0x03, 0x28, 0x02,
  0xC0, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0B, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x02, 0x80,
  0x0C, 0x80, 0x18, 0x80, 0x20, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82,
  0x00, 0x84, 0x00, 0x9A, 0x00, 0xB1, 0x00, 0xC0, 0x80, 0x80, 0xC0, 0x80,
  0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0x9E, 0x0F, 0x28, 0x44, 0x2C, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60,
  0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08,
  0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01,
  0x80, 0x80, 0x40, 0x8F, 0xC2, 0x40, 0xCA, 0x00, 0xB0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0, 0x87, 0xE0,
  0x98, 0x30, 0xA0, 0x08, 0xC0, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x04, 0xA0, 0x08,
  0x98, 0x30, 0x8F, 0xC0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE1, 0x0C, 0x19,
  0x30, 0x05, 0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x03, 0x30, 0x05, 0x0C, 0x19,
  0x07, 0xE1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x26, 0x00, 0x05,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xF8, 0x0F, 0xE0, 0x18, 0x0E,
  0x18, 0x00, 0x88, 0x00, 0x24, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x98, 0x00,
  0xC3, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x34, 0x01,
  0x4C, 0x09, 0x0F, 0xC4, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08,
  0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x09, 0x01, 0x80, 0x90, 0x18, 0x09,
  0x02, 0x41, 0x10, 0x24, 0x10, 0x82, 0x41, 0x08, 0x24, 0x10, 0x82, 0x42,
  0x08, 0x24, 0x20, 0x44, 0x22, 0x04, 0x42, 0x20, 0x44, 0x24, 0x04, 0x42,
  0x40, 0x24, 0x24, 0x02, 0x81, 0x40, 0x28, 0x18, 0x02, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x80, 0x80, 0x01, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10,
  0x08, 0x08, 0x10, 0x0C, 0x20, 0x04, 0x20, 0x02, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x40, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x10,
  0x08, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x00, 0xD0,
  0x00, 0x24, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x81, 0x00,
  0x20, 0x40, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x80, 0x10, 0x20,
  0x04, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x03, 0xFC, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x03, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0xF0, 0x38, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xC0, 0x0E, 0x00, 0x13, 0x18,
  0x02, 0x20, 0xC0, 0x24, 0x06, 0x02, 0x40, 0x30, 0x48, 0x01, 0x8C, 0x80,
  0x07, 0x00,
};

const GFXglyph IBMPlexMono_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 2, 28, 24, 11, -28 },
  { 8, 6, 10, 24, 9, -30 },
  { 16, 22, 28, 24, 1, -28 },
  { 93, 18, 36, 24, 3, -32 },
  { 174, 22, 28, 24, 1, -28 },
  { 251, 20, 28, 24, 2, -28 },
  { 321, 1, 10, 24, 12, -30 },
  { 323, 9, 36, 24, 10, -30 },
  { 364, 9, 36, 24, 5, -30 },
  { 405, 20, 20, 24, 2, -22 },
  { 455, 20, 19, 24, 2, -22 },
  { 503, 4, 10, 24, 9, -3 },
  { 508, 10, 1, 24, 7, -13 },
  { 510, 2, 2, 24, 11, -2 },
  { 511, 16, 36, 24, 4, -30 },
  { 583, 18, 28, 24, 3, -28 },
  { 646, 19, 28, 24, 3, -28 },
  { 713, 18, 28, 24, 3, -28 },
  { 776, 17, 28, 24, 3, -28 },
  { 836, 20, 28, 24, 2, -28 },
  { 906, 17, 28, 24, 3, -28 },
  { 966, 17, 28, 24, 3, -28 },
  { 1026, 17, 28, 24, 3, -28 },
  { 1086, 18, 28, 24, 3, -28 },
  { 1149, 17, 28, 24, 4, -28 },
  { 1209, 2, 21, 24, 11, -21 },
  { 1215, 4, 28, 24, 9, -21 },
  { 1229, 18, 21, 24, 3, -23 },
  { 1277, 20, 8, 24, 2, -16 },
  { 1297, 18, 21, 24, 3, -23 },
  { 1345, 16, 28, 24, 4, -28 },
  { 1401, 16, 32, 24, 4, -28 },
  { 1465, 20, 28, 24, 2, -28 },
  { 1535, 17, 28, 24, 4, -28 },
  { 1595, 18, 28, 24, 3, -28 },
  { 1658, 17, 28, 24, 4, -28 },
  { 1718, 17, 28, 24, 4, -28 },
  { 1778, 17, 28, 24, 4, -28 },
  { 1838, 18, 28, 24, 3, -28 },
  { 1901, 16, 28, 24, 4, -28 },
  { 1957, 16, 28, 24, 4, -28 },
  { 2013, 14, 28, 24, 4, -28 },
  { 2062, 18, 28, 24, 4, -28 },
  { 2125, 15, 28, 24, 6, -28 },
  { 2178, 18, 28, 24, 3, -28 },
  { 2241, 16, 28, 24, 4, -28 },
  { 2297, 18, 28, 24, 3, -28 },
  { 2360, 17, 28, 24, 4, -28 },
  { 2420, 18, 33, 24, 3, -28 },
  { 2495, 17, 28, 24, 4, -28 },
  { 2555, 18, 28, 24, 3, -28 },
  { 2618, 20, 28, 24, 2, -28 },
  { 2688, 16, 28, 24, 4, -28 },
  { 2744, 20, 28, 24, 2, -28 },
  { 2814, 20, 28, 24, 2, -28 },
  { 2884, 20, 28, 24, 2, -28 },
  { 2954, 22, 28, 24, 1, -28 },
  { 3031, 20, 28, 24, 2, -28 },
  { 3101, 9, 36, 24, 11, -30 },
  { 3142, 16, 36, 24, 4, -30 },
  { 3214, 9, 36, 24, 4, -30 },
  { 3255, 18, 15, 24, 3, -28 },
  { 3289, 20, 1, 24, 2, 5 },
  { 3292, 5, 7, 24, 8, -31 },
  { 3297, 18, 21, 24, 3, -21 },
  { 3345, 16, 30, 24, 5, -30 },
  { 3405, 16, 21, 24, 4, -21 },
  { 3447, 16, 30, 24, 3, -30 },
  { 3507, 16, 21, 24, 4, -21 },
  { 3549, 18, 30, 24, 3, -30 },
  { 3617, 18, 31, 24, 4, -23 },
  { 3687, 14, 30, 24, 5, -30 },
  { 3740, 16, 30, 24, 5, -30 },
  { 3800, 14, 38, 24, 4, -30 },
  { 3867, 16, 30, 24, 6, -30 },
  { 3927, 16, 30, 24, 4, -30 },
  { 3987, 18, 21, 24, 3, -21 },
  { 4035, 14, 21, 24, 5, -21 },
  { 4072, 16, 21, 24, 4, -21 },
  { 4114, 16, 29, 24, 5, -21 },
  { 4172, 16, 29, 24, 3, -21 },
  { 4230, 19, 21, 24, 3, -21 },
  { 4280, 17, 21, 24, 4, -21 },
  { 4325, 20, 28, 24, 1, -28 },
  { 4395, 14, 21, 24, 5, -21 },
  { 4432, 16, 21, 24, 4, -21 },
  { 4474, 20, 21, 24, 2, -21 },
  { 4527, 16, 21, 24, 4, -21 },
  { 4569, 18, 29, 24, 3, -21 },
  { 4635, 16, 21, 24, 4, -21 },
  { 4677, 14, 36, 24, 5, -30 },
  { 4740, 1, 36, 24, 12, -30 },
  { 4745, 14, 36, 24, 5, -30 },
  { 4808, 20, 7, 24, 2, -16 },
};

const GFXfont IBMPlexMono_Thin40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_THIN40PT7B_H_
