#ifndef _IBMPLEXMONO_THIN59PT7B_H_
#define _IBMPLEXMONO_THIN59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin59pt7bBitmaps[] PROGMEM = {
  0x00, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x40, 0x18,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x04, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x31, 0xE0, 0x0E, 0x06, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0xC0, 0x18, 0x03, 0x10, 0x03, 0x00, 0x26, 0x00, 0x60,
  0x00, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x40,
  0x06, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x08,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x10, 0x00, 0x60, 0x02, 0x00, 0x0C,
  0x00, 0x40, 0x01, 0x80, 0x08, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x20,
  0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01, 0x20, 0x03, 0x00, 0x63, 0x00, 0x60,
  0x08, 0x30, 0x0C, 0x02, 0x03, 0x81, 0x81, 0x80, 0x1C, 0x30, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x30, 0x04, 0x00, 0x02, 0x20,
  0x06, 0x00, 0x04, 0x40, 0x02, 0x00, 0x0C, 0x40, 0x01, 0x00, 0x08, 0xC0,
  0x01, 0x00, 0x10, 0x80, 0x01, 0x00, 0x10, 0x80, 0x01, 0x00, 0x20, 0x80,
  0x01, 0x00, 0x60, 0x80, 0x01, 0x00, 0x40, 0x80, 0x01, 0x00, 0xC0, 0x80,
  0x01, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x40, 0x03, 0x03, 0x00, 0x40,
  0x02, 0x02, 0x00, 0x20, 0x06, 0x06, 0x00, 0x30, 0x04, 0x04, 0x00, 0x1C,
  0x18, 0x08, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x20, 0x38, 0x30, 0x00, 0x60, 0x60, 0x18, 0x00, 0x40, 0x40, 0x0C, 0x00,
  0xC0, 0x80, 0x04, 0x00, 0x80, 0x80, 0x06, 0x01, 0x01, 0x80, 0x02, 0x01,
  0x01, 0x00, 0x02, 0x02, 0x01, 0x00, 0x02, 0x06, 0x01, 0x00, 0x02, 0x04,
  0x01, 0x00, 0x02, 0x08, 0x01, 0x00, 0x02, 0x08, 0x01, 0x00, 0x02, 0x10,
  0x01, 0x80, 0x02, 0x30, 0x00, 0x80, 0x06, 0x20, 0x00, 0x80, 0x04, 0x40,
  0x00, 0x40, 0x0C, 0x40, 0x00, 0x60, 0x18, 0x80, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18,
  0x01, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x18, 0x40,
  0x03, 0xF0, 0xC0, 0x80, 0x08, 0x06, 0x03, 0x00, 0x20, 0x30, 0x06, 0x00,
  0x80, 0x80, 0x0C, 0x02, 0x06, 0x00, 0x10, 0x08, 0x10, 0x00, 0x20, 0x20,
  0x40, 0x00, 0x41, 0x81, 0x00, 0x01, 0x86, 0x04, 0x00, 0x03, 0x10, 0x30,
  0x00, 0x06, 0x40, 0xC0, 0x00, 0x09, 0x01, 0x00, 0x00, 0x1C, 0x04, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x80, 0x80, 0x00,
  0x33, 0x03, 0x00, 0x00, 0x86, 0x06, 0x00, 0x04, 0x0C, 0x0C, 0x00, 0x60,
  0x18, 0x1C, 0x07, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0xBC, 0x00,
  0x80, 0x0F, 0x1E, 0x02, 0x01, 0xE0, 0x0F, 0x08, 0x38, 0x00, 0x07, 0xAF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x02, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x19, 0xCC, 0x63, 0x19, 0x8C, 0x62, 0x31, 0x88, 0x42, 0x00, 0xFF, 0xFE,
  0xEF, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x18, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x18, 0x20, 0x00, 0x06, 0x04, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x60, 0x10, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x20, 0x30, 0x00, 0x0C,
  0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x28, 0x00, 0x00, 0x12, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x70,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x80, 0x01, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFE,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x3F, 0xC0, 0x08, 0xE0, 0x18, 0x04, 0x80, 0x03, 0x02,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x38,
  0x00, 0x20, 0x07, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x3F, 0xC0, 0x18, 0xE0, 0x38, 0x08, 0x80, 0x03, 0x04,
  0x80, 0x00, 0xC2, 0x80, 0x00, 0x31, 0x80, 0x00, 0x09, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x20, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x0C, 0x40, 0x00, 0x06, 0x20, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x20,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x70, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x34, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x00, 0x78, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xC0, 0x70, 0x01, 0x80, 0x06, 0x01, 0x00, 0x01, 0x81, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x51, 0x00,
  0x00, 0x28, 0x40, 0x00, 0x6C, 0x18, 0x00, 0x64, 0x07, 0x00, 0xC2, 0x00,
  0x7F, 0x81, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xEF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0,
  0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x30, 0xC3, 0x0C,
  0x61, 0x86, 0x10, 0xC3, 0x08, 0x20, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0E, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x80, 0x00, 0xC2, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x90, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xC0, 0xE0, 0x02, 0x00, 0x30, 0x04, 0x00, 0x08, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x20, 0x00, 0x03, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x07,
  0xE1, 0x40, 0x0C, 0x19, 0x40, 0x10, 0x05, 0x40, 0x20, 0x05, 0x40, 0x60,
  0x03, 0x40, 0x40, 0x01, 0x40, 0x40, 0x01, 0x40, 0xC0, 0x01, 0x40, 0xC0,
  0x01, 0xC0, 0x80, 0x01, 0xC0, 0x80, 0x01, 0xC0, 0x80, 0x01, 0xC0, 0x80,
  0x01, 0xC0, 0x80, 0x01, 0xC0, 0x80, 0x01, 0x40, 0x80, 0x01, 0x40, 0xC0,
  0x01, 0x40, 0x40, 0x01, 0x40, 0x40, 0x01, 0x40, 0x40, 0x03, 0x40, 0x20,
  0x03, 0x40, 0x30, 0x05, 0x40, 0x18, 0x09, 0x40, 0x0F, 0xF1, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00, 0x03, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x40, 0x00,
  0x40, 0x02, 0x00, 0x01, 0x00, 0x30, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0xE0, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30,
  0x80, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x70, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x04, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x08, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x30, 0x10, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x23, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x01, 0xC1, 0x80, 0x03, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE6, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x02, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xD0, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x50, 0xC0, 0x00, 0x14, 0x18, 0x00, 0x09, 0x03, 0x00, 0x0C,
  0x40, 0x38, 0x0E, 0x10, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x20, 0x00, 0x10, 0x80,
  0x01, 0x82, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x40, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0A, 0x00, 0x03,
  0x04, 0xC0, 0x00, 0xC3, 0x18, 0x00, 0x31, 0x82, 0x00, 0x0C, 0xC0, 0xC0,
  0x03, 0x60, 0x18, 0x00, 0xF0, 0x02, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0xF4, 0x00, 0x00, 0x59, 0x00, 0x00, 0x6C, 0x80, 0x00, 0x26,
  0x20, 0x00, 0x13, 0x10, 0x00, 0x19, 0x8C, 0x00, 0x08, 0xC2, 0x00, 0x0C,
  0x61, 0x80, 0x04, 0x30, 0x40, 0x06, 0x18, 0x30, 0x02, 0x0C, 0x08, 0x03,
  0x06, 0x04, 0x01, 0x03, 0x01, 0x00, 0x81, 0x80, 0x80, 0x80, 0xC0, 0x60,
  0x40, 0x60, 0x10, 0x60, 0x30, 0x0C, 0x20, 0x18, 0x02, 0x30, 0x0C, 0x01,
  0x90, 0x06, 0x00, 0x58, 0x03, 0x00, 0x28, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xA0, 0x00, 0x03, 0xB0,
  0x00, 0x03, 0x90, 0x00, 0x03, 0x98, 0x00, 0x03, 0x88, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x84, 0x00, 0x03, 0x86, 0x00, 0x03, 0x82, 0x00, 0x03, 0x83,
  0x00, 0x03, 0x81, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0x80, 0x03, 0x80,
  0xC0, 0x03, 0x80, 0x40, 0x03, 0x80, 0x60, 0x03, 0x80, 0x20, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x10, 0x03, 0x80, 0x08, 0x03, 0x80, 0x08, 0x03, 0x80,
  0x04, 0x03, 0x80, 0x06, 0x03, 0x80, 0x02, 0x03, 0x80, 0x03, 0x03, 0x80,
  0x01, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0x83, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0x43, 0x80, 0x00, 0x63, 0x80, 0x00, 0x23, 0x80, 0x00, 0x33, 0x80,
  0x00, 0x13, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x0B, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x30, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x44, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x60, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x87, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x44, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x30, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x87, 0xFF,
  0xFE, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x04, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x23, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x08, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x60, 0x00, 0x04, 0x20, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x01, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x08,
  0x02, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x02,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x10, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x01, 0x10, 0x01, 0x80, 0x18, 0x80, 0x1C, 0x00,
  0xC4, 0x00, 0xA0, 0x04, 0x20, 0x05, 0x80, 0x21, 0x00, 0x24, 0x01, 0x08,
  0x03, 0x20, 0x08, 0x60, 0x11, 0x80, 0x43, 0x00, 0x84, 0x02, 0x08, 0x0C,
  0x20, 0x10, 0x40, 0x41, 0x00, 0x82, 0x02, 0x0C, 0x0C, 0x10, 0x30, 0x20,
  0x60, 0x81, 0x01, 0x03, 0x04, 0x08, 0x0C, 0x10, 0x20, 0x40, 0x20, 0x81,
  0x04, 0x01, 0x04, 0x0C, 0x20, 0x0C, 0x20, 0x61, 0x00, 0x21, 0x01, 0x18,
  0x01, 0x08, 0x08, 0x80, 0x08, 0x40, 0x44, 0x00, 0x66, 0x02, 0x60, 0x01,
  0x30, 0x12, 0x00, 0x09, 0x80, 0x90, 0x00, 0x68, 0x05, 0x80, 0x01, 0x40,
  0x28, 0x00, 0x0A, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x02,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0xFF, 0xFC, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x18, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x30, 0x02, 0x00, 0x04, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x60,
  0x00, 0xC0, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0xFE, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x00, 0x80,
  0x20, 0x00, 0x10, 0x10, 0x00, 0x06, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x0F, 0xFF, 0xE0, 0x1C, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xA0, 0x40, 0x00, 0x48, 0x0C, 0x00, 0x22,
  0x01, 0xC0, 0x70, 0xFC, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFE,
  0x00, 0xC7, 0x01, 0xC0, 0xCC, 0x00, 0x60, 0xD0, 0x00, 0x30, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x08, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x04, 0xC0, 0x00, 0x04, 0xE0, 0x00, 0x08, 0xE0, 0x00, 0x18, 0xD0, 0x00,
  0x30, 0xCC, 0x00, 0x60, 0xC7, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0x80, 0xE0, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x04, 0x10, 0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x10, 0x00, 0x02, 0x18, 0x00, 0x04, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x01, 0x80, 0x60, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x1F, 0xE0, 0x40, 0xE0, 0x70, 0x86, 0x00, 0x11, 0x18, 0x00, 0x12, 0x20,
  0x00, 0x14, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x34, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x58,
  0x00, 0x01, 0x90, 0x00, 0x03, 0x10, 0x00, 0x0A, 0x30, 0x00, 0x24, 0x30,
  0x00, 0x88, 0x18, 0x0E, 0x10, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xC0, 0x70, 0x01, 0x80, 0x04, 0x01, 0x80, 0x01, 0x01, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x68, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x88, 0x00, 0x1C, 0x0E,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x08, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x40, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x40, 0x04, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x1C,
  0x00, 0x1F, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x07, 0xF8, 0x0C, 0x70, 0x38, 0x32, 0x00, 0x18,
  0xD0, 0x00, 0x23, 0x80, 0x00, 0x4E, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x7F,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x10, 0x00, 0x30, 0x08, 0x00, 0x30, 0x04, 0x00, 0x30, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x20, 0x00, 0x80, 0x60, 0x00, 0x40, 0x60, 0x00, 0x20,
  0x70, 0x00, 0x10, 0x64, 0x00, 0x08, 0x41, 0x00, 0x04, 0x40, 0xC0, 0x02,
  0xC0, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x00, 0x80,
  0x20, 0x00, 0x20, 0x10, 0x00, 0x18, 0x08, 0x00, 0x06, 0x04, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x03, 0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x19, 0x06, 0x18, 0x33, 0x40, 0x26, 0x03,
  0x70, 0x06, 0x80, 0x2C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x00, 0x0E, 0x00, 0x20, 0x01, 0xC0, 0x04, 0x00, 0x38, 0x00, 0x80, 0x07,
  0x00, 0x10, 0x00, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0x40, 0x03, 0x80, 0x08,
  0x00, 0x70, 0x01, 0x00, 0x0E, 0x00, 0x20, 0x01, 0xC0, 0x04, 0x00, 0x38,
  0x00, 0x80, 0x07, 0x00, 0x10, 0x00, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0x40,
  0x03, 0x80, 0x08, 0x00, 0x70, 0x01, 0x00, 0x0E, 0x00, 0x20, 0x01, 0xC0,
  0x04, 0x00, 0x38, 0x00, 0x80, 0x07, 0x00, 0x10, 0x00, 0xE0, 0x02, 0x00,
  0x1C, 0x00, 0x40, 0x03, 0x80, 0x08, 0x00, 0x70, 0x01, 0x00, 0x08, 0x01,
  0xFE, 0x03, 0x1C, 0x0E, 0x0C, 0x80, 0x06, 0x34, 0x00, 0x08, 0xE0, 0x00,
  0x13, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x04, 0x01, 0x80,
  0x01, 0x01, 0x80, 0x00, 0x40, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x80, 0x0E,
  0x03, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xC7, 0x01, 0xC0, 0xCC,
  0x00, 0x60, 0xD0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x08, 0xC0,
  0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xE0,
  0x00, 0x08, 0xE0, 0x00, 0x18, 0xD0, 0x00, 0x30, 0xCC, 0x00, 0x60, 0xC7,
  0x01, 0xC0, 0xC0, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x03, 0x84, 0x30, 0x00, 0x88, 0xC0,
  0x00, 0x91, 0x00, 0x00, 0xA4, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xA0, 0x00,
  0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40,
  0x00, 0x02, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x51, 0x80,
  0x01, 0x21, 0x80, 0x04, 0x40, 0xC0, 0x70, 0x80, 0x7F, 0x81, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0xFF, 0xE0, 0x7F, 0xF0, 0x02, 0x1C,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0x18, 0x10, 0x00, 0x03, 0x08, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x80, 0x38, 0x03, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x1A, 0x00, 0x00,
  0xD8, 0x00, 0x0A, 0x40, 0x00, 0xD1, 0x80, 0x0C, 0x87, 0x01, 0x84, 0x0F,
  0xF0, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x10,
  0x30, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x03, 0x00, 0x02,
  0x00, 0x80, 0x03, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x06, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00, 0x80, 0x20, 0x00, 0x20,
  0x10, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01,
  0x04, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x80, 0x07, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x0A,
  0x00, 0x16, 0x00, 0x34, 0x00, 0x24, 0x00, 0x48, 0x00, 0xC8, 0x00, 0x98,
  0x01, 0x10, 0x01, 0x10, 0x02, 0x30, 0x02, 0x20, 0x04, 0x20, 0x0C, 0x40,
  0x10, 0x40, 0x10, 0x80, 0x20, 0x80, 0x21, 0x80, 0x40, 0x80, 0x41, 0x01,
  0x81, 0x00, 0x82, 0x02, 0x02, 0x03, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x04, 0x08, 0x18, 0x30, 0x08, 0x10, 0x10, 0x40, 0x10, 0x20, 0x20, 0x80,
  0x30, 0xC0, 0x41, 0x00, 0x21, 0x00, 0x86, 0x00, 0x42, 0x01, 0x88, 0x00,
  0x84, 0x01, 0x10, 0x01, 0x88, 0x02, 0x20, 0x01, 0x10, 0x04, 0x80, 0x02,
  0x60, 0x09, 0x00, 0x04, 0x80, 0x12, 0x00, 0x05, 0x00, 0x34, 0x00, 0x0A,
  0x00, 0x30, 0x00, 0x14, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01,
  0x90, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x80, 0x20, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x01, 0x80,
  0x40, 0x00, 0x40, 0x60, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x03,
  0x20, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0x40, 0x00, 0x18, 0x10, 0x00,
  0x08, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x20,
  0x0C, 0x00, 0x18, 0x04, 0x00, 0x06, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10, 0x18, 0x00, 0x04,
  0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x10, 0x00, 0x60, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x01,
  0x00, 0x60, 0x00, 0x60, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x02, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x10, 0x60, 0x00, 0x06, 0x10, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x61, 0x80, 0x00, 0x44, 0x06, 0x00,
  0x06, 0x60, 0x08, 0x00, 0x22, 0x00, 0x60, 0x01, 0x30, 0x01, 0x80, 0x11,
  0x00, 0x06, 0x00, 0x88, 0x00, 0x18, 0x08, 0x40, 0x00, 0x30, 0x86, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Thin59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 4, 41, 35, 16, -41 },
  { 22, 9, 15, 35, 13, -44 },
  { 39, 33, 41, 35, 1, -41 },
  { 209, 27, 55, 35, 4, -48 },
  { 395, 32, 43, 35, 2, -42 },
  { 567, 30, 43, 35, 2, -42 },
  { 729, 1, 15, 35, 17, -44 },
  { 731, 13, 53, 35, 14, -45 },
  { 818, 13, 53, 35, 8, -45 },
  { 905, 30, 29, 35, 3, -32 },
  { 1014, 28, 29, 35, 4, -33 },
  { 1116, 5, 15, 35, 14, -5 },
  { 1126, 15, 1, 35, 10, -18 },
  { 1128, 4, 4, 35, 16, -4 },
  { 1130, 23, 53, 35, 6, -45 },
  { 1283, 27, 43, 35, 4, -42 },
  { 1429, 27, 41, 35, 5, -41 },
  { 1568, 26, 42, 35, 5, -42 },
  { 1705, 25, 43, 35, 4, -42 },
  { 1840, 29, 41, 35, 3, -41 },
  { 1989, 25, 42, 35, 5, -41 },
  { 2121, 25, 42, 35, 5, -41 },
  { 2253, 25, 41, 35, 5, -41 },
  { 2382, 27, 43, 35, 4, -42 },
  { 2528, 25, 42, 35, 5, -42 },
  { 2660, 4, 31, 35, 16, -31 },
  { 2676, 6, 41, 35, 14, -31 },
  { 2707, 25, 32, 35, 5, -34 },
  { 2807, 28, 12, 35, 4, -24 },
  { 2849, 25, 32, 35, 5, -34 },
  { 2949, 23, 42, 35, 6, -42 },
  { 3070, 24, 48, 35, 5, -42 },
  { 3214, 29, 41, 35, 3, -41 },
  { 3363, 24, 41, 35, 6, -41 },
  { 3486, 26, 43, 35, 5, -42 },
  { 3626, 25, 41, 35, 6, -41 },
  { 3755, 24, 41, 35, 6, -41 },
  { 3878, 25, 41, 35, 6, -41 },
  { 4007, 26, 43, 35, 4, -42 },
  { 4147, 24, 41, 35, 6, -41 },
  { 4270, 25, 41, 35, 5, -41 },
  { 4399, 21, 42, 35, 6, -41 },
  { 4510, 26, 41, 35, 6, -41 },
  { 4644, 22, 41, 35, 9, -41 },
  { 4757, 25, 41, 35, 5, -41 },
  { 4886, 24, 41, 35, 6, -41 },
  { 5009, 27, 43, 35, 4, -42 },
  { 5155, 25, 41, 35, 6, -41 },
  { 5284, 27, 50, 35, 4, -42 },
  { 5453, 25, 41, 35, 6, -41 },
  { 5582, 27, 43, 35, 4, -42 },
  { 5728, 31, 41, 35, 2, -41 },
  { 5887, 24, 42, 35, 6, -41 },
  { 6013, 29, 41, 35, 3, -41 },
  { 6162, 29, 41, 35, 3, -41 },
  { 6311, 30, 41, 35, 3, -41 },
  { 6465, 32, 41, 35, 2, -41 },
  { 6629, 30, 41, 35, 3, -41 },
  { 6783, 14, 53, 35, 16, -45 },
  { 6876, 23, 53, 35, 6, -45 },
  { 7029, 14, 53, 35, 6, -45 },
  { 7122, 27, 22, 35, 4, -41 },
  { 7197, 28, 1, 35, 4, 7 },
  { 7201, 8, 10, 35, 12, -45 },
  { 7211, 26, 32, 35, 5, -31 },
  { 7315, 24, 45, 35, 7, -44 },
  { 7450, 24, 32, 35, 6, -31 },
  { 7546, 23, 45, 35, 5, -44 },
  { 7676, 25, 32, 35, 5, -31 },
  { 7776, 26, 44, 35, 5, -44 },
  { 7919, 28, 46, 35, 5, -33 },
  { 8080, 22, 44, 35, 7, -44 },
  { 8201, 25, 43, 35, 7, -43 },
  { 8336, 20, 55, 35, 6, -43 },
  { 8474, 25, 44, 35, 8, -44 },
  { 8612, 25, 44, 35, 5, -44 },
  { 8750, 27, 31, 35, 4, -31 },
  { 8855, 22, 31, 35, 7, -31 },
  { 8941, 25, 32, 35, 5, -31 },
  { 9041, 24, 43, 35, 7, -31 },
  { 9170, 23, 43, 35, 5, -31 },
  { 9294, 28, 30, 35, 5, -30 },
  { 9399, 26, 32, 35, 5, -31 },
  { 9503, 29, 41, 35, 2, -41 },
  { 9652, 21, 31, 35, 7, -30 },
  { 9734, 25, 30, 35, 5, -30 },
  { 9828, 31, 30, 35, 2, -30 },
  { 9945, 25, 30, 35, 5, -30 },
  { 10039, 26, 42, 35, 5, -30 },
  { 10176, 23, 30, 35, 6, -30 },
  { 10263, 22, 53, 35, 7, -45 },
  { 10409, 1, 53, 35, 17, -45 },
  { 10416, 22, 53, 35, 7, -45 },
  { 10562, 29, 10, 35, 3, -23 },
};

const GFXfont IBMPlexMono_Thin59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_THIN59PT7B_H_
