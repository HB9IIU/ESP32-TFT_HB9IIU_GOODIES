#ifndef _IBMPLEXMONO_THIN49PT7B_H_
#define _IBMPLEXMONO_THIN49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x07, 0xFC, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x08, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x30, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x10, 0x18, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x40,
  0x40, 0x00, 0x10, 0x08, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x08, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x08, 0x04,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x10,
  0x08, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xC4, 0x38, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x08, 0x40,
  0x20, 0x09, 0x80, 0x40, 0x02, 0x00, 0x80, 0x04, 0x01, 0x00, 0x08, 0x02,
  0x00, 0x10, 0x04, 0x00, 0x20, 0x08, 0x00, 0x40, 0x10, 0x00, 0x40, 0x20,
  0x00, 0xC0, 0x40, 0x00, 0x80, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x72, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x09, 0xE0, 0x00, 0x10, 0x70, 0x00, 0x20, 0x30,
  0x00, 0x40, 0x30, 0x00, 0x80, 0x20, 0x01, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x16, 0x00, 0x80, 0x26, 0x01, 0x00, 0xC6, 0x02, 0x01, 0x06, 0x04,
  0x0C, 0x03, 0x88, 0x70, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x04, 0xC0, 0x60, 0x01, 0x10, 0x04, 0x00, 0x64,
  0x00, 0x40, 0x08, 0x80, 0x08, 0x02, 0x10, 0x01, 0x00, 0x42, 0x00, 0x20,
  0x10, 0x40, 0x04, 0x02, 0x08, 0x00, 0x80, 0x81, 0x00, 0x10, 0x20, 0x20,
  0x02, 0x04, 0x02, 0x00, 0x81, 0x00, 0x60, 0x30, 0x20, 0x06, 0x0C, 0x08,
  0x00, 0x3E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xE0, 0x01, 0x01, 0x06,
  0x00, 0x20, 0x40, 0x20, 0x08, 0x10, 0x02, 0x01, 0x02, 0x00, 0x40, 0x40,
  0x80, 0x08, 0x10, 0x10, 0x00, 0x82, 0x02, 0x00, 0x10, 0x80, 0x40, 0x02,
  0x10, 0x08, 0x00, 0x44, 0x01, 0x00, 0x11, 0x80, 0x10, 0x02, 0x20, 0x02,
  0x00, 0x48, 0x00, 0x20, 0x11, 0x00, 0x02, 0x0C, 0x40, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x40, 0x00, 0x06, 0x10, 0x03, 0xE6,
  0x04, 0x01, 0x02, 0x01, 0x01, 0x82, 0x00, 0xC0, 0x81, 0x00, 0x30, 0x41,
  0x80, 0x08, 0x20, 0x80, 0x02, 0x10, 0x40, 0x00, 0x88, 0x20, 0x00, 0x24,
  0x10, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00, 0x01, 0x81, 0x00, 0x01,
  0x60, 0x80, 0x01, 0x98, 0x20, 0x00, 0x84, 0x08, 0x01, 0x81, 0x03, 0x03,
  0x80, 0x40, 0x7F, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x80, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x70, 0x04, 0x01, 0xC7, 0x82, 0x07, 0x00, 0x79, 0x1C, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x58, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x20, 0x20, 0x00, 0x30, 0x08, 0x00,
  0x10, 0x02, 0x00, 0x10, 0x01, 0x80, 0x10, 0x00, 0x40, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0xCC, 0x63, 0x11, 0x8C,
  0x42, 0x11, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x40, 0x01, 0x01, 0x00, 0x01, 0x02, 0x00, 0x01, 0x08, 0x00, 0x02,
  0x10, 0x00, 0x06, 0x20, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00,
  0x01, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x20, 0x00, 0x08, 0x40, 0x00,
  0x60, 0x80, 0x01, 0x81, 0x00, 0x06, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x08, 0x0C, 0x00,
  0x10, 0x20, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x38, 0x1C, 0x02, 0x00, 0x30, 0x20,
  0x00, 0xC2, 0x00, 0x02, 0x10, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x58, 0x00, 0x06, 0x20, 0x00, 0x20, 0xC0, 0x06, 0x03, 0x80, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x11, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x08, 0x40, 0x00, 0x08, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08,
  0x00, 0x04, 0x04, 0x00, 0x04, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00,
  0x80, 0x02, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x01, 0x00, 0x04, 0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0x80,
  0x00, 0x80, 0x80, 0x00, 0x40, 0x40, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x87, 0xF8, 0x04, 0xC0, 0x70, 0x28, 0x00, 0xC1, 0x80, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x40, 0x00, 0x09, 0x00, 0x00, 0x8C, 0x00,
  0x0C, 0x30, 0x00, 0xC0, 0x70, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x87, 0xF0,
  0x08, 0xC0, 0x70, 0x48, 0x00, 0xC2, 0x80, 0x03, 0x18, 0x00, 0x0D, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00,
  0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x05, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x01, 0x90,
  0x00, 0x08, 0x80, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x08, 0x20, 0x00,
  0x31, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x06, 0x40, 0x00, 0x09,
  0x00, 0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x04, 0x40, 0x00, 0x10, 0x80,
  0x00, 0xC3, 0x00, 0x02, 0x06, 0x00, 0x30, 0x06, 0x03, 0x80, 0x07, 0xF0,
  0x00, 0xE0, 0x38, 0x06, 0x00, 0x18, 0x20, 0x00, 0x31, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x90, 0x00, 0x06, 0x20, 0x00, 0x30, 0x40, 0x01, 0x80, 0xE0, 0x38, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0xE0, 0x70, 0x10, 0x01, 0x82, 0x00, 0x04,
  0x40, 0x00, 0x64, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x32, 0x00, 0x05, 0x10,
  0x01, 0xB0, 0xE0, 0x72, 0x03, 0xFC, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x31, 0x8C, 0x46, 0x31, 0x08,
  0x44, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0x80, 0xE0, 0x40, 0x06, 0x10, 0x00, 0x24, 0x00,
  0x04, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0x80, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x04, 0x08, 0x00, 0x42, 0x00,
  0x04, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x30, 0x00,
  0x06, 0x00, 0xF8, 0xC0, 0x60, 0xD8, 0x08, 0x0B, 0x02, 0x00, 0xE0, 0x40,
  0x0C, 0x10, 0x01, 0x82, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0xC1, 0x00,
  0x18, 0x20, 0x03, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x82, 0x00,
  0x30, 0x60, 0x06, 0x04, 0x00, 0xC0, 0xC0, 0x38, 0x0C, 0x0B, 0x00, 0xFE,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x28, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x44, 0x00, 0x00, 0x46, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x00, 0x01, 0x01, 0x00,
  0x01, 0x01, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00, 0x80, 0x02, 0x00, 0xC0,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x20,
  0x08, 0x00, 0x20, 0x08, 0x00, 0x30, 0x1F, 0xFF, 0xF0, 0x10, 0x00, 0x10,
  0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x08, 0x00, 0x30, 0x80,
  0x01, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0xFF, 0xFE,
  0x08, 0x00, 0x18, 0x80, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x04, 0x80, 0x01, 0x8F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x18, 0x0C,
  0x01, 0x00, 0x18, 0x10, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80,
  0x00, 0x28, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x02, 0x08, 0x00, 0x20, 0x20, 0x03,
  0x00, 0xC0, 0x60, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x30, 0x20,
  0x00, 0x61, 0x00, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00,
  0x22, 0x00, 0x03, 0x10, 0x00, 0x30, 0x80, 0x06, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x00, 0x02, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x01, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x50, 0x00,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x0C, 0x80, 0x00, 0x62,
  0x00, 0x05, 0x18, 0x00, 0x28, 0x60, 0x02, 0x41, 0xC0, 0x62, 0x01, 0xFC,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x2C, 0x00,
  0x11, 0x00, 0x04, 0x20, 0x02, 0x06, 0x03, 0x00, 0x7F, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x48, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2,
  0x00, 0x06, 0x08, 0x00, 0x10, 0x20, 0x00, 0x80, 0x80, 0x04, 0x02, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x80, 0x40, 0x02, 0x03, 0x00,
  0x08, 0x18, 0x00, 0x20, 0xE0, 0x00, 0x86, 0x40, 0x02, 0x10, 0x80, 0x08,
  0x82, 0x00, 0x24, 0x04, 0x00, 0xA0, 0x08, 0x03, 0x00, 0x20, 0x08, 0x00,
  0x40, 0x20, 0x00, 0x80, 0x80, 0x03, 0x02, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x20, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00, 0x00, 0x88, 0x00, 0x03, 0x20,
  0x00, 0x04, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE8, 0x00,
  0x0B, 0x40, 0x00, 0x59, 0x00, 0x02, 0xC8, 0x00, 0x26, 0x20, 0x01, 0x31,
  0x00, 0x11, 0x84, 0x00, 0x8C, 0x20, 0x08, 0x60, 0x80, 0x43, 0x04, 0x04,
  0x18, 0x30, 0x20, 0xC0, 0x82, 0x06, 0x04, 0x10, 0x30, 0x10, 0x81, 0x80,
  0x88, 0x0C, 0x02, 0x40, 0x60, 0x14, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x1A, 0x00, 0x01, 0x90, 0x00, 0x19,
  0x00, 0x01, 0x88, 0x00, 0x18, 0x80, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01,
  0x82, 0x00, 0x18, 0x20, 0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x80, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x18, 0x03,
  0x01, 0x80, 0x10, 0x18, 0x01, 0x81, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80,
  0x04, 0x18, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x11, 0x80, 0x01, 0x18,
  0x00, 0x09, 0x80, 0x00, 0x98, 0x00, 0x05, 0x80, 0x00, 0x58, 0x00, 0x03,
  0x00, 0xFE, 0x00, 0x07, 0x03, 0x00, 0x10, 0x01, 0x80, 0x40, 0x01, 0x01,
  0x00, 0x01, 0x02, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x06, 0x20,
  0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x08, 0x08, 0x00, 0x30, 0x08,
  0x00, 0xC0, 0x0E, 0x06, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x04, 0x00,
  0x0E, 0x20, 0x00, 0x19, 0x00, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x90,
  0x00, 0x0C, 0x80, 0x01, 0xC7, 0xFF, 0xF8, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x03, 0x00, 0x10, 0x01, 0x80, 0x40,
  0x01, 0x01, 0x00, 0x01, 0x02, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x08, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x04, 0x00, 0x0E, 0x20, 0x00, 0x19, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x01, 0xC7,
  0xFF, 0xF8, 0x20, 0x18, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x0C,
  0x02, 0x00, 0x20, 0x10, 0x00, 0x80, 0x80, 0x06, 0x04, 0x00, 0x10, 0x20,
  0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x08, 0x40, 0x00, 0x62, 0x00, 0x01,
  0x10, 0x00, 0x04, 0x80, 0x00, 0x34, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x00,
  0x0C, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x42, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xB0,
  0x00, 0x01, 0x30, 0x00, 0x06, 0x30, 0x00, 0x08, 0x30, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x42, 0x00, 0x0C,
  0x30, 0x00, 0x81, 0xC0, 0x70, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x18, 0x10, 0x00, 0x10, 0x18, 0x00, 0x10, 0x08, 0x00, 0x30, 0x08,
  0x00, 0x20, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x60, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x40, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01,
  0x00, 0x80, 0x01, 0x01, 0x00, 0x01, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x82, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x42, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x24, 0x00, 0x00, 0x28, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x18, 0x02, 0x40,
  0x18, 0x04, 0x40, 0x28, 0x04, 0x40, 0x28, 0x04, 0x40, 0x24, 0x04, 0x40,
  0x44, 0x04, 0x40, 0x44, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20,
  0x82, 0x04, 0x20, 0x82, 0x04, 0x20, 0x81, 0x08, 0x21, 0x01, 0x08, 0x21,
  0x01, 0x08, 0x21, 0x00, 0x88, 0x23, 0x00, 0x88, 0x22, 0x00, 0x88, 0x12,
  0x00, 0xC8, 0x12, 0x00, 0x48, 0x14, 0x00, 0x48, 0x14, 0x00, 0x48, 0x14,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x60, 0x00, 0x01, 0x90,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x83, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x40, 0x18, 0x00, 0x40, 0x04, 0x00, 0x60, 0x01, 0x00, 0x20,
  0x00, 0xC0, 0x20, 0x00, 0x20, 0x30, 0x00, 0x08, 0x10, 0x00, 0x06, 0x10,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x48, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x05, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x03, 0x00, 0x80, 0x01,
  0x00, 0x60, 0x01, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x80, 0x03, 0x00,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x18, 0x40, 0x00, 0x04,
  0x60, 0x00, 0x01, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x20, 0x02, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x40, 0x00, 0x40, 0x08, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x60, 0x00, 0x40,
  0x40, 0x00, 0x80, 0x40, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x10, 0x01,
  0x80, 0x40, 0x01, 0x00, 0x80, 0x01, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x02,
  0x10, 0x00, 0x06, 0x40, 0x00, 0x05, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFE,
  0x81, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x03, 0xF8, 0x00, 0x30, 0x18, 0x01,
  0x00, 0x30, 0x08, 0x00, 0x60, 0x40, 0x00, 0x81, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0x01, 0x80, 0x04, 0x18,
  0x00, 0x10, 0x40, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08, 0x00, 0x14, 0x10, 0x00, 0x50,
  0x60, 0x02, 0x40, 0xE0, 0x31, 0xF0, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x0F, 0xE0, 0x46,
  0x07, 0x09, 0x00, 0x31, 0x40, 0x01, 0x30, 0x00, 0x36, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x16, 0x00,
  0x02, 0xC0, 0x00, 0xD4, 0x00, 0x12, 0x40, 0x0C, 0x46, 0x07, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x70, 0x30, 0x08, 0x00, 0x81, 0x00, 0x04, 0x30,
  0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x03, 0x30, 0x00, 0x21, 0x00,
  0x04, 0x0C, 0x00, 0x80, 0x70, 0x30, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x07, 0xE0, 0x83,
  0x03, 0x11, 0x80, 0x1A, 0x60, 0x01, 0x48, 0x00, 0x1A, 0x00, 0x01, 0x40,
  0x00, 0x28, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x01, 0x20, 0x00, 0x62, 0x00, 0x1C, 0x60, 0x06, 0x83, 0x03, 0x10, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0xC0, 0x60, 0x10, 0x01, 0x82, 0x00, 0x08, 0x60,
  0x00, 0x44, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x43, 0x00,
  0x08, 0x18, 0x01, 0x80, 0xE0, 0x60, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x03, 0xF2, 0x00, 0x18, 0x1C, 0x00,
  0x40, 0x0C, 0x01, 0x00, 0x08, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00,
  0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08, 0x04, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x06, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x20, 0x00, 0xE1, 0x80, 0x00, 0x66, 0x00, 0x00, 0x48,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x80,
  0x00, 0x09, 0x80, 0x00, 0x31, 0x80, 0x00, 0xC1, 0xC0, 0x0E, 0x00, 0x7F,
  0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x3F, 0x82, 0x30, 0x38, 0x90, 0x03, 0x28, 0x00, 0x4C, 0x00, 0x0B,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0B, 0xFF, 0xFC,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x06, 0x80, 0x00, 0x88, 0x00, 0x10, 0x80,
  0x02, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x03, 0x00, 0x80, 0x40, 0x08,
  0x08, 0x00, 0x81, 0x00, 0x08, 0x70, 0x00, 0x8C, 0x80, 0x09, 0x84, 0x00,
  0xA0, 0x20, 0x0C, 0x03, 0x00, 0x80, 0x18, 0x08, 0x00, 0x80, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00,
  0x04, 0x80, 0x00, 0x28, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x03, 0xE2, 0xC3, 0x10, 0x4C, 0x04,
  0x80, 0xB0, 0x0C, 0x03, 0x80, 0x30, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00,
  0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60,
  0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08,
  0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01,
  0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x20, 0x06, 0x00, 0x80, 0x10, 0x03, 0xF8, 0x23, 0x03, 0x89, 0x00, 0x32,
  0x80, 0x04, 0xC0, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x30, 0x18, 0x02, 0x00, 0x20,
  0x20, 0x00, 0x83, 0x00, 0x02, 0x10, 0x00, 0x19, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00,
  0x0A, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80, 0x00, 0x24, 0x00, 0x01, 0x10,
  0x00, 0x18, 0xC0, 0x00, 0x82, 0x00, 0x08, 0x08, 0x00, 0xC0, 0x30, 0x18,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x11, 0x81, 0xC2, 0x40, 0x0C, 0x50, 0x00,
  0x4C, 0x00, 0x0D, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x35, 0x00, 0x04,
  0x90, 0x03, 0x11, 0x81, 0xC2, 0x0F, 0xE0, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC4, 0x60, 0x06,
  0x98, 0x00, 0x52, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x18,
  0x80, 0x07, 0x18, 0x01, 0xA0, 0xC0, 0xC4, 0x07, 0xE0, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0xFF, 0xC3, 0xFE, 0x00, 0x98,
  0x00, 0x01, 0x60, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x70, 0x1C,
  0x06, 0x00, 0x18, 0x60, 0x00, 0x62, 0x00, 0x01, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x24, 0x00, 0x02, 0x18, 0x00,
  0x20, 0x38, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x0D, 0x00,
  0x06, 0x40, 0x05, 0x18, 0x0C, 0x83, 0xF8, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x42, 0x00, 0x04, 0x20,
  0x00, 0x82, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x10, 0x08, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x60, 0x40,
  0x02, 0x04, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x09, 0x00, 0x00, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x0C, 0x00, 0xE0, 0x03, 0x00, 0x28, 0x01, 0x40, 0x09, 0x00, 0x50, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x24, 0x02, 0x20, 0x11, 0x00, 0x88,
  0x04, 0x40, 0x21, 0x01, 0x08, 0x10, 0x40, 0x42, 0x04, 0x10, 0x10, 0x81,
  0x02, 0x08, 0x20, 0x40, 0x82, 0x08, 0x20, 0x20, 0x81, 0x08, 0x08, 0x20,
  0x42, 0x01, 0x08, 0x10, 0x80, 0x44, 0x04, 0x40, 0x11, 0x01, 0x10, 0x04,
  0x40, 0x24, 0x00, 0x90, 0x0A, 0x00, 0x24, 0x02, 0x80, 0x0A, 0x00, 0xA0,
  0x02, 0x80, 0x28, 0x00, 0x60, 0x04, 0x00, 0x18, 0x00, 0x40, 0x00, 0x19,
  0x00, 0x00, 0x8C, 0x00, 0x08, 0x20, 0x00, 0x80, 0x80, 0x08, 0x02, 0x00,
  0xC0, 0x08, 0x04, 0x00, 0x60, 0x40, 0x01, 0x04, 0x00, 0x04, 0x60, 0x00,
  0x12, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x28, 0x00, 0x03, 0x20,
  0x00, 0x10, 0x80, 0x01, 0x06, 0x00, 0x10, 0x10, 0x01, 0x80, 0x40, 0x08,
  0x01, 0x00, 0x80, 0x0C, 0x08, 0x00, 0x20, 0xC0, 0x00, 0x84, 0x00, 0x02,
  0xC0, 0x00, 0x18, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x04, 0x40,
  0x00, 0x22, 0x00, 0x02, 0x10, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x40, 0x04, 0x03, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40,
  0x10, 0x01, 0x00, 0x80, 0x08, 0x08, 0x00, 0x60, 0x40, 0x01, 0x04, 0x00,
  0x08, 0x20, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x28,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x3F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x0E, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x03, 0xFF, 0x00, 0x0F,
  0x00, 0x01, 0x10, 0xC0, 0x02, 0x20, 0x60, 0x02, 0x40, 0x30, 0x02, 0x40,
  0x10, 0x04, 0x40, 0x08, 0x04, 0x80, 0x04, 0x08, 0x80, 0x03, 0x18, 0x80,
  0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 3, 34, 29, 13, -34 },
  { 14, 8, 12, 29, 11, -36 },
  { 26, 27, 34, 29, 1, -34 },
  { 141, 23, 46, 29, 3, -40 },
  { 274, 27, 36, 29, 1, -35 },
  { 396, 25, 36, 29, 2, -35 },
  { 509, 1, 12, 29, 14, -36 },
  { 511, 11, 44, 29, 12, -37 },
  { 572, 11, 44, 29, 7, -37 },
  { 633, 25, 24, 29, 2, -27 },
  { 708, 23, 23, 29, 3, -26 },
  { 775, 5, 12, 29, 11, -4 },
  { 783, 13, 1, 29, 8, -15 },
  { 785, 3, 3, 29, 13, -3 },
  { 787, 19, 44, 29, 5, -37 },
  { 892, 23, 36, 29, 3, -35 },
  { 996, 23, 34, 29, 4, -34 },
  { 1094, 22, 35, 29, 4, -35 },
  { 1191, 21, 36, 29, 3, -35 },
  { 1286, 25, 34, 29, 2, -34 },
  { 1393, 21, 35, 29, 4, -34 },
  { 1485, 21, 35, 29, 4, -34 },
  { 1577, 21, 34, 29, 4, -34 },
  { 1667, 22, 36, 29, 4, -35 },
  { 1766, 20, 35, 29, 5, -35 },
  { 1854, 3, 26, 29, 13, -26 },
  { 1864, 5, 34, 29, 11, -26 },
  { 1886, 21, 26, 29, 4, -28 },
  { 1955, 23, 10, 29, 3, -20 },
  { 1984, 21, 26, 29, 4, -28 },
  { 2053, 19, 35, 29, 5, -35 },
  { 2137, 19, 40, 29, 5, -35 },
  { 2232, 24, 34, 29, 3, -34 },
  { 2334, 20, 34, 29, 5, -34 },
  { 2419, 21, 36, 29, 4, -35 },
  { 2514, 21, 34, 29, 5, -34 },
  { 2604, 20, 34, 29, 5, -34 },
  { 2689, 20, 34, 29, 5, -34 },
  { 2774, 21, 36, 29, 4, -35 },
  { 2869, 20, 34, 29, 5, -34 },
  { 2954, 20, 34, 29, 5, -34 },
  { 3039, 18, 35, 29, 5, -34 },
  { 3118, 22, 34, 29, 5, -34 },
  { 3212, 19, 34, 29, 7, -34 },
  { 3293, 21, 34, 29, 4, -34 },
  { 3383, 20, 34, 29, 5, -34 },
  { 3468, 23, 36, 29, 3, -35 },
  { 3572, 21, 34, 29, 5, -34 },
  { 3662, 23, 42, 29, 3, -35 },
  { 3783, 21, 34, 29, 5, -34 },
  { 3873, 23, 36, 29, 3, -35 },
  { 3977, 25, 34, 29, 2, -34 },
  { 4084, 20, 35, 29, 5, -34 },
  { 4172, 24, 34, 29, 3, -34 },
  { 4274, 24, 34, 29, 3, -34 },
  { 4376, 25, 34, 29, 2, -34 },
  { 4483, 27, 34, 29, 1, -34 },
  { 4598, 25, 34, 29, 2, -34 },
  { 4705, 12, 44, 29, 13, -37 },
  { 4771, 19, 44, 29, 5, -37 },
  { 4876, 11, 44, 29, 5, -37 },
  { 4937, 23, 18, 29, 3, -34 },
  { 4989, 23, 1, 29, 3, 6 },
  { 4992, 6, 8, 29, 10, -37 },
  { 4998, 22, 27, 29, 4, -26 },
  { 5073, 19, 37, 29, 6, -36 },
  { 5161, 20, 27, 29, 5, -26 },
  { 5229, 19, 37, 29, 4, -36 },
  { 5317, 20, 27, 29, 5, -26 },
  { 5385, 22, 36, 29, 4, -36 },
  { 5484, 23, 38, 29, 4, -28 },
  { 5594, 18, 36, 29, 6, -36 },
  { 5675, 20, 37, 29, 6, -37 },
  { 5768, 17, 47, 29, 5, -37 },
  { 5868, 20, 36, 29, 7, -36 },
  { 5958, 21, 36, 29, 4, -36 },
  { 6053, 22, 26, 29, 4, -26 },
  { 6125, 18, 26, 29, 6, -26 },
  { 6184, 21, 27, 29, 4, -26 },
  { 6255, 19, 36, 29, 6, -26 },
  { 6341, 19, 36, 29, 4, -26 },
  { 6427, 23, 25, 29, 4, -25 },
  { 6499, 21, 27, 29, 4, -26 },
  { 6570, 24, 34, 29, 2, -34 },
  { 6672, 17, 26, 29, 6, -25 },
  { 6728, 20, 25, 29, 5, -25 },
  { 6791, 26, 25, 29, 2, -25 },
  { 6873, 21, 25, 29, 4, -25 },
  { 6939, 21, 35, 29, 4, -25 },
  { 7031, 19, 25, 29, 5, -25 },
  { 7091, 18, 44, 29, 6, -37 },
  { 7190, 1, 44, 29, 14, -37 },
  { 7196, 18, 44, 29, 6, -37 },
  { 7295, 24, 9, 29, 3, -19 },
};

const GFXfont IBMPlexMono_Thin49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_THIN49PT7B_H_
