#ifndef _IBMPLEXMONO_THIN25PT7B_H_
#define _IBMPLEXMONO_THIN25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x80, 0xB6, 0xDB, 0x40, 0x04, 0x60, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x84, 0x7C, 0x3C, 0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04,
  0x21, 0xE1, 0xF1, 0x10, 0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x0F, 0x86, 0x4D, 0x08, 0x61, 0x04, 0x20, 0x84, 0x08,
  0x81, 0xD0, 0x07, 0xC0, 0x44, 0x08, 0x41, 0x08, 0x21, 0x84, 0x30, 0x85,
  0x91, 0x0F, 0x80, 0x40, 0x08, 0x01, 0x00, 0x78, 0x0E, 0x20, 0xA0, 0x85,
  0x04, 0x48, 0x22, 0x41, 0x23, 0x12, 0x0F, 0x10, 0x00, 0x00, 0x47, 0x84,
  0x46, 0x24, 0x12, 0x20, 0xA1, 0x05, 0x08, 0x30, 0x23, 0x80, 0xF0, 0x0E,
  0x01, 0x8C, 0x08, 0x20, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x28, 0x3A, 0x21, 0x20, 0x91, 0x02, 0x88, 0x0C, 0x40, 0x22, 0x02, 0x88,
  0x34, 0x3E, 0x18, 0xFC, 0x0C, 0x42, 0x18, 0x42, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x08, 0x10, 0x30, 0xC0, 0x82, 0x04,
  0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x21, 0x08,
  0x23, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08, 0x20, 0xB9, 0x38,
  0x3E, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x04, 0x10, 0x40, 0xC0, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x5A, 0xA0, 0xFE, 0xC0, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x00, 0x1F, 0x04, 0x11,
  0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x84, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x90, 0x11, 0x04, 0x1F, 0x00, 0x04, 0x00, 0xC0,
  0x14, 0x02, 0x40, 0xC4, 0x08, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x1F,
  0x04, 0x11, 0x01, 0x40, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0xFF, 0xE0, 0x1F,
  0x08, 0x2C, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x7C, 0x01, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x18, 0x05, 0x06, 0x3F, 0x00, 0x00, 0x40, 0x06,
  0x00, 0x50, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x02, 0x08, 0x20, 0x41,
  0x02, 0x10, 0x11, 0x00, 0x8F, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x27, 0xC5, 0x04,
  0x40, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0xA0, 0x13, 0x04, 0x1F,
  0x00, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0xF8,
  0xA0, 0xD8, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x11, 0x04, 0x1F,
  0x00, 0xFF, 0xF0, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x1F, 0x0C, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x90, 0x11, 0x04,
  0x1F, 0x0E, 0x3A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0B, 0x06, 0x1F,
  0x00, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x03,
  0x20, 0xA3, 0xE8, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x00, 0xC0, 0x0C, 0x50, 0x00, 0x00, 0x5A, 0xA0, 0x00, 0x20, 0x18, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x10, 0x0C, 0x00, 0x3E, 0x20, 0xE0, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x16, 0x08, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x1F,
  0x08, 0x24, 0x05, 0x01, 0x80, 0x61, 0xF8, 0x8E, 0x21, 0x90, 0x64, 0x19,
  0x06, 0x41, 0x90, 0x62, 0x18, 0x7E, 0x00, 0x40, 0x10, 0x03, 0x00, 0x7F,
  0x02, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x42, 0x02,
  0x10, 0x10, 0x41, 0x02, 0x08, 0x10, 0x7F, 0xC2, 0x02, 0x20, 0x09, 0x00,
  0x50, 0x02, 0x80, 0x08, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x04, 0xFF, 0x10, 0x1A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0xFF, 0x80, 0x1F, 0x06, 0x11, 0x01, 0x40, 0x18, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x50,
  0x11, 0x84, 0x1F, 0x00, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04,
  0xFE, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1F, 0x04,
  0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x19, 0x05, 0x1F, 0x20, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0xE0, 0x3F, 0xC0,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x24, 0x08, 0x86, 0x1E, 0x00, 0x80, 0x70, 0x12, 0x04,
  0x41, 0x08, 0x21, 0x08, 0x22, 0x04, 0x80, 0xA8, 0x18, 0x82, 0x10, 0x41,
  0x08, 0x11, 0x02, 0x20, 0x24, 0x02, 0x80, 0x60, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0x80, 0x80, 0x38, 0x0F, 0x02, 0xD0, 0x5A, 0x13, 0x22,
  0x64, 0x8C, 0x51, 0x8C, 0x30, 0x86, 0x10, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0xC0, 0x38, 0x06, 0x80, 0xD0, 0x19, 0x03, 0x20,
  0x62, 0x0C, 0x41, 0x84, 0x30, 0x86, 0x08, 0xC1, 0x18, 0x13, 0x02, 0x60,
  0x2C, 0x03, 0x80, 0x60, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x90,
  0x11, 0x04, 0x1F, 0x00, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xBF, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x90, 0x11, 0x04,
  0x1F, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7C, 0xFF, 0x20, 0x28, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xBF, 0xC8, 0x82, 0x10, 0x82, 0x20,
  0x88, 0x12, 0x02, 0x80, 0x40, 0x1F, 0x0C, 0x1A, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x10, 0x03, 0x80, 0x0F, 0x80, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x0B, 0x02, 0x1F, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x05, 0x00, 0x90, 0x13, 0x06, 0x1F, 0x00, 0x80, 0x1C, 0x00,
  0x90, 0x04, 0x80, 0x44, 0x02, 0x10, 0x10, 0x81, 0x04, 0x08, 0x10, 0x40,
  0x84, 0x06, 0x20, 0x11, 0x00, 0x90, 0x02, 0x80, 0x14, 0x00, 0xC0, 0x02,
  0x00, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x21, 0x09, 0x18,
  0x48, 0xA2, 0x45, 0x12, 0x48, 0x92, 0x24, 0x91, 0x45, 0x0A, 0x28, 0x51,
  0x41, 0x86, 0x0C, 0x20, 0x20, 0x80, 0x1A, 0x00, 0x88, 0x08, 0x20, 0x81,
  0x08, 0x04, 0x40, 0x14, 0x00, 0xC0, 0x02, 0x00, 0x28, 0x02, 0x40, 0x11,
  0x01, 0x04, 0x10, 0x20, 0x80, 0x88, 0x02, 0x80, 0x18, 0x80, 0x0C, 0x00,
  0x90, 0x04, 0x40, 0x42, 0x04, 0x08, 0x20, 0x22, 0x01, 0x20, 0x05, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x7F, 0xF0, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x00, 0xFF, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0xFC,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x07, 0xF0, 0x04, 0x01, 0x40, 0x48, 0x08, 0x82, 0x18, 0x41,
  0x10, 0x14, 0x02, 0x80, 0x20, 0xFF, 0xF8, 0x89, 0x10, 0x3E, 0x08, 0x22,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x0F, 0xE6, 0x04, 0x80, 0x90, 0x12, 0x06,
  0x60, 0xC3, 0xC6, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE3,
  0x86, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xB0, 0x6B, 0xE0, 0x1E, 0x18, 0x48, 0x0A, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x28, 0x0D, 0x84, 0x1E, 0x00, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x11, 0xE5, 0x87, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x40, 0x58, 0x31, 0xF4, 0x1F, 0x04, 0x11, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x10, 0x01, 0x01, 0x90,
  0x61, 0xF0, 0x07, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x83, 0xFF, 0x80, 0x00, 0x70, 0x08, 0x1F, 0x82, 0x08, 0x40,
  0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x42, 0x08, 0x1F, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x7F, 0xC4, 0x02, 0x80, 0x18, 0x02, 0x40, 0x23, 0xFC, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0xC2, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0xFF,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x14, 0x04, 0x81,
  0x10, 0xC2, 0x20, 0x4C, 0x0A, 0x41, 0x84, 0x20, 0x84, 0x08, 0x80, 0x90,
  0x0A, 0x00, 0x80, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0xB9, 0xD9, 0x46, 0x10, 0xC2, 0x18,
  0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x42,
  0x9E, 0x70, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x09, 0x01, 0x10, 0x41, 0xF0, 0x9E, 0x38, 0x68,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0x06,
  0xBE, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x58, 0x74, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x83, 0x1F,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xF9, 0xF0, 0xA0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0xFF, 0xE0, 0x1F, 0x0C, 0x19, 0x01, 0x40, 0x04, 0x00, 0x60, 0x03,
  0xE0, 0x02, 0x00, 0x20, 0x06, 0x00, 0xB0, 0x21, 0xF8, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0xFF, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xF0, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28,
  0x73, 0xC8, 0x80, 0x70, 0x09, 0x01, 0x20, 0x42, 0x08, 0x41, 0x08, 0x40,
  0x88, 0x11, 0x02, 0x40, 0x28, 0x06, 0x00, 0x40, 0x86, 0x0C, 0x30, 0x61,
  0x43, 0x0A, 0x28, 0x91, 0x44, 0x89, 0x22, 0x49, 0x12, 0x50, 0xA2, 0x85,
  0x14, 0x18, 0x60, 0xC2, 0x02, 0x00, 0x80, 0x68, 0x08, 0x82, 0x08, 0x81,
  0x20, 0x14, 0x01, 0x00, 0x50, 0x12, 0x02, 0x20, 0x82, 0x20, 0x28, 0x06,
  0x80, 0x30, 0x09, 0x01, 0x20, 0x46, 0x08, 0x41, 0x08, 0x40, 0x88, 0x12,
  0x01, 0x40, 0x28, 0x06, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x1E,
  0x00, 0xFF, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x10, 0x0F, 0xF8, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x3E, 0x03, 0x80, 0x40, 0x20, 0x10, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x7C, 0xFF, 0xFF, 0xFC, 0xF8, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x40, 0x20, 0x08, 0x02, 0xE3, 0x82, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xC0, 0x38, 0x1A, 0x20,
  0x90, 0x85, 0x02, 0x28, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 1, 17, 15, 7, -17 },
  { 4, 3, 6, 15, 6, -19 },
  { 7, 13, 17, 15, 1, -17 },
  { 35, 11, 23, 15, 2, -20 },
  { 67, 13, 17, 15, 1, -17 },
  { 95, 13, 17, 15, 1, -17 },
  { 123, 1, 6, 15, 7, -19 },
  { 124, 6, 22, 15, 6, -19 },
  { 141, 6, 22, 15, 3, -19 },
  { 158, 13, 12, 15, 1, -14 },
  { 178, 11, 13, 15, 2, -14 },
  { 196, 2, 6, 15, 6, -2 },
  { 198, 7, 1, 15, 4, -8 },
  { 199, 1, 2, 15, 7, -2 },
  { 200, 9, 22, 15, 3, -19 },
  { 225, 11, 17, 15, 2, -17 },
  { 249, 12, 17, 15, 2, -17 },
  { 275, 11, 17, 15, 2, -17 },
  { 299, 10, 17, 15, 2, -17 },
  { 321, 13, 17, 15, 1, -17 },
  { 349, 11, 17, 15, 2, -17 },
  { 373, 11, 17, 15, 2, -17 },
  { 397, 11, 17, 15, 2, -17 },
  { 421, 11, 17, 15, 2, -17 },
  { 445, 11, 17, 15, 2, -17 },
  { 469, 1, 14, 15, 7, -14 },
  { 471, 2, 18, 15, 6, -14 },
  { 476, 11, 13, 15, 2, -14 },
  { 494, 11, 5, 15, 2, -10 },
  { 501, 11, 13, 15, 2, -14 },
  { 519, 9, 17, 15, 3, -17 },
  { 539, 10, 20, 15, 2, -17 },
  { 564, 13, 17, 15, 1, -17 },
  { 592, 11, 17, 15, 2, -17 },
  { 616, 11, 17, 15, 2, -17 },
  { 640, 10, 17, 15, 3, -17 },
  { 662, 10, 17, 15, 3, -17 },
  { 684, 10, 17, 15, 3, -17 },
  { 706, 11, 17, 15, 2, -17 },
  { 730, 11, 17, 15, 2, -17 },
  { 754, 11, 17, 15, 2, -17 },
  { 778, 10, 17, 15, 2, -17 },
  { 800, 11, 17, 15, 3, -17 },
  { 824, 9, 17, 15, 4, -17 },
  { 844, 11, 17, 15, 2, -17 },
  { 868, 11, 17, 15, 2, -17 },
  { 892, 11, 17, 15, 2, -17 },
  { 916, 10, 17, 15, 3, -17 },
  { 938, 11, 21, 15, 2, -17 },
  { 967, 10, 17, 15, 3, -17 },
  { 989, 11, 17, 15, 2, -17 },
  { 1013, 13, 17, 15, 1, -17 },
  { 1041, 11, 17, 15, 2, -17 },
  { 1065, 13, 17, 15, 1, -17 },
  { 1093, 13, 17, 15, 1, -17 },
  { 1121, 13, 17, 15, 1, -17 },
  { 1149, 13, 17, 15, 1, -17 },
  { 1177, 13, 17, 15, 1, -17 },
  { 1205, 6, 22, 15, 7, -19 },
  { 1222, 9, 22, 15, 3, -19 },
  { 1247, 6, 22, 15, 2, -19 },
  { 1264, 11, 9, 15, 2, -17 },
  { 1277, 13, 1, 15, 1, 3 },
  { 1279, 3, 4, 15, 5, -19 },
  { 1281, 11, 13, 15, 2, -13 },
  { 1299, 10, 19, 15, 3, -19 },
  { 1323, 10, 13, 15, 3, -13 },
  { 1340, 10, 19, 15, 2, -19 },
  { 1364, 11, 13, 15, 2, -13 },
  { 1382, 11, 19, 15, 2, -19 },
  { 1409, 12, 20, 15, 2, -15 },
  { 1439, 9, 19, 15, 3, -19 },
  { 1461, 10, 19, 15, 3, -19 },
  { 1485, 9, 24, 15, 2, -19 },
  { 1512, 11, 19, 15, 3, -19 },
  { 1539, 11, 19, 15, 2, -19 },
  { 1566, 11, 13, 15, 2, -13 },
  { 1584, 9, 13, 15, 3, -13 },
  { 1599, 11, 13, 15, 2, -13 },
  { 1617, 10, 18, 15, 3, -13 },
  { 1640, 10, 18, 15, 2, -13 },
  { 1663, 12, 13, 15, 2, -13 },
  { 1683, 11, 13, 15, 2, -13 },
  { 1701, 12, 17, 15, 1, -17 },
  { 1727, 9, 13, 15, 3, -13 },
  { 1742, 11, 13, 15, 2, -13 },
  { 1760, 13, 13, 15, 1, -13 },
  { 1782, 11, 13, 15, 2, -13 },
  { 1800, 11, 18, 15, 2, -13 },
  { 1825, 9, 13, 15, 3, -13 },
  { 1840, 9, 22, 15, 3, -19 },
  { 1865, 1, 22, 15, 7, -19 },
  { 1868, 9, 22, 15, 3, -19 },
  { 1893, 13, 5, 15, 1, -10 },
};

const GFXfont IBMPlexMono_Thin25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_THIN25PT7B_H_
