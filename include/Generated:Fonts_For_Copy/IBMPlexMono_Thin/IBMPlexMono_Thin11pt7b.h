#ifndef _IBMPLEXMONO_THIN11PT7B_H_
#define _IBMPLEXMONO_THIN11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x28, 0xA6, 0xCC, 0x53, 0x35, 0x14, 0x43, 0xB5, 0x9E,
  0x2D, 0x39, 0x72, 0x00, 0x66, 0xAA, 0x98, 0x0D, 0xD9, 0x63, 0x31, 0x44,
  0x89, 0xFA, 0x68, 0x9D, 0xE0, 0x6A, 0xAA, 0x90, 0x88, 0x92, 0x49, 0x50,
  0x42, 0x36, 0xC9, 0x00, 0x42, 0x11, 0xF4, 0x21, 0x00, 0xE0, 0xE0, 0x80,
  0x11, 0x22, 0x24, 0x48, 0x88, 0x74, 0xA3, 0x1A, 0xC6, 0x4E, 0x23, 0x29,
  0x42, 0x10, 0x9F, 0x74, 0xA4, 0x21, 0x13, 0x1F, 0x79, 0x16, 0x11, 0x97,
  0x31, 0x95, 0x29, 0x7C, 0x42, 0x74, 0x3D, 0x20, 0x86, 0x4E, 0x22, 0x21,
  0xE9, 0x46, 0x4E, 0xFC, 0xA4, 0x42, 0x21, 0x08, 0x74, 0x64, 0xC9, 0x46,
  0x2E, 0x74, 0xA3, 0x17, 0x08, 0x88, 0x84, 0x87, 0x19, 0x31, 0x06, 0x0C,
  0xF8, 0x3E, 0x82, 0x0C, 0x36, 0x40, 0x79, 0x91, 0x64, 0x04, 0x79, 0xBD,
  0xDD, 0xB8, 0x70, 0x23, 0x19, 0x29, 0x7A, 0x31, 0xF4, 0xA5, 0xE8, 0xC6,
  0x3E, 0x74, 0xA3, 0x08, 0x42, 0x6E, 0xF4, 0xA3, 0x18, 0xC6, 0x5E, 0xFC,
  0x21, 0xF8, 0x42, 0x1F, 0xFC, 0x21, 0xE8, 0x42, 0x10, 0x74, 0xA3, 0x0B,
  0xC6, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xFA, 0x10, 0x84, 0x21, 0x1F,
  0x71, 0x11, 0x11, 0x96, 0x8C, 0xA9, 0x8A, 0x52, 0x51, 0x88, 0x88, 0x88,
  0x8F, 0x8C, 0x67, 0xDE, 0xE6, 0x31, 0x8C, 0x73, 0x9A, 0xD6, 0x71, 0x74,
  0xA3, 0x18, 0xC6, 0x4E, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74, 0xA3, 0x18,
  0xC6, 0x4E, 0x41, 0x80, 0xF4, 0x63, 0x1F, 0x52, 0x53, 0x74, 0xA3, 0xC1,
  0x86, 0x2E, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x8C, 0x63, 0x18, 0xCA,
  0x4E, 0x8C, 0x65, 0x29, 0x31, 0x84, 0x8C, 0x6B, 0xDE, 0xDA, 0x52, 0x8C,
  0x98, 0x46, 0x52, 0x51, 0x85, 0x24, 0x8C, 0x20, 0x82, 0x08, 0xF8, 0x84,
  0x44, 0x42, 0x1F, 0xF2, 0x49, 0x24, 0x9C, 0x88, 0x84, 0x42, 0x22, 0x11,
  0xE4, 0x92, 0x49, 0x3C, 0x23, 0x25, 0x10, 0xF8, 0xB0, 0x64, 0x85, 0xE9,
  0x74, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x74, 0xA1, 0x09, 0xB0, 0x11, 0x79,
  0x99, 0x97, 0x74, 0xBF, 0x09, 0xB8, 0x3A, 0x3E, 0x84, 0x21, 0x1F, 0x0B,
  0xA5, 0x27, 0x41, 0xF1, 0xF0, 0x88, 0xF9, 0x99, 0x99, 0x20, 0x38, 0x42,
  0x10, 0x9F, 0x10, 0xF1, 0x11, 0x11, 0x1F, 0x88, 0xBC, 0x8C, 0xA9, 0xC2,
  0x10, 0x84, 0x21, 0x1F, 0xDD, 0x73, 0x9C, 0xE4, 0xF9, 0x99, 0x99, 0x74,
  0xA3, 0x19, 0x38, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x79, 0x99, 0x97, 0x11,
  0xDB, 0x10, 0x84, 0x7C, 0x74, 0x38, 0x38, 0xB8, 0x20, 0x8F, 0xC8, 0x20,
  0x82, 0x07, 0x99, 0x99, 0x97, 0x9C, 0xA5, 0x46, 0x10, 0x96, 0xDB, 0x75,
  0xC9, 0x20, 0x9C, 0x98, 0x4D, 0x4C, 0x9C, 0xA4, 0xC6, 0x21, 0x18, 0xF1,
  0x24, 0x8F, 0x34, 0x22, 0xC2, 0x24, 0x43, 0xFF, 0xC0, 0xE2, 0x44, 0x34,
  0x42, 0x2E, 0xCD, 0x64,
};

const GFXglyph IBMPlexMono_Thin11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 2, 3, 7, 2, -8 },
  { 3, 6, 8, 7, 0, -8 },
  { 9, 5, 10, 7, 1, -9 },
  { 16, 6, 8, 7, 0, -8 },
  { 22, 6, 8, 7, 0, -8 },
  { 28, 1, 3, 7, 3, -8 },
  { 29, 2, 10, 7, 3, -8 },
  { 32, 3, 10, 7, 1, -8 },
  { 36, 5, 5, 7, 1, -6 },
  { 40, 5, 7, 7, 1, -7 },
  { 45, 1, 3, 7, 3, -1 },
  { 46, 3, 1, 7, 2, -4 },
  { 47, 1, 1, 7, 3, -1 },
  { 48, 4, 10, 7, 1, -8 },
  { 53, 5, 8, 7, 1, -8 },
  { 58, 5, 8, 7, 1, -8 },
  { 63, 5, 8, 7, 1, -8 },
  { 68, 4, 8, 7, 1, -8 },
  { 72, 5, 8, 7, 1, -8 },
  { 77, 5, 8, 7, 1, -8 },
  { 82, 5, 8, 7, 1, -8 },
  { 87, 5, 8, 7, 1, -8 },
  { 92, 5, 8, 7, 1, -8 },
  { 97, 5, 8, 7, 1, -8 },
  { 102, 1, 6, 7, 3, -6 },
  { 103, 1, 8, 7, 3, -6 },
  { 104, 5, 6, 7, 1, -6 },
  { 108, 5, 3, 7, 1, -5 },
  { 110, 5, 6, 7, 1, -6 },
  { 114, 4, 8, 7, 1, -8 },
  { 118, 4, 9, 7, 1, -8 },
  { 123, 5, 8, 7, 1, -8 },
  { 128, 5, 8, 7, 1, -8 },
  { 133, 5, 8, 7, 1, -8 },
  { 138, 5, 8, 7, 1, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 8, 7, 1, -8 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 4, 8, 7, 1, -8 },
  { 172, 5, 8, 7, 1, -8 },
  { 177, 4, 8, 7, 2, -8 },
  { 181, 5, 8, 7, 1, -8 },
  { 186, 5, 8, 7, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 5, 8, 7, 1, -8 },
  { 201, 5, 10, 7, 1, -8 },
  { 208, 5, 8, 7, 1, -8 },
  { 213, 5, 8, 7, 1, -8 },
  { 218, 6, 8, 7, 0, -8 },
  { 224, 5, 8, 7, 1, -8 },
  { 229, 5, 8, 7, 1, -8 },
  { 234, 5, 8, 7, 1, -8 },
  { 239, 5, 8, 7, 1, -8 },
  { 244, 6, 8, 7, 0, -8 },
  { 250, 5, 8, 7, 1, -8 },
  { 255, 3, 10, 7, 3, -8 },
  { 259, 4, 10, 7, 1, -8 },
  { 264, 3, 10, 7, 1, -8 },
  { 268, 5, 4, 7, 1, -8 },
  { 271, 5, 1, 7, 1, 1 },
  { 272, 2, 2, 7, 2, -10 },
  { 273, 5, 6, 7, 1, -6 },
  { 277, 5, 8, 7, 1, -8 },
  { 282, 5, 6, 7, 1, -6 },
  { 286, 4, 8, 7, 1, -8 },
  { 290, 5, 6, 7, 1, -6 },
  { 294, 5, 8, 7, 1, -8 },
  { 299, 5, 9, 7, 1, -7 },
  { 305, 4, 8, 7, 1, -8 },
  { 309, 5, 8, 7, 1, -8 },
  { 314, 4, 10, 7, 1, -8 },
  { 319, 4, 8, 7, 2, -8 },
  { 323, 5, 8, 7, 1, -8 },
  { 328, 5, 6, 7, 1, -6 },
  { 332, 4, 6, 7, 1, -6 },
  { 335, 5, 6, 7, 1, -6 },
  { 339, 5, 8, 7, 1, -6 },
  { 344, 4, 8, 7, 1, -6 },
  { 348, 5, 6, 7, 1, -6 },
  { 352, 5, 6, 7, 1, -6 },
  { 356, 6, 8, 7, 0, -8 },
  { 362, 4, 6, 7, 1, -6 },
  { 365, 5, 6, 7, 1, -6 },
  { 369, 6, 6, 7, 0, -6 },
  { 374, 5, 6, 7, 1, -6 },
  { 378, 5, 8, 7, 1, -6 },
  { 383, 4, 6, 7, 1, -6 },
  { 386, 4, 10, 7, 1, -8 },
  { 391, 1, 10, 7, 3, -8 },
  { 393, 4, 10, 7, 1, -8 },
  { 398, 5, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_Thin11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_THIN11PT7B_H_
