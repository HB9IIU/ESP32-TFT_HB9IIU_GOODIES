#ifndef _IBMPLEXMONO_THIN60PT7B_H_
#define _IBMPLEXMONO_THIN60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x64, 0x64, 0x44, 0x44, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x10, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x08, 0x03, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x80, 0x30, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x21, 0xC0, 0x06, 0x02, 0x07, 0x01,
  0x80, 0x20, 0x18, 0x10, 0x02, 0x00, 0xC2, 0x00, 0x20, 0x06, 0x20, 0x02,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x40, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x60, 0x02, 0x00, 0x02, 0x00, 0x20, 0x00, 0x30, 0x02, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0xF2, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x02, 0x78, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0x20, 0x00, 0x20, 0x02, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x20, 0x03, 0x00, 0x02, 0x00, 0x30, 0x00, 0x20, 0x03,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x20, 0x02, 0x00, 0x02, 0x00, 0x2C, 0x00,
  0x20, 0x06, 0x60, 0x02, 0x00, 0x43, 0x00, 0x20, 0x0C, 0x18, 0x02, 0x01,
  0x80, 0xE0, 0x20, 0x60, 0x03, 0xC2, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x30, 0x04, 0x00, 0x02, 0x20, 0x02, 0x00, 0x02,
  0x40, 0x03, 0x00, 0x04, 0x40, 0x01, 0x00, 0x0C, 0xC0, 0x01, 0x00, 0x08,
  0xC0, 0x01, 0x00, 0x10, 0x80, 0x01, 0x80, 0x10, 0x80, 0x01, 0x80, 0x20,
  0x80, 0x01, 0x80, 0x60, 0x80, 0x01, 0x80, 0x40, 0xC0, 0x01, 0x80, 0x80,
  0xC0, 0x01, 0x00, 0x80, 0x40, 0x01, 0x01, 0x00, 0x40, 0x03, 0x03, 0x00,
  0x20, 0x02, 0x02, 0x00, 0x30, 0x04, 0x04, 0x00, 0x1C, 0x18, 0x04, 0x00,
  0x07, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x30, 0x18, 0x30, 0x00, 0x20, 0x20, 0x0C, 0x00, 0x40, 0x40, 0x04,
  0x00, 0xC0, 0xC0, 0x02, 0x00, 0x80, 0x80, 0x02, 0x01, 0x00, 0x80, 0x03,
  0x01, 0x01, 0x80, 0x03, 0x02, 0x01, 0x80, 0x01, 0x06, 0x01, 0x80, 0x01,
  0x04, 0x01, 0x80, 0x01, 0x08, 0x01, 0x80, 0x01, 0x08, 0x01, 0x80, 0x03,
  0x10, 0x00, 0x80, 0x03, 0x30, 0x00, 0x80, 0x02, 0x20, 0x00, 0xC0, 0x02,
  0x40, 0x00, 0x40, 0x04, 0x40, 0x00, 0x20, 0x0C, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x83, 0x00, 0x1F, 0xC4, 0x06, 0x00, 0x60, 0x20, 0x08,
  0x01, 0x81, 0x80, 0x10, 0x06, 0x04, 0x00, 0x20, 0x10, 0x30, 0x00, 0xC0,
  0x40, 0x80, 0x01, 0x81, 0x02, 0x00, 0x03, 0x04, 0x08, 0x00, 0x06, 0x10,
  0x20, 0x00, 0x08, 0x40, 0x80, 0x00, 0x13, 0x02, 0x00, 0x00, 0x28, 0x08,
  0x00, 0x00, 0xE0, 0x20, 0x00, 0x01, 0x80, 0x80, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x36, 0x04, 0x00, 0x00, 0x8C, 0x18, 0x00, 0x04, 0x10, 0x30, 0x00,
  0x20, 0x20, 0x60, 0x03, 0x00, 0x40, 0xE0, 0x38, 0x00, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x3C, 0x03, 0x00, 0xF0, 0x1E, 0x0C, 0x1E, 0x00, 0x07, 0xB7, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x63, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x84, 0x10, 0xC2,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x18, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x01, 0xC0, 0x38, 0x01, 0x80, 0x06, 0x01, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x04, 0x30, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x01, 0xE0, 0x1C, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x20, 0x02, 0x00, 0x01, 0x80, 0x08, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x3F,
  0xC0, 0x08, 0xE0, 0x1C, 0x04, 0x80, 0x03, 0x02, 0x80, 0x00, 0x41, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x1C, 0x00,
  0x18, 0x03, 0x80, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x1F, 0xE0, 0x02, 0x38, 0x07, 0x01, 0x98, 0x00,
  0x60, 0x48, 0x00, 0x0C, 0x14, 0x00, 0x01, 0x87, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x04, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x10, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xC0,
  0x70, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x03, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x28, 0x60, 0x00, 0x34, 0x18, 0x00, 0x62, 0x03, 0x80,
  0xE3, 0x00, 0x7F, 0x81, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x18,
  0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x04, 0x30, 0x82, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x08, 0x30, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x06,
  0x00, 0x20, 0x08, 0x00, 0x10, 0x18, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x07, 0xE2, 0x80,
  0x18, 0x13, 0x80, 0x20, 0x0B, 0x80, 0x60, 0x07, 0x80, 0x40, 0x03, 0x80,
  0x80, 0x03, 0x80, 0x80, 0x03, 0x80, 0x80, 0x03, 0x81, 0x80, 0x03, 0x81,
  0x80, 0x03, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x81,
  0x80, 0x03, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x80, 0x80, 0x03, 0x80,
  0x80, 0x03, 0x80, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x40, 0x07, 0x80,
  0x60, 0x07, 0x80, 0x30, 0x0B, 0xC0, 0x0F, 0xF3, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x08, 0x00, 0x40, 0x00, 0x20, 0x01, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x18, 0x01, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0x80, 0x40, 0x00, 0x70, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x22, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x1C,
  0x0F, 0xFF, 0xFC, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x38, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x18, 0x30, 0x00, 0x04, 0x06, 0x00, 0x02, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE6, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x10, 0x10, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x01, 0xFF, 0xE8, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC2, 0x00,
  0x00, 0x38, 0x20, 0x00, 0x0B, 0x02, 0x00, 0x02, 0x60, 0x30, 0x01, 0x8C,
  0x03, 0x80, 0xE1, 0x80, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x46, 0x00, 0x03, 0x08, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x38, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x58,
  0x00, 0x0C, 0x11, 0x80, 0x01, 0x84, 0x10, 0x00, 0x31, 0x03, 0x00, 0x06,
  0x60, 0x30, 0x00, 0xD8, 0x02, 0x00, 0x1E, 0x00, 0x60, 0x03, 0x80, 0x06,
  0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7A,
  0x00, 0x00, 0x16, 0xC0, 0x00, 0x0D, 0x90, 0x00, 0x02, 0x64, 0x00, 0x00,
  0x98, 0x80, 0x00, 0x46, 0x20, 0x00, 0x11, 0x84, 0x00, 0x0C, 0x61, 0x00,
  0x02, 0x18, 0x60, 0x01, 0x86, 0x08, 0x00, 0x41, 0x83, 0x00, 0x30, 0x60,
  0x40, 0x08, 0x18, 0x18, 0x06, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x10, 0x20, 0x18, 0x04, 0x08, 0x06, 0x01, 0x86, 0x01, 0x80, 0x21,
  0x00, 0x60, 0x0C, 0xC0, 0x18, 0x01, 0x20, 0x06, 0x00, 0x78, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x90, 0x00,
  0x01, 0x98, 0x00, 0x01, 0x88, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x82, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x40,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x20, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x04, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x02, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01,
  0x81, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x41, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x21, 0x80, 0x00, 0x31, 0x80, 0x00, 0x11, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x09, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x05, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x08, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x3F, 0xFF,
  0xF8, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x08, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x38, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x04,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x7F, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x80, 0x00,
  0x18, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x10, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x02, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0x40, 0x00, 0x20, 0x01, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x10, 0x80, 0x0C, 0x00,
  0x42, 0x00, 0x30, 0x01, 0x08, 0x01, 0xE0, 0x04, 0x20, 0x04, 0x80, 0x10,
  0x80, 0x12, 0x00, 0x43, 0x00, 0x48, 0x03, 0x0C, 0x03, 0x10, 0x0C, 0x30,
  0x08, 0x40, 0x30, 0x40, 0x21, 0x00, 0x81, 0x01, 0x86, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0xC0, 0x81, 0x02, 0x01,
  0x02, 0x04, 0x08, 0x04, 0x08, 0x18, 0x20, 0x10, 0x20, 0x61, 0x80, 0x61,
  0x81, 0x84, 0x00, 0x86, 0x02, 0x10, 0x02, 0x10, 0x08, 0xC0, 0x0C, 0x40,
  0x22, 0x00, 0x11, 0x00, 0x88, 0x00, 0x44, 0x02, 0x60, 0x01, 0x90, 0x09,
  0x80, 0x02, 0x40, 0x24, 0x00, 0x09, 0x00, 0x90, 0x00, 0x24, 0x03, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x04, 0x00, 0x40, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x04, 0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x10, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0xC0, 0x60, 0x30, 0x10,
  0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x30, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xFC, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x0E, 0x0C, 0x00, 0x02, 0xC0, 0xC0, 0x00, 0x58, 0x0C, 0x00,
  0x31, 0x00, 0xE0, 0x18, 0x3F, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFE, 0x00,
  0xC3, 0x01, 0xC0, 0xCC, 0x00, 0x60, 0xD8, 0x00, 0x10, 0xF0, 0x00, 0x08,
  0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x08,
  0xD8, 0x00, 0x10, 0xCC, 0x00, 0x60, 0xC3, 0x01, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0x01, 0xC0, 0x10, 0x00, 0xC0, 0xC0, 0x00, 0xC1,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x98, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x09, 0x00, 0x00, 0x31, 0x00, 0x00, 0xC3,
  0x00, 0x03, 0x01, 0x00, 0x0C, 0x01, 0xC0, 0x70, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x7F, 0x03, 0x03, 0x80, 0xC3, 0x04, 0x00, 0x33, 0x08, 0x00, 0x1B, 0x10,
  0x00, 0x0F, 0x30, 0x00, 0x07, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x20, 0x00, 0x03, 0x30, 0x00, 0x07, 0x10,
  0x00, 0x0F, 0x08, 0x00, 0x1B, 0x06, 0x00, 0x33, 0x03, 0x80, 0xC3, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x01, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x04, 0x40, 0x00, 0x03, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x84, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0x88, 0x00, 0x1C, 0x06, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x04, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x20, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x18,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x1F, 0xC0, 0x43, 0x01,
  0xC2, 0x60, 0x03, 0x14, 0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x00, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x7F, 0xFF, 0xE0, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x1A, 0x00, 0x03, 0x08, 0xC0, 0x00, 0xCC, 0x18, 0x00, 0x36, 0x03, 0x00,
  0x0F, 0x00, 0x60, 0x03, 0x80, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x30,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x3F,
  0x0C, 0xC3, 0x86, 0x1C, 0xD0, 0x08, 0x80, 0x4E, 0x00, 0x50, 0x02, 0xE0,
  0x06, 0x00, 0x2C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0x01, 0xFC, 0x04, 0x30, 0x1C, 0x26, 0x00, 0x31, 0x40, 0x00, 0xCC,
  0x00, 0x02, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x18, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0x60, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x06, 0x01, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0xC3, 0x01, 0xC0, 0xCC, 0x00, 0x60, 0xD8, 0x00,
  0x10, 0xF0, 0x00, 0x08, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xE0, 0x00,
  0x0C, 0xF0, 0x00, 0x08, 0xD8, 0x00, 0x10, 0xCC, 0x00, 0x60, 0xC3, 0x01,
  0xC0, 0xC0, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0xC3, 0x04, 0x00, 0x33, 0x08, 0x00,
  0x1B, 0x10, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x20, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x20, 0x00, 0x03, 0x30, 0x00,
  0x07, 0x10, 0x00, 0x0F, 0x08, 0x00, 0x1B, 0x06, 0x00, 0x33, 0x03, 0x80,
  0xC3, 0x00, 0xFF, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0x1C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x06, 0x40, 0x00,
  0x33, 0x00, 0x02, 0x8C, 0x00, 0x64, 0x38, 0x0E, 0x20, 0x3F, 0xC0, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x30, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x40, 0x02, 0x00, 0x40, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01,
  0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x40, 0x01, 0x80, 0x02, 0x40, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x60, 0x02, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x0C, 0x10, 0x04, 0x30, 0x08, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x08, 0x10, 0x10, 0x08, 0x08,
  0x18, 0x10, 0x08, 0x18, 0x08, 0x10, 0x0C, 0x10, 0x08, 0x20, 0x04, 0x10,
  0x08, 0x20, 0x04, 0x10, 0x08, 0x20, 0x04, 0x10, 0x0C, 0x60, 0x06, 0x10,
  0x0C, 0x40, 0x02, 0x30, 0x04, 0x40, 0x02, 0x20, 0x04, 0x40, 0x02, 0x20,
  0x04, 0xC0, 0x03, 0x20, 0x04, 0x80, 0x01, 0x20, 0x06, 0x80, 0x01, 0x60,
  0x02, 0x80, 0x01, 0x40, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x88, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x08, 0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x10, 0x00,
  0x10, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x18, 0x00, 0x06, 0x02, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x20, 0x06, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x20,
  0x00, 0x60, 0x18, 0x00, 0x08, 0x04, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x10, 0x20, 0x00, 0x06, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0C, 0x30, 0xC0, 0x00, 0x21, 0x80, 0x80, 0x00, 0x84, 0x01, 0x00,
  0x02, 0x20, 0x02, 0x00, 0x10, 0x80, 0x04, 0x00, 0x44, 0x00, 0x08, 0x02,
  0x10, 0x00, 0x10, 0x18, 0x40, 0x00, 0x30, 0xC3, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 4, 42, 36, 16, -42 },
  { 22, 10, 15, 36, 13, -44 },
  { 41, 34, 42, 36, 1, -42 },
  { 220, 28, 56, 36, 4, -49 },
  { 416, 32, 44, 36, 2, -43 },
  { 592, 30, 44, 36, 3, -43 },
  { 757, 2, 15, 36, 17, -44 },
  { 761, 14, 54, 36, 14, -46 },
  { 856, 14, 54, 36, 8, -46 },
  { 951, 30, 30, 36, 3, -33 },
  { 1064, 28, 29, 36, 4, -33 },
  { 1166, 6, 15, 36, 14, -5 },
  { 1178, 16, 1, 36, 10, -19 },
  { 1180, 4, 4, 36, 16, -4 },
  { 1182, 24, 54, 36, 6, -46 },
  { 1344, 28, 44, 36, 4, -43 },
  { 1498, 28, 42, 36, 5, -42 },
  { 1645, 26, 43, 36, 5, -43 },
  { 1785, 25, 44, 36, 4, -43 },
  { 1923, 30, 42, 36, 3, -42 },
  { 2081, 25, 43, 36, 5, -42 },
  { 2216, 26, 43, 36, 5, -42 },
  { 2356, 26, 42, 36, 5, -42 },
  { 2493, 28, 44, 36, 4, -43 },
  { 2647, 25, 43, 36, 6, -43 },
  { 2782, 4, 32, 36, 16, -32 },
  { 2798, 6, 42, 36, 14, -32 },
  { 2830, 26, 32, 36, 5, -34 },
  { 2934, 28, 12, 36, 4, -24 },
  { 2976, 26, 32, 36, 5, -34 },
  { 3080, 24, 43, 36, 6, -43 },
  { 3209, 24, 49, 36, 6, -43 },
  { 3356, 30, 42, 36, 3, -42 },
  { 3514, 25, 42, 36, 6, -42 },
  { 3646, 26, 44, 36, 5, -43 },
  { 3789, 26, 42, 36, 6, -42 },
  { 3926, 25, 42, 36, 6, -42 },
  { 4058, 25, 42, 36, 6, -42 },
  { 4190, 27, 44, 36, 4, -43 },
  { 4339, 24, 42, 36, 6, -42 },
  { 4465, 24, 42, 36, 6, -42 },
  { 4591, 22, 43, 36, 6, -42 },
  { 4710, 27, 42, 36, 6, -42 },
  { 4852, 23, 42, 36, 9, -42 },
  { 4973, 26, 42, 36, 5, -42 },
  { 5110, 24, 42, 36, 6, -42 },
  { 5236, 28, 44, 36, 4, -43 },
  { 5390, 26, 42, 36, 6, -42 },
  { 5527, 28, 51, 36, 4, -43 },
  { 5706, 26, 42, 36, 6, -42 },
  { 5843, 28, 44, 36, 4, -43 },
  { 5997, 32, 42, 36, 2, -42 },
  { 6165, 24, 43, 36, 6, -42 },
  { 6294, 30, 42, 36, 3, -42 },
  { 6452, 30, 42, 36, 3, -42 },
  { 6610, 30, 42, 36, 3, -42 },
  { 6768, 32, 42, 36, 2, -42 },
  { 6936, 30, 42, 36, 3, -42 },
  { 7094, 14, 54, 36, 16, -46 },
  { 7189, 24, 54, 36, 6, -46 },
  { 7351, 14, 54, 36, 6, -46 },
  { 7446, 28, 23, 36, 4, -42 },
  { 7527, 28, 1, 36, 4, 7 },
  { 7531, 8, 10, 36, 12, -46 },
  { 7541, 27, 33, 36, 5, -32 },
  { 7653, 24, 45, 36, 7, -44 },
  { 7788, 23, 33, 36, 7, -32 },
  { 7883, 24, 45, 36, 5, -44 },
  { 8018, 25, 33, 36, 6, -32 },
  { 8122, 27, 44, 36, 5, -44 },
  { 8271, 28, 47, 36, 5, -34 },
  { 8436, 21, 44, 36, 8, -44 },
  { 8552, 25, 45, 36, 7, -45 },
  { 8693, 21, 57, 36, 6, -45 },
  { 8843, 26, 44, 36, 8, -44 },
  { 8986, 26, 44, 36, 5, -44 },
  { 9129, 28, 32, 36, 4, -32 },
  { 9241, 21, 32, 36, 8, -32 },
  { 9325, 26, 33, 36, 5, -32 },
  { 9433, 24, 44, 36, 7, -32 },
  { 9565, 24, 44, 36, 5, -32 },
  { 9697, 28, 31, 36, 5, -31 },
  { 9806, 26, 33, 36, 5, -32 },
  { 9914, 29, 42, 36, 2, -42 },
  { 10067, 21, 32, 36, 7, -31 },
  { 10151, 24, 31, 36, 6, -31 },
  { 10244, 32, 31, 36, 2, -31 },
  { 10368, 26, 31, 36, 5, -31 },
  { 10469, 26, 43, 36, 5, -31 },
  { 10609, 24, 31, 36, 6, -31 },
  { 10702, 22, 54, 36, 7, -46 },
  { 10851, 2, 54, 36, 17, -46 },
  { 10865, 22, 54, 36, 7, -46 },
  { 11014, 30, 10, 36, 3, -23 },
};

const GFXfont IBMPlexMono_Thin60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_THIN60PT7B_H_
