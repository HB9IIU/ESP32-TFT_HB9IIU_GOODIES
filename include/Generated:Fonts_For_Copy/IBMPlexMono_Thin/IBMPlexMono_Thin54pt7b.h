#ifndef _IBMPLEXMONO_THIN54PT7B_H_
#define _IBMPLEXMONO_THIN54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x20, 0x00, 0x00, 0x07, 0xF7, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x04, 0x01, 0x00, 0x00, 0x10, 0x0C, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0x00, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x80, 0x20, 0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x80, 0x40, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x10, 0x04, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0x00, 0x80, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x80, 0x20, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0x08, 0xF0, 0x18, 0x08, 0x18, 0x30, 0x08, 0x04,
  0x20, 0x08, 0x02, 0x40, 0x08, 0x03, 0x40, 0x08, 0x00, 0x40, 0x08, 0x00,
  0xC0, 0x08, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x08, 0x00, 0x40, 0x08, 0x00, 0x20, 0x08, 0x00, 0x30, 0x08, 0x00,
  0x18, 0x08, 0x00, 0x07, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x08, 0x70, 0x00, 0x08, 0x18, 0x00, 0x08, 0x04, 0x00, 0x08, 0x02,
  0x00, 0x08, 0x03, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01,
  0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01,
  0x80, 0x08, 0x01, 0xC0, 0x08, 0x03, 0x60, 0x08, 0x02, 0x30, 0x08, 0x04,
  0x18, 0x08, 0x18, 0x07, 0x08, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0xC1, 0x80, 0x00, 0x88, 0x06, 0x00, 0x08, 0x80,
  0x18, 0x00, 0x44, 0x00, 0x40, 0x04, 0x40, 0x02, 0x00, 0x62, 0x00, 0x18,
  0x02, 0x10, 0x00, 0x40, 0x20, 0x80, 0x02, 0x01, 0x04, 0x00, 0x10, 0x10,
  0x20, 0x00, 0x81, 0x81, 0x00, 0x0C, 0x08, 0x08, 0x00, 0x40, 0x80, 0x20,
  0x02, 0x04, 0x01, 0x00, 0x30, 0x40, 0x04, 0x03, 0x02, 0x00, 0x18, 0x30,
  0x20, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x03, 0x83, 0x00,
  0x10, 0x30, 0x0C, 0x00, 0x81, 0x00, 0x20, 0x08, 0x18, 0x00, 0x80, 0xC0,
  0x80, 0x04, 0x04, 0x04, 0x00, 0x20, 0x40, 0x20, 0x01, 0x02, 0x01, 0x00,
  0x0C, 0x20, 0x08, 0x00, 0x63, 0x00, 0x40, 0x02, 0x10, 0x02, 0x00, 0x11,
  0x00, 0x10, 0x00, 0x88, 0x00, 0x80, 0x04, 0x80, 0x02, 0x00, 0x4C, 0x00,
  0x18, 0x06, 0x40, 0x00, 0x60, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x18, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x02, 0x10, 0x01, 0xF1, 0x83, 0x00, 0x20, 0x20, 0x30, 0x04,
  0x08, 0x03, 0x00, 0x83, 0x00, 0x20, 0x10, 0x40, 0x02, 0x06, 0x08, 0x00,
  0x20, 0x83, 0x00, 0x02, 0x10, 0x60, 0x00, 0x62, 0x0C, 0x00, 0x06, 0x41,
  0x80, 0x00, 0x68, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x1C, 0x08, 0x00, 0x02, 0x40, 0x80, 0x00, 0x84, 0x18, 0x00, 0x30, 0x41,
  0x80, 0x0C, 0x0C, 0x1C, 0x06, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x03, 0x80, 0x10, 0x07, 0x9E, 0x02, 0x07, 0x80, 0x38,
  0x47, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x61, 0x8C, 0x30, 0xC2, 0x08,
  0x61, 0x04, 0x10, 0xC0, 0xFF, 0xFC, 0x7F, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x0C, 0x01,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x18, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x34, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0x40, 0x00, 0x30,
  0x20, 0x00, 0x60, 0x10, 0x00, 0x60, 0x08, 0x00, 0x60, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x0C, 0x07, 0x00, 0x60, 0x01, 0x01,
  0x80, 0x01, 0x06, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x1C, 0x07, 0x00, 0xC0,
  0x06, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x11, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x24, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x38,
  0x07, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x08, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x10, 0x04, 0x00, 0x04, 0x00, 0x80, 0x01,
  0x80, 0x10, 0x00, 0x20, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x20, 0x06, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x80, 0x20, 0x00, 0x10, 0x08, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xFF, 0xF8, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x41, 0xFE,
  0x01, 0x18, 0x07, 0x04, 0x80, 0x06, 0x14, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x2C,
  0x00, 0x01, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x38, 0x06, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x7F, 0x00,
  0x47, 0x01, 0x80, 0x90, 0x00, 0xC1, 0x40, 0x00, 0xC5, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80,
  0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x0C, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x40, 0x80, 0x01, 0x80, 0xC0, 0x06,
  0x00, 0xE0, 0x30, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x70, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x10,
  0x30, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x04, 0x40, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80,
  0x80, 0x01, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x01, 0x20,
  0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x80, 0x00, 0x50, 0x80, 0x00,
  0xA0, 0xC0, 0x06, 0x40, 0xE0, 0x31, 0x80, 0x7F, 0x82, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF7, 0x1C, 0xF1, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x61, 0x8C, 0x30, 0xC2, 0x08, 0x61, 0x04, 0x10, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x04, 0x00, 0x0C, 0x20, 0x00,
  0x19, 0x80, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x03, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0C,
  0x06, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x08, 0x10, 0x00, 0x30, 0xC0, 0x00,
  0x42, 0x00, 0x01, 0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x90, 0x03, 0xE2, 0x40, 0x30, 0x6F, 0x01, 0x80, 0x78, 0x0C,
  0x00, 0xE0, 0x20, 0x03, 0x80, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x10, 0x00,
  0xE0, 0x40, 0x03, 0x81, 0x00, 0x0E, 0x04, 0x00, 0x38, 0x10, 0x00, 0xE0,
  0x40, 0x03, 0x81, 0x00, 0x0E, 0x04, 0x00, 0x38, 0x10, 0x00, 0xE0, 0x60,
  0x03, 0x80, 0x80, 0x0E, 0x02, 0x00, 0x3C, 0x04, 0x01, 0xD0, 0x18, 0x0B,
  0x40, 0x1F, 0xCD, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x08, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00,
  0x08, 0x01, 0x00, 0x01, 0x00, 0x20, 0x00, 0x20, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00, 0x10, 0x01,
  0x00, 0x02, 0x00, 0x20, 0x00, 0x20, 0x0F, 0xFF, 0xFC, 0x01, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x01, 0x00, 0x03, 0x82,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x88, 0x00, 0x01, 0x10, 0x00, 0x03, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x18, 0x80, 0x00, 0x61, 0x00, 0x03, 0x03, 0xFF, 0xFE,
  0x04, 0x00, 0x03, 0x08, 0x00, 0x01, 0x10, 0x00, 0x01, 0x20, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x88, 0x00, 0x06, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xC0, 0x60, 0x03, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x03, 0x20, 0x00, 0x01, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x60, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x01, 0x00, 0x0E, 0x02, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01,
  0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40,
  0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00, 0x06,
  0x08, 0x00, 0x70, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xA0,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0x80, 0xE0, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00,
  0x03, 0x20, 0x00, 0x03, 0x10, 0x00, 0x05, 0x18, 0x00, 0x09, 0x0C, 0x00,
  0x09, 0x06, 0x00, 0x31, 0x01, 0x80, 0xE1, 0x00, 0x7F, 0x80, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x01,
  0x80, 0xC0, 0x70, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x10, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60,
  0x80, 0x00, 0xC0, 0x80, 0x01, 0x80, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00,
  0x80, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x00, 0x80, 0x20, 0x00,
  0x80, 0x60, 0x00, 0x80, 0xC0, 0x00, 0x81, 0x80, 0x00, 0x83, 0x40, 0x00,
  0x86, 0x60, 0x00, 0x84, 0x20, 0x00, 0x88, 0x10, 0x00, 0x90, 0x18, 0x00,
  0xA0, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x06, 0x00, 0x80, 0x02, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x2D, 0x00, 0x00, 0x5A, 0x00, 0x01, 0x32, 0x00, 0x02, 0x64, 0x00, 0x0C,
  0xCC, 0x00, 0x11, 0x88, 0x00, 0x63, 0x18, 0x00, 0x86, 0x10, 0x03, 0x0C,
  0x20, 0x04, 0x18, 0x20, 0x08, 0x30, 0x40, 0x20, 0x60, 0x40, 0x40, 0xC0,
  0x81, 0x01, 0x80, 0x82, 0x03, 0x01, 0x0C, 0x06, 0x03, 0x10, 0x0C, 0x02,
  0x60, 0x18, 0x04, 0x80, 0x30, 0x05, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x20, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80,
  0x00, 0x61, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00,
  0x60, 0x40, 0x01, 0x81, 0x00, 0x06, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x10, 0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x01,
  0x80, 0x06, 0x06, 0x00, 0x08, 0x18, 0x00, 0x30, 0x60, 0x00, 0x41, 0x80,
  0x01, 0x86, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x11, 0x80, 0x00,
  0x26, 0x00, 0x00, 0x98, 0x00, 0x01, 0x60, 0x00, 0x05, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x0C,
  0x01, 0x00, 0x03, 0x01, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x18, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x06, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x82, 0x00, 0x03, 0x88, 0x00,
  0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x02, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xC8, 0x00, 0x0E, 0x3F, 0xFF, 0xE0,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x0C, 0x01,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x18, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0xFF, 0x82, 0x00, 0x03, 0x88, 0x00, 0x03, 0x20, 0x00,
  0x06, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00,
  0x1A, 0x00, 0x00, 0xC8, 0x00, 0x0E, 0x3F, 0xFF, 0xE0, 0x80, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x20, 0x02, 0x00, 0x80, 0x0C, 0x02, 0x00,
  0x10, 0x08, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x80, 0x01, 0x02, 0x00, 0x06,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80, 0x00, 0x62, 0x00, 0x00, 0x88,
  0x00, 0x01, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0x80, 0x07, 0x00, 0xF0, 0x18, 0x00, 0x18, 0x30, 0x00, 0x04, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x02, 0x30, 0x00, 0x04, 0x18,
  0x00, 0x18, 0x07, 0x00, 0x70, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0xD0, 0x00,
  0x02, 0x40, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x04, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x38, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x10,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x20, 0x00, 0x18,
  0x08, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00,
  0x20, 0x06, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x40, 0x08, 0x00, 0x18, 0x02, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0x30, 0x10, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x02, 0x40, 0x0C, 0x00, 0x98, 0x03, 0x00, 0x22, 0x00,
  0xA0, 0x08, 0x80, 0x68, 0x02, 0x20, 0x12, 0x00, 0x88, 0x04, 0xC0, 0x62,
  0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x81, 0x08, 0x08, 0x20,
  0x42, 0x06, 0x08, 0x10, 0xC1, 0x02, 0x04, 0x30, 0x40, 0x41, 0x04, 0x30,
  0x10, 0x41, 0x08, 0x04, 0x10, 0x42, 0x01, 0x84, 0x10, 0x80, 0x23, 0x04,
  0x40, 0x08, 0x81, 0x10, 0x03, 0x20, 0x44, 0x00, 0x48, 0x13, 0x00, 0x12,
  0x06, 0x80, 0x04, 0x81, 0xA0, 0x00, 0xA0, 0x38, 0x00, 0x28, 0x0C, 0x00,
  0x0A, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x10, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x80, 0x18, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x04, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x10, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x40, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x04, 0x30, 0x00, 0x06, 0x08, 0x00, 0x02, 0x06, 0x00, 0x02, 0x01, 0x00,
  0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x80, 0x06,
  0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x30, 0x60, 0x00,
  0x08, 0x20, 0x00, 0x06, 0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0x81, 0x81, 0x81, 0x01, 0x03, 0x03,
  0x02, 0x02, 0x01, 0xFC, 0x00, 0x03, 0x81, 0xC0, 0x02, 0x00, 0x30, 0x02,
  0x00, 0x0C, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF,
  0xC0, 0x18, 0x00, 0x20, 0x30, 0x00, 0x10, 0x30, 0x00, 0x08, 0x10, 0x00,
  0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x18, 0x18,
  0x00, 0x14, 0x06, 0x00, 0x32, 0x01, 0xC0, 0x71, 0xF8, 0x3F, 0xC0, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x07, 0xF0, 0x08, 0xE0, 0x70, 0x48, 0x00,
  0xC2, 0x80, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x24, 0x00, 0x01, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00,
  0x06, 0x50, 0x00, 0x62, 0x40, 0x06, 0x11, 0xC0, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x38, 0x0C, 0x03, 0x00, 0x10, 0x30, 0x00, 0x43, 0x00,
  0x01, 0x10, 0x00, 0x0D, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x02, 0x20, 0x00, 0x09, 0x80, 0x00, 0x86, 0x00, 0x0C, 0x18,
  0x00, 0xC0, 0x70, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x3F, 0x81, 0x03, 0x01, 0x84, 0x30, 0x01, 0x91, 0x80, 0x02,
  0x44, 0x00, 0x05, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0,
  0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x10, 0x00,
  0x14, 0x60, 0x00, 0x90, 0xC0, 0x06, 0x40, 0xC0, 0x61, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x0E, 0x03, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x01, 0x03,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06, 0x40,
  0x00, 0x05, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x01, 0x30, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30, 0x1C, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x20, 0x00, 0xC0, 0x70,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00,
  0x40, 0x60, 0x00, 0x20, 0x20, 0x00, 0x18, 0x10, 0x00, 0x04, 0x08, 0x00,
  0x02, 0x04, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x40,
  0x00, 0x40, 0x20, 0x00, 0x60, 0x08, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00,
  0xC0, 0x60, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x41, 0xFC, 0x08, 0xC0, 0x61, 0x20, 0x03, 0x28, 0x00, 0x26,
  0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x09, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xD8, 0x00, 0x02,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03,
  0x00, 0x10, 0x06, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xE0, 0x00, 0xC3, 0x60, 0x01, 0x88, 0x40, 0x03, 0x20,
  0x40, 0x07, 0x80, 0x40, 0x0E, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0x60, 0x00, 0x80, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x60, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xC0,
  0xF8, 0x4C, 0x30, 0x83, 0x28, 0x0C, 0x80, 0xD8, 0x02, 0x80, 0x2C, 0x01,
  0x80, 0x14, 0x00, 0x40, 0x0A, 0x00, 0x20, 0x05, 0x00, 0x10, 0x03, 0x80,
  0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0x00, 0x38,
  0x00, 0x80, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x20, 0x07, 0x00, 0x10, 0x03,
  0x80, 0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0x00,
  0x38, 0x00, 0x80, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x20, 0x07, 0x00, 0x10,
  0x03, 0x80, 0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01,
  0x00, 0x38, 0x00, 0x80, 0x18, 0x03, 0xF8, 0x11, 0x80, 0xC2, 0x40, 0x06,
  0x50, 0x00, 0x4C, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0xFE, 0x00, 0x0E, 0x03, 0x00, 0x30, 0x01, 0x00, 0x80,
  0x01, 0x03, 0x00, 0x01, 0x04, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x06, 0x40, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x18, 0x60, 0x00, 0x20, 0x40, 0x00, 0x80, 0x60, 0x02, 0x00, 0x70,
  0x18, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x04, 0x70, 0x38, 0x24, 0x00,
  0x61, 0x40, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x12, 0x00, 0x00, 0xD0,
  0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x06, 0xC0, 0x00, 0x26, 0x00,
  0x03, 0x28, 0x00, 0x31, 0x20, 0x03, 0x08, 0xE0, 0x70, 0x41, 0xFC, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x06, 0x10, 0xC0, 0x06, 0x46, 0x00,
  0x09, 0x10, 0x00, 0x14, 0x80, 0x00, 0x32, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x40,
  0x00, 0x51, 0x80, 0x02, 0x43, 0x00, 0x19, 0x03, 0x01, 0x84, 0x03, 0xF8,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x08, 0xE0, 0x00, 0x02,
  0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x00, 0xC1, 0x80, 0x00, 0xC2, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x80, 0x70, 0x0E, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x72, 0x00, 0x0B, 0x18,
  0x01, 0xB0, 0xE0, 0x63, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x98, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x43,
  0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80,
  0x04, 0x02, 0x00, 0x10, 0x04, 0x00, 0x40, 0x10, 0x02, 0x00, 0x60, 0x08,
  0x00, 0x80, 0x60, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x10, 0x20, 0x00,
  0x40, 0x80, 0x00, 0x82, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x13,
  0x00, 0x00, 0x48, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00,
  0xD0, 0x01, 0x40, 0x09, 0x00, 0x34, 0x00, 0x90, 0x02, 0x40, 0x08, 0x80,
  0x26, 0x01, 0x08, 0x02, 0x20, 0x10, 0x80, 0x22, 0x01, 0x0C, 0x02, 0x20,
  0x10, 0x40, 0x42, 0x02, 0x04, 0x04, 0x20, 0x20, 0x40, 0x41, 0x02, 0x02,
  0x04, 0x10, 0x20, 0x20, 0x41, 0x04, 0x02, 0x08, 0x10, 0x40, 0x20, 0x81,
  0x04, 0x01, 0x08, 0x08, 0x40, 0x10, 0x80, 0x88, 0x01, 0x08, 0x08, 0x80,
  0x11, 0x80, 0x88, 0x00, 0x90, 0x08, 0x80, 0x09, 0x00, 0xD0, 0x00, 0x90,
  0x05, 0x00, 0x09, 0x00, 0x50, 0x00, 0x50, 0x07, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x60, 0x80,
  0x01, 0x81, 0x80, 0x02, 0x01, 0x80, 0x08, 0x01, 0x00, 0x30, 0x01, 0x00,
  0xC0, 0x03, 0x01, 0x00, 0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x02, 0x60,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x18, 0x08, 0x00,
  0x20, 0x18, 0x00, 0x80, 0x18, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x30,
  0x00, 0x10, 0x40, 0x00, 0x31, 0x00, 0x00, 0x26, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x40, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x08, 0x00, 0x08, 0x08,
  0x00, 0x10, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x30, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01,
  0x00, 0x80, 0x00, 0x80, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x62, 0x00, 0x00, 0x22, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x0F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x46, 0x18, 0x00, 0x13, 0x03,
  0x00, 0x04, 0x80, 0x60, 0x02, 0x40, 0x0C, 0x00, 0x90, 0x01, 0x80, 0x64,
  0x00, 0x30, 0x12, 0x00, 0x03, 0x18, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 4, 38, 32, 14, -38 },
  { 20, 8, 14, 32, 12, -40 },
  { 34, 30, 38, 32, 1, -38 },
  { 177, 24, 49, 32, 4, -43 },
  { 324, 29, 39, 32, 2, -38 },
  { 466, 27, 39, 32, 2, -38 },
  { 598, 1, 14, 32, 16, -40 },
  { 600, 12, 48, 32, 13, -41 },
  { 672, 13, 48, 32, 7, -41 },
  { 750, 27, 27, 32, 3, -30 },
  { 842, 26, 27, 32, 3, -30 },
  { 930, 6, 13, 32, 12, -4 },
  { 940, 14, 1, 32, 9, -17 },
  { 942, 4, 3, 32, 14, -3 },
  { 944, 21, 48, 32, 6, -41 },
  { 1070, 25, 39, 32, 4, -38 },
  { 1192, 25, 38, 32, 5, -38 },
  { 1311, 23, 38, 32, 5, -38 },
  { 1421, 22, 39, 32, 4, -38 },
  { 1529, 27, 38, 32, 3, -38 },
  { 1658, 22, 39, 32, 5, -38 },
  { 1766, 23, 39, 32, 5, -38 },
  { 1879, 24, 38, 32, 4, -38 },
  { 1993, 25, 39, 32, 4, -38 },
  { 2115, 23, 38, 32, 5, -38 },
  { 2225, 4, 28, 32, 14, -28 },
  { 2239, 6, 37, 32, 12, -28 },
  { 2267, 23, 29, 32, 5, -31 },
  { 2351, 26, 11, 32, 3, -22 },
  { 2387, 23, 29, 32, 5, -31 },
  { 2471, 22, 38, 32, 5, -38 },
  { 2576, 22, 44, 32, 5, -38 },
  { 2697, 27, 38, 32, 3, -38 },
  { 2826, 23, 38, 32, 5, -38 },
  { 2936, 24, 39, 32, 4, -38 },
  { 3053, 23, 38, 32, 6, -38 },
  { 3163, 22, 38, 32, 6, -38 },
  { 3268, 22, 38, 32, 6, -38 },
  { 3373, 24, 39, 32, 4, -38 },
  { 3490, 22, 38, 32, 5, -38 },
  { 3595, 22, 38, 32, 5, -38 },
  { 3700, 20, 39, 32, 5, -38 },
  { 3798, 24, 38, 32, 6, -38 },
  { 3912, 21, 38, 32, 8, -38 },
  { 4012, 23, 38, 32, 5, -38 },
  { 4122, 22, 38, 32, 5, -38 },
  { 4227, 25, 39, 32, 4, -38 },
  { 4349, 22, 38, 32, 6, -38 },
  { 4454, 25, 46, 32, 4, -38 },
  { 4598, 22, 38, 32, 6, -38 },
  { 4703, 24, 39, 32, 4, -38 },
  { 4820, 28, 38, 32, 2, -38 },
  { 4953, 22, 39, 32, 5, -38 },
  { 5061, 26, 38, 32, 3, -38 },
  { 5185, 26, 38, 32, 3, -38 },
  { 5309, 27, 38, 32, 3, -38 },
  { 5438, 29, 38, 32, 2, -38 },
  { 5576, 27, 38, 32, 3, -38 },
  { 5705, 13, 48, 32, 14, -41 },
  { 5783, 21, 48, 32, 6, -41 },
  { 5909, 13, 48, 32, 5, -41 },
  { 5987, 25, 20, 32, 4, -38 },
  { 6050, 26, 1, 32, 3, 7 },
  { 6054, 7, 9, 32, 11, -41 },
  { 6062, 25, 30, 32, 4, -29 },
  { 6156, 21, 41, 32, 7, -40 },
  { 6264, 21, 30, 32, 6, -29 },
  { 6343, 22, 41, 32, 4, -40 },
  { 6456, 23, 30, 32, 5, -29 },
  { 6543, 24, 40, 32, 5, -40 },
  { 6663, 25, 41, 32, 5, -30 },
  { 6792, 19, 40, 32, 7, -40 },
  { 6887, 23, 40, 32, 6, -40 },
  { 7002, 19, 51, 32, 5, -40 },
  { 7124, 23, 40, 32, 7, -40 },
  { 7239, 23, 40, 32, 5, -40 },
  { 7354, 25, 29, 32, 4, -29 },
  { 7445, 19, 29, 32, 7, -29 },
  { 7514, 23, 30, 32, 5, -29 },
  { 7601, 21, 40, 32, 7, -29 },
  { 7706, 22, 40, 32, 4, -29 },
  { 7816, 26, 28, 32, 4, -28 },
  { 7907, 23, 30, 32, 5, -29 },
  { 7994, 26, 38, 32, 2, -38 },
  { 8118, 20, 29, 32, 6, -28 },
  { 8191, 22, 28, 32, 5, -28 },
  { 8268, 28, 28, 32, 2, -28 },
  { 8366, 23, 28, 32, 5, -28 },
  { 8447, 24, 39, 32, 4, -28 },
  { 8564, 21, 28, 32, 6, -28 },
  { 8638, 20, 48, 32, 6, -41 },
  { 8758, 1, 48, 32, 16, -41 },
  { 8764, 20, 48, 32, 6, -41 },
  { 8884, 26, 9, 32, 3, -21 },
};

const GFXfont IBMPlexMono_Thin54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_THIN54PT7B_H_
