#ifndef _IBMPLEXMONO_THIN56PT7B_H_
#define _IBMPLEXMONO_THIN56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x40, 0x00, 0x00, 0x00, 0xEF, 0xE0, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x04, 0x00, 0x02, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x04, 0x01, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00, 0x02, 0x00, 0x80, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60,
  0x10, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x20, 0x08, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0x11, 0xE0, 0x0C,
  0x04, 0x0C, 0x04, 0x01, 0x01, 0x82, 0x00, 0x40, 0x11, 0x80, 0x10, 0x06,
  0x40, 0x04, 0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00, 0x10,
  0x00, 0x40, 0x04, 0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00,
  0x10, 0x00, 0x60, 0x04, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x30, 0x10, 0x00, 0x07, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x10, 0xE0, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x40, 0x30, 0x00, 0x10, 0x06, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00, 0x20,
  0x00, 0x40, 0x08, 0x00, 0x10, 0x02, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x00,
  0x20, 0x00, 0x40, 0x08, 0x00, 0x10, 0x02, 0x80, 0x04, 0x00, 0xB0, 0x01,
  0x00, 0x46, 0x00, 0x40, 0x30, 0xC0, 0x10, 0x18, 0x1C, 0x04, 0x0C, 0x01,
  0xE1, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x12, 0x00, 0x80,
  0x00, 0x98, 0x01, 0x00, 0x06, 0x40, 0x06, 0x00, 0x13, 0x00, 0x08, 0x00,
  0x88, 0x00, 0x20, 0x02, 0x20, 0x00, 0x80, 0x10, 0x80, 0x02, 0x00, 0xC2,
  0x00, 0x08, 0x02, 0x08, 0x00, 0x20, 0x10, 0x20, 0x00, 0x80, 0x40, 0x80,
  0x02, 0x02, 0x03, 0x00, 0x08, 0x18, 0x04, 0x00, 0x60, 0x40, 0x18, 0x01,
  0x02, 0x00, 0x20, 0x08, 0x08, 0x00, 0x60, 0xC0, 0x40, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x18, 0x18, 0x38, 0x00, 0x40, 0xC0, 0x30,
  0x02, 0x02, 0x00, 0x40, 0x08, 0x10, 0x00, 0x80, 0x40, 0x40, 0x02, 0x03,
  0x03, 0x00, 0x08, 0x08, 0x08, 0x00, 0x30, 0x40, 0x20, 0x00, 0xC1, 0x00,
  0x80, 0x03, 0x08, 0x02, 0x00, 0x0C, 0x60, 0x08, 0x00, 0x31, 0x00, 0x30,
  0x00, 0x88, 0x00, 0x40, 0x02, 0x20, 0x01, 0x00, 0x09, 0x00, 0x02, 0x00,
  0x4C, 0x00, 0x0C, 0x03, 0x20, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x20,
  0x01, 0xF0, 0x81, 0x00, 0x10, 0x10, 0x08, 0x01, 0x03, 0x00, 0x40, 0x10,
  0x20, 0x06, 0x03, 0x04, 0x00, 0x30, 0x30, 0x40, 0x01, 0x02, 0x04, 0x00,
  0x08, 0x20, 0xC0, 0x00, 0x42, 0x0C, 0x00, 0x02, 0x20, 0xC0, 0x00, 0x32,
  0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x0B, 0x06, 0x00, 0x01, 0x90, 0x20, 0x00, 0x10, 0x81, 0x00, 0x02,
  0x04, 0x18, 0x00, 0xC0, 0x20, 0x70, 0x38, 0x03, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x04, 0x00, 0x37, 0x80, 0x40, 0x1C,
  0x0F, 0x04, 0x1E, 0x00, 0x0F, 0x4F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x40, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0xCC, 0x63, 0x19, 0x8C, 0x62, 0x11, 0x88,
  0x40, 0xFF, 0xFE, 0xEF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x38, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0x20, 0x18, 0x00, 0x04, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x01, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x18,
  0x00, 0x04, 0x03, 0x00, 0x02, 0x00, 0x60, 0x03, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x03, 0x10, 0x00, 0x01, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x60, 0x10, 0x00, 0x30, 0x04, 0x00, 0x18, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0x01, 0xC0, 0x08, 0x00, 0x60, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x18, 0x60, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x06, 0x03, 0x80, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x90, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x24, 0x00, 0x00, 0xC6, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x03, 0x80, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x10, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20,
  0x08, 0x00, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x08, 0x00, 0x80,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x10, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xFF, 0xFC, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0xFF, 0x00, 0x4E, 0x01, 0x80, 0xA0, 0x00, 0xC3, 0x80, 0x00, 0xC6,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x32, 0x00, 0x00, 0x42, 0x00, 0x01,
  0x03, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0xFF, 0x00,
  0x43, 0x01, 0xC0, 0x4C, 0x00, 0x30, 0x50, 0x00, 0x18, 0xE0, 0x00, 0x0C,
  0xA0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x08, 0x60, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0x30,
  0x10, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x04, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x38, 0x06,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x70, 0x03, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x20, 0x00, 0x07, 0x30, 0x00,
  0x0A, 0x18, 0x00, 0x1A, 0x0C, 0x00, 0x32, 0x03, 0x00, 0xC6, 0x00, 0xFF,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xEF, 0xE0, 0x38, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61,
  0x8C, 0x30, 0xC3, 0x18, 0x61, 0x84, 0x10, 0xC2, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x18, 0x06, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x60,
  0x00, 0x11, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x03, 0x80, 0x18, 0x01, 0x80, 0x60,
  0x01, 0x81, 0x80, 0x01, 0x02, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x24, 0x00, 0xFC, 0x48, 0x03, 0x06, 0xD0, 0x08, 0x03, 0xE0, 0x20, 0x07,
  0xC0, 0xC0, 0x07, 0x81, 0x00, 0x0E, 0x02, 0x00, 0x1C, 0x04, 0x00, 0x38,
  0x08, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x81,
  0x80, 0x07, 0x03, 0x00, 0x0E, 0x02, 0x00, 0x1C, 0x04, 0x00, 0x3C, 0x08,
  0x00, 0x78, 0x10, 0x00, 0xF0, 0x30, 0x01, 0xA0, 0x20, 0x03, 0x40, 0x60,
  0x0E, 0x80, 0x60, 0x2D, 0x00, 0x7F, 0x9A, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x01, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x10, 0x01, 0x80, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x40, 0x06, 0x00, 0x04, 0x00,
  0x40, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x10, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x70, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x44, 0x00, 0x00, 0x43, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x20, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x60, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x80, 0x03, 0x80, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x10, 0x80, 0x00, 0x18, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x20, 0x80, 0x00, 0xC0, 0x80, 0x03, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xE0, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x03, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x70, 0x80, 0x00, 0x58, 0x20, 0x00, 0x6C, 0x0C, 0x00, 0x66, 0x03,
  0x80, 0xC3, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x16, 0x00, 0x00, 0x90, 0x00, 0x0C,
  0xC0, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x38, 0x0C, 0x00, 0x3F,
  0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x01, 0x10, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x00,
  0x01, 0x80, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x20, 0x00, 0x80, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x80, 0x02, 0x00, 0x80, 0x01,
  0x00, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x40, 0xE0, 0x00, 0x20, 0xC8, 0x00,
  0x10, 0xC6, 0x00, 0x08, 0x41, 0x00, 0x04, 0x40, 0x40, 0x02, 0x40, 0x30,
  0x01, 0x40, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00,
  0x40, 0x10, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x40, 0x00, 0x04, 0x20,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x24, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x05,
  0xA0, 0x00, 0x0D, 0xB0, 0x00, 0x09, 0x90, 0x00, 0x09, 0x90, 0x00, 0x11,
  0x88, 0x00, 0x11, 0x88, 0x00, 0x31, 0x84, 0x00, 0x21, 0x84, 0x00, 0x61,
  0x86, 0x00, 0x41, 0x82, 0x00, 0xC1, 0x83, 0x00, 0x81, 0x81, 0x00, 0x81,
  0x81, 0x01, 0x01, 0x80, 0x81, 0x01, 0x80, 0x83, 0x01, 0x80, 0x42, 0x01,
  0x80, 0x46, 0x01, 0x80, 0x64, 0x01, 0x80, 0x2C, 0x01, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x80, 0x00, 0x1D,
  0x80, 0x00, 0x39, 0x00, 0x00, 0x73, 0x00, 0x00, 0xE2, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0x84, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x08, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x10, 0x00, 0x70, 0x10, 0x00, 0xE0, 0x20, 0x01, 0xC0, 0x20,
  0x03, 0x80, 0x40, 0x07, 0x00, 0x40, 0x0E, 0x00, 0x80, 0x1C, 0x00, 0x80,
  0x38, 0x01, 0x80, 0x70, 0x01, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x02, 0x03,
  0x80, 0x06, 0x07, 0x00, 0x04, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x08, 0x38,
  0x00, 0x18, 0x70, 0x00, 0x10, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x23, 0x80,
  0x00, 0x67, 0x00, 0x00, 0x4E, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xB8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0x20, 0x18, 0x00, 0x04, 0x04, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x18, 0x18, 0x00, 0x04, 0x03, 0x00, 0x02, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x64, 0x00, 0x00, 0x48, 0x00, 0x00, 0x50, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x64, 0x00, 0x03, 0x0F, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x60, 0x38, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00,
  0x20, 0x18, 0x00, 0x04, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x44, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x19, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x18, 0x00, 0x04,
  0x03, 0x00, 0x02, 0x00, 0x60, 0x03, 0x00, 0x06, 0x03, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xFF, 0x81, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x64, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0x64, 0x00, 0x03, 0x0F, 0xFF, 0xF8,
  0x10, 0x06, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0C, 0x01,
  0x00, 0x08, 0x02, 0x00, 0x08, 0x04, 0x00, 0x18, 0x08, 0x00, 0x10, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x30, 0x40, 0x00, 0x20, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0xA0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x41, 0x00, 0x01, 0x81, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x00, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x08, 0x10, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x08,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x20, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00, 0x40, 0x02, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x80, 0x01, 0x00,
  0x08, 0x00, 0x10, 0x01, 0x00, 0x01, 0x80, 0x10, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x26, 0x00, 0x60,
  0x04, 0x40, 0x0C, 0x00, 0x88, 0x03, 0x80, 0x11, 0x00, 0x58, 0x02, 0x20,
  0x09, 0x00, 0x44, 0x03, 0x20, 0x08, 0x80, 0x46, 0x03, 0x10, 0x08, 0x40,
  0x42, 0x01, 0x08, 0x08, 0x60, 0x41, 0x01, 0x0C, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x10, 0x60, 0x40, 0x82, 0x08, 0x0C, 0x10, 0x41, 0x00, 0x82,
  0x08, 0x60, 0x10, 0x41, 0x08, 0x03, 0x18, 0x21, 0x00, 0x22, 0x04, 0x20,
  0x04, 0x40, 0xC8, 0x00, 0x88, 0x19, 0x00, 0x19, 0x01, 0x20, 0x01, 0x20,
  0x2C, 0x00, 0x24, 0x05, 0x00, 0x06, 0x80, 0xA0, 0x00, 0x50, 0x1C, 0x00,
  0x0A, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00, 0x40, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x10, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x01, 0x80, 0x00, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x04, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xFE, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00,
  0x60, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x40, 0x04,
  0x00, 0x08, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x40, 0x00, 0x18,
  0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x44, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x30, 0x08, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xE0, 0x0E, 0x00,
  0x08, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x08, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x18, 0x10, 0x00, 0x06, 0x04, 0x00, 0x02, 0x81, 0x80, 0x01,
  0xA0, 0x30, 0x00, 0xC8, 0x03, 0x00, 0xC3, 0xF0, 0x3F, 0xC0, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x86, 0x03, 0x02, 0x60,
  0x03, 0x0B, 0x00, 0x06, 0x28, 0x00, 0x08, 0xC0, 0x00, 0x13, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x12, 0x80, 0x00, 0x8B, 0x00, 0x06, 0x26, 0x00,
  0x30, 0x86, 0x03, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0E, 0x07,
  0x00, 0x40, 0x06, 0x02, 0x00, 0x04, 0x10, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x80, 0x00, 0x31, 0x00, 0x00, 0x82, 0x00, 0x04,
  0x04, 0x00, 0x20, 0x0E, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x03, 0xF8, 0x30, 0x38, 0x1C, 0x60, 0xC0,
  0x04, 0xC2, 0x00, 0x05, 0x88, 0x00, 0x07, 0x30, 0x00, 0x06, 0x40, 0x00,
  0x0C, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xD0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0,
  0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x19, 0x00, 0x00, 0x33, 0x00, 0x00, 0x62, 0x00, 0x01, 0xC2, 0x00,
  0x05, 0x83, 0x00, 0x13, 0x03, 0x81, 0xC6, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0x01, 0xC0, 0x04, 0x00, 0x20, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x30, 0x00, 0x04, 0x10, 0x00, 0x08, 0x08, 0x00, 0x10, 0x04, 0x00,
  0x20, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC8, 0x00, 0x38,
  0x1E, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x04, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x03, 0x00, 0x03, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFC, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x1F, 0xC0, 0x8E, 0x07, 0x09, 0x80, 0x08, 0xA0,
  0x00, 0x4A, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x7F, 0xFF, 0xE0, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0xD0, 0x00,
  0x02, 0x20, 0x00, 0x18, 0x40, 0x00, 0x60, 0x80, 0x01, 0x81, 0x00, 0x06,
  0x02, 0x00, 0x10, 0x04, 0x00, 0x40, 0x08, 0x03, 0x00, 0x10, 0x0C, 0x00,
  0x20, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x83, 0xC0, 0x01, 0x08, 0xC0, 0x02,
  0x20, 0x80, 0x05, 0x80, 0x80, 0x0E, 0x00, 0x80, 0x18, 0x01, 0x80, 0x20,
  0x01, 0x80, 0x40, 0x01, 0x80, 0x80, 0x01, 0x01, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x03, 0x20, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x80, 0x00, 0x02, 0xFF, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x7C, 0x26, 0x0C, 0x60, 0xCA, 0x01, 0x30, 0x1A, 0x80, 0x28, 0x02, 0xC0,
  0x0C, 0x00, 0xB0, 0x03, 0x00, 0x28, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0x03,
  0x80, 0x08, 0x00, 0xE0, 0x02, 0x00, 0x38, 0x00, 0x80, 0x0E, 0x00, 0x20,
  0x03, 0x80, 0x08, 0x00, 0xE0, 0x02, 0x00, 0x38, 0x00, 0x80, 0x0E, 0x00,
  0x20, 0x03, 0x80, 0x08, 0x00, 0xE0, 0x02, 0x00, 0x38, 0x00, 0x80, 0x0E,
  0x00, 0x20, 0x03, 0x80, 0x08, 0x00, 0xE0, 0x02, 0x00, 0x38, 0x00, 0x80,
  0x0E, 0x00, 0x20, 0x03, 0x80, 0x08, 0x00, 0xE0, 0x02, 0x00, 0x38, 0x00,
  0x80, 0x0E, 0x00, 0x20, 0x03, 0x80, 0x08, 0x00, 0xE0, 0x02, 0x00, 0x30,
  0x01, 0xFC, 0x08, 0xE0, 0x70, 0x98, 0x00, 0x8A, 0x00, 0x04, 0xA0, 0x00,
  0x6C, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x03, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0x10, 0x10, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x08,
  0x18, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x02, 0x18, 0x0C, 0x09, 0x80, 0x0C, 0x2C, 0x00, 0x18, 0xA0,
  0x00, 0x23, 0x00, 0x00, 0x4C, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xA0, 0x00, 0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4A,
  0x00, 0x02, 0x2C, 0x00, 0x18, 0x98, 0x00, 0xC2, 0x18, 0x0C, 0x08, 0x1F,
  0xC0, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x03, 0x8C, 0x18,
  0x00, 0x98, 0x40, 0x00, 0xB1, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x90, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x90,
  0x00, 0x03, 0x20, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x38, 0x40,
  0x00, 0xB0, 0x60, 0x02, 0x60, 0x70, 0x38, 0xC0, 0x3F, 0xC1, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0xFF, 0xF0, 0x7F, 0xE0, 0x06, 0x30, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0x00, 0xE0, 0x08,
  0x00, 0x30, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x60,
  0x00, 0x02, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x70, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x28, 0x00, 0x0D, 0x80, 0x02, 0x98, 0x00, 0xD1, 0xC0, 0x62, 0x07,
  0xF0, 0x00, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80, 0x20, 0x01,
  0x00, 0x40, 0x02, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x60,
  0x03, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x08, 0x10, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x48, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40,
  0x02, 0x80, 0x09, 0x00, 0x14, 0x00, 0x48, 0x00, 0xA0, 0x02, 0x40, 0x09,
  0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x20, 0x08, 0x40, 0x11, 0x00,
  0xC2, 0x00, 0x88, 0x04, 0x10, 0x0C, 0x40, 0x20, 0x40, 0x43, 0x01, 0x02,
  0x02, 0x08, 0x18, 0x10, 0x10, 0x40, 0x80, 0x80, 0x82, 0x04, 0x02, 0x0C,
  0x10, 0x20, 0x10, 0x40, 0xC2, 0x00, 0x82, 0x02, 0x10, 0x04, 0x10, 0x10,
  0x80, 0x10, 0x80, 0x84, 0x00, 0x84, 0x04, 0x40, 0x04, 0x40, 0x22, 0x00,
  0x32, 0x00, 0x90, 0x00, 0x90, 0x04, 0x80, 0x04, 0x80, 0x28, 0x00, 0x24,
  0x01, 0x40, 0x01, 0xE0, 0x0A, 0x00, 0x06, 0x00, 0x70, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x02, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x18,
  0x08, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0xC0,
  0x01, 0x00, 0x80, 0x01, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x46, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x00,
  0x03, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x20,
  0x18, 0x00, 0x10, 0x10, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x04,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x30,
  0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x02, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x82, 0x00, 0x00, 0x42, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x24, 0x00, 0x00, 0x28, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x70, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x3F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x21, 0x0C, 0x00, 0x04, 0x40, 0x40, 0x00, 0x90, 0x04, 0x00, 0x12,
  0x00, 0x40, 0x04, 0x80, 0x04, 0x00, 0x90, 0x00, 0xC0, 0x22, 0x00, 0x0C,
  0x0C, 0xC0, 0x00, 0xC3, 0x10, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 4, 39, 34, 15, -39 },
  { 21, 9, 14, 34, 12, -41 },
  { 37, 31, 39, 34, 1, -39 },
  { 189, 26, 53, 34, 4, -46 },
  { 362, 30, 41, 34, 2, -40 },
  { 516, 28, 41, 34, 2, -40 },
  { 660, 1, 14, 34, 16, -41 },
  { 662, 13, 51, 34, 13, -43 },
  { 745, 12, 51, 34, 8, -43 },
  { 822, 28, 28, 34, 3, -31 },
  { 920, 27, 27, 34, 3, -31 },
  { 1012, 5, 14, 34, 13, -4 },
  { 1021, 15, 1, 34, 9, -18 },
  { 1023, 4, 3, 34, 15, -3 },
  { 1025, 22, 51, 34, 6, -43 },
  { 1166, 26, 41, 34, 4, -40 },
  { 1300, 26, 39, 34, 5, -39 },
  { 1427, 24, 40, 34, 5, -40 },
  { 1547, 23, 41, 34, 4, -40 },
  { 1665, 28, 39, 34, 3, -39 },
  { 1802, 23, 40, 34, 5, -39 },
  { 1917, 24, 40, 34, 5, -39 },
  { 2037, 25, 39, 34, 4, -39 },
  { 2159, 26, 41, 34, 4, -40 },
  { 2293, 24, 40, 34, 5, -40 },
  { 2413, 4, 29, 34, 15, -29 },
  { 2428, 6, 39, 34, 13, -29 },
  { 2458, 24, 30, 34, 5, -32 },
  { 2548, 27, 11, 34, 3, -23 },
  { 2586, 24, 30, 34, 5, -32 },
  { 2676, 22, 40, 34, 6, -40 },
  { 2786, 23, 46, 34, 5, -40 },
  { 2919, 28, 39, 34, 3, -39 },
  { 3056, 24, 39, 34, 5, -39 },
  { 3173, 25, 41, 34, 4, -40 },
  { 3302, 24, 39, 34, 6, -39 },
  { 3419, 23, 39, 34, 6, -39 },
  { 3532, 23, 39, 34, 6, -39 },
  { 3645, 25, 41, 34, 4, -40 },
  { 3774, 23, 39, 34, 5, -39 },
  { 3887, 23, 39, 34, 5, -39 },
  { 4000, 21, 40, 34, 5, -39 },
  { 4105, 25, 39, 34, 6, -39 },
  { 4227, 22, 39, 34, 8, -39 },
  { 4335, 24, 39, 34, 5, -39 },
  { 4452, 23, 39, 34, 5, -39 },
  { 4565, 26, 41, 34, 4, -40 },
  { 4699, 23, 39, 34, 6, -39 },
  { 4812, 26, 48, 34, 4, -40 },
  { 4968, 23, 39, 34, 6, -39 },
  { 5081, 26, 41, 34, 4, -40 },
  { 5215, 29, 39, 34, 2, -39 },
  { 5357, 23, 40, 34, 5, -39 },
  { 5472, 28, 39, 34, 3, -39 },
  { 5609, 27, 39, 34, 3, -39 },
  { 5741, 28, 39, 34, 3, -39 },
  { 5878, 30, 39, 34, 2, -39 },
  { 6025, 28, 39, 34, 3, -39 },
  { 6162, 13, 51, 34, 15, -43 },
  { 6245, 22, 51, 34, 6, -43 },
  { 6386, 14, 51, 34, 5, -43 },
  { 6476, 26, 21, 34, 4, -39 },
  { 6545, 27, 1, 34, 3, 7 },
  { 6549, 8, 9, 34, 11, -42 },
  { 6558, 26, 31, 34, 4, -30 },
  { 6659, 22, 42, 34, 7, -41 },
  { 6775, 22, 31, 34, 6, -30 },
  { 6861, 23, 42, 34, 4, -41 },
  { 6982, 24, 31, 34, 5, -30 },
  { 7075, 25, 41, 34, 5, -41 },
  { 7204, 26, 43, 34, 5, -31 },
  { 7344, 20, 41, 34, 7, -41 },
  { 7447, 23, 42, 34, 7, -42 },
  { 7568, 20, 53, 34, 5, -42 },
  { 7701, 23, 41, 34, 8, -41 },
  { 7819, 24, 41, 34, 5, -41 },
  { 7942, 26, 30, 34, 4, -30 },
  { 8040, 20, 30, 34, 7, -30 },
  { 8115, 24, 31, 34, 5, -30 },
  { 8208, 22, 41, 34, 7, -30 },
  { 8321, 23, 41, 34, 4, -30 },
  { 8439, 27, 29, 34, 4, -29 },
  { 8537, 24, 31, 34, 5, -30 },
  { 8630, 27, 39, 34, 2, -39 },
  { 8762, 19, 30, 34, 7, -29 },
  { 8834, 23, 29, 34, 5, -29 },
  { 8918, 29, 29, 34, 2, -29 },
  { 9024, 24, 29, 34, 5, -29 },
  { 9111, 24, 40, 34, 5, -29 },
  { 9231, 22, 29, 34, 6, -29 },
  { 9311, 21, 51, 34, 6, -43 },
  { 9445, 1, 51, 34, 16, -43 },
  { 9452, 21, 51, 34, 6, -43 },
  { 9586, 27, 10, 34, 3, -22 },
};

const GFXfont IBMPlexMono_Thin56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_THIN56PT7B_H_
