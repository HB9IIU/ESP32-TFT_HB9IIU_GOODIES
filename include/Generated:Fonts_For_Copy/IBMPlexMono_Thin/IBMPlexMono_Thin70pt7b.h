#ifndef _IBMPLEXMONO_THIN70PT7B_H_
#define _IBMPLEXMONO_THIN70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x42, 0x44, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x80, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xE0, 0x87, 0x80, 0x03, 0x00, 0x80, 0xE0, 0x0C, 0x00,
  0x80, 0x30, 0x18, 0x00, 0x80, 0x1C, 0x30, 0x00, 0x80, 0x0C, 0x30, 0x00,
  0x80, 0x06, 0x60, 0x00, 0x80, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x80, 0x00, 0x40, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x80, 0x00, 0x40, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x03, 0x80, 0x80, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00,
  0x80, 0xE0, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00,
  0x80, 0x02, 0xC0, 0x00, 0x80, 0x06, 0xE0, 0x00, 0x80, 0x04, 0x70, 0x00,
  0x80, 0x0C, 0x38, 0x00, 0x80, 0x18, 0x1C, 0x00, 0x80, 0x30, 0x07, 0x00,
  0x80, 0xC0, 0x01, 0xE0, 0x87, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x80, 0x18, 0x00, 0x00, 0x84, 0x00, 0x20, 0x00, 0x06, 0x30, 0x00, 0x40,
  0x00, 0x30, 0x80, 0x01, 0x80, 0x00, 0x86, 0x00, 0x02, 0x00, 0x06, 0x10,
  0x00, 0x08, 0x00, 0x10, 0x40, 0x00, 0x20, 0x00, 0xC1, 0x00, 0x00, 0xC0,
  0x06, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x04, 0x00, 0x03, 0x00,
  0x40, 0x10, 0x00, 0x08, 0x02, 0x00, 0x40, 0x00, 0x20, 0x18, 0x01, 0x80,
  0x00, 0x80, 0x40, 0x02, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x08,
  0x00, 0x10, 0x00, 0x80, 0x40, 0x00, 0x20, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x01,
  0x00, 0x00, 0x80, 0xC0, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x10, 0x00, 0x80, 0x40, 0x00, 0x60, 0x06, 0x01, 0x00, 0x00,
  0x80, 0x10, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x30, 0x00, 0x08, 0x06, 0x00,
  0xC0, 0x00, 0x20, 0x10, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x03,
  0x02, 0x00, 0x30, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x00, 0x20, 0xC0, 0x03,
  0x00, 0x00, 0x82, 0x00, 0x04, 0x00, 0x02, 0x18, 0x00, 0x10, 0x00, 0x18,
  0x40, 0x00, 0x60, 0x00, 0x43, 0x00, 0x00, 0x80, 0x03, 0x18, 0x00, 0x03,
  0x00, 0x08, 0x40, 0x00, 0x06, 0x00, 0x43, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x01, 0xFC, 0x30,
  0x18, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x04, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x60, 0x03, 0x00, 0x10, 0x18, 0x00, 0x30, 0x02, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x18, 0x18, 0x00, 0x02, 0x03, 0x03, 0x00, 0x00,
  0x20, 0x60, 0x60, 0x00, 0x06, 0x08, 0x0C, 0x00, 0x00, 0x61, 0x01, 0x80,
  0x00, 0x06, 0x20, 0x30, 0x00, 0x00, 0x6C, 0x06, 0x00, 0x00, 0x05, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x01,
  0x40, 0x20, 0x00, 0x00, 0x6C, 0x06, 0x00, 0x00, 0x08, 0xC0, 0x60, 0x00,
  0x03, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x70, 0x0E, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x2F, 0x00, 0x06, 0x00, 0x0F, 0x1E, 0x00, 0x60,
  0x07, 0x80, 0x3E, 0x06, 0x07, 0xC0, 0x00, 0x7C, 0x63, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x18,
  0x30, 0x60, 0x83, 0x06, 0x08, 0x10, 0x60, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x03, 0xFF, 0x00, 0x18, 0x60, 0x0E, 0x00, 0xCC, 0x00, 0x0C, 0x04, 0x80,
  0x00, 0x30, 0x28, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x1F, 0xE0, 0x00, 0x83, 0x80, 0x70, 0x06,
  0x30, 0x00, 0x70, 0x19, 0x80, 0x00, 0x60, 0x48, 0x00, 0x00, 0xC1, 0x60,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x04, 0xE0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x81, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x0F, 0x18, 0x00, 0x00, 0x28, 0x30, 0x00, 0x01, 0x20, 0x60, 0x00, 0x08,
  0x80, 0xE0, 0x00, 0xC6, 0x00, 0xE0, 0x1C, 0x10, 0x00, 0x7F, 0xC0, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x1E, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x04,
  0x08, 0x30, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x10, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x18, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x10, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xE1, 0xC0, 0x07, 0x06, 0x38, 0x01, 0x80, 0x36, 0x00, 0x60, 0x02,
  0xC0, 0x18, 0x00, 0x38, 0x02, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x08, 0x00, 0x06,
  0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x04, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x60, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30,
  0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x00, 0x80, 0x03, 0xC0,
  0x18, 0x00, 0xB8, 0x01, 0x80, 0x27, 0x00, 0x0F, 0x78, 0xA0, 0x00, 0x10,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x10, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x04, 0x00, 0x07, 0x80, 0x20, 0x00, 0x07, 0x01, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x70, 0x10, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x38, 0x40, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0x60, 0xC0, 0x00, 0x02, 0xC0, 0x80, 0x00, 0x09, 0x80, 0xC0, 0x00, 0x23,
  0x00, 0xC0, 0x01, 0x86, 0x00, 0x70, 0x0E, 0x0C, 0x00, 0x1F, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x21, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x02, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x08, 0x0D, 0x80, 0x00, 0x20,
  0x62, 0x00, 0x00, 0x83, 0x0C, 0x00, 0x02, 0x18, 0x18, 0x00, 0x08, 0xC0,
  0x20, 0x00, 0x22, 0x00, 0xC0, 0x00, 0x90, 0x01, 0x80, 0x02, 0xC0, 0x02,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x80, 0x00, 0x20,
  0x02, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x20, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x01, 0x6C, 0x00,
  0x00, 0x0D, 0x90, 0x00, 0x00, 0x26, 0x60, 0x00, 0x01, 0x98, 0x80, 0x00,
  0x04, 0x63, 0x00, 0x00, 0x31, 0x8C, 0x00, 0x00, 0x86, 0x18, 0x00, 0x02,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x80, 0x00, 0x41, 0x83, 0x00, 0x03, 0x06,
  0x04, 0x00, 0x08, 0x18, 0x18, 0x00, 0x60, 0x60, 0x20, 0x01, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x01, 0x00, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08,
  0x04, 0x01, 0x80, 0x30, 0x10, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x01, 0x02,
  0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x08, 0x40, 0x06, 0x00, 0x33, 0x00,
  0x18, 0x00, 0x48, 0x00, 0x60, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x01, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x08, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x04, 0x00,
  0x00, 0x70, 0x20, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x70, 0x80, 0x00,
  0x0E, 0x07, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x70, 0x20, 0x00, 0x00, 0xE1,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x70, 0x80, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xC0, 0x20,
  0x01, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x06, 0x00, 0x10, 0x00, 0x10, 0x00, 0x80, 0x00, 0xC0,
  0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x1C, 0x10, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x04, 0x70,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x08, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x08, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x40, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x18, 0x80, 0x03, 0x00, 0x04,
  0x20, 0x00, 0xC0, 0x01, 0x08, 0x00, 0x78, 0x00, 0x42, 0x00, 0x1A, 0x00,
  0x10, 0x80, 0x04, 0x80, 0x04, 0x30, 0x03, 0x30, 0x01, 0x0C, 0x00, 0xCC,
  0x00, 0xC3, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x08, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x03, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40,
  0x30, 0x30, 0x08, 0x10, 0x0C, 0x0C, 0x02, 0x04, 0x02, 0x01, 0x00, 0x81,
  0x81, 0x80, 0x60, 0x20, 0x60, 0x60, 0x18, 0x18, 0x18, 0x10, 0x02, 0x06,
  0x06, 0x04, 0x00, 0x81, 0x81, 0x83, 0x00, 0x30, 0x60, 0x20, 0x80, 0x04,
  0x18, 0x08, 0x20, 0x01, 0x04, 0x02, 0x18, 0x00, 0x61, 0x00, 0x86, 0x00,
  0x18, 0x40, 0x21, 0x00, 0x02, 0x10, 0x08, 0xC0, 0x00, 0xC4, 0x03, 0x30,
  0x00, 0x33, 0x00, 0xC8, 0x00, 0x04, 0xC0, 0x32, 0x00, 0x01, 0x30, 0x0D,
  0x80, 0x00, 0x6C, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0x80, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x01, 0x40, 0x60, 0x00, 0x01, 0x40, 0x20, 0x00, 0x02, 0x40, 0x10,
  0x00, 0x04, 0x40, 0x0C, 0x00, 0x18, 0x40, 0x07, 0x00, 0xF0, 0x7F, 0x00,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x83, 0x80, 0x70,
  0x11, 0xC0, 0x03, 0x02, 0x60, 0x00, 0x10, 0x58, 0x00, 0x01, 0x0A, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x65, 0x00, 0x00, 0x08, 0xB0, 0x00, 0x02,
  0x13, 0x00, 0x00, 0x82, 0x38, 0x00, 0x60, 0x41, 0xC0, 0x38, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x01, 0xFE, 0x01, 0x01, 0xC0, 0x38, 0x20, 0x60, 0x01, 0x84,
  0x10, 0x00, 0x0C, 0x84, 0x00, 0x00, 0xD1, 0x00, 0x00, 0x0A, 0x60, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x05, 0x08, 0x00, 0x01, 0xA0, 0x80, 0x00, 0x64,
  0x0C, 0x00, 0x30, 0x80, 0xE0, 0x1C, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x40, 0x00, 0x0E, 0x03, 0xA0, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x01, 0xFF, 0x00, 0x83, 0x80, 0xE0, 0x46, 0x00, 0x0C, 0x26, 0x00,
  0x03, 0x16, 0x00, 0x00, 0xCA, 0x00, 0x00, 0x26, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x7F, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x0C, 0x00, 0x80, 0x01, 0xC0, 0x04, 0x00, 0x18, 0x00, 0x20, 0x01,
  0x80, 0x01, 0x00, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x10, 0x36, 0x00, 0x00, 0x83, 0x18, 0x00, 0x04,
  0x30, 0x60, 0x00, 0x23, 0x01, 0x80, 0x01, 0x30, 0x06, 0x00, 0x0B, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x07, 0xF0, 0xCC, 0x0C, 0x1C, 0x18, 0xD8, 0x06, 0x30, 0x0C,
  0xF0, 0x03, 0x20, 0x06, 0xE0, 0x01, 0x40, 0x02, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0xFF, 0x80, 0x41, 0xC0, 0x70, 0x23, 0x00,
  0x06, 0x13, 0x00, 0x01, 0x8B, 0x00, 0x00, 0x65, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x10, 0x70, 0x0E, 0x02, 0x38, 0x00, 0x60, 0x4C, 0x00, 0x02,
  0x0B, 0x00, 0x00, 0x21, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0xA0,
  0x00, 0x01, 0x16, 0x00, 0x00, 0x42, 0x60, 0x00, 0x10, 0x47, 0x00, 0x0C,
  0x08, 0x38, 0x07, 0x01, 0x00, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x07, 0x04, 0x0C,
  0x00, 0x30, 0x82, 0x00, 0x01, 0x90, 0x80, 0x00, 0x1A, 0x20, 0x00, 0x01,
  0x4C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0xA1, 0x00, 0x00, 0x34, 0x10,
  0x00, 0x0C, 0x81, 0x80, 0x06, 0x10, 0x1C, 0x03, 0x82, 0x00, 0x7F, 0x80,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x40, 0x00, 0x05, 0x30, 0x00,
  0x06, 0x8C, 0x00, 0x06, 0x43, 0x00, 0x06, 0x20, 0x70, 0x1C, 0x10, 0x0F,
  0xF8, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x09,
  0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x34, 0x00, 0x09, 0x80, 0x02, 0x40,
  0x01, 0x98, 0x00, 0x24, 0x00, 0x10, 0x80, 0x02, 0x60, 0x01, 0x08, 0x00,
  0x66, 0x00, 0x30, 0xC0, 0x06, 0x20, 0x03, 0x04, 0x00, 0x42, 0x00, 0x20,
  0x40, 0x04, 0x20, 0x02, 0x04, 0x00, 0x43, 0x00, 0x60, 0x60, 0x0C, 0x30,
  0x04, 0x02, 0x00, 0xC1, 0x00, 0x40, 0x20, 0x08, 0x10, 0x04, 0x02, 0x00,
  0x81, 0x00, 0xC0, 0x30, 0x08, 0x18, 0x08, 0x01, 0x00, 0x81, 0x80, 0x80,
  0x10, 0x18, 0x08, 0x08, 0x01, 0x01, 0x00, 0x81, 0x80, 0x18, 0x10, 0x08,
  0x10, 0x00, 0x81, 0x00, 0x81, 0x00, 0x08, 0x10, 0x0C, 0x10, 0x00, 0x83,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x04, 0x20, 0x00, 0x42, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x04, 0x20, 0x00, 0x62, 0x00, 0x66, 0x00, 0x06, 0x60, 0x06,
  0x40, 0x00, 0x26, 0x00, 0x24, 0x00, 0x02, 0x40, 0x02, 0xC0, 0x00, 0x34,
  0x00, 0x28, 0x00, 0x01, 0x40, 0x03, 0x80, 0x00, 0x14, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x41, 0x86, 0x00, 0x00, 0x30, 0x80, 0x40,
  0x00, 0x08, 0x40, 0x08, 0x00, 0x02, 0x30, 0x01, 0x00, 0x00, 0x88, 0x00,
  0x20, 0x00, 0x66, 0x00, 0x04, 0x00, 0x11, 0x00, 0x00, 0x80, 0x0C, 0x40,
  0x00, 0x30, 0x02, 0x30, 0x00, 0x02, 0x01, 0x0C, 0x00, 0x00, 0x61, 0x82,
  0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph IBMPlexMono_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 4, 49, 42, 19, -49 },
  { 26, 10, 18, 42, 16, -52 },
  { 49, 38, 49, 42, 2, -49 },
  { 282, 32, 65, 42, 5, -57 },
  { 542, 38, 51, 42, 2, -50 },
  { 785, 35, 51, 42, 3, -50 },
  { 1009, 2, 18, 42, 20, -52 },
  { 1014, 16, 63, 42, 17, -53 },
  { 1140, 16, 63, 42, 9, -53 },
  { 1266, 36, 35, 42, 3, -38 },
  { 1424, 34, 33, 42, 4, -38 },
  { 1565, 7, 17, 42, 16, -5 },
  { 1580, 18, 1, 42, 12, -22 },
  { 1583, 4, 4, 42, 19, -4 },
  { 1585, 28, 63, 42, 7, -53 },
  { 1806, 32, 51, 42, 5, -50 },
  { 2010, 33, 49, 42, 6, -49 },
  { 2213, 30, 50, 42, 6, -50 },
  { 2401, 29, 51, 42, 5, -50 },
  { 2586, 36, 49, 42, 3, -49 },
  { 2807, 29, 50, 42, 6, -49 },
  { 2989, 30, 50, 42, 6, -49 },
  { 3177, 31, 49, 42, 5, -49 },
  { 3367, 32, 51, 42, 5, -50 },
  { 3571, 30, 50, 42, 6, -50 },
  { 3759, 4, 36, 42, 19, -36 },
  { 3777, 7, 48, 42, 16, -36 },
  { 3819, 30, 37, 42, 6, -40 },
  { 3958, 34, 13, 42, 4, -28 },
  { 4014, 30, 37, 42, 6, -40 },
  { 4153, 28, 50, 42, 7, -50 },
  { 4328, 27, 57, 42, 7, -50 },
  { 4521, 34, 49, 42, 4, -49 },
  { 4730, 29, 49, 42, 7, -49 },
  { 4908, 30, 51, 42, 6, -50 },
  { 5100, 29, 49, 42, 8, -49 },
  { 5278, 28, 49, 42, 8, -49 },
  { 5450, 28, 49, 42, 8, -49 },
  { 5622, 31, 51, 42, 5, -50 },
  { 5820, 28, 49, 42, 7, -49 },
  { 5992, 30, 49, 42, 6, -49 },
  { 6176, 25, 50, 42, 7, -49 },
  { 6333, 30, 49, 42, 8, -49 },
  { 6517, 27, 49, 42, 10, -49 },
  { 6683, 30, 49, 42, 6, -49 },
  { 6867, 28, 49, 42, 7, -49 },
  { 7039, 32, 51, 42, 5, -50 },
  { 7243, 29, 49, 42, 8, -49 },
  { 7421, 32, 59, 42, 5, -50 },
  { 7657, 29, 49, 42, 8, -49 },
  { 7835, 32, 51, 42, 5, -50 },
  { 8039, 36, 49, 42, 3, -49 },
  { 8260, 28, 50, 42, 7, -49 },
  { 8435, 34, 49, 42, 4, -49 },
  { 8644, 34, 49, 42, 4, -49 },
  { 8853, 36, 49, 42, 3, -49 },
  { 9074, 38, 49, 42, 2, -49 },
  { 9307, 36, 49, 42, 3, -49 },
  { 9528, 16, 63, 42, 19, -53 },
  { 9654, 28, 63, 42, 7, -53 },
  { 9875, 16, 63, 42, 7, -53 },
  { 10001, 32, 26, 42, 5, -49 },
  { 10105, 34, 1, 42, 4, 9 },
  { 10110, 9, 11, 42, 14, -53 },
  { 10123, 32, 38, 42, 5, -37 },
  { 10275, 27, 53, 42, 9, -52 },
  { 10454, 27, 38, 42, 8, -37 },
  { 10583, 27, 53, 42, 6, -52 },
  { 10762, 30, 38, 42, 6, -37 },
  { 10905, 31, 52, 42, 6, -52 },
  { 11107, 33, 54, 42, 6, -39 },
  { 11330, 25, 52, 42, 9, -52 },
  { 11493, 29, 52, 42, 8, -52 },
  { 11682, 24, 66, 42, 7, -52 },
  { 11880, 29, 52, 42, 10, -52 },
  { 12069, 30, 52, 42, 6, -52 },
  { 12264, 32, 37, 42, 5, -37 },
  { 12412, 25, 37, 42, 9, -37 },
  { 12528, 30, 38, 42, 6, -37 },
  { 12671, 27, 51, 42, 9, -37 },
  { 12844, 27, 51, 42, 6, -37 },
  { 13017, 33, 36, 42, 6, -36 },
  { 13166, 30, 38, 42, 6, -37 },
  { 13309, 34, 49, 42, 3, -49 },
  { 13518, 25, 37, 42, 8, -36 },
  { 13634, 28, 36, 42, 7, -36 },
  { 13760, 36, 36, 42, 3, -36 },
  { 13922, 30, 36, 42, 6, -36 },
  { 14057, 30, 50, 42, 6, -36 },
  { 14245, 28, 36, 42, 7, -36 },
  { 14371, 26, 63, 42, 8, -53 },
  { 14576, 2, 63, 42, 20, -53 },
  { 14592, 26, 63, 42, 8, -53 },
  { 14797, 34, 12, 42, 4, -27 },
};

const GFXfont IBMPlexMono_Thin70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_THIN70PT7B_H_
