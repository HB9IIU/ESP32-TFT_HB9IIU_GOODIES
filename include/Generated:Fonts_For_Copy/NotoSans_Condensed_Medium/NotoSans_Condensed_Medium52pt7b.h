#ifndef _NOTOSANS_CONDENSED_MEDIUM52PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0xFC,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xBC, 0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x38, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x81, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x71, 0xE3, 0xE3, 0x81, 0x1F, 0x1C,
  0x01, 0xF0, 0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38, 0x01, 0xF1, 0xC0, 0x0F,
  0xCE, 0x00, 0x7F, 0x70, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0E, 0xFE, 0x00,
  0x73, 0xF0, 0x03, 0x8F, 0x80, 0x1C, 0x3E, 0x00, 0xE1, 0xF0, 0x07, 0x0F,
  0x80, 0x38, 0x7B, 0x01, 0xC7, 0xDF, 0x0E, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x0F, 0x00,
  0x1F, 0xF8, 0x01, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0xF0, 0xF0, 0x0F,
  0x00, 0x1E, 0x1E, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x78, 0x00, 0xF0, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x83, 0xE0, 0x03, 0xC0, 0xF0, 0x78, 0x00, 0x78,
  0x1E, 0x1F, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0x78, 0x78, 0x00,
  0x3C, 0x0F, 0x1E, 0x00, 0x07, 0x81, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0xF8,
  0xFE, 0x0F, 0x0F, 0x1E, 0x3F, 0xE1, 0xE1, 0xE3, 0xCF, 0xFE, 0x3E, 0x7C,
  0xF1, 0xE3, 0xC3, 0xFF, 0x1E, 0x3C, 0x3C, 0x7F, 0xC7, 0x8F, 0x07, 0x87,
  0xF8, 0xF1, 0xE0, 0xF0, 0x38, 0x3E, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x83,
  0xE0, 0x00, 0xF0, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x0F, 0x80, 0x07, 0x83,
  0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x3E, 0x00, 0x3C, 0x0F, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x3C, 0x07, 0x83, 0xC0,
  0x0F, 0x00, 0x78, 0xF8, 0x01, 0xE0, 0x0F, 0x9E, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0x0F, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x07, 0xC3,
  0xF7, 0xE0, 0x7C, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0xFC, 0x1F,
  0x8F, 0x8F, 0x80, 0xFD, 0xF8, 0xF8, 0x07, 0xFF, 0x0F, 0x80, 0x3F, 0xF0,
  0xF8, 0x03, 0xFE, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E,
  0x78, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0xF8, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x40, 0xF0, 0x6F, 0xCF,
  0x3E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x83,
  0xF0, 0xFC, 0x1E, 0x0F, 0x00, 0x60, 0x60, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9F, 0x08, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C,
  0x7E, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xDF, 0xDF,
  0xFE, 0x7D, 0xF1, 0xF3, 0x87, 0xC4, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3E, 0x07, 0xF0, 0xE0, 0x1F, 0x84, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xC0, 0xFE, 0x30, 0x07,
  0xE2, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x07, 0xEF, 0x01, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x01,
  0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x78,
  0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7C, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE8, 0x00, 0xFC, 0xF0, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x60, 0x0F, 0x1F,
  0xE0, 0xF9, 0xFF, 0xC7, 0xDF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x0F, 0xEF,
  0xE0, 0x3F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0xFD, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x03, 0xF0, 0xFC, 0x3F,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7,
  0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xCF, 0xE0, 0xFC, 0x3F, 0x8F, 0xC0, 0xFE, 0x7C, 0x03, 0xF7, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xDF, 0x00,
  0xFE, 0xFE, 0x1F, 0xE3, 0xFF, 0xEF, 0x1F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC0,
  0xFF, 0x3E, 0x01, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x82, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x1F, 0x7F, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0x3E, 0x7E, 0x7F, 0x7F,
  0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0x81, 0xF9,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x3F, 0xF0, 0x78, 0xF0, 0x1F, 0xFE,
  0x1E, 0x3C, 0x0F, 0xFF, 0x87, 0x8F, 0x07, 0xC3, 0xE0, 0xF7, 0x81, 0xE0,
  0xF8, 0x3D, 0xE0, 0xF8, 0x3E, 0x0F, 0x78, 0x3C, 0x0F, 0x83, 0xDE, 0x0F,
  0x03, 0xC0, 0xF7, 0x83, 0xC0, 0xF0, 0x3D, 0xE1, 0xF0, 0x3C, 0x0F, 0x78,
  0x7C, 0x0F, 0x03, 0xFE, 0x1F, 0x03, 0xC0, 0xFF, 0x87, 0xC0, 0xF0, 0x3D,
  0xE1, 0xF0, 0x3C, 0x0F, 0x78, 0x3C, 0x1F, 0x07, 0x9E, 0x0F, 0x07, 0xC1,
  0xE7, 0x83, 0xE1, 0xF8, 0xF9, 0xE0, 0xFD, 0xEF, 0x7C, 0x78, 0x1F, 0xFB,
  0xFE, 0x1F, 0x03, 0xFC, 0x7F, 0x83, 0xC0, 0x7E, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF8, 0x1F, 0xF3,
  0xE0, 0x0F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x3F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x07, 0xF3, 0xE0, 0x07, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBE,
  0x00, 0xFE, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x81, 0xE1, 0xFC, 0x00, 0x8F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x08, 0x7F,
  0xC1, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF8, 0xF8, 0x01,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0xF8, 0x03,
  0xF8, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0x80, 0xF8, 0x7F, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7F, 0x00,
  0x1F, 0x1F, 0xC0, 0x0F, 0x8F, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0xCF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F,
  0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F,
  0x80, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xCF, 0xC0,
  0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0,
  0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xEF, 0xFD, 0xE0, 0x00, 0xF7, 0xFE, 0xF8, 0x00, 0xFB,
  0xFF, 0x7C, 0x00, 0x79, 0xFF, 0x9E, 0x00, 0x3C, 0xFF, 0xCF, 0x80, 0x3E,
  0x7F, 0xE7, 0xC0, 0x1F, 0x3F, 0xF1, 0xE0, 0x0F, 0x1F, 0xF8, 0xF8, 0x0F,
  0x8F, 0xFC, 0x7C, 0x07, 0xC7, 0xFE, 0x3E, 0x03, 0xC3, 0xFF, 0x0F, 0x03,
  0xE1, 0xFF, 0x87, 0xC1, 0xF0, 0xFF, 0xC3, 0xE0, 0xF0, 0x7F, 0xE0, 0xF0,
  0x78, 0x3F, 0xF0, 0x7C, 0x7C, 0x1F, 0xF8, 0x3E, 0x3C, 0x0F, 0xFC, 0x0F,
  0x1E, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xFF, 0x03, 0xEF, 0x81, 0xFF, 0x81,
  0xF7, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xFE,
  0x01, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xF8,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFD, 0xF0, 0x07, 0xFE, 0xFC, 0x03, 0xFF, 0x3E,
  0x01, 0xFF, 0x9F, 0x80, 0xFF, 0xC7, 0xC0, 0x7F, 0xE3, 0xF0, 0x3F, 0xF0,
  0xF8, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0xC3, 0xFF,
  0x03, 0xE1, 0xFF, 0x81, 0xF8, 0xFF, 0xC0, 0x7C, 0x7F, 0xE0, 0x3F, 0x3F,
  0xF0, 0x0F, 0x8F, 0xF8, 0x07, 0xE7, 0xFC, 0x03, 0xF3, 0xFE, 0x00, 0xF9,
  0xFF, 0x00, 0x7E, 0xFF, 0x80, 0x1F, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x03,
  0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x7F, 0xEF, 0x80, 0x7E, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xFE, 0x3F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x00,
  0xFE, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0x7C, 0x7E, 0x00,
  0xC7, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE8, 0x00, 0x7E, 0xE0, 0x07, 0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x7F,
  0xC3, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xDF, 0x00, 0x1F, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x3E,
  0x00, 0xF7, 0x80, 0x3E, 0x1F, 0x00, 0x7B, 0xC0, 0x1F, 0x0F, 0xC0, 0x3D,
  0xE0, 0x1F, 0x83, 0xE0, 0x3E, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x9E, 0x03, 0xE0, 0x7C, 0x07, 0x8F, 0x01, 0xF0, 0x1F,
  0x03, 0xC7, 0xC1, 0xF8, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x07, 0xC1, 0xF1,
  0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x78, 0x3E, 0x01, 0xF8, 0x78, 0x3C, 0x1F,
  0x00, 0x7C, 0x7C, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0x80,
  0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x3E, 0xF8,
  0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00, 0x0F,
  0x78, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F,
  0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xE7,
  0x80, 0x03, 0xC7, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x81,
  0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0x78, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0x20, 0x00, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF,
  0x9F, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xEF, 0xFF,
  0xBD, 0xFF, 0xE7, 0x9F, 0xF8, 0xF1, 0xFE, 0x1E, 0x06, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x30, 0x0F, 0x8F, 0xF0, 0x7D, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1E, 0xFF, 0xF8, 0xFF, 0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x00,
  0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xF9, 0xFE, 0x0F, 0xCF, 0xFF, 0xFC,
  0x7B, 0xFF, 0xE3, 0xCF, 0xFE, 0x1E, 0x1F, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0,
  0x43, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0x3F, 0x81, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x81, 0xF0, 0x7F, 0x8F, 0x87, 0xFF, 0x7C, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0x07, 0xF9, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F,
  0xCF, 0x80, 0x7E, 0x7E, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xBC, 0x3F,
  0xF9, 0xE0, 0xFF, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0x7E, 0x3E, 0x03,
  0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0x3F, 0x80, 0x61, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC3, 0xC3,
  0xFF, 0x9E, 0x3F, 0xFE, 0xF1, 0xFF, 0xF7, 0x9F, 0x83, 0xFC, 0xF8, 0x0F,
  0xEF, 0xC0, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3F, 0x07, 0xF9,
  0xFF, 0xFF, 0xC7, 0xFF, 0xBE, 0x1F, 0xFD, 0xF0, 0x7F, 0x8F, 0x80, 0x60,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x40, 0x07, 0xE3, 0x80, 0x7F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x08, 0x0F, 0x9F,
  0xF1, 0xF7, 0xFF, 0x3D, 0xFF, 0xF7, 0xBF, 0xFE, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x31, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00,
  0x00, 0x1F, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x01,
  0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF,
  0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0,
  0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0x87,
  0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x40, 0x78, 0xFF, 0x03, 0xFE, 0x3C,
  0xFF, 0xE3, 0xFF, 0x9E, 0xFF, 0xF3, 0xFF, 0xCF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xF0, 0x7F, 0xC1, 0xFB, 0xF0, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xE0, 0x3F,
  0xF8, 0x07, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03,
  0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00,
  0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0,
  0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C,
  0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F,
  0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01,
  0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x38, 0x1E, 0x3F, 0xE3, 0xCF, 0xFE, 0x7B, 0xFF,
  0xEF, 0x7F, 0xFD, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x07, 0x8F, 0xF8, 0x3C, 0xFF, 0xE1, 0xEF, 0xFF, 0x8F, 0x7F, 0xFC,
  0x7F, 0x03, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0xDF,
  0xC0, 0xFC, 0xFF, 0x0F, 0xE7, 0xBF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF7, 0xFF,
  0x0F, 0x8F, 0xF0, 0x7C, 0x08, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x3F, 0xC3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF1, 0xFF, 0xF7,
  0x9F, 0x83, 0xFC, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x3F, 0x07, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xBE, 0x1F, 0xFD,
  0xF0, 0x7F, 0x8F, 0x80, 0x60, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x33, 0xC3, 0xFF, 0x1F, 0xBC, 0xFE, 0xF7, 0xFB, 0xDF, 0xEF, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xE7, 0xE0, 0x33, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7D, 0x00, 0x3E, 0xE0, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0x87, 0xFF, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x11, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x04, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFE, 0xF3, 0xFF,
  0xEF, 0x1F, 0xFC, 0xF0, 0xFF, 0x0F, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F,
  0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x3C,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x7F, 0x00, 0x7D, 0xF0,
  0x0F, 0xE0, 0x1F, 0x3E, 0x01, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C,
  0x7C, 0x07, 0xF8, 0x0F, 0x8F, 0x81, 0xEF, 0x03, 0xE1, 0xF0, 0x3D, 0xE0,
  0x7C, 0x3E, 0x07, 0xBE, 0x0F, 0x83, 0xE0, 0xF3, 0xC1, 0xF0, 0x7C, 0x3E,
  0x78, 0x3C, 0x0F, 0x87, 0x8F, 0x0F, 0x81, 0xF0, 0xF1, 0xE1, 0xF0, 0x1F,
  0x1E, 0x3E, 0x3E, 0x03, 0xE3, 0xC3, 0xC7, 0x80, 0x7C, 0xF8, 0x79, 0xF0,
  0x0F, 0x9E, 0x0F, 0x3E, 0x00, 0xF3, 0xC1, 0xE7, 0xC0, 0x1E, 0x78, 0x3E,
  0xF8, 0x03, 0xEF, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x7B, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x80,
  0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7E, 0x3E, 0x01,
  0xF3, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF8,
  0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0,
  0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x7F, 0x03, 0xFE, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFA, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 38, 13, 3, -37 },
  { 35, 15, 13, 21, 3, -37 },
  { 60, 25, 37, 27, 1, -37 },
  { 176, 21, 42, 25, 2, -39 },
  { 287, 35, 38, 39, 2, -38 },
  { 454, 28, 39, 30, 2, -38 },
  { 591, 6, 13, 12, 3, -37 },
  { 601, 12, 45, 16, 2, -37 },
  { 669, 12, 45, 16, 1, -37 },
  { 737, 20, 20, 24, 2, -40 },
  { 787, 21, 25, 25, 2, -31 },
  { 853, 8, 13, 13, 2, -6 },
  { 866, 12, 4, 15, 2, -16 },
  { 872, 7, 8, 13, 3, -7 },
  { 879, 18, 37, 20, 1, -37 },
  { 963, 21, 39, 25, 2, -38 },
  { 1066, 14, 37, 25, 3, -37 },
  { 1131, 21, 38, 25, 2, -38 },
  { 1231, 20, 39, 25, 2, -38 },
  { 1329, 23, 37, 25, 1, -37 },
  { 1436, 20, 38, 25, 3, -37 },
  { 1531, 21, 39, 25, 2, -38 },
  { 1634, 21, 37, 25, 2, -37 },
  { 1732, 21, 39, 25, 2, -38 },
  { 1835, 21, 39, 25, 2, -38 },
  { 1938, 7, 29, 13, 3, -28 },
  { 1964, 8, 35, 13, 2, -28 },
  { 1999, 21, 25, 25, 2, -31 },
  { 2065, 21, 15, 25, 2, -26 },
  { 2105, 21, 25, 25, 2, -31 },
  { 2171, 17, 39, 19, 1, -38 },
  { 2254, 34, 41, 38, 2, -37 },
  { 2429, 27, 37, 27, 0, -37 },
  { 2554, 22, 37, 28, 4, -37 },
  { 2656, 22, 39, 27, 3, -38 },
  { 2764, 24, 37, 31, 4, -37 },
  { 2875, 17, 37, 24, 4, -37 },
  { 2954, 17, 37, 23, 4, -37 },
  { 3033, 25, 39, 31, 3, -38 },
  { 3155, 24, 37, 32, 4, -37 },
  { 3266, 12, 37, 16, 2, -37 },
  { 3322, 12, 47, 13, -3, -37 },
  { 3393, 23, 37, 27, 4, -37 },
  { 3500, 17, 37, 22, 4, -37 },
  { 3579, 33, 37, 41, 4, -37 },
  { 3732, 25, 37, 33, 4, -37 },
  { 3848, 27, 39, 33, 3, -38 },
  { 3980, 20, 37, 26, 4, -37 },
  { 4073, 27, 47, 33, 3, -38 },
  { 4232, 23, 37, 27, 4, -37 },
  { 4339, 20, 39, 24, 2, -38 },
  { 4437, 22, 37, 23, 1, -37 },
  { 4539, 23, 38, 31, 4, -37 },
  { 4649, 26, 37, 26, 0, -37 },
  { 4770, 41, 37, 41, 0, -37 },
  { 4960, 25, 37, 25, 0, -37 },
  { 5076, 24, 37, 24, 0, -37 },
  { 5187, 20, 37, 23, 1, -37 },
  { 5280, 11, 45, 16, 4, -37 },
  { 5342, 18, 37, 20, 1, -37 },
  { 5426, 12, 45, 16, 1, -37 },
  { 5494, 24, 21, 26, 1, -37 },
  { 5557, 22, 4, 22, 0, 4 },
  { 5568, 11, 8, 15, 2, -40 },
  { 5579, 19, 30, 25, 2, -29 },
  { 5651, 21, 41, 27, 4, -40 },
  { 5759, 18, 30, 21, 2, -29 },
  { 5827, 21, 41, 27, 2, -40 },
  { 5935, 20, 30, 25, 2, -29 },
  { 6010, 16, 40, 15, 1, -40 },
  { 6090, 21, 41, 27, 2, -29 },
  { 6198, 19, 40, 27, 4, -40 },
  { 6293, 6, 39, 12, 3, -39 },
  { 6323, 11, 51, 12, -2, -39 },
  { 6394, 20, 40, 24, 4, -40 },
  { 6494, 5, 40, 12, 4, -40 },
  { 6519, 33, 29, 40, 4, -29 },
  { 6639, 19, 29, 27, 4, -29 },
  { 6708, 22, 30, 26, 2, -29 },
  { 6791, 21, 41, 27, 4, -29 },
  { 6899, 21, 41, 27, 2, -29 },
  { 7007, 14, 29, 18, 4, -29 },
  { 7058, 17, 30, 20, 2, -29 },
  { 7122, 14, 35, 16, 1, -34 },
  { 7184, 20, 29, 27, 3, -28 },
  { 7257, 22, 28, 22, 0, -28 },
  { 7334, 35, 28, 35, 0, -28 },
  { 7457, 21, 28, 23, 1, -28 },
  { 7531, 22, 40, 23, 0, -28 },
  { 7641, 17, 28, 19, 1, -28 },
  { 7701, 15, 45, 19, 2, -37 },
  { 7786, 4, 52, 24, 10, -40 },
  { 7812, 15, 45, 19, 2, -37 },
  { 7897, 21, 7, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Medium52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_MEDIUM52PT7B_H_
