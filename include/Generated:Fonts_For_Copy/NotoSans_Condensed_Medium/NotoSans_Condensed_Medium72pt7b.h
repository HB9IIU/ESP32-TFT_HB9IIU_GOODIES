#ifndef _NOTOSANS_CONDENSED_MEDIUM72PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0x7F, 0x9F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x9F, 0xE3, 0xF0, 0x78, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E,
  0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xEF, 0x1F, 0xC7, 0xF8, 0xF0, 0x1C, 0x7F, 0x0F, 0x00, 0x47,
  0xE0, 0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0xFE, 0x0F,
  0x00, 0x0F, 0xE0, 0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x07, 0xF0, 0xF0, 0x00,
  0x7F, 0x8F, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xF7, 0xFE, 0x00, 0x0F, 0x1F, 0xF0, 0x00, 0xF0,
  0xFF, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x7F, 0x80, 0x0F,
  0x07, 0xFE, 0x00, 0xF0, 0xFF, 0xFC, 0x0F, 0x1F, 0xEF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE1, 0xF8, 0x06, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0xC0, 0xFC, 0x07,
  0xC3, 0xF0, 0x7F, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0xFF, 0xF0, 0x7E, 0x0F,
  0xC3, 0xE1, 0xFF, 0xF8, 0x7E, 0x0F, 0xC7, 0xE3, 0xFF, 0xFC, 0x3F, 0x1F,
  0x87, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0x8F, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF,
  0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0xFE, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xFC,
  0x1F, 0x87, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0x80,
  0x7F, 0x83, 0xFE, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0xFF, 0x00, 0xFF,
  0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0xFF, 0x07,
  0xF0, 0x01, 0xFF, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x03,
  0xFF, 0xE0, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x0F, 0x80, 0x67, 0xE0, 0xF8, 0x3E,
  0x7F, 0xCF, 0xBF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3E, 0x03, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE3,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF8, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0xEF, 0xE7, 0xF9, 0xFD, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFE, 0xF8, 0x1F, 0xCE, 0x03, 0xF8, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xF0,
  0x07, 0xFC, 0x3C, 0x00, 0x3F, 0xC1, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFF,
  0xC7, 0xE0, 0x07, 0xFC, 0x38, 0x00, 0x3F, 0xC1, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x01, 0xFE, 0xC0, 0x00,
  0x3F, 0xEF, 0x80, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x3F,
  0x1F, 0xE0, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x7E,
  0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF8,
  0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0xE0, 0x07, 0xF0,
  0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7E, 0x00,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xC0,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFA, 0x00, 0x01, 0xFF, 0x60,
  0x00, 0x7F, 0xCF, 0x00, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0xFF, 0xC0, 0x3F, 0x1F,
  0xFF, 0x03, 0xF9, 0xFF, 0xFC, 0x1F, 0xDF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF,
  0xC7, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xCF,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07,
  0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xBF, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07,
  0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF7,
  0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF7, 0xF1, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0x7F,
  0x01, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x3E, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFC, 0xFC, 0x3C, 0x0F,
  0xC3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x07, 0xFE, 0x38, 0x01, 0xFE, 0x20, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x7C, 0x1F,
  0x80, 0x3F, 0xFF, 0xC0, 0xFC, 0x3E, 0x00, 0xFF, 0xFF, 0x81, 0xF8, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xF1, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xE3, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xDF, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0xBF, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFD, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xFB, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF7, 0xC0, 0x7E,
  0x00, 0xF8, 0x07, 0xFF, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0xFE, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7D, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF3, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x03,
  0xFC, 0x0F, 0x8F, 0xC0, 0x7E, 0x07, 0xF8, 0x3F, 0x1F, 0x80, 0xFE, 0x1E,
  0xF8, 0xFC, 0x3F, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x7E, 0x01, 0xFF, 0xF1,
  0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0x3F,
  0x80, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xF8, 0xFE, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFF, 0xBF, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0xFE,
  0x03, 0xFF, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x08, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0xFF, 0xE0, 0x0F, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xF8, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F,
  0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x07, 0xFE, 0x1F, 0xC0, 0x0F, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x7C, 0x0F,
  0xFC, 0x00, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0x8F, 0xFC, 0x00, 0x07,
  0xF0, 0xFF, 0xC0, 0x00, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x07,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xB0, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF,
  0x1F, 0xC0, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFE,
  0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xFF, 0xDF,
  0xC0, 0x00, 0x1F, 0xBF, 0xFE, 0x7E, 0x00, 0x00, 0xFD, 0xFF, 0xF3, 0xF0,
  0x00, 0x0F, 0xEF, 0xFF, 0x9F, 0xC0, 0x00, 0x7E, 0x7F, 0xFC, 0x7E, 0x00,
  0x03, 0xF3, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0xFF, 0x1F, 0xC0, 0x01,
  0xF8, 0xFF, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xFF, 0xE3, 0xF0, 0x00, 0xFE,
  0x3F, 0xFF, 0x1F, 0xC0, 0x07, 0xE1, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0x0F,
  0xFF, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xFF,
  0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x07, 0xE0, 0xFF, 0xFC,
  0x1F, 0x80, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0xFF, 0x03,
  0xF0, 0x1F, 0x81, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE,
  0x0F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0x87,
  0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x3F, 0x00, 0xFF, 0xFC, 0x07, 0xF1, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0xFF, 0x00, 0xFC, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xDF, 0xE0, 0x00, 0xFF, 0xF9,
  0xFC, 0x00, 0x1F, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0xE3, 0xF8, 0x00, 0x7F,
  0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0x87, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0x00,
  0x3F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xFC, 0x1F,
  0xC0, 0x1F, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xFE,
  0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFF, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFC, 0x01, 0xFC,
  0x1F, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0xFE, 0x00,
  0x7F, 0x8F, 0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0xF8, 0x00, 0xFF, 0x3F, 0xFF,
  0x00, 0x1F, 0xE7, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0xFC, 0x00, 0x3F, 0xDF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xCF, 0xE0,
  0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFC, 0xFE, 0x01,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0x80, 0x7F, 0xF0, 0x7F, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x3F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F,
  0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFD, 0xFC,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x7C, 0x7F, 0xC0,
  0x01, 0x8F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x40, 0x00, 0x1F, 0xEF,
  0x00, 0x07, 0xFD, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE7, 0xF0,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0x83, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x00, 0x1F,
  0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xF8, 0x3C,
  0x01, 0xFE, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xF7,
  0xFC, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xF7, 0xF8, 0x1F, 0xFD, 0xFF, 0xFF, 0xBF, 0x7F, 0xFF, 0xCF,
  0xCF, 0xFF, 0xF3, 0xF1, 0xFF, 0xF0, 0x7C, 0x3F, 0xF8, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x00,
  0xFE, 0x0F, 0xF8, 0x07, 0xF1, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xC1, 0xFD,
  0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0x80,
  0xFF, 0x9F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07,
  0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF8, 0x03, 0xFC, 0xFF, 0xE0, 0x3F, 0xE7,
  0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xF9, 0xFF, 0xFF, 0x0F, 0xC7,
  0xFF, 0xF0, 0x7E, 0x1F, 0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0,
  0x0C, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0x1F, 0xF0, 0x07, 0x1F, 0xFE, 0x7F, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0x80, 0x7F, 0x00, 0xFF, 0xC3, 0xF8, 0x1F, 0xFF, 0x1F, 0xC1, 0xFF, 0xFC,
  0xFE, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xDF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xF3,
  0xF0, 0x7F, 0xFF, 0x1F, 0x81, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0x03, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x21, 0xFF,
  0x00, 0x0C, 0x0F, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xC1, 0x80, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF,
  0xE3, 0xF0, 0xFF, 0xFF, 0x9F, 0x87, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFC, 0x07, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xDF,
  0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0xFF, 0xC7, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xBF, 0x83, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0x8F, 0xE0, 0x1F, 0xF8, 0x7F,
  0x00, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x20, 0x00, 0x0F, 0xF1, 0xC0, 0x00, 0xFF,
  0x8F, 0xC0, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x04, 0x00, 0xFE, 0x0F, 0xFC, 0x1F,
  0xC7, 0xFF, 0xC3, 0xF9, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x08, 0x3F, 0x9F, 0xCF,
  0xEF, 0xFF, 0xF9, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0x00, 0x20, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF9, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xCF, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x18, 0x03, 0xF0, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xC3, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0x03, 0xFE, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0xFF,
  0xF8, 0x7E, 0x3F, 0xFF, 0x8F, 0xCF, 0xFF, 0xF9, 0xFB, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x80, 0x07, 0xE0, 0x7F, 0xC0, 0x3F,
  0x0F, 0xFF, 0x81, 0xF8, 0xFF, 0xFE, 0x0F, 0xCF, 0xFF, 0xF8, 0x7E, 0x7F,
  0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0x1F, 0xFC, 0x07, 0xFC, 0xFF, 0xC0, 0x1F,
  0xE7, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE,
  0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0x7F, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0x83, 0xF8, 0xFF,
  0xF8, 0x1F, 0xC1, 0xFF, 0x80, 0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF,
  0x9F, 0x87, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xE7,
  0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xC7, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xF9,
  0xFC, 0x0F, 0xFF, 0x8F, 0xE0, 0x1F, 0xF8, 0x7F, 0x00, 0x1C, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xDF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xF0, 0xFE, 0x7F, 0x80, 0x18, 0xFE, 0x00, 0x11, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x80, 0x01, 0xFD, 0xE0, 0x07, 0xFB, 0xFC,
  0x7F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xE7, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xEF, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFF, 0xDF, 0x9F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFE, 0x7E,
  0x1F, 0xFF, 0x8F, 0xC1, 0xFF, 0xC0, 0xF8, 0x03, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xCF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0x7C, 0x00, 0xFE, 0x3F, 0x80, 0x3E, 0xF8, 0x01, 0xF8, 0x7F,
  0x00, 0xFD, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x03, 0xF8,
  0x1F, 0x8F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x1F, 0xC1,
  0xF0, 0x7C, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xC1, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x00, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7C, 0x07, 0xC7, 0xF0, 0x03, 0xF9, 0xF8,
  0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x00,
  0x7C, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0,
  0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x37, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0xC0, 0x00, 0x7F, 0xE2, 0x00, 0x00, 0x0C,
  0x00,
};

const GFXglyph NotoSans_Condensed_Medium72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 52, 18, 4, -51 },
  { 66, 21, 18, 29, 4, -51 },
  { 114, 34, 51, 38, 2, -51 },
  { 331, 28, 59, 35, 3, -55 },
  { 538, 48, 53, 54, 3, -52 },
  { 856, 39, 53, 41, 2, -52 },
  { 1115, 8, 18, 16, 4, -51 },
  { 1133, 17, 63, 22, 3, -52 },
  { 1267, 16, 63, 22, 2, -52 },
  { 1393, 28, 28, 33, 2, -55 },
  { 1491, 29, 35, 35, 3, -43 },
  { 1618, 11, 17, 18, 3, -8 },
  { 1642, 17, 7, 21, 2, -23 },
  { 1657, 9, 10, 18, 4, -9 },
  { 1669, 26, 52, 28, 1, -52 },
  { 1838, 28, 53, 34, 3, -52 },
  { 2024, 19, 51, 34, 5, -51 },
  { 2146, 28, 52, 34, 3, -52 },
  { 2328, 28, 53, 34, 3, -52 },
  { 2514, 32, 52, 34, 1, -52 },
  { 2722, 27, 52, 34, 4, -51 },
  { 2898, 29, 53, 34, 3, -52 },
  { 3091, 30, 51, 34, 2, -51 },
  { 3283, 29, 53, 34, 3, -52 },
  { 3476, 28, 53, 34, 3, -52 },
  { 3662, 9, 40, 18, 4, -39 },
  { 3707, 11, 48, 18, 2, -39 },
  { 3773, 30, 34, 35, 2, -43 },
  { 3901, 29, 21, 35, 3, -36 },
  { 3978, 29, 34, 35, 3, -43 },
  { 4102, 24, 53, 26, 1, -52 },
  { 4261, 47, 58, 53, 3, -52 },
  { 4602, 38, 51, 38, 0, -51 },
  { 4845, 30, 51, 39, 6, -51 },
  { 5037, 31, 53, 37, 4, -52 },
  { 5243, 33, 51, 42, 6, -51 },
  { 5454, 23, 51, 33, 6, -51 },
  { 5601, 23, 51, 31, 6, -51 },
  { 5748, 35, 53, 43, 4, -52 },
  { 5980, 32, 51, 44, 6, -51 },
  { 6184, 18, 51, 22, 2, -51 },
  { 6299, 17, 65, 18, -4, -51 },
  { 6438, 31, 51, 37, 6, -51 },
  { 6636, 23, 51, 31, 6, -51 },
  { 6783, 45, 51, 57, 6, -51 },
  { 7070, 35, 51, 46, 6, -51 },
  { 7294, 38, 53, 45, 4, -52 },
  { 7546, 28, 51, 36, 6, -51 },
  { 7725, 38, 64, 45, 4, -52 },
  { 8029, 31, 51, 38, 6, -51 },
  { 8227, 27, 53, 33, 3, -52 },
  { 8406, 30, 51, 32, 1, -51 },
  { 8598, 33, 52, 43, 5, -51 },
  { 8813, 37, 51, 37, 0, -51 },
  { 9049, 57, 51, 57, 0, -51 },
  { 9413, 34, 51, 34, 0, -51 },
  { 9630, 34, 51, 34, 0, -51 },
  { 9847, 28, 51, 31, 2, -51 },
  { 10026, 16, 64, 23, 5, -52 },
  { 10154, 26, 52, 28, 1, -52 },
  { 10323, 16, 64, 23, 2, -52 },
  { 10451, 32, 29, 36, 2, -51 },
  { 10567, 31, 5, 31, 0, 6 },
  { 10587, 15, 11, 21, 3, -55 },
  { 10608, 26, 41, 34, 3, -40 },
  { 10742, 29, 56, 37, 5, -55 },
  { 10945, 24, 41, 29, 3, -40 },
  { 11068, 29, 56, 37, 3, -55 },
  { 11271, 28, 41, 34, 3, -40 },
  { 11415, 22, 55, 21, 1, -55 },
  { 11567, 29, 57, 37, 3, -40 },
  { 11774, 27, 55, 37, 5, -55 },
  { 11960, 9, 54, 17, 4, -54 },
  { 12021, 15, 71, 17, -2, -54 },
  { 12155, 28, 55, 33, 5, -55 },
  { 12348, 7, 55, 17, 5, -55 },
  { 12397, 46, 40, 56, 5, -40 },
  { 12627, 27, 40, 37, 5, -40 },
  { 12762, 30, 41, 36, 3, -40 },
  { 12916, 29, 57, 37, 5, -40 },
  { 13123, 29, 57, 37, 3, -40 },
  { 13330, 19, 40, 25, 5, -40 },
  { 13425, 23, 41, 28, 3, -40 },
  { 13543, 20, 48, 22, 1, -47 },
  { 13663, 27, 40, 37, 5, -39 },
  { 13798, 31, 39, 31, 0, -39 },
  { 13950, 47, 39, 49, 1, -39 },
  { 14180, 29, 39, 31, 1, -39 },
  { 14322, 31, 56, 31, 0, -39 },
  { 14539, 23, 39, 26, 2, -39 },
  { 14652, 22, 64, 26, 2, -52 },
  { 14828, 7, 72, 33, 13, -55 },
  { 14891, 21, 64, 26, 3, -52 },
  { 15059, 30, 10, 35, 2, -30 },
};

const GFXfont NotoSans_Condensed_Medium72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_MEDIUM72PT7B_H_
