#ifndef _NOTOSANS_CONDENSED_MEDIUM19PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0x92, 0x48, 0x0F, 0x80, 0xCF, 0x3C, 0xF2, 0xC8, 0x09,
  0x06, 0x41, 0x90, 0x64, 0x7F, 0xDF, 0xF1, 0x20, 0x48, 0x32, 0x3F, 0xE3,
  0x60, 0x98, 0x26, 0x09, 0x00, 0x10, 0x7B, 0xFE, 0x8D, 0x1A, 0x1C, 0x1E,
  0x16, 0x24, 0x5F, 0xFF, 0xC2, 0x04, 0x00, 0x60, 0xCF, 0x08, 0x99, 0x89,
  0x90, 0x9B, 0x09, 0xB0, 0x9A, 0xFF, 0x6B, 0x65, 0x90, 0xD9, 0x09, 0x91,
  0x99, 0x18, 0xB3, 0x0E, 0x38, 0x1F, 0x06, 0x41, 0x90, 0x6C, 0x1B, 0x03,
  0x81, 0xE6, 0xDD, 0xB3, 0x6C, 0x73, 0x1C, 0xFF, 0x9F, 0x70, 0xFF, 0xC0,
  0x13, 0x66, 0xCC, 0xCC, 0xCC, 0xCC, 0xC4, 0x62, 0x30, 0xC3, 0x08, 0x63,
  0x0C, 0x63, 0x18, 0xC6, 0x31, 0x18, 0xCC, 0x60, 0x30, 0x23, 0xF9, 0xC3,
  0x9D, 0x92, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0xFB,
  0x60, 0xFF, 0xF8, 0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x08, 0x30, 0x60,
  0x83, 0x06, 0x18, 0x00, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x37, 0xCF, 0x80, 0x08, 0xDF, 0xF5, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x39, 0xFA, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x61, 0x83,
  0x0F, 0xFF, 0xC0, 0x39, 0xFA, 0x18, 0x30, 0x61, 0x9E, 0x3E, 0x06, 0x0C,
  0x18, 0x3D, 0xFF, 0x80, 0x06, 0x03, 0x03, 0x81, 0xC1, 0xE0, 0xB0, 0xD8,
  0xCC, 0x66, 0x7F, 0xFF, 0xE0, 0xC0, 0x60, 0x30, 0x7C, 0xFB, 0x06, 0x0C,
  0x18, 0x3F, 0x07, 0x06, 0x0C, 0x18, 0x3D, 0xDF, 0x00, 0x1E, 0x7D, 0x86,
  0x0C, 0x1B, 0x3F, 0x63, 0xC7, 0x8F, 0x1E, 0x36, 0xE7, 0x80, 0xFF, 0xFC,
  0x18, 0x30, 0x41, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x00, 0x38,
  0xFB, 0x1E, 0x3C, 0x6D, 0x8E, 0x3E, 0xCF, 0x8F, 0x0E, 0x3E, 0xEF, 0x80,
  0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7E, 0x0C, 0x18, 0x69, 0xDF,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xFB, 0x40, 0x02, 0x1C,
  0xE7, 0x0C, 0x0E, 0x07, 0x03, 0x02, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81,
  0xC0, 0xE0, 0x70, 0x63, 0x9C, 0x60, 0x80, 0x39, 0xFA, 0x30, 0x30, 0x41,
  0x86, 0x18, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x07, 0x01, 0xFC, 0x30,
  0x66, 0x02, 0x47, 0xBC, 0xD9, 0xD9, 0x99, 0x99, 0x99, 0x99, 0x9B, 0xCA,
  0xAC, 0xEE, 0x40, 0x06, 0x00, 0x3F, 0x80, 0x60, 0x0C, 0x03, 0x01, 0xE0,
  0x78, 0x16, 0x0C, 0xC3, 0x30, 0xCC, 0x3F, 0x1F, 0xE6, 0x19, 0x86, 0xC0,
  0xF0, 0x30, 0xF8, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0xFE, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFF, 0xFE, 0x1E, 0x3F, 0x71, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xE0, 0x60, 0x7F, 0x1F, 0xF8, 0x7F, 0x31, 0xD8, 0x7C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x6F, 0xF7, 0xE0, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x3F, 0x7E, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00,
  0x0F, 0x1F, 0xDC, 0x2C, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xC1, 0xE0, 0xF8,
  0x6C, 0x37, 0xF8, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xFF, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE,
  0xC1, 0xE1, 0xB1, 0x98, 0xCC, 0xC6, 0xC3, 0x61, 0xF0, 0xEC, 0x66, 0x31,
  0x98, 0xEC, 0x36, 0x1C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xBD,
  0x05, 0xEC, 0x6F, 0x63, 0x79, 0x13, 0xCD, 0x9E, 0x6C, 0xF1, 0x47, 0x8E,
  0x3C, 0x71, 0xE3, 0x0C, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xD8, 0xF6, 0x3C,
  0xCF, 0x33, 0xC6, 0xF1, 0xBC, 0x3F, 0x0F, 0xC1, 0xF0, 0x70, 0x1E, 0x0F,
  0xC6, 0x1B, 0x86, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1D,
  0x86, 0x7F, 0x8F, 0xC0, 0xF8, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE,
  0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1E, 0x0F, 0xC6, 0x1B, 0x86, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1D, 0x86, 0x7F, 0x8F, 0xC0,
  0x70, 0x0C, 0x01, 0xC0, 0xF8, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x19,
  0xF8, 0xCC, 0x66, 0x31, 0x98, 0xCC, 0x36, 0x1C, 0x38, 0xFF, 0x0E, 0x0C,
  0x1C, 0x1C, 0x1E, 0x0E, 0x0C, 0x18, 0x3F, 0xDF, 0x00, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x6C,
  0x37, 0xF1, 0xF0, 0xC0, 0xF0, 0x64, 0x19, 0x86, 0x61, 0x98, 0xC3, 0x30,
  0xCC, 0x32, 0x0D, 0x81, 0xE0, 0x78, 0x1C, 0x03, 0x00, 0xC1, 0x07, 0x87,
  0x0F, 0x0E, 0x1B, 0x14, 0x66, 0x28, 0xCC, 0xD9, 0x99, 0xB3, 0x13, 0x64,
  0x34, 0x58, 0x68, 0xB0, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x06, 0x00,
  0xC1, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x38, 0x1C, 0x1B, 0x0D,
  0x8C, 0x66, 0x36, 0x0C, 0xC1, 0xE1, 0x98, 0xCC, 0x63, 0x61, 0xB0, 0x50,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0x7F, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x7F, 0xFF, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC0, 0x81, 0x83, 0x03, 0x06,
  0x04, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xF0, 0x08, 0x06, 0x07, 0x02, 0xC3, 0x21, 0x19,
  0x8D, 0x83, 0xFF, 0xCE, 0x70, 0x7C, 0x9C, 0x18, 0x37, 0xF8, 0xF1, 0xE3,
  0xCE, 0xEC, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0xF6, 0xDE, 0x7D, 0x9C, 0x30, 0xC3, 0x0C, 0x30, 0x65, 0xF0,
  0x03, 0x03, 0x03, 0x03, 0x7B, 0xE7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7,
  0x6F, 0x7B, 0x7C, 0xCF, 0x1E, 0x3F, 0xF8, 0x30, 0x60, 0x66, 0x7C, 0x08,
  0xF3, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x7B,
  0xE7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x6F, 0x7B, 0x03, 0x02, 0x86,
  0xFC, 0x30, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xF0, 0xFF, 0xFF, 0xF0, 0x33, 0x00, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0x40, 0xC0, 0xC0, 0xC0, 0xC1, 0xC6, 0xCC,
  0xCC, 0xD8, 0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0xFE, 0x73, 0xC7, 0x1C, 0x61, 0xC6, 0x1C, 0x61, 0xC6, 0x1C, 0x61,
  0xC6, 0x1C, 0x61, 0xDE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x7C, 0xE6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x6E, 0x3C, 0xDE,
  0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xF6, 0xDE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x7B, 0xE7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x6F, 0x7B,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x00,
  0xFF, 0x2C, 0x30, 0x70, 0xE0, 0xC3, 0x9F, 0xE0, 0x20, 0x82, 0x3E, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x0D, 0x3C, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0x6F, 0x7B, 0xC3, 0x43, 0x66, 0x66, 0x66, 0x24, 0x3C, 0x3C,
  0x1C, 0x18, 0xC7, 0x1A, 0x38, 0x99, 0x4C, 0xCA, 0x66, 0xDB, 0x16, 0xD0,
  0xA7, 0x87, 0x1C, 0x38, 0xE1, 0xC6, 0x00, 0xE3, 0x66, 0x34, 0x3C, 0x18,
  0x1C, 0x3C, 0x26, 0x66, 0xC3, 0xC3, 0x63, 0x66, 0x66, 0x26, 0x34, 0x3C,
  0x3C, 0x1C, 0x18, 0x18, 0x18, 0x30, 0xF0, 0x40, 0xF8, 0x61, 0x8C, 0x31,
  0x86, 0x30, 0xFF, 0xF0, 0x09, 0xCC, 0x42, 0x10, 0x8C, 0xC7, 0x08, 0x42,
  0x10, 0x87, 0x18, 0xFF, 0xFF, 0xC0, 0x87, 0x18, 0x42, 0x10, 0x86, 0x19,
  0xC8, 0x42, 0x11, 0x9C, 0xC0, 0xF3, 0xFE, 0x10,
};

const GFXglyph NotoSans_Condensed_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 10, 14, 10, 0, -14 },
  { 29, 7, 15, 9, 1, -14 },
  { 43, 12, 14, 14, 1, -14 },
  { 64, 10, 14, 11, 1, -14 },
  { 82, 2, 5, 4, 1, -14 },
  { 84, 4, 17, 6, 1, -14 },
  { 93, 5, 17, 6, 0, -14 },
  { 104, 7, 7, 9, 1, -14 },
  { 111, 7, 9, 9, 1, -11 },
  { 119, 3, 4, 5, 1, -2 },
  { 121, 4, 2, 6, 1, -6 },
  { 122, 3, 2, 5, 1, -2 },
  { 123, 7, 14, 7, 0, -14 },
  { 136, 7, 14, 9, 1, -14 },
  { 149, 5, 14, 9, 1, -14 },
  { 158, 7, 14, 9, 1, -14 },
  { 171, 7, 14, 9, 1, -14 },
  { 184, 9, 14, 9, 0, -14 },
  { 200, 7, 14, 9, 1, -14 },
  { 213, 7, 14, 9, 1, -14 },
  { 226, 7, 14, 9, 1, -14 },
  { 239, 7, 14, 9, 1, -14 },
  { 252, 7, 14, 9, 1, -14 },
  { 265, 3, 10, 5, 1, -10 },
  { 269, 3, 12, 5, 1, -10 },
  { 274, 7, 9, 9, 1, -11 },
  { 282, 7, 5, 9, 1, -9 },
  { 287, 7, 9, 9, 1, -11 },
  { 295, 7, 14, 7, 0, -14 },
  { 308, 12, 16, 14, 1, -14 },
  { 332, 10, 14, 10, 0, -14 },
  { 350, 8, 14, 10, 1, -14 },
  { 364, 8, 14, 10, 1, -14 },
  { 378, 9, 14, 11, 1, -14 },
  { 394, 7, 14, 9, 1, -14 },
  { 407, 7, 14, 8, 1, -14 },
  { 420, 9, 14, 11, 1, -14 },
  { 436, 9, 14, 12, 1, -14 },
  { 452, 4, 14, 6, 1, -14 },
  { 459, 4, 18, 5, -1, -14 },
  { 468, 9, 14, 10, 1, -14 },
  { 484, 7, 14, 8, 1, -14 },
  { 497, 13, 14, 15, 1, -14 },
  { 520, 10, 14, 12, 1, -14 },
  { 538, 10, 14, 12, 1, -14 },
  { 556, 8, 14, 10, 1, -14 },
  { 570, 10, 17, 12, 1, -14 },
  { 592, 9, 14, 10, 1, -14 },
  { 608, 7, 14, 9, 1, -14 },
  { 621, 8, 14, 8, 0, -14 },
  { 635, 9, 14, 11, 1, -14 },
  { 651, 10, 14, 10, 0, -14 },
  { 669, 15, 14, 15, 0, -14 },
  { 696, 9, 14, 9, 0, -14 },
  { 712, 9, 14, 9, 0, -14 },
  { 728, 8, 14, 8, 0, -14 },
  { 742, 4, 17, 6, 1, -14 },
  { 751, 7, 14, 7, 0, -14 },
  { 764, 4, 17, 6, 1, -14 },
  { 773, 9, 8, 9, 0, -14 },
  { 782, 8, 1, 8, 0, 2 },
  { 783, 4, 3, 5, 1, -15 },
  { 785, 7, 10, 9, 1, -10 },
  { 794, 8, 14, 10, 1, -14 },
  { 808, 6, 10, 8, 1, -10 },
  { 816, 8, 14, 10, 1, -14 },
  { 830, 7, 10, 9, 1, -10 },
  { 839, 6, 15, 6, 0, -15 },
  { 851, 8, 15, 10, 1, -10 },
  { 866, 8, 14, 10, 1, -14 },
  { 880, 2, 14, 4, 1, -14 },
  { 884, 4, 19, 4, -1, -14 },
  { 894, 8, 14, 9, 1, -14 },
  { 908, 2, 14, 4, 1, -14 },
  { 912, 12, 10, 15, 1, -10 },
  { 927, 8, 10, 10, 1, -10 },
  { 937, 8, 10, 10, 1, -10 },
  { 947, 8, 15, 10, 1, -10 },
  { 962, 8, 15, 10, 1, -10 },
  { 977, 5, 10, 7, 1, -10 },
  { 984, 6, 10, 7, 1, -10 },
  { 992, 6, 13, 6, 0, -13 },
  { 1002, 8, 10, 10, 1, -10 },
  { 1012, 8, 10, 8, 0, -10 },
  { 1022, 13, 10, 13, 0, -10 },
  { 1039, 8, 10, 8, 0, -10 },
  { 1049, 8, 15, 8, 0, -10 },
  { 1064, 6, 10, 7, 1, -10 },
  { 1072, 5, 17, 7, 1, -14 },
  { 1083, 1, 18, 9, 4, -14 },
  { 1086, 5, 17, 7, 1, -14 },
  { 1097, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Medium19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_MEDIUM19PT7B_H_
