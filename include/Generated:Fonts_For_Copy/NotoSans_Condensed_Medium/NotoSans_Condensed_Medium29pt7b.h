#ifndef _NOTOSANS_CONDENSED_MEDIUM29PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xD8, 0x0B, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xC7, 0xC7, 0xC3, 0x0E, 0x30, 0x39, 0xC0, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF, 0x18, 0xE0, 0x63, 0x01, 0x8C,
  0x06, 0x30, 0x18, 0xC3, 0xFF, 0xEF, 0xFF, 0x8C, 0x70, 0x31, 0x80, 0xC6,
  0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x06, 0x00, 0x60, 0x0F, 0x83, 0xFE,
  0x7F, 0xE7, 0x62, 0xE6, 0x0E, 0x60, 0xE6, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x7E, 0x06, 0x70, 0x67, 0x06, 0x7C, 0x6E, 0xFF, 0xEF, 0xFC,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x06, 0x0F, 0xC1, 0xC1, 0x98,
  0x30, 0x73, 0x86, 0x0E, 0x71, 0x81, 0x8E, 0x30, 0x30, 0xCE, 0x06, 0x39,
  0x80, 0xE7, 0x71, 0x1C, 0xEC, 0xF9, 0x99, 0xBB, 0xBF, 0x76, 0x33, 0xCC,
  0xC6, 0x03, 0x98, 0xC0, 0x63, 0x18, 0x0C, 0x63, 0x03, 0x0C, 0x60, 0x61,
  0x8C, 0x1C, 0x39, 0x83, 0x03, 0xE0, 0xE0, 0x7C, 0x0F, 0x00, 0x1F, 0x80,
  0x39, 0xC0, 0x31, 0xC0, 0x30, 0xC0, 0x31, 0xC0, 0x39, 0xC0, 0x3B, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x0E, 0x73, 0x9C, 0xE3, 0xDC,
  0xE1, 0xDC, 0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0x78, 0x79, 0xFC, 0x7F, 0xDC,
  0x3F, 0x8F, 0xFF, 0xFF, 0xB6, 0x0E, 0x18, 0x71, 0xC3, 0x86, 0x1C, 0x38,
  0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC3, 0x83, 0x07,
  0x0E, 0x0E, 0x0C, 0x1C, 0xC1, 0x87, 0x0C, 0x38, 0xE1, 0x87, 0x1C, 0x70,
  0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE7, 0x1C, 0xE3, 0x00,
  0x0E, 0x01, 0xC0, 0x38, 0x67, 0x3F, 0xFF, 0xFF, 0xC3, 0x80, 0xD8, 0x3B,
  0x8E, 0x38, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x77, 0x76, 0x6E, 0xC0, 0xFF, 0xFF, 0xF8, 0x5F, 0xF0, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x0E, 0x00, 0x0F, 0x03, 0xF8, 0x3F, 0xC7, 0x0E, 0x70, 0xE7, 0x0E,
  0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x66, 0x0E, 0x70, 0xE7, 0x0E, 0x79, 0xC3, 0xFC, 0x1F, 0x80, 0x07,
  0x0F, 0x1F, 0x3F, 0x77, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0x07, 0xFC, 0xFF,
  0xC6, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xFC, 0xFF, 0xC4, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC1, 0xF8, 0x1F, 0x01, 0xFC, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0xC3, 0xEF, 0xFC, 0x7F, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1B, 0x81,
  0xDC, 0x0C, 0xE0, 0xC7, 0x06, 0x38, 0x61, 0xC7, 0x0E, 0x30, 0x73, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F,
  0xC7, 0xFC, 0x7F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F,
  0x07, 0xFC, 0x7F, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0xE3, 0xCF, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x1F, 0xE3,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE7, 0x8E, 0xFC, 0xF9, 0xEF,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0x77, 0x0E, 0x39, 0xE3,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x1F,
  0x03, 0xFC, 0x79, 0xE7, 0x0E, 0x60, 0xE6, 0x0E, 0x70, 0xE7, 0x0E, 0x3F,
  0xC1, 0xF8, 0x1F, 0x83, 0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0xE7, 0xFC, 0x3F, 0x80, 0x1F, 0x03, 0xF8, 0x7F, 0xC7,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0xFE, 0x0F, 0x71, 0xF7,
  0xF6, 0x3F, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x47, 0x87,
  0xF8, 0x7E, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x05, 0xFF, 0x77, 0x77, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x77, 0x6E, 0xEC, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x3F,
  0x3F, 0xE7, 0xFD, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x1C, 0x0E, 0x01, 0xC3,
  0x80, 0x1C, 0x60, 0x01, 0x9C, 0x3F, 0x3B, 0x0F, 0xE3, 0x63, 0x9C, 0x6C,
  0x63, 0x8F, 0x9C, 0x71, 0xF3, 0x8E, 0x3E, 0x71, 0xC7, 0xCE, 0x38, 0xF8,
  0xC7, 0x3B, 0x1D, 0xE6, 0x63, 0xE7, 0x8E, 0x18, 0x61, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x20, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x6E, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x30,
  0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE1, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x7F, 0x80, 0x7E, 0x00,
  0xE0, 0xFE, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0xCE, 0x3E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x03, 0xF0, 0x7F,
  0xC7, 0xFC, 0x78, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xCC, 0x3F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFF, 0x0F,
  0xFE, 0x38, 0x3C, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x03, 0xB8, 0x0E,
  0xE0, 0x7B, 0x83, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xEF, 0xFB, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFB, 0xFE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0x9E, 0x02, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x1D, 0xE0, 0x73, 0xE3,
  0xC7, 0xFF, 0x0F, 0xF8, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0x80, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF, 0xE0, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0xFD, 0xF9, 0xC0, 0xE0, 0x7F,
  0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0xEF,
  0x07, 0x70, 0x3F, 0x81, 0xFE, 0x0F, 0x78, 0x71, 0xC3, 0x8F, 0x1C, 0x38,
  0xE1, 0xE7, 0x07, 0x38, 0x3D, 0xC0, 0xEE, 0x07, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0D, 0xFB, 0x01, 0xBF, 0x70, 0x77, 0xEE, 0x0C, 0xFC, 0xC1, 0x9F,
  0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x31, 0x8F, 0xC6, 0x71, 0xF8, 0xEE, 0x3F,
  0x1D, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0x83, 0xF0, 0x70, 0x7E,
  0x0E, 0x0E, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x3E, 0xE0, 0xFB, 0x83, 0xE7, 0x0F, 0x9C, 0x3E, 0x38, 0xF8, 0xE3, 0xE1,
  0xCF, 0x87, 0x3E, 0x0E, 0xF8, 0x3B, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1C, 0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3C, 0x1C, 0x78,
  0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78,
  0x0E, 0x38, 0x1C, 0x3E, 0x7C, 0x1F, 0xF8, 0x07, 0xF0, 0xFC, 0x0F, 0xFC,
  0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE7, 0xEF, 0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3C,
  0x1C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0x78, 0x0E, 0x38, 0x1C, 0x3E, 0x7C, 0x1F, 0xF8, 0x07, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0xFE, 0x07, 0xFE,
  0x3F, 0xF9, 0xC3, 0xCE, 0x0E, 0x70, 0x7B, 0x81, 0xDC, 0x1E, 0xE0, 0xE7,
  0x0F, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x71, 0xC3, 0x8F, 0x1C, 0x38, 0xE1,
  0xE7, 0x07, 0x38, 0x3D, 0xC0, 0xEE, 0x07, 0x80, 0x1F, 0x87, 0xFD, 0xFF,
  0x38, 0x2E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1F, 0xDF, 0x7F, 0xE7,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3B, 0x83, 0xDF, 0x7C, 0x7F, 0xE1, 0xFC, 0x00, 0xE0,
  0x0F, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x0E, 0x0E,
  0x1C, 0x1C, 0x38, 0x30, 0x30, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x01,
  0x9C, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1D, 0xC0, 0xE0, 0x73,
  0x83, 0xE0, 0xE7, 0x07, 0xC1, 0xCE, 0x0D, 0x83, 0x9C, 0x1B, 0x07, 0x1C,
  0x76, 0x1C, 0x38, 0xEE, 0x38, 0x71, 0xDC, 0x70, 0xE3, 0x18, 0xE0, 0xC6,
  0x31, 0x81, 0xDC, 0x77, 0x03, 0xB8, 0xEE, 0x07, 0x60, 0xDC, 0x0E, 0xC1,
  0xB8, 0x0D, 0x83, 0x60, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x0F,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x39, 0xC0, 0xE3, 0x87, 0x0E, 0x1C, 0x1C,
  0xE0, 0x73, 0x80, 0xCE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xCE, 0x07, 0x38, 0x38, 0x70, 0xE1, 0xC7,
  0x07, 0x9C, 0x0E, 0xE0, 0x3C, 0xE0, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1C,
  0x38, 0x70, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x3F, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0, 0x60, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0E,
  0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x38, 0x03,
  0xC0, 0x1F, 0x01, 0xD8, 0x0C, 0xE0, 0xE7, 0x06, 0x18, 0x70, 0xE3, 0x83,
  0x38, 0x1D, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x87, 0x1F,
  0x0F, 0xF8, 0xEF, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x79, 0xFF, 0x7C, 0xFE,
  0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xE3, 0xDF, 0xF9, 0xF3, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E,
  0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E,
  0xF0, 0xEF, 0x1E, 0xFF, 0xCC, 0xF8, 0x0F, 0x8F, 0xF3, 0xF9, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x33,
  0xFC, 0x7E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1E,
  0x73, 0xFF, 0x7F, 0xF7, 0x0F, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0x77, 0x8F, 0x3F, 0xF1, 0xF3, 0x0F,
  0x03, 0xFC, 0x39, 0xC7, 0x0E, 0x70, 0xE6, 0x06, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x86, 0x3F, 0xE1, 0xFC, 0x0F,
  0x8F, 0xC7, 0x23, 0x03, 0x81, 0xC0, 0xFD, 0xFE, 0xFF, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x1E, 0x33, 0xFF, 0x7F, 0xF7, 0x0F, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0x77, 0x8F, 0x3F, 0xF1, 0xF7,
  0x00, 0x70, 0x07, 0x00, 0x74, 0x0E, 0x7F, 0xE7, 0xFC, 0x3F, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0xFE, 0xFF, 0xFE,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x08, 0x71, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFE,
  0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x0E,
  0xE3, 0xDC, 0x73, 0x9C, 0x77, 0x0E, 0xE1, 0xFC, 0x3F, 0x87, 0xB8, 0xE7,
  0x1C, 0x73, 0x8F, 0x70, 0xEE, 0x1F, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x8F, 0x1B, 0xFB, 0xFB, 0xFF, 0xFF,
  0x78, 0xF8, 0xEE, 0x0E, 0x0D, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xC7, 0x9B, 0xFB, 0xFF, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0x0E, 0x70,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70,
  0x77, 0x8E, 0x3F, 0xC1, 0xF8, 0xC7, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0,
  0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xF0,
  0xEF, 0x9E, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x33, 0xFF, 0x7F, 0xF7, 0x0F, 0x70, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xF7,
  0x9F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0xC7, 0xCF, 0xFF, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x3F, 0xFE, 0xFC, 0x0E,
  0x07, 0x01, 0xE0, 0xFC, 0x1F, 0x03, 0xC0, 0xE0, 0x70, 0x3E, 0x1F, 0xFF,
  0xFC, 0x18, 0x18, 0x18, 0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0x1F, 0x1F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xE7, 0xDF, 0xF9, 0xF3, 0xE0, 0x7E, 0x07, 0x70, 0x77, 0x07,
  0x70, 0xE3, 0x0E, 0x38, 0xE3, 0x8C, 0x39, 0xC1, 0x9C, 0x1D, 0x81, 0xD8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0xE0, 0xF0, 0x6C, 0x1E, 0x1D, 0xC3,
  0xC3, 0xB8, 0x78, 0x77, 0x1F, 0x0E, 0xE3, 0x71, 0x8C, 0x66, 0x71, 0xCC,
  0xCE, 0x3B, 0x99, 0xC7, 0x73, 0xB0, 0x6C, 0x7E, 0x0D, 0x87, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x70, 0x77, 0x0F, 0x38,
  0xE3, 0x9C, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1F,
  0x81, 0xDC, 0x39, 0xC3, 0x8E, 0x70, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0x70,
  0x77, 0x07, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0x8C, 0x19, 0xC1, 0xDC, 0x1D,
  0x80, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x7C, 0x07, 0xC0, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0xFF,
  0xFF, 0x03, 0x0F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0xF0, 0xF0, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1F, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xC0, 0x78, 0x3E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xC0, 0xF8, 0x7C, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xE1, 0xF0, 0xF0, 0x60, 0x00, 0x7C, 0x1F, 0xFF, 0xC7,
  0xF8, 0x1C,
};

const GFXglyph NotoSans_Condensed_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 8, 8, 12, 2, -21 },
  { 17, 14, 21, 15, 1, -21 },
  { 54, 12, 24, 14, 1, -22 },
  { 90, 19, 21, 22, 1, -21 },
  { 140, 16, 21, 17, 1, -21 },
  { 182, 3, 8, 6, 2, -21 },
  { 185, 7, 26, 9, 1, -21 },
  { 208, 6, 26, 9, 1, -21 },
  { 228, 11, 11, 13, 1, -22 },
  { 244, 12, 14, 14, 1, -17 },
  { 265, 4, 7, 7, 1, -3 },
  { 269, 7, 3, 9, 1, -9 },
  { 272, 3, 4, 7, 2, -4 },
  { 274, 11, 21, 11, 0, -21 },
  { 303, 12, 21, 14, 1, -21 },
  { 335, 8, 21, 14, 2, -21 },
  { 356, 12, 21, 14, 1, -21 },
  { 388, 12, 21, 14, 1, -21 },
  { 420, 13, 21, 14, 0, -21 },
  { 455, 12, 21, 14, 1, -21 },
  { 487, 12, 21, 14, 1, -21 },
  { 519, 12, 21, 14, 1, -21 },
  { 551, 12, 21, 14, 1, -21 },
  { 583, 12, 21, 14, 1, -21 },
  { 615, 3, 16, 7, 2, -16 },
  { 621, 4, 20, 7, 1, -16 },
  { 631, 12, 13, 14, 1, -17 },
  { 651, 12, 8, 14, 1, -14 },
  { 663, 12, 13, 14, 1, -17 },
  { 683, 10, 21, 11, 0, -21 },
  { 710, 19, 23, 21, 1, -21 },
  { 765, 15, 21, 15, 0, -21 },
  { 805, 12, 21, 16, 2, -21 },
  { 837, 13, 21, 15, 1, -21 },
  { 872, 14, 21, 17, 2, -21 },
  { 909, 10, 21, 13, 2, -21 },
  { 936, 10, 21, 13, 2, -21 },
  { 963, 14, 21, 17, 2, -21 },
  { 1000, 13, 21, 18, 2, -21 },
  { 1035, 7, 21, 9, 1, -21 },
  { 1054, 7, 27, 7, -2, -21 },
  { 1078, 13, 21, 15, 2, -21 },
  { 1113, 10, 21, 12, 2, -21 },
  { 1140, 19, 21, 23, 2, -21 },
  { 1190, 14, 21, 19, 2, -21 },
  { 1227, 16, 21, 18, 1, -21 },
  { 1269, 12, 21, 15, 2, -21 },
  { 1301, 16, 26, 18, 1, -21 },
  { 1353, 13, 21, 15, 2, -21 },
  { 1388, 11, 21, 13, 1, -21 },
  { 1417, 13, 21, 13, 0, -21 },
  { 1452, 13, 21, 17, 2, -21 },
  { 1487, 15, 21, 15, 0, -21 },
  { 1527, 23, 21, 23, 0, -21 },
  { 1588, 14, 21, 14, 0, -21 },
  { 1625, 14, 21, 14, 0, -21 },
  { 1662, 11, 21, 13, 1, -21 },
  { 1691, 6, 26, 9, 2, -21 },
  { 1711, 11, 21, 11, 0, -21 },
  { 1740, 6, 26, 9, 1, -21 },
  { 1760, 13, 12, 14, 1, -21 },
  { 1780, 13, 2, 12, 0, 2 },
  { 1784, 6, 4, 8, 1, -22 },
  { 1787, 11, 16, 14, 1, -16 },
  { 1809, 12, 22, 15, 2, -22 },
  { 1842, 10, 16, 12, 1, -16 },
  { 1862, 12, 22, 15, 1, -22 },
  { 1895, 12, 16, 14, 1, -16 },
  { 1919, 9, 22, 9, 0, -22 },
  { 1944, 12, 23, 15, 1, -16 },
  { 1979, 11, 22, 15, 2, -22 },
  { 2010, 3, 22, 7, 2, -22 },
  { 2019, 6, 29, 7, -1, -22 },
  { 2041, 11, 22, 13, 2, -22 },
  { 2072, 3, 22, 7, 2, -22 },
  { 2081, 19, 16, 22, 2, -16 },
  { 2119, 11, 16, 15, 2, -16 },
  { 2141, 12, 16, 15, 1, -16 },
  { 2165, 12, 23, 15, 2, -16 },
  { 2200, 12, 23, 15, 1, -16 },
  { 2235, 8, 16, 10, 2, -16 },
  { 2251, 9, 16, 11, 1, -16 },
  { 2269, 8, 19, 9, 0, -19 },
  { 2288, 11, 16, 15, 2, -16 },
  { 2310, 12, 16, 13, 0, -16 },
  { 2334, 19, 16, 20, 0, -16 },
  { 2372, 12, 16, 13, 0, -16 },
  { 2396, 12, 23, 13, 0, -16 },
  { 2431, 9, 16, 11, 1, -16 },
  { 2449, 8, 26, 11, 1, -21 },
  { 2475, 3, 29, 13, 5, -22 },
  { 2486, 9, 26, 11, 1, -21 },
  { 2516, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Medium29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_MEDIUM29PT7B_H_
