#ifndef _NOTOSANS_CONDENSED_MEDIUM25PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xED, 0xB6, 0xDB, 0x6C, 0x07, 0xFC, 0xE7, 0x67, 0x67, 0x67,
  0x66, 0x66, 0x66, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0x8F, 0xFF,
  0xFF, 0xF1, 0x98, 0x31, 0x83, 0x18, 0x31, 0x8F, 0xFE, 0xFF, 0xE3, 0x30,
  0x33, 0x06, 0x30, 0x63, 0x06, 0x60, 0x0C, 0x03, 0x01, 0xF1, 0xFF, 0xEC,
  0xBB, 0x0C, 0xC3, 0xB0, 0x7C, 0x0F, 0x80, 0xF0, 0x3E, 0x0D, 0xC3, 0x30,
  0xDF, 0xBE, 0xFF, 0x8F, 0x00, 0xC0, 0x30, 0x38, 0x18, 0x3E, 0x18, 0x33,
  0x0C, 0x19, 0x86, 0x0C, 0x66, 0x06, 0x33, 0x03, 0x1B, 0x01, 0x99, 0x9C,
  0xCD, 0xDF, 0x3E, 0xD9, 0x8E, 0x6C, 0xC0, 0x66, 0x30, 0x33, 0x18, 0x31,
  0x8C, 0x18, 0xCC, 0x0C, 0x66, 0x0C, 0x1F, 0x06, 0x0F, 0x00, 0x1E, 0x01,
  0xF8, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0x80, 0xDC, 0x07, 0xC0, 0x3C,
  0x03, 0xF1, 0xD9, 0x8D, 0xCE, 0xEC, 0x3F, 0x60, 0xF3, 0x83, 0x9C, 0x3C,
  0x7F, 0xF1, 0xF1, 0xC0, 0xED, 0xB6, 0xD8, 0x1C, 0x63, 0x0C, 0x71, 0x86,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC3, 0x0C, 0x18, 0x70,
  0xC3, 0x18, 0x63, 0x1C, 0xE3, 0x18, 0xC6, 0x31, 0x8C, 0x67, 0x39, 0x8C,
  0xC6, 0x60, 0x1C, 0x06, 0x03, 0x1D, 0x7F, 0xF8, 0xE0, 0xD8, 0x6E, 0x73,
  0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x76, 0x6E, 0xCC, 0xFF, 0xF0, 0x6F, 0x60,
  0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x00, 0x1E, 0x0F, 0xC7,
  0x39, 0x86, 0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x76, 0x19, 0xCE, 0x7F, 0x0F, 0x80, 0x0C, 0x73, 0xFB, 0xCD,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x3E, 0x3F,
  0xCE, 0x39, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x3E, 0x3F, 0xE6,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x38, 0x3C, 0x3E, 0x0F, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x1E, 0x0E, 0xFF, 0xBF, 0x80, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x39, 0xC3, 0x1C, 0x61,
  0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F,
  0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xF8, 0x7F, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x0E, 0xFF, 0x3F, 0x80, 0x0F, 0x87,
  0xE3, 0x81, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0xFC, 0xDF, 0xB8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x76, 0x1D, 0xC6, 0x3F, 0x87, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x3F, 0x1F, 0xE6, 0x3B,
  0x87, 0xE1, 0xD8, 0x67, 0x38, 0xFC, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE1,
  0xF0, 0x3C, 0x1F, 0x87, 0x7F, 0x8F, 0xC0, 0x3E, 0x1F, 0xC7, 0x3B, 0x86,
  0xE1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xDF, 0xF7, 0xFC, 0x27, 0x01, 0x80,
  0x60, 0x38, 0x1C, 0x7E, 0x1F, 0x00, 0x5F, 0xE0, 0x00, 0x00, 0x6F, 0x80,
  0x27, 0x76, 0x00, 0x00, 0x00, 0x07, 0x66, 0xEC, 0xC0, 0x00, 0x40, 0x30,
  0x3C, 0x3C, 0x3C, 0x3C, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1C, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1C, 0x3E, 0x3E, 0x3E, 0x0E, 0x02, 0x00,
  0x7E, 0x7F, 0x91, 0xC0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x70, 0x38, 0x1C, 0x00, 0x03, 0xE0, 0x0F,
  0xF8, 0x1C, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x63, 0xF3, 0x67, 0xF3, 0x66,
  0x33, 0xC6, 0x33, 0xCE, 0x33, 0xCC, 0x33, 0xCC, 0x73, 0xC6, 0x73, 0xC7,
  0xFE, 0x63, 0x9E, 0x60, 0x00, 0x70, 0x00, 0x38, 0x08, 0x1F, 0xF0, 0x07,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xE0, 0x77,
  0x03, 0x18, 0x18, 0xC1, 0xC7, 0x0E, 0x18, 0x7F, 0xC3, 0xFF, 0x38, 0x39,
  0xC1, 0xCC, 0x06, 0xE0, 0x3F, 0x01, 0xC0, 0xFE, 0x3F, 0xEE, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xFE, 0x3F, 0xEE, 0x1F, 0x83, 0xE0, 0xF8,
  0x3E, 0x1F, 0x8F, 0xFF, 0xBF, 0xC0, 0x0F, 0xC3, 0xFC, 0xF1, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0xC1, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xF3, 0x9F, 0x70,
  0xEE, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x77, 0x3E, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xE0, 0xFF, 0x8F,
  0x0C, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC0, 0x76, 0x03, 0xB8, 0x1D, 0xC0, 0xE7, 0x07, 0x1F, 0xF8,
  0x7F, 0x80, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0C, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0xFF, 0xF0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0xFF, 0x80, 0xE0, 0xFC, 0x3B, 0x8E,
  0x71, 0xCE, 0x71, 0xCC, 0x3B, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0x73,
  0x8E, 0x71, 0xC7, 0x38, 0xE7, 0x0E, 0xE1, 0xDC, 0x1C, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xD8,
  0x1F, 0xD8, 0x1F, 0xD8, 0x37, 0xCC, 0x37, 0xCC, 0x37, 0xCC, 0x67, 0xCE,
  0x67, 0xC6, 0x67, 0xC6, 0xE7, 0xC7, 0xC7, 0xC3, 0xC7, 0xC3, 0xC7, 0xC3,
  0x87, 0xC1, 0x87, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xD8, 0x3D, 0xC3,
  0xCC, 0x3C, 0xE3, 0xC6, 0x3C, 0x73, 0xC7, 0x3C, 0x3B, 0xC3, 0xBC, 0x1F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0x0F, 0xC0, 0xFF, 0x0E, 0x3C, 0xE0,
  0x67, 0x03, 0xB0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x36, 0x03, 0xB8, 0x1D, 0xC0, 0xC7, 0x0E, 0x3F, 0xE0, 0x7E, 0x00,
  0xFE, 0x3F, 0xCE, 0x7B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE3, 0xBF,
  0xCF, 0xE3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0F,
  0xC0, 0xFF, 0x0E, 0x3C, 0xE0, 0x67, 0x03, 0xB0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03, 0xB8, 0x1D, 0xC0, 0xE7,
  0x0E, 0x3F, 0xE0, 0x7E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0xFC,
  0x1F, 0xE3, 0x9E, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xE7, 0x9F,
  0xE3, 0xF8, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xE7, 0x0E, 0xE1, 0xDC, 0x1C,
  0x3F, 0x3F, 0xDC, 0x7C, 0x0E, 0x07, 0x03, 0x80, 0xF0, 0x3E, 0x0F, 0x81,
  0xE0, 0x70, 0x18, 0x0C, 0x07, 0x87, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xFC,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF8, 0x3F, 0x8E, 0x7F, 0xC7, 0xF0, 0xE0,
  0x3F, 0x01, 0x98, 0x1C, 0xC0, 0xE7, 0x06, 0x38, 0x30, 0xC3, 0x86, 0x1C,
  0x38, 0xC0, 0xC6, 0x06, 0x70, 0x3B, 0x81, 0xD8, 0x06, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x60, 0x7E, 0x0E, 0x06, 0x60, 0xF0,
  0x66, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x0E, 0x71, 0xB8, 0xC3, 0x19,
  0x8C, 0x31, 0x99, 0xC3, 0x99, 0x9C, 0x3B, 0x99, 0x81, 0xB1, 0xD8, 0x1B,
  0x0D, 0x81, 0xB0, 0xF8, 0x1B, 0x0F, 0x81, 0xE0, 0xF0, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x60, 0x77, 0x0E, 0x30, 0xC3, 0x9C, 0x19, 0xC1, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x19, 0x83, 0x9C, 0x30,
  0xC7, 0x0E, 0x70, 0xEE, 0x07, 0xE0, 0x76, 0x0E, 0x70, 0xE7, 0x0C, 0x31,
  0xC3, 0x98, 0x19, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x0C, 0x01, 0xC0, 0x78, 0x0F, 0x03,
  0xB0, 0x66, 0x1C, 0x63, 0x0C, 0xE0, 0xD8, 0x1B, 0x01, 0x80, 0xFF, 0xFF,
  0xFC, 0xE3, 0x8C, 0x30, 0x1E, 0x3F, 0x88, 0xE0, 0x30, 0x18, 0x0C, 0xFE,
  0xFB, 0xE1, 0xE0, 0xF0, 0xFC, 0x7F, 0xFB, 0xEC, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x33, 0x0D, 0xF3, 0xDE, 0xE1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x86, 0xE3, 0xBF, 0xED, 0xF0, 0x0E, 0x3F, 0x7B, 0x60,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7F, 0x3F, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC7, 0x33, 0xED, 0xEF, 0x61, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0x71, 0xDF, 0xF3, 0xEC, 0x0E, 0x0F,
  0xC7, 0x39, 0x86, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x06, 0x01,
  0xC2, 0x3F, 0x87, 0xE0, 0x1F, 0x1F, 0x38, 0x38, 0x38, 0x3E, 0xFE, 0xFE,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x08,
  0xCF, 0xB7, 0x3D, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x1D, 0xC7, 0x7F, 0xCF, 0xB0, 0x0C, 0x03, 0x01, 0xD0, 0xF7, 0xF8, 0xF8,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x73, 0x7D, 0xEF, 0xE3, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0xBC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x10, 0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x6C, 0x3B, 0x1C, 0xCE, 0x33, 0x0D, 0xC3, 0xF0, 0xFC, 0x3B,
  0x8C, 0xE3, 0x1C, 0xC3, 0x30, 0xEC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xCE, 0x18, 0xDF, 0x7E, 0xF7, 0xEE, 0xE3, 0xC7, 0xC3, 0x87, 0xC3, 0x87,
  0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87,
  0xC3, 0x87, 0xC3, 0x87, 0xCE, 0x6F, 0xBD, 0xFC, 0x7C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x0E, 0x07, 0xF1, 0xEE,
  0x30, 0xEE, 0x0D, 0xC1, 0xB8, 0x37, 0x07, 0xE0, 0xDC, 0x19, 0x87, 0x38,
  0xE3, 0xF8, 0x3E, 0x00, 0xCE, 0x37, 0xCF, 0x7B, 0x86, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1B, 0x8E, 0xFF, 0xB7, 0xCC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1C, 0xCF, 0xB7, 0xBD, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1D, 0xC7, 0x7F, 0xCF, 0xB0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xCF, 0x7F, 0xF8, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x3C, 0x7F, 0xE2, 0xC0, 0xC0, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0x30, 0x60, 0xFF, 0xFF, 0xE6,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x0F, 0x8F, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFC, 0x7F, 0xFB,
  0xEC, 0xE0, 0xFC, 0x19, 0x83, 0x30, 0xE7, 0x1C, 0x63, 0x0C, 0x61, 0x9C,
  0x3B, 0x03, 0x60, 0x6C, 0x0F, 0x80, 0xE0, 0x1C, 0x00, 0xE1, 0xC3, 0xF0,
  0xE1, 0xD8, 0x70, 0xCC, 0x6C, 0x67, 0x36, 0x73, 0x9B, 0x38, 0xCD, 0x98,
  0x66, 0xCC, 0x36, 0x36, 0x1F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xE0, 0xE0, 0xE0, 0xCE, 0x38, 0xC6, 0x1D, 0xC1, 0xB0, 0x3E, 0x03,
  0x80, 0x70, 0x1F, 0x03, 0x60, 0xEE, 0x18, 0xC7, 0x1D, 0xC1, 0xC0, 0xE0,
  0xFC, 0x19, 0x83, 0x30, 0xE7, 0x1C, 0x63, 0x0C, 0x61, 0xDC, 0x1B, 0x03,
  0x60, 0x6C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x83,
  0xE0, 0x78, 0x00, 0xFE, 0xFE, 0xFE, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0x70, 0x60, 0xE0, 0xFF, 0xFF, 0x06, 0x3C, 0x71, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x73, 0xC7, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xC1, 0xE1,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xE0, 0xC1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x30, 0x78, 0x71, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xCF, 0x1C, 0x00, 0x20, 0x7F, 0x1D, 0xFE, 0x1E,
};

const GFXglyph NotoSans_Condensed_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 18, 6, 2, -18 },
  { 8, 8, 7, 10, 1, -18 },
  { 15, 12, 18, 13, 1, -18 },
  { 42, 10, 20, 12, 1, -19 },
  { 67, 17, 18, 19, 1, -18 },
  { 106, 13, 18, 14, 1, -18 },
  { 136, 3, 7, 6, 1, -18 },
  { 139, 6, 22, 8, 1, -18 },
  { 156, 5, 22, 8, 1, -18 },
  { 170, 9, 10, 11, 1, -19 },
  { 182, 10, 12, 12, 1, -15 },
  { 197, 4, 6, 6, 1, -3 },
  { 200, 6, 2, 7, 1, -8 },
  { 202, 4, 3, 6, 1, -3 },
  { 204, 9, 18, 10, 0, -18 },
  { 225, 10, 18, 12, 1, -18 },
  { 248, 6, 18, 12, 2, -18 },
  { 262, 10, 18, 12, 1, -18 },
  { 285, 10, 18, 12, 1, -18 },
  { 308, 12, 18, 12, 0, -18 },
  { 335, 10, 18, 12, 1, -18 },
  { 358, 10, 18, 12, 1, -18 },
  { 381, 10, 18, 12, 1, -18 },
  { 404, 10, 18, 12, 1, -18 },
  { 427, 10, 18, 12, 1, -18 },
  { 450, 3, 14, 6, 2, -14 },
  { 456, 4, 17, 6, 1, -14 },
  { 465, 10, 12, 12, 1, -15 },
  { 480, 10, 7, 12, 1, -12 },
  { 489, 10, 12, 12, 1, -15 },
  { 504, 9, 18, 9, 0, -18 },
  { 525, 16, 20, 19, 1, -18 },
  { 565, 13, 18, 13, 0, -18 },
  { 595, 10, 18, 14, 2, -18 },
  { 618, 11, 18, 13, 1, -18 },
  { 643, 11, 18, 15, 2, -18 },
  { 668, 8, 18, 11, 2, -18 },
  { 686, 8, 18, 11, 2, -18 },
  { 704, 13, 18, 15, 1, -18 },
  { 734, 11, 18, 15, 2, -18 },
  { 759, 6, 18, 8, 1, -18 },
  { 773, 5, 23, 6, -1, -18 },
  { 788, 11, 18, 13, 2, -18 },
  { 813, 8, 18, 11, 2, -18 },
  { 831, 16, 18, 20, 2, -18 },
  { 867, 12, 18, 16, 2, -18 },
  { 894, 13, 18, 16, 1, -18 },
  { 924, 10, 18, 13, 2, -18 },
  { 947, 13, 22, 16, 1, -18 },
  { 983, 11, 18, 13, 2, -18 },
  { 1008, 9, 18, 11, 1, -18 },
  { 1029, 11, 18, 11, 0, -18 },
  { 1054, 11, 18, 15, 2, -18 },
  { 1079, 13, 18, 13, 0, -18 },
  { 1109, 20, 18, 20, 0, -18 },
  { 1154, 12, 18, 12, 0, -18 },
  { 1181, 12, 18, 12, 0, -18 },
  { 1208, 9, 18, 11, 1, -18 },
  { 1229, 5, 22, 8, 2, -18 },
  { 1243, 9, 18, 10, 0, -18 },
  { 1264, 5, 22, 8, 1, -18 },
  { 1278, 11, 11, 12, 1, -18 },
  { 1294, 11, 2, 11, 0, 2 },
  { 1297, 5, 4, 7, 1, -19 },
  { 1300, 9, 14, 12, 1, -14 },
  { 1316, 10, 19, 13, 2, -19 },
  { 1340, 8, 14, 10, 1, -14 },
  { 1354, 10, 19, 13, 1, -19 },
  { 1378, 10, 14, 12, 1, -14 },
  { 1396, 8, 19, 7, 0, -19 },
  { 1415, 10, 20, 13, 1, -14 },
  { 1440, 9, 19, 13, 2, -19 },
  { 1462, 2, 19, 6, 2, -19 },
  { 1467, 5, 25, 6, -1, -19 },
  { 1483, 10, 19, 12, 2, -19 },
  { 1507, 2, 19, 6, 2, -19 },
  { 1512, 16, 14, 19, 2, -14 },
  { 1540, 9, 14, 13, 2, -14 },
  { 1556, 11, 14, 13, 1, -14 },
  { 1576, 10, 20, 13, 2, -14 },
  { 1601, 10, 20, 13, 1, -14 },
  { 1626, 6, 14, 9, 2, -14 },
  { 1637, 8, 14, 10, 1, -14 },
  { 1651, 7, 16, 8, 0, -16 },
  { 1665, 9, 14, 13, 2, -14 },
  { 1681, 11, 14, 11, 0, -14 },
  { 1701, 17, 14, 17, 0, -14 },
  { 1731, 11, 14, 11, 0, -14 },
  { 1751, 11, 20, 11, 0, -14 },
  { 1779, 8, 14, 9, 1, -14 },
  { 1793, 7, 22, 9, 1, -18 },
  { 1813, 2, 25, 11, 5, -19 },
  { 1820, 7, 22, 9, 1, -18 },
  { 1840, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Medium25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_MEDIUM25PT7B_H_
