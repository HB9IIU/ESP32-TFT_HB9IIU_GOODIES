#ifndef _NOTOSANS_CONDENSED_MEDIUM27PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEC, 0x02, 0xFF, 0x80, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x0C, 0x60, 0x63, 0x03, 0x30, 0x19, 0x81, 0x8C,
  0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xCC, 0x06, 0x61, 0xFF, 0xEF,
  0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x01, 0x98, 0x18, 0xC0, 0x04,
  0x00, 0x80, 0x10, 0x1F, 0xE7, 0xFC, 0xC8, 0xB9, 0x07, 0x20, 0xE4, 0x0F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x0B, 0xC1, 0x38, 0x27, 0x84, 0xFF, 0xFB,
  0xFE, 0x0F, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x00, 0x1F, 0x03, 0x06,
  0xE1, 0x83, 0x98, 0x60, 0xC6, 0x38, 0x31, 0x8C, 0x0C, 0x63, 0x03, 0x19,
  0x80, 0xC6, 0x67, 0x39, 0xB3, 0xE6, 0xED, 0xD9, 0xF7, 0x63, 0x11, 0x98,
  0xC0, 0x66, 0x30, 0x31, 0x8C, 0x0C, 0x63, 0x07, 0x18, 0xC1, 0x86, 0x70,
  0xE0, 0xF8, 0x30, 0x3C, 0x04, 0x00, 0x7C, 0x03, 0xF8, 0x0C, 0x60, 0x71,
  0xC1, 0xC6, 0x03, 0x18, 0x0E, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE1, 0xDD,
  0xC6, 0xE3, 0x9B, 0x8E, 0xEE, 0x1F, 0xB8, 0x3C, 0xE0, 0xF3, 0xC7, 0xC7,
  0xFB, 0x8F, 0xC7, 0xFF, 0xFC, 0x1C, 0x63, 0x8C, 0x71, 0xC6, 0x18, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x0C, 0x38, 0x60, 0xC0, 0xE1,
  0x87, 0x0C, 0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18,
  0xE3, 0x8C, 0x71, 0x8E, 0x00, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xFF, 0xFF,
  0xF1, 0xE0, 0x7C, 0x33, 0x1C, 0xE1, 0x10, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x77, 0x66, 0xEC, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x04, 0x07,
  0xE0, 0xFE, 0x38, 0xE6, 0x1D, 0xC1, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x06, 0x71, 0xCE, 0x38, 0xFE,
  0x0F, 0x80, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x04, 0x0F, 0xE3, 0xFE, 0x30,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0x04,
  0x0F, 0xF3, 0xFF, 0x20, 0xE0, 0x1C, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x87,
  0xE0, 0xFC, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xD8, 0x7B,
  0xFE, 0x7F, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x07,
  0x60, 0x33, 0x03, 0x98, 0x18, 0xC1, 0x86, 0x0C, 0x30, 0xC1, 0x86, 0x0C,
  0x7F, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xCF,
  0xF9, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x7F, 0x8C, 0x78,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0xC3, 0xDF, 0xF1, 0xFC,
  0x00, 0x01, 0x01, 0xF8, 0x7F, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xEF, 0x9F, 0xFB, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x07, 0x70,
  0xCE, 0x38, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x00, 0x04, 0x07, 0xF1, 0xFF,
  0x38, 0xEE, 0x0D, 0xC1, 0x98, 0x33, 0x8E, 0x3B, 0x83, 0xE0, 0xFC, 0x3D,
  0xC7, 0x1D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x39, 0xFF, 0x1F, 0xC0,
  0x04, 0x07, 0xE1, 0xFE, 0x38, 0xEE, 0x1D, 0xC1, 0xB8, 0x3F, 0x07, 0xE0,
  0xFC, 0x3D, 0xCF, 0xBF, 0xF3, 0xEE, 0x01, 0x80, 0x30, 0x0E, 0x03, 0x80,
  0xF1, 0xFC, 0x3F, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x2F, 0xF8, 0x27, 0x77,
  0x00, 0x00, 0x00, 0x00, 0x77, 0x66, 0xEC, 0xC0, 0x00, 0x20, 0x1C, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x30, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x38, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0x60, 0x08, 0x00, 0x08, 0x3F, 0xBF, 0xE8, 0x70, 0x18,
  0x0C, 0x06, 0x07, 0x07, 0x07, 0x83, 0x83, 0x81, 0x80, 0xC0, 0x00, 0x00,
  0x08, 0x0E, 0x0F, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xEF, 0x81, 0xC0, 0x70,
  0xE0, 0x0C, 0x30, 0x01, 0x9C, 0x7E, 0x66, 0x3F, 0x99, 0x9C, 0x63, 0xE6,
  0x18, 0xF1, 0x8E, 0x3C, 0x63, 0x8F, 0x18, 0xE7, 0xC6, 0x39, 0xB9, 0xCE,
  0x66, 0x3E, 0xF1, 0x87, 0x38, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x40,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0,
  0x0E, 0xC0, 0x33, 0x00, 0xCE, 0x07, 0x38, 0x1C, 0x60, 0x61, 0xC3, 0x87,
  0x0F, 0xFC, 0x3F, 0xF0, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x1F, 0x80,
  0x7E, 0x01, 0xC0, 0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0E, 0xFF, 0x9F, 0xF3, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F,
  0x07, 0xE1, 0xFF, 0xFB, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xC2,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC2, 0x1F, 0xE0, 0xFE,
  0xFF, 0x07, 0xFE, 0x38, 0x79, 0xC1, 0xCE, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x06, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x1C, 0xE7, 0xC7, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x00, 0x00, 0xC0, 0x3F, 0xE1, 0xFF, 0x8F, 0x02, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xF8, 0x3F,
  0x60, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x38, 0x1C, 0xF0, 0x71, 0xFF,
  0xC3, 0xFE, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0xFD, 0xF3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3B, 0xFF, 0xC0, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xBF, 0x7C, 0xE0, 0xFE, 0x0E, 0xE1, 0xCE,
  0x38, 0xE3, 0x8E, 0x70, 0xEE, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x0E,
  0x70, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x70,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xDF, 0xE0, 0x6F, 0xB0,
  0x77, 0xD8, 0x33, 0xEE, 0x19, 0xF3, 0x1C, 0xF9, 0x8C, 0x7C, 0xE6, 0x3E,
  0x77, 0x1F, 0x1B, 0x0F, 0x8D, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xE0,
  0xF8, 0x70, 0x60, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xB8, 0x7D, 0xC3, 0xE7, 0x1F, 0x38, 0xF8, 0xE7, 0xC7, 0x3E, 0x1D,
  0xF0, 0xEF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0E, 0x01, 0x00,
  0x1F, 0xC0, 0x7F, 0xC1, 0xC1, 0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x30,
  0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x38, 0x38, 0x78, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1,
  0xDF, 0xFB, 0xFE, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xC1, 0xC7, 0x01,
  0xCE, 0x03, 0x9C, 0x07, 0x30, 0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x38, 0x38, 0x78,
  0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0xFF, 0x0F, 0xFC, 0xE3, 0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE3, 0xCF, 0xF8, 0xFF, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE1,
  0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x70, 0x06, 0x0F, 0xF7, 0xFD, 0xC2,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xF8, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0x70, 0xE7, 0xFE, 0x1F, 0x80, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x30, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0x63, 0x81,
  0xCE, 0x07, 0x30, 0x0C, 0xC0, 0x37, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xD8, 0x1E, 0x0E,
  0xE0, 0xF0, 0x67, 0x0F, 0x87, 0x38, 0x6C, 0x38, 0xC3, 0x61, 0xC6, 0x1B,
  0x8E, 0x39, 0xCC, 0x61, 0xCE, 0x67, 0x0E, 0x63, 0x38, 0x33, 0x1D, 0xC1,
  0x98, 0xEE, 0x0F, 0xC3, 0x60, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07,
  0xC0, 0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x71,
  0xC1, 0xDC, 0x0E, 0xE0, 0x36, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xE0,
  0x1B, 0x01, 0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x70, 0x73, 0x83, 0xB8,
  0x0E, 0xE0, 0x7B, 0x83, 0x9C, 0x18, 0x61, 0xC3, 0x8E, 0x1C, 0xE0, 0x77,
  0x03, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xFF, 0xFF, 0xF0, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xFF, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0xE0, 0x0F,
  0x01, 0xB0, 0x1B, 0x83, 0x98, 0x31, 0xC7, 0x0C, 0x60, 0xEE, 0x06, 0xC0,
  0x70, 0xFF, 0xFF, 0xFF, 0xE1, 0xC3, 0x06, 0x0C, 0x1F, 0x1F, 0xE3, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0xFD, 0xFF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3,
  0xDF, 0xB7, 0xCC, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B,
  0x86, 0xFC, 0xFF, 0xDC, 0x3B, 0x83, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x3B, 0xC7, 0x6F, 0xCC, 0xF0, 0x0F, 0x1F, 0xDF, 0xEE,
  0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x09, 0xFC,
  0x7E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xB9, 0xFB,
  0x7B, 0xEE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xEC, 0x1D, 0xC7, 0x9F, 0xB3, 0xE6, 0x0E, 0x07, 0xF1, 0xEF, 0x38, 0x66,
  0x0D, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x04,
  0x7F, 0x87, 0xF0, 0x07, 0x0F, 0xC7, 0xC7, 0x03, 0x81, 0xC0, 0xFD, 0xFE,
  0xFF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0x1E, 0x67, 0xED, 0xEF, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB0, 0x77, 0x1E, 0x7E, 0xCF, 0xB8,
  0x07, 0x00, 0xE0, 0x1D, 0x07, 0xBF, 0xE7, 0xF8, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0xF3, 0x7E, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xDF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x71, 0xC0, 0x00, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC6, 0xFB, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x1F,
  0x8E, 0xE3, 0xB9, 0xCE, 0xE3, 0xB0, 0xDC, 0x3F, 0x0F, 0xE3, 0x9C, 0xE7,
  0x38, 0xEE, 0x3B, 0x87, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xCF, 0x1E, 0x6F, 0xDF, 0xBF, 0xFD, 0xFC, 0x3C, 0x7E, 0x1C,
  0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0E, 0xCF, 0x37,
  0xEF, 0xBF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0x76, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB8, 0x77, 0x1C, 0x7F,
  0x87, 0xE0, 0xCF, 0x1B, 0xF3, 0xEF, 0x70, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEF, 0x1D, 0xBF, 0x33, 0xC7, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x1E, 0x67, 0xED, 0xEF, 0xB8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0x77,
  0x1E, 0x7E, 0xCF, 0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0xCF, 0xBF, 0x7F, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x00, 0x1E, 0x3F, 0xBC, 0xDC, 0x0E, 0x07, 0x01, 0xE0, 0x7C, 0x1F,
  0x03, 0x80, 0xE0, 0x78, 0x77, 0xFB, 0xF8, 0x18, 0x18, 0x38, 0x3F, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F,
  0x1F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x87, 0xE3, 0xDF, 0xB7, 0xCC, 0xE0, 0x7E, 0x06, 0x60,
  0xE7, 0x0E, 0x70, 0xC3, 0x1C, 0x31, 0xC3, 0x9C, 0x39, 0x81, 0xB8, 0x1B,
  0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0xE1, 0xF8, 0x78, 0x76,
  0x1E, 0x1D, 0xC7, 0x86, 0x71, 0xF1, 0x9C, 0x6C, 0xE3, 0x3B, 0x38, 0xCC,
  0xCC, 0x3B, 0x33, 0x0E, 0xCE, 0xC1, 0xB1, 0xF0, 0x78, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x80, 0xE1, 0xE0, 0x60, 0xEE, 0x1C, 0xC7, 0x1C, 0xE1, 0xB8,
  0x3F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6E, 0x1C, 0xE3, 0x1C, 0xE1,
  0xF8, 0x38, 0xE0, 0x7E, 0x06, 0x60, 0xE7, 0x0E, 0x70, 0xC3, 0x1C, 0x39,
  0xC3, 0x9C, 0x19, 0x81, 0xB8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF,
  0xFF, 0x0F, 0x1F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF8,
  0xE0, 0xF8, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF8, 0x38, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x07, 0x1F, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x38, 0xF8, 0xF0, 0xFC, 0x3F, 0xFE, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 11, 2, -19 },
  { 16, 13, 19, 14, 1, -19 },
  { 47, 11, 23, 13, 1, -21 },
  { 79, 18, 20, 20, 1, -20 },
  { 124, 14, 20, 15, 1, -20 },
  { 159, 2, 7, 6, 2, -19 },
  { 161, 6, 23, 8, 1, -19 },
  { 179, 6, 23, 8, 1, -19 },
  { 197, 10, 11, 12, 1, -21 },
  { 211, 11, 13, 13, 1, -16 },
  { 229, 4, 7, 7, 1, -3 },
  { 233, 6, 3, 8, 1, -9 },
  { 236, 3, 4, 7, 2, -4 },
  { 238, 10, 19, 10, 0, -19 },
  { 262, 11, 20, 13, 1, -20 },
  { 290, 7, 19, 13, 2, -19 },
  { 307, 11, 20, 13, 1, -20 },
  { 335, 11, 20, 13, 1, -20 },
  { 363, 13, 19, 13, 0, -19 },
  { 394, 11, 19, 13, 1, -19 },
  { 421, 11, 20, 13, 1, -20 },
  { 449, 11, 19, 13, 1, -19 },
  { 476, 11, 20, 13, 1, -20 },
  { 504, 11, 20, 13, 1, -20 },
  { 532, 3, 15, 7, 2, -15 },
  { 538, 4, 19, 7, 1, -15 },
  { 548, 11, 13, 13, 1, -16 },
  { 566, 11, 7, 13, 1, -13 },
  { 576, 11, 13, 13, 1, -16 },
  { 594, 9, 20, 10, 0, -20 },
  { 617, 18, 21, 20, 1, -19 },
  { 665, 14, 19, 14, 0, -19 },
  { 699, 11, 19, 15, 2, -19 },
  { 726, 12, 20, 14, 1, -20 },
  { 756, 13, 19, 16, 2, -19 },
  { 787, 9, 19, 12, 2, -19 },
  { 809, 9, 19, 12, 2, -19 },
  { 831, 14, 20, 16, 1, -20 },
  { 866, 12, 19, 16, 2, -19 },
  { 895, 6, 19, 8, 1, -19 },
  { 910, 7, 24, 7, -2, -19 },
  { 931, 12, 19, 14, 2, -19 },
  { 960, 9, 19, 12, 2, -19 },
  { 982, 17, 19, 21, 2, -19 },
  { 1023, 13, 19, 17, 2, -19 },
  { 1054, 15, 20, 17, 1, -20 },
  { 1092, 11, 19, 14, 2, -19 },
  { 1119, 15, 25, 17, 1, -20 },
  { 1166, 12, 19, 14, 2, -19 },
  { 1195, 10, 20, 12, 1, -20 },
  { 1220, 12, 19, 12, 0, -19 },
  { 1249, 12, 19, 16, 2, -19 },
  { 1278, 14, 19, 14, 0, -19 },
  { 1312, 21, 19, 21, 0, -19 },
  { 1362, 13, 19, 13, 0, -19 },
  { 1393, 13, 19, 13, 0, -19 },
  { 1424, 10, 19, 12, 1, -19 },
  { 1448, 6, 23, 9, 2, -19 },
  { 1466, 10, 19, 10, 0, -19 },
  { 1490, 6, 23, 9, 1, -19 },
  { 1508, 12, 11, 13, 1, -19 },
  { 1525, 12, 2, 12, 0, 2 },
  { 1528, 6, 5, 8, 1, -21 },
  { 1532, 10, 15, 13, 1, -15 },
  { 1551, 11, 21, 14, 2, -21 },
  { 1580, 9, 15, 11, 1, -15 },
  { 1597, 11, 21, 14, 1, -21 },
  { 1626, 11, 15, 13, 1, -15 },
  { 1647, 9, 21, 8, 0, -21 },
  { 1671, 11, 21, 14, 1, -15 },
  { 1700, 10, 21, 14, 2, -21 },
  { 1727, 3, 20, 6, 2, -20 },
  { 1735, 6, 26, 6, -1, -20 },
  { 1755, 10, 21, 13, 2, -21 },
  { 1782, 3, 21, 6, 2, -21 },
  { 1790, 17, 15, 21, 2, -15 },
  { 1822, 10, 15, 14, 2, -15 },
  { 1841, 11, 15, 14, 1, -15 },
  { 1862, 11, 21, 14, 2, -15 },
  { 1891, 11, 21, 14, 1, -15 },
  { 1920, 7, 15, 9, 2, -15 },
  { 1934, 9, 15, 11, 1, -15 },
  { 1951, 8, 18, 8, 0, -18 },
  { 1969, 10, 15, 14, 2, -15 },
  { 1988, 12, 15, 12, 0, -15 },
  { 2011, 18, 15, 18, 0, -15 },
  { 2045, 11, 15, 12, 0, -15 },
  { 2066, 12, 21, 12, 0, -15 },
  { 2098, 8, 15, 10, 1, -15 },
  { 2113, 8, 23, 10, 1, -19 },
  { 2136, 2, 27, 12, 5, -21 },
  { 2143, 8, 23, 10, 1, -19 },
  { 2166, 11, 3, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Medium27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_MEDIUM27PT7B_H_
