#ifndef _NOTOSANS_CONDENSED_MEDIUM28PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0xE7, 0xE7, 0xC7,
  0xC7, 0xC7, 0xC6, 0xC6, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6,
  0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x8F,
  0xFF, 0x7F, 0xF8, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0xE0, 0xE6,
  0x00, 0x04, 0x00, 0x80, 0x7E, 0x1F, 0xF7, 0xDD, 0xC8, 0x39, 0x07, 0x20,
  0x74, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x5E, 0x09, 0xC1, 0x18, 0x23, 0x84,
  0xFF, 0xFB, 0xFE, 0x07, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3C, 0x0E, 0x0F,
  0xC1, 0x81, 0x98, 0x70, 0x63, 0x0C, 0x0C, 0x61, 0x81, 0x8E, 0x60, 0x31,
  0xCC, 0x06, 0x33, 0x80, 0xC6, 0x67, 0x8C, 0xDD, 0xF9, 0xFB, 0x33, 0x1E,
  0x6E, 0x70, 0x19, 0xCE, 0x03, 0x39, 0xC0, 0xE7, 0x38, 0x18, 0xE7, 0x03,
  0x1C, 0xE0, 0xC1, 0x98, 0x18, 0x3F, 0x07, 0x03, 0xC0, 0x1F, 0x00, 0x7F,
  0x00, 0xE7, 0x01, 0x8E, 0x03, 0x1C, 0x06, 0x38, 0x0E, 0x60, 0x1D, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xFC, 0x73, 0xB8, 0xEE, 0x39, 0xDC, 0x3F, 0x38,
  0x7E, 0x70, 0x78, 0xE0, 0xF1, 0xE3, 0xF1, 0xFF, 0x71, 0xF8, 0xF0, 0xFF,
  0x6D, 0xB0, 0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC1, 0x83, 0x87, 0x07, 0x07, 0xE1,
  0x87, 0x0C, 0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0x8E, 0x39, 0xC6, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x76, 0x6F, 0xFE,
  0x3E, 0x07, 0xC1, 0xD8, 0x73, 0x86, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x77, 0x76, 0xEE, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0,
  0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03,
  0x80, 0x1F, 0x07, 0xF1, 0xE7, 0x38, 0xE6, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x07, 0x71,
  0xCF, 0x38, 0xFE, 0x0F, 0x80, 0x0E, 0x3C, 0xFB, 0xBE, 0xE9, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x3F,
  0x0F, 0xFB, 0xCF, 0x20, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xF9, 0x87, 0x20, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x3F, 0x87, 0xC0, 0xFE, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF8, 0x7B, 0xFF, 0x7F, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE0, 0xC7, 0x0C,
  0x38, 0x61, 0xC6, 0x0E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xF8, 0x7B, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0xF0,
  0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x38, 0xEF, 0xDF, 0xFB, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x3B, 0x07, 0x70, 0xEF, 0x38, 0xFF, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x00, 0x1F, 0x87, 0xF9, 0xC7, 0xB0, 0x76, 0x0E, 0xC1,
  0xDC, 0x33, 0xCE, 0x3F, 0x83, 0xE0, 0xFE, 0x39, 0xE7, 0x0F, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0xEE, 0x1D, 0xFF, 0x1F, 0xC0, 0x1F, 0x07, 0xF1, 0xCF,
  0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xFF, 0x9F,
  0xF1, 0xCE, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0xF1, 0xFC, 0x3F, 0x00,
  0xFF, 0xA0, 0x00, 0x00, 0x2F, 0xF8, 0x77, 0x72, 0x00, 0x00, 0x00, 0x00,
  0x77, 0x76, 0xEE, 0xC0, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xE1, 0xF0, 0x78,
  0x3C, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0x40,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x18, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0x78, 0x0C, 0x01, 0x00, 0x00, 0x7F, 0x3F, 0xE6, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x07, 0x01, 0xC0, 0x70, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0xE0, 0x70, 0x60, 0x0E, 0x38, 0x01, 0x8C, 0x3C, 0x76, 0x1F, 0x8D,
  0x8E, 0x63, 0x63, 0x18, 0xF9, 0xC6, 0x3E, 0x61, 0x8F, 0x98, 0x63, 0xE6,
  0x18, 0xF9, 0xCE, 0x36, 0x33, 0x9D, 0x8F, 0xBE, 0x61, 0xC7, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x10, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x36, 0x00, 0xEC, 0x01, 0xDC, 0x03, 0xB8, 0x06,
  0x70, 0x1C, 0x60, 0x38, 0xE0, 0x61, 0xC1, 0xC3, 0x83, 0xFF, 0x87, 0xFF,
  0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0x70,
  0xFF, 0x0F, 0xFC, 0xE3, 0xEE, 0x0E, 0xE0, 0xEE, 0x06, 0xE0, 0xEE, 0x0E,
  0xFF, 0xCF, 0xF0, 0xFF, 0xCE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x3E, 0xFF, 0xCF, 0xF8, 0x07, 0xF8, 0xFF, 0x8F, 0x8C, 0x70,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xF1, 0x87,
  0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0x3F, 0x3F, 0xF1, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x07, 0xF8,
  0x3F, 0xF1, 0xE1, 0x8F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x83, 0xFE, 0x0F, 0xD8, 0x3F, 0x70, 0x1D, 0xC0, 0x77, 0x01,
  0xDE, 0x07, 0x38, 0x1C, 0xF8, 0x71, 0xFF, 0xC1, 0xFE, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x73, 0xFF, 0xF0,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0xFE, 0xF8, 0x40, 0xE0,
  0x77, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x38, 0x71, 0xC3, 0x9C, 0x1D, 0xC0,
  0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xEE, 0x0E, 0x78, 0x71, 0xC3, 0x8F, 0x1C,
  0x38, 0xE1, 0xE7, 0x07, 0x38, 0x1D, 0xC0, 0xF0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFE, 0xC0, 0xDF, 0xB0,
  0x37, 0xEE, 0x1D, 0xF9, 0x86, 0x7E, 0x61, 0x9F, 0x9C, 0xE7, 0xE7, 0x31,
  0xF8, 0xCC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xE1, 0xF8, 0x78, 0x7E,
  0x1E, 0x1F, 0x83, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x7E, 0xE1, 0xFB, 0x87, 0xE7, 0x1F, 0x9C, 0x7E, 0x39, 0xF8,
  0xE7, 0xE1, 0xDF, 0x87, 0x7E, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0x0F, 0xE0, 0x3F, 0xE0, 0xF1, 0xE1, 0xC0, 0xE7, 0x01,
  0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x38, 0x1C, 0x78,
  0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x1F, 0xF3, 0x9F, 0x70, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0xFF, 0x7F, 0x8E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0xE0, 0x3F,
  0xF0, 0xF1, 0xE1, 0xC0, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x0E, 0x38, 0x1C, 0x78, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0xFF, 0x0F, 0xFC, 0xFF,
  0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF,
  0x8F, 0xF0, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0,
  0xFE, 0x07, 0x1F, 0xE7, 0xF9, 0xE7, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x81, 0xDC, 0x7B, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x73, 0xC7, 0x8F, 0xF8, 0x3F, 0x80, 0xE0, 0x1F, 0x80,
  0x77, 0x01, 0xDC, 0x0E, 0x70, 0x38, 0xC0, 0xE3, 0x83, 0x0E, 0x1C, 0x38,
  0x70, 0x61, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x33, 0x00, 0xEC, 0x03,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x38, 0x1F, 0x81,
  0xE0, 0x76, 0x07, 0x81, 0xDC, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC3, 0xF0,
  0xE7, 0x0F, 0xC3, 0x8C, 0x33, 0x0C, 0x38, 0xCC, 0x70, 0xE3, 0x39, 0xC3,
  0x9C, 0xE7, 0x06, 0x71, 0x9C, 0x1D, 0x86, 0x60, 0x76, 0x1B, 0x81, 0xD8,
  0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x70, 0x3B, 0x83, 0x8E, 0x1C, 0x71, 0xC1, 0xCE, 0x0E,
  0xE0, 0x37, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xFC,
  0x0E, 0xE0, 0x73, 0x87, 0x1C, 0x38, 0x73, 0x83, 0x9C, 0x1F, 0xC0, 0x70,
  0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0x73, 0x03,
  0xB8, 0x0D, 0xC0, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xE0, 0x1C, 0x07, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0xFF, 0xF1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x7F, 0xFF, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1B, 0x83, 0x98, 0x31,
  0xC3, 0x0C, 0x70, 0xE6, 0x06, 0xE0, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xF1,
  0xC3, 0x87, 0x3F, 0x9F, 0xF2, 0x1C, 0x03, 0x00, 0xC0, 0x31, 0xFD, 0xFF,
  0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE3, 0xDF, 0xB7, 0xCC, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xF1, 0xDC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0x6F,
  0xEC, 0xF8, 0x1F, 0xCF, 0xE7, 0x89, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x06, 0x01, 0xC0, 0x78, 0x8F, 0xE1, 0xF8, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1F, 0x73, 0xFF, 0x71, 0xF7, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F,
  0x79, 0xF3, 0xFF, 0x1F, 0x70, 0x1F, 0x87, 0xF9, 0xC7, 0x38, 0x76, 0x0F,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x84, 0x7F,
  0x87, 0xF0, 0x0F, 0x8F, 0xC7, 0x07, 0x03, 0x81, 0xC1, 0xFD, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0x1F, 0x73, 0xFF, 0x71, 0xF7, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x79, 0xF3, 0xF7, 0x1F,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x40, 0xE7, 0xFC, 0x7F, 0xC1, 0xE0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xF1, 0xDC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0E, 0xDF, 0xA0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x18, 0x71, 0xC2, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xEF, 0xB8, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x77, 0x1C, 0xE3, 0x9C, 0xE3, 0xB8,
  0x77, 0x0F, 0xC1, 0xFC, 0x3D, 0x87, 0x38, 0xE3, 0x9C, 0x73, 0x87, 0x70,
  0xEE, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xCF, 0x9F,
  0x37, 0xFF, 0xEF, 0x1F, 0x3F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x30, 0x7E,
  0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83,
  0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1C, 0xCF, 0x9B, 0xFB, 0xC7,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0x1F, 0x83, 0xFC, 0x70, 0xE7, 0x0E, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0E, 0x79,
  0xE3, 0xFC, 0x1F, 0x80, 0xCF, 0x9B, 0xFB, 0xC7, 0x70, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1D, 0xFF, 0xBB,
  0xE7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x1F,
  0x73, 0xFF, 0x71, 0xF7, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x79, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xCF, 0xBF, 0xEF, 0x8E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x3F, 0xBF,
  0xB8, 0x5C, 0x0E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x01, 0xC0, 0xE0, 0x7C,
  0x7F, 0xFB, 0xF8, 0x18, 0x18, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x1F, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFF, 0x3E, 0xFF, 0xCF, 0xB8, 0xE0, 0x76, 0x07, 0x70, 0xE7, 0x0E,
  0x70, 0xE3, 0x0C, 0x39, 0xC3, 0x9C, 0x19, 0xC1, 0x98, 0x1F, 0x81, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xE0, 0xEC, 0x1C, 0x19, 0xC7, 0xC3,
  0x38, 0xD8, 0xE7, 0x1B, 0x1C, 0x63, 0x63, 0x0C, 0xEE, 0x61, 0xDC, 0xDC,
  0x3B, 0x1B, 0x83, 0x63, 0x70, 0x6C, 0x6C, 0x0D, 0x8D, 0x81, 0xE0, 0xF0,
  0x3C, 0x1E, 0x03, 0x83, 0x80, 0x70, 0xF7, 0x0E, 0x39, 0xC3, 0x9C, 0x1F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1D, 0x83, 0x9C, 0x38,
  0xE7, 0x0E, 0xF0, 0x70, 0xE0, 0x76, 0x07, 0x70, 0xE7, 0x0E, 0x30, 0xE3,
  0x8C, 0x39, 0xC3, 0x9C, 0x19, 0xC1, 0xD8, 0x1F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0xC0, 0x78, 0x07,
  0x00, 0xFF, 0x7F, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0xFF, 0xFE, 0x07, 0x0F, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0xF0, 0xE0, 0x78, 0x18, 0x18, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xF8, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x1C, 0x0F, 0x07, 0x1E, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x38, 0xF8, 0xF0, 0x38, 0x3F, 0xC7, 0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_Condensed_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 8, 7, 11, 2, -20 },
  { 16, 13, 20, 15, 1, -20 },
  { 49, 11, 23, 13, 1, -21 },
  { 81, 19, 20, 21, 1, -20 },
  { 129, 15, 20, 16, 1, -20 },
  { 167, 3, 7, 6, 2, -20 },
  { 170, 7, 24, 8, 1, -20 },
  { 191, 6, 24, 8, 1, -20 },
  { 209, 11, 10, 13, 1, -21 },
  { 223, 11, 14, 13, 1, -17 },
  { 243, 4, 7, 7, 1, -3 },
  { 247, 6, 3, 8, 1, -9 },
  { 250, 3, 4, 7, 2, -4 },
  { 252, 10, 20, 11, 0, -20 },
  { 277, 11, 20, 13, 1, -20 },
  { 305, 7, 20, 13, 2, -20 },
  { 323, 11, 20, 13, 1, -20 },
  { 351, 11, 20, 13, 1, -20 },
  { 379, 13, 20, 13, 0, -20 },
  { 412, 11, 20, 13, 1, -20 },
  { 440, 11, 20, 13, 1, -20 },
  { 468, 11, 20, 13, 1, -20 },
  { 496, 11, 20, 13, 1, -20 },
  { 524, 11, 20, 13, 1, -20 },
  { 552, 3, 15, 7, 2, -15 },
  { 558, 4, 19, 7, 1, -15 },
  { 568, 11, 14, 13, 1, -17 },
  { 588, 11, 8, 13, 1, -14 },
  { 599, 11, 14, 13, 1, -17 },
  { 619, 10, 20, 10, 0, -20 },
  { 644, 18, 22, 21, 1, -20 },
  { 694, 15, 20, 15, 0, -20 },
  { 732, 12, 20, 15, 2, -20 },
  { 762, 13, 20, 14, 1, -20 },
  { 795, 13, 20, 16, 2, -20 },
  { 828, 9, 20, 13, 2, -20 },
  { 851, 9, 20, 12, 2, -20 },
  { 874, 14, 20, 17, 1, -20 },
  { 909, 13, 20, 17, 2, -20 },
  { 942, 7, 20, 9, 1, -20 },
  { 960, 7, 26, 7, -2, -20 },
  { 983, 13, 20, 14, 2, -20 },
  { 1016, 9, 20, 12, 2, -20 },
  { 1039, 18, 20, 22, 2, -20 },
  { 1084, 14, 20, 18, 2, -20 },
  { 1119, 15, 20, 18, 1, -20 },
  { 1157, 11, 20, 14, 2, -20 },
  { 1185, 15, 25, 18, 1, -20 },
  { 1232, 12, 20, 15, 2, -20 },
  { 1262, 11, 20, 13, 1, -20 },
  { 1290, 12, 20, 12, 0, -20 },
  { 1320, 13, 20, 17, 2, -20 },
  { 1353, 14, 20, 14, 0, -20 },
  { 1388, 22, 20, 22, 0, -20 },
  { 1443, 13, 20, 13, 0, -20 },
  { 1476, 13, 20, 13, 0, -20 },
  { 1509, 11, 20, 12, 1, -20 },
  { 1537, 6, 24, 9, 2, -20 },
  { 1555, 10, 20, 11, 0, -20 },
  { 1580, 6, 24, 9, 1, -20 },
  { 1598, 12, 12, 14, 1, -20 },
  { 1616, 12, 2, 12, 0, 2 },
  { 1619, 6, 4, 8, 1, -21 },
  { 1622, 10, 15, 13, 1, -15 },
  { 1641, 11, 21, 14, 2, -21 },
  { 1670, 10, 15, 11, 1, -15 },
  { 1689, 12, 21, 14, 1, -21 },
  { 1721, 11, 15, 13, 1, -15 },
  { 1742, 9, 21, 8, 0, -21 },
  { 1766, 12, 22, 14, 1, -15 },
  { 1799, 11, 21, 14, 2, -21 },
  { 1828, 3, 21, 7, 2, -21 },
  { 1836, 6, 28, 7, -1, -21 },
  { 1857, 11, 21, 13, 2, -21 },
  { 1886, 3, 21, 7, 2, -21 },
  { 1894, 18, 15, 22, 2, -15 },
  { 1928, 11, 15, 14, 2, -15 },
  { 1949, 12, 15, 14, 1, -15 },
  { 1972, 11, 22, 14, 2, -15 },
  { 2003, 12, 22, 14, 1, -15 },
  { 2036, 7, 15, 10, 2, -15 },
  { 2050, 9, 15, 11, 1, -15 },
  { 2067, 8, 18, 9, 0, -18 },
  { 2085, 11, 15, 14, 2, -15 },
  { 2106, 12, 15, 12, 0, -15 },
  { 2129, 19, 15, 19, 0, -15 },
  { 2165, 12, 15, 12, 0, -15 },
  { 2188, 12, 22, 12, 0, -15 },
  { 2221, 9, 15, 10, 1, -15 },
  { 2238, 8, 24, 10, 1, -20 },
  { 2262, 3, 28, 13, 5, -21 },
  { 2273, 8, 24, 10, 1, -20 },
  { 2297, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_Medium28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_MEDIUM28PT7B_H_
