#ifndef _NOTOSANS_CONDENSED_MEDIUM21PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0xDB, 0x69, 0x05, 0xF8, 0xCF, 0x3C, 0xF3, 0x4C, 0x0C,
  0x81, 0x30, 0x26, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0x88, 0x13, 0x1F,
  0xFB, 0xFF, 0x19, 0x83, 0x20, 0x64, 0x09, 0x80, 0x18, 0x18, 0x7F, 0xFF,
  0xD8, 0xD8, 0xD8, 0x78, 0x3C, 0x1F, 0x1B, 0x1B, 0x9B, 0xFE, 0x7C, 0x18,
  0x18, 0x70, 0x63, 0x63, 0x0C, 0x8C, 0x32, 0x20, 0xC9, 0x83, 0x24, 0x0C,
  0xB7, 0xB6, 0xD6, 0x72, 0xCC, 0x1B, 0x30, 0x4C, 0xC3, 0x33, 0x0C, 0xCC,
  0x61, 0x61, 0x87, 0x80, 0x3C, 0x0F, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xF8,
  0x0F, 0x03, 0xC0, 0xEC, 0xD9, 0xDB, 0x1F, 0x61, 0xCC, 0x39, 0xFF, 0x9F,
  0x38, 0xFF, 0x40, 0x19, 0x98, 0xC6, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x31,
  0x8C, 0x31, 0xC0, 0xC4, 0x66, 0x33, 0x33, 0x33, 0x33, 0x33, 0x66, 0x6C,
  0x18, 0x18, 0x91, 0xFF, 0x18, 0x3C, 0x6E, 0x64, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7F, 0x68, 0xFF, 0xC0, 0x5F, 0x80,
  0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0x3C, 0x7E, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x66, 0x7E, 0x3C, 0x0C, 0x77, 0xFB, 0x4C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7C, 0xFE, 0x47, 0x03, 0x03, 0x06,
  0x06, 0x0E, 0x0C, 0x18, 0x30, 0x70, 0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0x87,
  0x03, 0x03, 0x06, 0x3C, 0x3C, 0x06, 0x03, 0x03, 0x03, 0x07, 0xFE, 0xFC,
  0x03, 0x01, 0xC0, 0x70, 0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x10,
  0xCF, 0xFF, 0xFF, 0x03, 0x00, 0xC0, 0x30, 0x7E, 0x7E, 0x60, 0x40, 0xC0,
  0xC0, 0xFE, 0x7E, 0x07, 0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0x1E, 0x3E,
  0x60, 0x60, 0xC0, 0xC8, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0x63, 0x7E,
  0x3C, 0xFF, 0xFF, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x70, 0x3E, 0x7E, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x3C,
  0x6E, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7E, 0x3C, 0x7E, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xE7, 0x7F, 0x13, 0x03, 0x06, 0x06, 0x7C, 0x78, 0xFD, 0x00,
  0x00, 0x5F, 0x80, 0xFD, 0x00, 0x00, 0x0F, 0xED, 0x00, 0x01, 0x07, 0x1C,
  0x70, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x0F, 0x3C, 0xF0, 0xC0, 0x7D, 0xFC, 0x18,
  0x30, 0x60, 0xC3, 0x0C, 0x30, 0x60, 0xC0, 0x03, 0x07, 0x0C, 0x00, 0x0F,
  0xC0, 0x71, 0x83, 0x03, 0x18, 0x06, 0x67, 0xDB, 0x33, 0x2C, 0xCC, 0xF2,
  0x33, 0xC8, 0xCB, 0x23, 0x2C, 0xDD, 0xB3, 0xDE, 0x46, 0x21, 0x80, 0x03,
  0x02, 0x07, 0xF0, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x28, 0x0D, 0x81, 0xB0,
  0x36, 0x0C, 0x61, 0x8C, 0x31, 0x87, 0xF1, 0xFF, 0x30, 0x66, 0x0D, 0xC1,
  0xF0, 0x18, 0xFC, 0xFF, 0xC7, 0xC3, 0xC3, 0xC3, 0xFE, 0xFE, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0x1F, 0x9F, 0xDC, 0x0C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0xFC, 0x7E, 0xFC, 0x7F,
  0x31, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C,
  0x77, 0xF3, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0x7E, 0xC1, 0x83,
  0x06, 0x0C, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E,
  0xFD, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x1F, 0xCF, 0xF7, 0x05, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x0F, 0xC3, 0xF0, 0x3E, 0x0D, 0x83, 0x70, 0xCF,
  0xF1, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xFB, 0x98, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x3B, 0xE0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x3F, 0xB8, 0xC3, 0xE3, 0xB1, 0x99, 0x8C, 0xC6, 0xC3,
  0xE1, 0xF0, 0xF8, 0x66, 0x33, 0x98, 0xCC, 0x76, 0x1B, 0x0E, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x80,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x05, 0xF8, 0x6F, 0x63, 0x7B,
  0x13, 0xD9, 0x9E, 0x6C, 0xF3, 0x67, 0x9E, 0x3C, 0x71, 0xE3, 0x8F, 0x18,
  0x60, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xF6, 0x3D, 0x8F, 0x33, 0xCC,
  0xF1, 0xBC, 0x6F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1C, 0x1F, 0x07, 0xF1, 0xC3,
  0x30, 0x7E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xB0,
  0x77, 0x0C, 0x7F, 0x07, 0xC0, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7,
  0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x07, 0xF9, 0xC3,
  0x30, 0x7E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xB0,
  0x77, 0x0C, 0x7F, 0x87, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0xFC,
  0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x3B, 0x19, 0xFC, 0xF8, 0x66, 0x33, 0x18,
  0xCC, 0x76, 0x1B, 0x0E, 0x3F, 0x7E, 0xC2, 0xC0, 0xC0, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x03, 0x03, 0x86, 0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x3F, 0xF9, 0xF8, 0xC0, 0xFC, 0x19, 0x83, 0x30, 0x66, 0x18,
  0x63, 0x0C, 0x61, 0x8C, 0x33, 0x03, 0x60, 0x6C, 0x0D, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0xC1, 0x83, 0xF0, 0xE1, 0x98, 0x70, 0xCC, 0x38, 0x66, 0x34,
  0x73, 0x1B, 0x31, 0xCD, 0x98, 0x64, 0xCC, 0x36, 0x66, 0x1B, 0x16, 0x0D,
  0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE0, 0xE0, 0x70, 0x60, 0xE1, 0xD8,
  0x63, 0x38, 0xCC, 0x1F, 0x07, 0x81, 0xE0, 0x30, 0x1E, 0x07, 0x83, 0x30,
  0xCC, 0x71, 0x98, 0x6E, 0x1C, 0xC1, 0xD8, 0x66, 0x19, 0xCC, 0x33, 0x0D,
  0x81, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC7, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x04, 0x06, 0x06, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0x0C, 0x03, 0x01, 0xE0, 0x68, 0x33, 0x0C, 0x42, 0x19,
  0x82, 0xC0, 0xC0, 0xFF, 0x80, 0xE6, 0x30, 0x08, 0x7E, 0x46, 0x06, 0x07,
  0x3F, 0xFF, 0xC7, 0xC7, 0xC7, 0xEF, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x46, 0xFB, 0xCD, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0xFD,
  0xBC, 0x08, 0x7D, 0x8F, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0xF9, 0xF0,
  0x03, 0x03, 0x03, 0x03, 0x13, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0x7F, 0x3D, 0x08, 0x7E, 0x66, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0,
  0xC0, 0xE0, 0x7F, 0x3F, 0x1E, 0x78, 0xC1, 0x83, 0x1F, 0x8C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x7D, 0x67, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0x03, 0x03, 0x83, 0x7F, 0x7C, 0xE0,
  0xE0, 0xE0, 0xE0, 0xC4, 0xDF, 0xF3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0x5D, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x11, 0xC4, 0x00,
  0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCD, 0xEE, 0x00, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1B, 0x99, 0xD8, 0xFC, 0x6C, 0x3F, 0x1D,
  0x8E, 0x67, 0x33, 0x8D, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04,
  0x23, 0x7B, 0xEF, 0x79, 0xF8, 0xE3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xF8,
  0xC3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0x04, 0xDF, 0xF3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x08, 0x3F, 0x19, 0xD8,
  0x6C, 0x3E, 0x0F, 0x07, 0x87, 0xC3, 0x71, 0x9F, 0xC7, 0xC0, 0x04, 0x6F,
  0xBC, 0xDC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF, 0xDB, 0xCE,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x10, 0x7D, 0x67, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0x7F, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x11, 0xFC, 0x70, 0xC3,
  0xC3, 0x87, 0x0C, 0x3F, 0xFE, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x3C, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0x7F, 0x3D, 0xC1, 0xB1, 0x98, 0xCC, 0x66, 0x31, 0xB0, 0xD8, 0x6C,
  0x14, 0x0E, 0x07, 0x00, 0xC3, 0x8D, 0x8E, 0x36, 0x79, 0x99, 0xA6, 0x66,
  0x98, 0xD3, 0x63, 0xCD, 0x0F, 0x3C, 0x3C, 0x70, 0xF1, 0xC1, 0x87, 0x00,
  0xE3, 0xB9, 0x8D, 0x87, 0xC1, 0xC0, 0xE0, 0x70, 0x6C, 0x37, 0x31, 0xB8,
  0xE0, 0xC1, 0xB1, 0x98, 0xCC, 0x63, 0x31, 0xB0, 0xD8, 0x6C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC3, 0xC1, 0xC0, 0xFC, 0x31, 0x86, 0x30, 0xC6,
  0x18, 0xC3, 0xFF, 0xC0, 0x1C, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xE3, 0x87,
  0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC3, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0x73, 0x0C, 0x30, 0xC3, 0x0C,
  0x73, 0x80, 0x71, 0xFF, 0x8F,
};

const GFXglyph NotoSans_Condensed_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 6, 5, 9, 1, -15 },
  { 11, 11, 15, 11, 0, -15 },
  { 32, 8, 17, 10, 1, -16 },
  { 49, 14, 15, 16, 1, -15 },
  { 76, 11, 15, 12, 1, -15 },
  { 97, 2, 5, 5, 1, -15 },
  { 99, 5, 18, 6, 1, -15 },
  { 111, 4, 18, 6, 1, -15 },
  { 120, 8, 8, 9, 1, -16 },
  { 128, 8, 10, 10, 1, -12 },
  { 138, 3, 5, 5, 1, -2 },
  { 140, 5, 2, 6, 1, -7 },
  { 142, 3, 3, 5, 1, -3 },
  { 144, 8, 15, 8, 0, -15 },
  { 159, 8, 15, 10, 1, -15 },
  { 174, 6, 15, 10, 1, -15 },
  { 186, 8, 15, 10, 1, -15 },
  { 201, 8, 15, 10, 1, -15 },
  { 216, 10, 15, 10, 0, -15 },
  { 235, 8, 15, 10, 1, -15 },
  { 250, 8, 15, 10, 1, -15 },
  { 265, 8, 15, 10, 1, -15 },
  { 280, 8, 15, 10, 1, -15 },
  { 295, 8, 15, 10, 1, -15 },
  { 310, 3, 11, 5, 1, -11 },
  { 315, 3, 14, 5, 1, -11 },
  { 321, 8, 9, 10, 1, -12 },
  { 330, 8, 6, 10, 1, -10 },
  { 336, 8, 9, 10, 1, -12 },
  { 345, 7, 15, 8, 0, -15 },
  { 359, 14, 17, 16, 1, -15 },
  { 389, 11, 15, 11, 0, -15 },
  { 410, 8, 15, 11, 2, -15 },
  { 425, 9, 15, 11, 1, -15 },
  { 442, 9, 15, 12, 2, -15 },
  { 459, 7, 15, 10, 2, -15 },
  { 473, 7, 15, 9, 2, -15 },
  { 487, 10, 15, 13, 1, -15 },
  { 506, 9, 15, 13, 2, -15 },
  { 523, 5, 15, 7, 1, -15 },
  { 533, 5, 19, 5, -1, -15 },
  { 545, 9, 15, 11, 2, -15 },
  { 562, 7, 15, 9, 2, -15 },
  { 576, 13, 15, 17, 2, -15 },
  { 601, 10, 15, 14, 2, -15 },
  { 620, 11, 15, 13, 1, -15 },
  { 641, 8, 15, 11, 2, -15 },
  { 656, 11, 19, 13, 1, -15 },
  { 683, 9, 15, 11, 2, -15 },
  { 700, 8, 15, 10, 1, -15 },
  { 715, 9, 15, 9, 0, -15 },
  { 732, 9, 15, 13, 2, -15 },
  { 749, 11, 15, 11, 0, -15 },
  { 770, 17, 15, 17, 0, -15 },
  { 802, 10, 15, 10, 0, -15 },
  { 821, 10, 15, 10, 0, -15 },
  { 840, 8, 15, 9, 1, -15 },
  { 855, 5, 18, 7, 1, -15 },
  { 867, 8, 15, 8, 0, -15 },
  { 882, 4, 18, 7, 1, -15 },
  { 891, 10, 9, 10, 0, -15 },
  { 903, 9, 1, 9, 0, 2 },
  { 905, 4, 3, 6, 1, -16 },
  { 907, 8, 12, 10, 1, -12 },
  { 919, 9, 16, 11, 1, -16 },
  { 937, 7, 12, 8, 1, -12 },
  { 948, 8, 16, 11, 1, -16 },
  { 964, 8, 12, 10, 1, -12 },
  { 976, 7, 16, 6, 0, -16 },
  { 990, 8, 17, 11, 1, -12 },
  { 1007, 8, 16, 11, 1, -16 },
  { 1023, 3, 16, 5, 1, -16 },
  { 1029, 5, 21, 5, -1, -16 },
  { 1043, 9, 16, 10, 1, -16 },
  { 1061, 3, 16, 5, 1, -16 },
  { 1067, 14, 12, 16, 1, -12 },
  { 1088, 8, 12, 11, 1, -12 },
  { 1100, 9, 12, 11, 1, -12 },
  { 1114, 9, 17, 11, 1, -12 },
  { 1134, 8, 17, 11, 1, -12 },
  { 1151, 6, 12, 7, 1, -12 },
  { 1160, 6, 12, 8, 1, -12 },
  { 1169, 6, 14, 7, 0, -14 },
  { 1180, 8, 11, 11, 1, -11 },
  { 1191, 9, 11, 9, 0, -11 },
  { 1204, 14, 11, 14, 0, -11 },
  { 1224, 9, 11, 9, 0, -11 },
  { 1237, 9, 16, 9, 0, -11 },
  { 1255, 6, 11, 8, 1, -11 },
  { 1264, 6, 18, 8, 1, -15 },
  { 1278, 2, 21, 10, 4, -16 },
  { 1284, 6, 18, 8, 1, -15 },
  { 1298, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Medium21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_MEDIUM21PT7B_H_
