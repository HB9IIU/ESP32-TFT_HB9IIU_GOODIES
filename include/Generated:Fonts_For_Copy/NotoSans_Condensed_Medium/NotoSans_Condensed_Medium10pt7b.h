#ifndef _NOTOSANS_CONDENSED_MEDIUM10PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF8, 0x31, 0xBE, 0xAF, 0xA9, 0x40, 0x27, 0xA6, 0x33, 0xB6,
  0x20, 0x6D, 0x52, 0xA3, 0xF1, 0xA5, 0x49, 0x80, 0x71, 0x47, 0x1A, 0x9A,
  0x67, 0xC0, 0xC0, 0x69, 0x48, 0x92, 0x20, 0xC9, 0x12, 0x92, 0x80, 0x2B,
  0x65, 0x22, 0xF2, 0x20, 0x60, 0xE0, 0x80, 0x32, 0x24, 0x44, 0x80, 0x75,
  0x99, 0x95, 0x70, 0x75, 0x54, 0xF1, 0x13, 0x24, 0xF0, 0xF1, 0x17, 0x11,
  0xF0, 0x31, 0x94, 0xA9, 0x3C, 0x40, 0xF2, 0x72, 0x78, 0x74, 0xAD, 0x95,
  0x70, 0xF1, 0x12, 0x22, 0x40, 0x75, 0x56, 0x99, 0x70, 0x79, 0x97, 0x11,
  0x60, 0x88, 0x40, 0x60, 0x12, 0xC3, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80,
  0xE4, 0xA4, 0x10, 0x3C, 0x85, 0x6D, 0x5A, 0xAA, 0x90, 0x1C, 0x21, 0x94,
  0xA7, 0xE6, 0x20, 0xE9, 0x9E, 0x99, 0xE0, 0xF8, 0x88, 0x88, 0x70, 0xE9,
  0x99, 0x99, 0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x78, 0x8B, 0x99,
  0x70, 0x99, 0x9F, 0x99, 0x90, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xC0,
  0x9A, 0xCC, 0xAA, 0x90, 0x92, 0x49, 0x38, 0x8F, 0x3C, 0xF5, 0xB6, 0xDA,
  0x40, 0x8E, 0x73, 0x5A, 0xCE, 0x60, 0xF4, 0xA3, 0x18, 0xC9, 0xC0, 0xE9,
  0x9E, 0x88, 0x80, 0xF4, 0xE3, 0x18, 0xCB, 0xC2, 0x18, 0xE9, 0x9E, 0xAA,
  0x90, 0x7C, 0x42, 0x11, 0xF0, 0xF2, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99,
  0xF0, 0x8C, 0x54, 0xA5, 0x28, 0x80, 0x99, 0x99, 0x5A, 0x5A, 0x66, 0x66,
  0x64, 0xDA, 0x98, 0x45, 0x2A, 0x60, 0x9A, 0x94, 0xC2, 0x10, 0x80, 0xF1,
  0x22, 0x44, 0xF0, 0xEA, 0xAA, 0xC0, 0x84, 0x44, 0x22, 0x10, 0xD5, 0x55,
  0xC0, 0x22, 0x95, 0x10, 0xF0, 0xD0, 0x71, 0x79, 0x70, 0x88, 0xCA, 0x99,
  0x9E, 0x25, 0x48, 0x47, 0x08, 0x4A, 0xBD, 0xC5, 0x6D, 0x79, 0xF4, 0x70,
  0x29, 0x74, 0x92, 0x22, 0xF7, 0x15, 0xB4, 0x4E, 0x88, 0xCA, 0x99, 0x99,
  0xBE, 0x45, 0x55, 0xC0, 0x88, 0x9A, 0xCC, 0xAB, 0xFF, 0x4A, 0xDA, 0x69,
  0xA6, 0x90, 0x4A, 0x99, 0x99, 0x22, 0xB3, 0x15, 0x38, 0x4A, 0x99, 0x9E,
  0x88, 0x22, 0xF7, 0x15, 0xB4, 0x21, 0x7A, 0xA0, 0x2D, 0xC6, 0x1E, 0x4B,
  0xA4, 0x98, 0xB6, 0xDE, 0x95, 0x66, 0x60, 0x92, 0xE9, 0xB3, 0x66, 0xC0,
  0xD6, 0x66, 0x90, 0x95, 0x66, 0x22, 0xC0, 0xE5, 0x2E, 0x29, 0x2C, 0x92,
  0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_Medium10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 4, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 1, 2, 2, 1, -7 },
  { 27, 3, 9, 3, 0, -7 },
  { 31, 3, 9, 3, 0, -7 },
  { 35, 4, 4, 5, 0, -8 },
  { 37, 4, 5, 5, 0, -6 },
  { 40, 2, 2, 2, 0, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 1, 1, 2, 1, -1 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 2, 7, 5, 1, -7 },
  { 53, 4, 7, 5, 0, -7 },
  { 57, 4, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 3, 7, 5, 1, -7 },
  { 69, 4, 7, 5, 0, -7 },
  { 73, 4, 7, 5, 0, -7 },
  { 77, 4, 7, 5, 0, -7 },
  { 81, 4, 7, 5, 0, -7 },
  { 85, 1, 5, 2, 1, -5 },
  { 86, 2, 6, 2, 0, -5 },
  { 88, 4, 5, 5, 0, -6 },
  { 91, 4, 3, 5, 0, -5 },
  { 93, 4, 5, 5, 0, -6 },
  { 96, 3, 7, 4, 0, -7 },
  { 99, 7, 8, 7, 0, -7 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 4, 7, 5, 1, -7 },
  { 115, 4, 7, 5, 1, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 3, 7, 5, 1, -7 },
  { 126, 3, 7, 4, 1, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 3, 7, 3, 0, -7 },
  { 140, 3, 9, 3, -1, -7 },
  { 144, 4, 7, 5, 1, -7 },
  { 148, 3, 7, 4, 1, -7 },
  { 151, 6, 7, 8, 1, -7 },
  { 157, 5, 7, 6, 1, -7 },
  { 162, 5, 7, 6, 1, -7 },
  { 167, 4, 7, 5, 1, -7 },
  { 171, 5, 9, 6, 1, -7 },
  { 177, 4, 7, 5, 1, -7 },
  { 181, 4, 7, 5, 0, -7 },
  { 185, 4, 7, 4, 0, -7 },
  { 189, 4, 7, 6, 1, -7 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 8, 7, 8, 0, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 5, 7, 5, 0, -7 },
  { 215, 4, 7, 4, 0, -7 },
  { 219, 2, 9, 3, 1, -7 },
  { 222, 4, 7, 4, 0, -7 },
  { 226, 2, 9, 3, 0, -7 },
  { 229, 5, 4, 5, 0, -7 },
  { 232, 4, 1, 4, 0, 1 },
  { 233, 2, 2, 3, 0, -8 },
  { 234, 4, 5, 5, 0, -5 },
  { 237, 4, 8, 5, 1, -8 },
  { 241, 4, 6, 4, 0, -6 },
  { 244, 5, 8, 5, 0, -8 },
  { 249, 4, 5, 5, 0, -5 },
  { 252, 3, 8, 3, 0, -8 },
  { 255, 5, 8, 5, 0, -6 },
  { 260, 4, 8, 5, 1, -8 },
  { 264, 1, 7, 2, 1, -7 },
  { 265, 2, 9, 2, 0, -7 },
  { 268, 4, 8, 5, 1, -8 },
  { 272, 1, 8, 2, 1, -8 },
  { 273, 6, 6, 8, 1, -6 },
  { 278, 4, 6, 5, 1, -6 },
  { 281, 5, 6, 5, 0, -6 },
  { 285, 4, 8, 5, 1, -6 },
  { 289, 5, 8, 5, 0, -6 },
  { 294, 2, 6, 3, 1, -6 },
  { 296, 4, 6, 4, 0, -6 },
  { 299, 3, 7, 3, 0, -7 },
  { 302, 3, 5, 5, 1, -5 },
  { 304, 4, 5, 4, 0, -5 },
  { 307, 7, 5, 7, 0, -5 },
  { 312, 4, 5, 4, 0, -5 },
  { 315, 4, 7, 4, 0, -5 },
  { 319, 3, 5, 4, 0, -5 },
  { 321, 3, 9, 4, 0, -7 },
  { 325, 1, 10, 5, 2, -8 },
  { 327, 3, 9, 4, 0, -7 },
  { 331, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Medium10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_MEDIUM10PT7B_H_
