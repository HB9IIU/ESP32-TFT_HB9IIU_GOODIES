#ifndef _NOTOSANS_CONDENSED_MEDIUM54PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x08,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0x7C, 0x3F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFC, 0xC3, 0xC7, 0xC3, 0x01, 0x1F, 0x0C, 0x00, 0xFC, 0x30, 0x03, 0xE0,
  0xC0, 0x07, 0xC3, 0x00, 0x1F, 0x0C, 0x00, 0x7E, 0x30, 0x01, 0xFC, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xCF, 0xE0, 0x03,
  0x0F, 0x80, 0x0C, 0x3E, 0x00, 0x30, 0x7C, 0x00, 0xC1, 0xF0, 0x03, 0x0F,
  0xA0, 0x0C, 0x3E, 0xE0, 0x31, 0xFB, 0xF0, 0xDF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x01,
  0xE0, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0x7C, 0x78, 0x03, 0xE0, 0x07, 0x87,
  0xC0, 0x3C, 0x00, 0x78, 0x3C, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x78, 0x00,
  0xF8, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x0F,
  0x00, 0x0F, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x0F, 0x03,
  0xC3, 0xE0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x0F, 0x83, 0xC3, 0xC1, 0xC0,
  0xF8, 0x3C, 0x7C, 0x7F, 0x07, 0x83, 0xC7, 0x8F, 0xF8, 0x78, 0x7C, 0xF9,
  0xFF, 0xC7, 0xC7, 0x8F, 0x1F, 0x3E, 0x3F, 0xF8, 0xF1, 0xE1, 0xE3, 0xFF,
  0x1E, 0x3E, 0x1E, 0x1F, 0xE1, 0xE3, 0xC1, 0xF0, 0x7C, 0x3E, 0x3C, 0x1F,
  0x00, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0x7C, 0x3C, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3C, 0x1F,
  0x00, 0x3E, 0x03, 0xC1, 0xF0, 0x03, 0xC0, 0x3E, 0x1E, 0x00, 0x3C, 0x01,
  0xE1, 0xE0, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x0F,
  0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3E,
  0x1F, 0xFF, 0x01, 0xF0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7C,
  0x1F, 0xC7, 0xC7, 0xE0, 0x7E, 0x7E, 0x3F, 0x01, 0xFB, 0xF1, 0xF0, 0x07,
  0xFF, 0x0F, 0x80, 0x3F, 0xF8, 0x7C, 0x00, 0xFF, 0x83, 0xF0, 0x03, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x1F, 0xFC, 0x1F,
  0xE3, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF,
  0xC3, 0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01,
  0x83, 0xC1, 0xDF, 0xDE, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x8F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xE0, 0x0C, 0x0E,
  0x00, 0x20, 0x40, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x3F,
  0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x3E, 0x03, 0xF0,
  0xFC, 0x0F, 0x81, 0xFC, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xDF, 0x7F, 0x3F,
  0xFC, 0xFD, 0xF1, 0xF9, 0xC3, 0xF1, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3E, 0x03,
  0xF8, 0xE0, 0x0F, 0xC2, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3C, 0x03, 0xF8, 0xC0, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xBE, 0x07, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xF0, 0x00, 0x7B, 0xF0, 0x00, 0xF3,
  0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xC3,
  0xF0, 0x07, 0xC3, 0xF0, 0x07, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x1E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xBF, 0x80, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xEC, 0x00, 0xFE, 0xF8,
  0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0x1F, 0xE0, 0x7D, 0xFF,
  0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFC, 0xFF, 0x01, 0xFB,
  0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03,
  0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC1,
  0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F,
  0x00, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x7E, 0x7E, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7E, 0x07, 0xF3, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E, 0x01,
  0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xF9, 0xF8,
  0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x14, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x0F,
  0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0x9F, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x08,
  0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x40, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3F,
  0xFF, 0xFF, 0xFB, 0xF7, 0xC2, 0x00, 0x3E, 0x3F, 0x7F, 0x7F, 0x7F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9C, 0x07, 0xE4, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00,
  0xF8, 0xF0, 0x0F, 0xFC, 0x1E, 0x7C, 0x0F, 0xFF, 0x87, 0x9E, 0x07, 0xFF,
  0xE0, 0xF7, 0x81, 0xF0, 0xF8, 0x3F, 0xE0, 0xF8, 0x3E, 0x0F, 0xF8, 0x3C,
  0x0F, 0x83, 0xFC, 0x1F, 0x03, 0xE0, 0xFF, 0x07, 0xC0, 0xF0, 0x3F, 0xC1,
  0xE0, 0x3C, 0x0F, 0xF0, 0x78, 0x0F, 0x03, 0xFC, 0x1E, 0x03, 0xC0, 0xFF,
  0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xE0, 0x3C, 0x0F, 0xF0, 0x78, 0x0F, 0x03,
  0xFC, 0x1E, 0x07, 0xC0, 0xFF, 0x07, 0x81, 0xF0, 0x7F, 0xC1, 0xF0, 0x7C,
  0x1E, 0xF0, 0x3E, 0x3B, 0x8F, 0xBC, 0x0F, 0xFE, 0xFF, 0xCF, 0x81, 0xFF,
  0x3F, 0xF1, 0xE0, 0x3F, 0x87, 0xF8, 0x78, 0x07, 0xC0, 0xF8, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0x9F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0x80, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC,
  0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFC, 0x03,
  0x87, 0xF0, 0x01, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x08, 0x3F, 0xF3, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x03, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0xC3, 0xF0, 0x0F, 0xF1,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x03, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x01, 0xE1, 0xFE, 0x00, 0x10, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xFE, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7,
  0xF8, 0x01, 0xF0, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE8, 0x7F, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x83,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFB, 0xC0, 0x00, 0xFF, 0xFE, 0xF8, 0x00, 0x3F, 0xFF, 0xBE, 0x00,
  0x0F, 0x7F, 0xEF, 0x80, 0x07, 0xDF, 0xF9, 0xF0, 0x01, 0xF7, 0xFE, 0x7C,
  0x00, 0x79, 0xFF, 0x9F, 0x00, 0x3E, 0x7F, 0xE3, 0xE0, 0x0F, 0x9F, 0xF8,
  0xF8, 0x03, 0xC7, 0xFE, 0x3E, 0x01, 0xF1, 0xFF, 0x87, 0x80, 0x7C, 0x7F,
  0xE1, 0xF0, 0x1E, 0x1F, 0xF8, 0x7C, 0x0F, 0x87, 0xFE, 0x1F, 0x03, 0xE1,
  0xFF, 0x83, 0xE0, 0xF8, 0x7F, 0xE0, 0xF8, 0x3C, 0x1F, 0xF8, 0x3E, 0x1F,
  0x07, 0xFE, 0x07, 0xC7, 0xC1, 0xFF, 0x81, 0xF1, 0xE0, 0x7F, 0xE0, 0x7C,
  0xF8, 0x1F, 0xF8, 0x0F, 0x3E, 0x07, 0xFE, 0x03, 0xEF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0x7C, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x7C, 0x00, 0xFF, 0xEF,
  0xC0, 0x1F, 0xFC, 0xF8, 0x03, 0xFF, 0x9F, 0x80, 0x7F, 0xF1, 0xF0, 0x0F,
  0xFE, 0x3F, 0x01, 0xFF, 0xC3, 0xE0, 0x3F, 0xF8, 0x7E, 0x07, 0xFF, 0x07,
  0xC0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x0F, 0x83, 0xFF, 0x81, 0xF8, 0x7F,
  0xF0, 0x3F, 0x0F, 0xFE, 0x03, 0xF1, 0xFF, 0xC0, 0x7E, 0x3F, 0xF8, 0x07,
  0xE7, 0xFF, 0x00, 0xFC, 0xFF, 0xE0, 0x0F, 0xCF, 0xFC, 0x01, 0xF9, 0xFF,
  0x80, 0x1F, 0xBF, 0xF0, 0x03, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xB0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x0F,
  0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x5F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xF0, 0xFC, 0x03,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xC0, 0xF1, 0xF8, 0x00, 0x8F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x80, 0x03, 0xF7, 0x00, 0x3F, 0x3F, 0xCF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F,
  0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0x7F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0x78, 0x03, 0xF0, 0xFC, 0x03, 0xEF, 0x00, 0x7C, 0x0F, 0x80, 0x7D,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xBE, 0x03, 0xF0, 0x3E, 0x01, 0xE7, 0xC0,
  0x7E, 0x07, 0xE0, 0x3C, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0x8F, 0x01, 0xF0,
  0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x3E, 0x0F, 0xC0, 0x3E,
  0x07, 0x87, 0xC1, 0xF8, 0x07, 0xE1, 0xF0, 0xF8, 0x3E, 0x00, 0x7C, 0x3E,
  0x0F, 0x07, 0xC0, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x3E,
  0x3F, 0x00, 0x3E, 0x1E, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x78, 0xF8,
  0x00, 0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x01,
  0xF3, 0xC0, 0x3E, 0xFC, 0x00, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x03, 0xFF,
  0x00, 0x7B, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x00, 0x0F, 0xFC, 0x01,
  0xEF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x78, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xC0, 0x7E, 0x08, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0x81, 0xF7, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xDF, 0x3F, 0xF8, 0xF1, 0xFF, 0x0F, 0x01, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x06, 0x00, 0xF8, 0xFF,
  0x03, 0xE7, 0xFF, 0x0F, 0xBF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x07, 0xF3,
  0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x80, 0xFC, 0xFF, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0x3F, 0xFC,
  0x3C, 0x7F, 0xF0, 0xF0, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0x63, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x4F, 0xF0, 0x71, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3C, 0x1F, 0x07, 0xFC, 0x7C, 0x3F, 0xF9, 0xF1, 0xFF, 0xF7,
  0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x83,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0x8F, 0x03, 0xFC, 0x3C,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x10, 0xFE, 0x03, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x20,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFE, 0x20,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0xFF,
  0xE3, 0xC7, 0xFF, 0xDF, 0x1F, 0xFF, 0xFC, 0xFE, 0x0F, 0xF3, 0xF0, 0x1F,
  0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F,
  0x01, 0xFC, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0x0F, 0xFE,
  0x7C, 0x0F, 0xF1, 0xF0, 0x04, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x20, 0x01, 0xF8, 0xE0,
  0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0x80, 0xF8, 0xFF,
  0x8F, 0x9F, 0xFC, 0xFB, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x79,
  0xFF, 0xFF, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x03, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0xFF,
  0xDF, 0xFB, 0xFE, 0x7F, 0x87, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8,
  0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x8F,
  0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xC0, 0x7E, 0x3F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x0F,
  0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xF0,
  0x3C, 0x3F, 0xC0, 0xFF, 0x8F, 0x3F, 0xF8, 0x7F, 0xF3, 0xCF, 0xFF, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0x87, 0xFF, 0xE0, 0x7F,
  0x80, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8,
  0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0,
  0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3C, 0x0F, 0x0F, 0xF8, 0xF3, 0xFF, 0xCF,
  0x3F, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x3F, 0x1F, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0xC3, 0xFE, 0x0F, 0x1F, 0xFC, 0x3E, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFE, 0x03, 0xF3, 0xFE, 0x1F,
  0xCF, 0xFF, 0xFE, 0x3E, 0xFF, 0xF0, 0xF9, 0xFF, 0xC3, 0xE3, 0xFC, 0x0F,
  0x80, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xF0, 0xF0, 0xFF, 0xE3, 0xC7, 0xFF, 0xDF, 0x1F,
  0xFF, 0xFC, 0xFE, 0x0F, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x01, 0xFC, 0xFE, 0x0F, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x0F, 0xF1, 0xF0, 0x04,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3B, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF,
  0xE7, 0xFF, 0xF7, 0xE0, 0x3B, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x04, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE1, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x04, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFC, 0xF3, 0xFF, 0x8F, 0x1F, 0xF0, 0xF0, 0x10, 0x00, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x01,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0xC0, 0x1F, 0x7C, 0x01, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xC0, 0x3E, 0x3E, 0x03, 0xFC, 0x03, 0xE3, 0xE0, 0x3F,
  0xE0, 0x3E, 0x3E, 0x03, 0xDE, 0x03, 0xE3, 0xF0, 0x3D, 0xE0, 0x7C, 0x1F,
  0x07, 0xDE, 0x07, 0xC1, 0xF0, 0x7D, 0xF0, 0x7C, 0x1F, 0x07, 0x9F, 0x07,
  0xC1, 0xF0, 0x78, 0xF0, 0xFC, 0x1F, 0x8F, 0x8F, 0x0F, 0x80, 0xF8, 0xF8,
  0xF0, 0xF8, 0x0F, 0x8F, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0xF8, 0xF8, 0x0F,
  0x8F, 0x07, 0x9F, 0x00, 0x7D, 0xF0, 0x79, 0xF0, 0x07, 0xDF, 0x07, 0x9F,
  0x00, 0x7D, 0xE0, 0x7D, 0xF0, 0x07, 0xDE, 0x07, 0xDE, 0x00, 0x3D, 0xE0,
  0x3F, 0xE0, 0x03, 0xDE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x01,
  0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x07, 0xE0,
  0x7E, 0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3F, 0x01, 0xF8,
  0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x05, 0xFF, 0x80,
  0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0x20, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_Medium54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 40, 14, 3, -39 },
  { 36, 16, 14, 22, 3, -39 },
  { 64, 26, 39, 28, 1, -39 },
  { 191, 22, 44, 26, 2, -41 },
  { 312, 36, 39, 40, 2, -39 },
  { 488, 29, 40, 31, 2, -39 },
  { 633, 6, 14, 12, 3, -39 },
  { 644, 13, 48, 16, 2, -39 },
  { 722, 13, 48, 16, 1, -39 },
  { 800, 21, 21, 24, 2, -41 },
  { 856, 22, 26, 26, 2, -32 },
  { 928, 8, 13, 13, 2, -6 },
  { 941, 12, 5, 16, 2, -17 },
  { 949, 7, 8, 13, 3, -7 },
  { 956, 19, 39, 21, 1, -39 },
  { 1049, 22, 40, 26, 2, -39 },
  { 1159, 15, 39, 26, 3, -39 },
  { 1233, 21, 39, 26, 2, -39 },
  { 1336, 21, 40, 26, 2, -39 },
  { 1441, 24, 39, 26, 1, -39 },
  { 1558, 20, 40, 26, 3, -39 },
  { 1658, 22, 40, 26, 2, -39 },
  { 1768, 22, 39, 26, 2, -39 },
  { 1876, 22, 40, 26, 2, -39 },
  { 1986, 21, 40, 26, 2, -39 },
  { 2091, 7, 30, 13, 3, -29 },
  { 2118, 8, 36, 13, 2, -29 },
  { 2154, 22, 25, 26, 2, -32 },
  { 2223, 22, 16, 26, 2, -27 },
  { 2267, 22, 25, 26, 2, -32 },
  { 2336, 18, 40, 20, 1, -39 },
  { 2426, 34, 44, 40, 3, -39 },
  { 2613, 28, 39, 28, 0, -39 },
  { 2750, 23, 39, 29, 4, -39 },
  { 2863, 23, 40, 28, 3, -39 },
  { 2978, 25, 39, 32, 4, -39 },
  { 3100, 18, 39, 25, 4, -39 },
  { 3188, 18, 39, 23, 4, -39 },
  { 3276, 26, 40, 33, 3, -39 },
  { 3406, 25, 39, 33, 4, -39 },
  { 3528, 13, 39, 17, 2, -39 },
  { 3592, 13, 50, 14, -3, -39 },
  { 3674, 24, 39, 28, 4, -39 },
  { 3791, 18, 39, 23, 4, -39 },
  { 3879, 34, 39, 43, 4, -39 },
  { 4045, 27, 39, 35, 4, -39 },
  { 4177, 28, 40, 34, 3, -39 },
  { 4317, 21, 39, 27, 4, -39 },
  { 4420, 28, 48, 34, 3, -39 },
  { 4588, 24, 39, 28, 4, -39 },
  { 4705, 21, 40, 25, 2, -39 },
  { 4810, 22, 39, 24, 1, -39 },
  { 4918, 24, 40, 32, 4, -39 },
  { 5038, 27, 39, 27, 0, -39 },
  { 5170, 43, 39, 43, 0, -39 },
  { 5380, 26, 39, 26, 0, -39 },
  { 5507, 25, 39, 25, 0, -39 },
  { 5629, 21, 39, 23, 1, -39 },
  { 5732, 12, 48, 17, 4, -39 },
  { 5804, 19, 39, 21, 1, -39 },
  { 5897, 11, 48, 17, 2, -39 },
  { 5963, 25, 23, 27, 1, -39 },
  { 6035, 23, 3, 23, 0, 5 },
  { 6044, 11, 8, 16, 2, -41 },
  { 6055, 20, 31, 26, 2, -30 },
  { 6133, 22, 42, 28, 4, -41 },
  { 6249, 18, 31, 22, 2, -30 },
  { 6319, 22, 42, 28, 2, -41 },
  { 6435, 21, 31, 26, 2, -30 },
  { 6517, 17, 41, 16, 1, -41 },
  { 6605, 22, 43, 28, 2, -30 },
  { 6724, 20, 41, 28, 4, -41 },
  { 6827, 6, 40, 13, 3, -40 },
  { 6857, 11, 53, 13, -2, -40 },
  { 6930, 21, 41, 25, 4, -41 },
  { 7038, 5, 41, 13, 4, -41 },
  { 7064, 34, 30, 42, 4, -30 },
  { 7192, 20, 30, 28, 4, -30 },
  { 7267, 23, 31, 27, 2, -30 },
  { 7357, 22, 43, 28, 4, -30 },
  { 7476, 22, 43, 28, 2, -30 },
  { 7595, 14, 30, 19, 4, -30 },
  { 7648, 17, 31, 21, 2, -30 },
  { 7714, 15, 37, 17, 1, -36 },
  { 7784, 20, 30, 28, 4, -29 },
  { 7859, 23, 29, 23, 0, -29 },
  { 7943, 36, 29, 37, 0, -29 },
  { 8074, 22, 29, 23, 1, -29 },
  { 8154, 23, 42, 23, 0, -29 },
  { 8275, 17, 29, 20, 1, -29 },
  { 8337, 16, 48, 20, 2, -39 },
  { 8433, 5, 54, 25, 10, -41 },
  { 8467, 16, 48, 20, 2, -39 },
  { 8563, 22, 8, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Medium54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_MEDIUM54PT7B_H_
