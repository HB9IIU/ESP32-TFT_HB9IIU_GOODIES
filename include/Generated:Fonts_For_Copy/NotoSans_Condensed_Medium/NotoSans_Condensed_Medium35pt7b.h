#ifndef _NOTOSANS_CONDENSED_MEDIUM35PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x02, 0x7B, 0xFF, 0x70, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1D, 0x87, 0x61, 0xC0, 0x03, 0x0C, 0x03, 0x86, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x30,
  0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x0E, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1F, 0x83, 0xFF, 0xBF, 0xFB, 0xF9, 0xDC, 0xC0,
  0xE6, 0x07, 0x30, 0x39, 0x81, 0xEC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x06, 0xF8, 0x33, 0xC1, 0x8E, 0x0C, 0x70, 0x63, 0xC3, 0x3F, 0xFF,
  0xDF, 0xFC, 0x7F, 0xC0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0xE0, 0x3F, 0x01, 0xC0, 0x73, 0x81, 0xC0, 0x73, 0x83, 0x80, 0x61,
  0x83, 0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xC6, 0x00, 0xE1,
  0xCE, 0x00, 0xE1, 0xCE, 0x00, 0x61, 0x9C, 0xF8, 0x73, 0x9C, 0xFC, 0x73,
  0x99, 0xCE, 0x3F, 0x39, 0xCE, 0x1E, 0x39, 0x86, 0x00, 0x73, 0x87, 0x00,
  0x73, 0x87, 0x00, 0xE3, 0x87, 0x00, 0xE3, 0x87, 0x00, 0xC3, 0x87, 0x01,
  0xC1, 0x86, 0x01, 0xC1, 0xCE, 0x03, 0x81, 0xCE, 0x03, 0x80, 0xFC, 0x07,
  0x00, 0x78, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03,
  0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x1C, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x87, 0x9E,
  0x78, 0xF3, 0x87, 0x9C, 0xF0, 0xF7, 0x9E, 0x0F, 0xF3, 0xC0, 0xFC, 0x78,
  0x0F, 0x8F, 0x01, 0xE0, 0xF0, 0x7E, 0x1F, 0xFF, 0xE1, 0xFF, 0x9E, 0x1F,
  0xC3, 0xE0, 0xFF, 0xFF, 0xFE, 0xE6, 0x60, 0x0F, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x07, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E,
  0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0x43, 0x09, 0xEF, 0xEF, 0xFF, 0x8F, 0xFD, 0x0F,
  0x80, 0x3F, 0x01, 0xCE, 0x0F, 0x3C, 0x38, 0x60, 0x21, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0xE7, 0x9E, 0x71, 0xC7, 0x38,
  0xE0, 0xFF, 0xFF, 0xFF, 0x27, 0xBF, 0xEF, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x0F, 0x1E, 0x78, 0x39, 0xE0, 0xF7,
  0x03, 0xDC, 0x0F, 0x70, 0x3D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x03, 0xDE, 0x0F,
  0x78, 0x38, 0xF1, 0xE3, 0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0x03, 0xC1, 0xF0,
  0xFC, 0x7F, 0x3F, 0xFE, 0xF7, 0x3C, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0xE0, 0xFF, 0xCF, 0xFF, 0x9C, 0x1E,
  0x20, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0x98, 0x1E, 0x40, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0x01, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x6E, 0x01, 0xDC, 0x03, 0xB8,
  0x0E, 0x70, 0x18, 0xE0, 0x71, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C,
  0x1C, 0x70, 0x38, 0xE0, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x30,
  0x3F, 0xF1, 0xFF, 0xC7, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x7B, 0xFF, 0xDF, 0xFC, 0xFF,
  0x80, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xCF, 0x87, 0x7F, 0x1F, 0xFE, 0x7C, 0x7F,
  0xE0, 0xFF, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDE, 0x07,
  0x78, 0x3C, 0xF0, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x9E, 0x0F,
  0x70, 0x3D, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x38, 0x38, 0xF3, 0xE1, 0xFF,
  0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xC7, 0x9E, 0x0F, 0x70, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xE0, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xE0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xDC, 0x0F, 0x78, 0x7C,
  0xFF, 0x73, 0xFD, 0xC3, 0xC7, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x77, 0xBF, 0xE6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9E, 0xFF, 0xDC, 0x39, 0xE7, 0xDE,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x39, 0xE7, 0x9C,
  0x71, 0xCE, 0x38, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80,
  0x00, 0x3F, 0xCF, 0xFE, 0x7F, 0xE6, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x01, 0xE0, 0x1F, 0x01,
  0xF0, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x3E, 0x07,
  0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x3F,
  0xC7, 0x61, 0xFF, 0x1F, 0x87, 0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC3,
  0xE3, 0x87, 0x0F, 0x0C, 0x1C, 0x3C, 0x30, 0x71, 0xF0, 0xC1, 0xC7, 0xC3,
  0x8F, 0x1F, 0x8E, 0x3C, 0x6E, 0x3D, 0xF3, 0xB8, 0x7E, 0xFC, 0xE0, 0xF1,
  0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x80,
  0x7F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0x7B, 0x80,
  0x1C, 0xE0, 0x07, 0x3C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x78, 0x0E,
  0x1E, 0x07, 0x83, 0x81, 0xE0, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x3E,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xEE, 0x3F,
  0x3F, 0xF8, 0xFF, 0xF3, 0x87, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xF0, 0x27, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0xFC, 0xE0, 0x3C, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x3E, 0xE0, 0x3C, 0xE0, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xE0, 0x63, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0x79, 0xF0, 0x3C, 0x7F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xCF, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF9, 0xFF, 0xFF,
  0x80, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0F, 0x9F, 0xFE, 0xFC, 0xF8, 0xE0, 0x1F, 0xC0,
  0x7B, 0x81, 0xE7, 0x03, 0xCE, 0x0F, 0x1C, 0x3C, 0x38, 0x78, 0x71, 0xE0,
  0xE3, 0x81, 0xCF, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xF8, 0x1F, 0xF0, 0x3E,
  0xF0, 0x79, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0xC7, 0x07, 0x8E, 0x07,
  0x9C, 0x0F, 0x38, 0x0F, 0x70, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0x7E,
  0xE0, 0x1D, 0xFB, 0x80, 0x7F, 0xEE, 0x03, 0xBF, 0xBC, 0x0E, 0xFE, 0x70,
  0x3B, 0xF9, 0xC1, 0xCF, 0xE7, 0x87, 0x3F, 0x8E, 0x1C, 0xFE, 0x38, 0xE3,
  0xF8, 0xE3, 0x8F, 0xE1, 0xCE, 0x3F, 0x87, 0x78, 0xFE, 0x1D, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xE0, 0xFE, 0x0F, 0x83, 0xF8, 0x1E,
  0x0F, 0xE0, 0x70, 0x3C, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xB8, 0x1F, 0xDE, 0x0F, 0xE7, 0x07, 0xF3,
  0xC3, 0xF8, 0xE1, 0xFC, 0x78, 0xFE, 0x3C, 0x7F, 0x0F, 0x3F, 0x87, 0x9F,
  0xC1, 0xEF, 0xE0, 0xF3, 0xF0, 0x3D, 0xF8, 0x1E, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x78, 0x07, 0x9E, 0x01, 0xEF,
  0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x87, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD,
  0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC1, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x3C, 0x78, 0x07, 0x9E,
  0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x8F,
  0x87, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0xC7, 0x0F, 0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xE7, 0x0F, 0x8F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x71, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0xC7, 0x07, 0x8E,
  0x07, 0x9C, 0x0F, 0x38, 0x0F, 0x70, 0x1E, 0xE0, 0x1E, 0x0F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x9F, 0x06, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x7B, 0x81, 0xEF,
  0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0x9F, 0xFF, 0x1F,
  0xFC, 0x1F, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xE3,
  0xC0, 0x3C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x01, 0xE7, 0x01,
  0xF0, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1C, 0x78, 0x1F, 0x81,
  0xC3, 0x83, 0xB8, 0x3C, 0x38, 0x3B, 0x83, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C,
  0x39, 0xC3, 0x81, 0xC3, 0x9C, 0x38, 0x1C, 0x71, 0xC7, 0x81, 0xC7, 0x1E,
  0x78, 0x1E, 0x70, 0xE7, 0x01, 0xE7, 0x0E, 0x70, 0x0E, 0xF0, 0xE7, 0x00,
  0xEE, 0x0E, 0xF0, 0x0E, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x87, 0x83,
  0xC1, 0xC3, 0xC0, 0xF1, 0xE0, 0x38, 0xE0, 0x1E, 0xF0, 0x07, 0x70, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x0E, 0xE0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x8F, 0x03, 0x87, 0x83, 0xC1,
  0xC1, 0xE0, 0xF1, 0xE0, 0x38, 0xF0, 0x1E, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C,
  0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xE0,
  0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x70, 0x1C,
  0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x78,
  0x3C, 0x1C, 0x0E, 0x07, 0x1F, 0xE1, 0xFF, 0x8F, 0xFE, 0x20, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x1F, 0xF9, 0xFF, 0xDE, 0x0E, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0x7D, 0xFB, 0xFD, 0xCF, 0xC6, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF3, 0xE1, 0xEF, 0xE3, 0xFF, 0xE7, 0xC1, 0xEF, 0x83, 0xDE,
  0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xDE, 0x03, 0xBE, 0x0F, 0x7C, 0x1E, 0xFF, 0xF9, 0xDF, 0xE3,
  0x8F, 0x80, 0x0F, 0xE7, 0xFD, 0xFF, 0xBC, 0x1F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC1,
  0x7F, 0xE7, 0xFC, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1F, 0x3C, 0xFF, 0xF7, 0xFF,
  0xDE, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0x7F,
  0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0xEF,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x02, 0x7F, 0xF1, 0xFF, 0x87, 0xFC,
  0x03, 0xC1, 0xFC, 0x3F, 0x8F, 0x11, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3F,
  0xDF, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x1F, 0x1C, 0xFF, 0x77, 0xFF, 0xDE, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFB, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x90, 0x1E, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xC0, 0x7F, 0xF7, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x0F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFE, 0xFD, 0xF0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x3F, 0xC1, 0xEF, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0xCF, 0x0F, 0x78, 0x3D,
  0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3E, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F,
  0x0F, 0x3C, 0x1C, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3,
  0xE1, 0xF9, 0xDF, 0xE7, 0xFB, 0xFF, 0xFF, 0xF7, 0xC3, 0xF1, 0xEF, 0x83,
  0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38,
  0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81,
  0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F,
  0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x78, 0xE3, 0xE3, 0xBF, 0xEF, 0xFF, 0xBE,
  0x1E, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1E, 0xF0,
  0x3B, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0x9E, 0x1E, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFC, 0x00, 0xE3, 0xE1, 0xCF, 0xE3, 0xFF, 0xE7, 0xC1, 0xEF, 0x83, 0xDE,
  0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xDE, 0x03, 0xBE, 0x0F, 0x7C, 0x1E, 0xFF, 0xF9, 0xFF, 0xE3,
  0xCF, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0x1C, 0xFF, 0x77, 0xFF, 0xDE, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0x7F, 0xFC, 0xFF,
  0xF1, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xE3, 0xF9, 0xFE, 0xFF, 0xF9, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0xF8, 0x2F, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0xFF, 0xFF, 0xF9, 0xFE, 0x00, 0x18, 0x1C, 0x0E, 0x07,
  0x07, 0xFF, 0xFF, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF9, 0xFC, 0x7E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xDE, 0x1F, 0x7F, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0xF0, 0x1E, 0xE0, 0x3D,
  0xC0, 0x73, 0xC0, 0xE7, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x1E, 0x3C, 0x1C,
  0x78, 0x38, 0xE0, 0x71, 0xC0, 0xF7, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x3C, 0x0F, 0x70,
  0x3C, 0x0E, 0x70, 0x7C, 0x0E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1C, 0x38,
  0x7E, 0x1C, 0x38, 0x66, 0x1C, 0x38, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x1C,
  0xE7, 0x38, 0x1C, 0xC7, 0x38, 0x1D, 0xC3, 0x38, 0x1D, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0xF0, 0x78, 0xF0, 0xE1, 0xE3,
  0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0x00, 0xEE, 0x03, 0xDE, 0x07, 0x1C, 0x1E, 0x3C, 0x38,
  0x38, 0xF0, 0x7B, 0xC0, 0x78, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0x73, 0xC0,
  0xE7, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x1E, 0x3C, 0x1C, 0x78, 0x38, 0xE0,
  0x79, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x0F, 0x8F, 0xC3, 0xC0, 0xFC, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3E, 0x07, 0xC0,
  0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xF8, 0x1F, 0x07, 0xE1, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x1F, 0x0F, 0xC1, 0xF0, 0x30, 0x00, 0x1C,
  0x02, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE8, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 10, 9, 14, 2, -25 },
  { 29, 17, 25, 18, 1, -25 },
  { 83, 13, 29, 17, 2, -27 },
  { 131, 24, 25, 26, 1, -25 },
  { 206, 19, 25, 20, 1, -25 },
  { 266, 4, 9, 8, 2, -25 },
  { 271, 8, 31, 11, 2, -25 },
  { 302, 8, 31, 11, 1, -25 },
  { 333, 14, 14, 16, 1, -27 },
  { 358, 15, 17, 17, 1, -21 },
  { 390, 6, 9, 9, 1, -4 },
  { 397, 8, 3, 10, 1, -11 },
  { 400, 5, 5, 9, 2, -5 },
  { 404, 13, 25, 13, 0, -25 },
  { 445, 14, 25, 17, 1, -25 },
  { 489, 10, 25, 17, 2, -25 },
  { 521, 14, 25, 17, 1, -25 },
  { 565, 14, 25, 17, 1, -25 },
  { 609, 15, 25, 17, 1, -25 },
  { 656, 13, 25, 17, 2, -25 },
  { 697, 14, 25, 17, 1, -25 },
  { 741, 14, 25, 17, 1, -25 },
  { 785, 14, 25, 17, 1, -25 },
  { 829, 14, 25, 17, 1, -25 },
  { 873, 5, 19, 9, 2, -19 },
  { 885, 6, 24, 9, 1, -19 },
  { 903, 15, 17, 17, 1, -21 },
  { 935, 14, 10, 17, 1, -17 },
  { 953, 15, 17, 17, 1, -21 },
  { 985, 12, 25, 13, 0, -25 },
  { 1023, 22, 28, 26, 2, -25 },
  { 1100, 18, 25, 18, 0, -25 },
  { 1157, 14, 25, 19, 3, -25 },
  { 1201, 15, 25, 18, 2, -25 },
  { 1248, 16, 25, 21, 3, -25 },
  { 1298, 11, 25, 16, 3, -25 },
  { 1333, 11, 25, 15, 3, -25 },
  { 1368, 17, 25, 21, 2, -25 },
  { 1422, 16, 25, 21, 3, -25 },
  { 1472, 9, 25, 11, 1, -25 },
  { 1501, 8, 32, 9, -2, -25 },
  { 1533, 15, 25, 18, 3, -25 },
  { 1580, 11, 25, 15, 3, -25 },
  { 1615, 22, 25, 28, 3, -25 },
  { 1684, 17, 25, 23, 3, -25 },
  { 1738, 18, 25, 22, 2, -25 },
  { 1795, 13, 25, 18, 3, -25 },
  { 1836, 18, 31, 22, 2, -25 },
  { 1906, 15, 25, 18, 3, -25 },
  { 1953, 14, 25, 16, 1, -25 },
  { 1997, 15, 25, 16, 0, -25 },
  { 2044, 15, 25, 21, 3, -25 },
  { 2091, 18, 25, 18, 0, -25 },
  { 2148, 28, 25, 28, 0, -25 },
  { 2236, 17, 25, 17, 0, -25 },
  { 2290, 16, 25, 16, 0, -25 },
  { 2340, 13, 25, 15, 1, -25 },
  { 2381, 8, 31, 11, 2, -25 },
  { 2412, 13, 25, 13, 0, -25 },
  { 2453, 8, 31, 11, 1, -25 },
  { 2484, 16, 15, 17, 1, -25 },
  { 2514, 15, 2, 15, 0, 3 },
  { 2518, 8, 6, 10, 1, -27 },
  { 2524, 13, 19, 17, 1, -19 },
  { 2555, 15, 27, 18, 2, -27 },
  { 2606, 11, 19, 14, 2, -19 },
  { 2633, 14, 27, 18, 2, -27 },
  { 2681, 13, 19, 17, 2, -19 },
  { 2712, 11, 27, 10, 0, -27 },
  { 2750, 14, 27, 18, 2, -19 },
  { 2798, 14, 27, 18, 2, -27 },
  { 2846, 4, 26, 8, 2, -26 },
  { 2859, 7, 34, 8, -1, -26 },
  { 2889, 14, 27, 16, 2, -27 },
  { 2937, 4, 27, 8, 2, -27 },
  { 2951, 23, 19, 27, 2, -19 },
  { 3006, 14, 19, 18, 2, -19 },
  { 3040, 14, 19, 18, 2, -19 },
  { 3074, 15, 27, 18, 2, -19 },
  { 3125, 14, 27, 18, 2, -19 },
  { 3173, 10, 19, 12, 2, -19 },
  { 3197, 11, 19, 14, 1, -19 },
  { 3224, 9, 23, 11, 1, -23 },
  { 3250, 14, 19, 18, 2, -19 },
  { 3284, 15, 19, 15, 0, -19 },
  { 3320, 24, 19, 24, 0, -19 },
  { 3377, 15, 19, 15, 0, -19 },
  { 3413, 15, 27, 15, 0, -19 },
  { 3464, 11, 19, 13, 1, -19 },
  { 3491, 10, 31, 13, 1, -25 },
  { 3530, 3, 35, 16, 6, -27 },
  { 3544, 11, 31, 13, 1, -25 },
  { 3587, 15, 5, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Medium35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_MEDIUM35PT7B_H_
