#ifndef _NOTOSANS_CONDENSED_MEDIUM69PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x0E, 0x00, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E,
  0x07, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xE7, 0x0F, 0xC7, 0xF0, 0xE0, 0x10, 0xFC, 0x1C, 0x00, 0x3F,
  0x83, 0x80, 0x07, 0xF0, 0x70, 0x00, 0xFE, 0x0E, 0x00, 0x1F, 0xC1, 0xC0,
  0x03, 0xF8, 0x38, 0x00, 0x7F, 0x07, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0xFF,
  0x1C, 0x00, 0x0F, 0xFB, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x73, 0xFE,
  0x00, 0x0E, 0x3F, 0xC0, 0x01, 0xC3, 0xFC, 0x00, 0x38, 0x3F, 0x80, 0x07,
  0x03, 0xF0, 0x00, 0xE0, 0x7E, 0x00, 0x1C, 0x0F, 0xC0, 0x03, 0x81, 0xF8,
  0x00, 0x70, 0x7F, 0xC0, 0x0E, 0x0F, 0xDE, 0x01, 0xC3, 0xFB, 0xFC, 0x3B,
  0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x00,
  0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x1F, 0x87, 0xFE, 0x0F, 0xC0, 0xF8, 0x7E, 0x3F, 0xFC, 0x1F, 0x03, 0xE1,
  0xF0, 0xFF, 0xF8, 0x7C, 0x1F, 0x8F, 0xC7, 0xFF, 0xF1, 0xF8, 0xFC, 0x3E,
  0x1F, 0x0F, 0xC3, 0xFF, 0xF1, 0xF8, 0xFC, 0x1F, 0x0F, 0xFF, 0x87, 0xC3,
  0xF0, 0x7E, 0x1F, 0xFE, 0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0xE0, 0xFC, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x3E, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0x03, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xC1, 0xFE, 0x7F, 0x80, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xC3,
  0xF8, 0x03, 0xFD, 0xFC, 0x3F, 0xC0, 0x1F, 0xEF, 0xE1, 0xFC, 0x00, 0x7F,
  0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0x07, 0xFF, 0x83, 0xFC,
  0x00, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xBF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xDF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0x3E, 0x7C, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x1F, 0x00, 0xCF, 0xC3, 0xE1,
  0xF9, 0xFF, 0x7D, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF8,
  0x07, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC,
  0x7F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xEF, 0xE7, 0xFD, 0xFD, 0xFF, 0x3F, 0xFF, 0xC7, 0xF3,
  0xE0, 0xFE, 0x78, 0x1F, 0xC6, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xE0, 0xFF, 0xC3, 0xF0, 0x07, 0xFC, 0x38, 0x00, 0x7F, 0x82, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xC0, 0x7F, 0xE3, 0xE0, 0x03, 0xFC, 0x30, 0x00, 0x3F, 0x84,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFA, 0x00, 0x01, 0xFF, 0x70, 0x00, 0x7F, 0xCF, 0xE0, 0x7F,
  0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE3,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xA0, 0x00, 0x3F, 0xCE, 0x00, 0x1F, 0xF3, 0xF8, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x40, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0xF8, 0x0F, 0xE3, 0xFF, 0xC1, 0xFC, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F, 0xFB, 0xFE,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x9F, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC,
  0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xEF, 0xF8, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFE, 0xFE, 0x1F,
  0xFF, 0x9F, 0xC1, 0xFF, 0xE3, 0xF0, 0x0F, 0xF0, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x03, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF3, 0xF8, 0x70, 0x07, 0x03,
  0xF8, 0x7F, 0x1F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x1F, 0xC1, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF,
  0x3C, 0x00, 0xFE, 0x20, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x7F, 0xF8, 0x0F, 0x83, 0xF0, 0x07, 0xFF, 0xE0,
  0x7C, 0x3F, 0x00, 0xFF, 0xFF, 0x03, 0xF1, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F,
  0x8F, 0x80, 0x7F, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE7,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0xBF, 0x03, 0xF0, 0x0F, 0x80, 0xFD, 0xF0,
  0x1F, 0x80, 0x7C, 0x07, 0xEF, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0x7C, 0x0F,
  0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0xFC, 0x03,
  0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xDF, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0xFC, 0x0F, 0xC0, 0x3F, 0x01,
  0xF7, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xBF, 0x01, 0xF0, 0x1F, 0xC0, 0xF8,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xC7, 0xC0, 0x7E, 0x0F, 0xF8, 0x7E, 0x3E,
  0x01, 0xFD, 0xFB, 0xEF, 0xE1, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x0F, 0xC0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x3E, 0x00, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xF8, 0x01, 0xFF, 0x9F, 0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF9,
  0xFC, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x3F, 0x80, 0x3F, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF,
  0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xBF,
  0x80, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x0F, 0xC1, 0xFF, 0x80, 0x0C, 0x0F, 0xF0, 0x00, 0x20, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x04, 0x1F, 0xF8, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xF0, 0xFE, 0x00,
  0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00,
  0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x00,
  0x3C, 0x0F, 0xF8, 0x00, 0x02, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0x3F, 0xE0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x1F, 0xC3, 0xFE, 0x00,
  0x0F, 0xE1, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x03, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x1C, 0x00, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x7F,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x7F, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0xFF, 0xFC, 0x00, 0x01,
  0xFB, 0xFF, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0xFE, 0xFC, 0x00, 0x03, 0xF7,
  0xFF, 0xEF, 0xC0, 0x00, 0x3F, 0x7F, 0xFE, 0x7E, 0x00, 0x03, 0xF7, 0xFF,
  0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xFF, 0xE7,
  0xF0, 0x00, 0x7E, 0x7F, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xFF, 0xE3, 0xF0,
  0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xFF, 0xE1, 0xF8, 0x01,
  0xF8, 0x7F, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x01, 0xF8,
  0x7F, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xFF, 0xE0, 0xFC, 0x03, 0xF0, 0x7F,
  0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFE, 0x07,
  0xF0, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0xFE, 0x01, 0xF9, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0xFE, 0x01, 0xF9, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0xFE,
  0x00, 0x1F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xF9,
  0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xF0, 0x07, 0xFF,
  0xE1, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xFE, 0x0F, 0xE0, 0x1F,
  0xFF, 0x83, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xC0,
  0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xC1, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0xFE, 0x00, 0xFE, 0x1F, 0xFF, 0x80,
  0x3F, 0x87, 0xFF, 0xE0, 0x07, 0xF0, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0xFE,
  0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x0F, 0xE3, 0xFF, 0xE0, 0x01, 0xFC, 0xFF,
  0xF8, 0x00, 0x7F, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xFF, 0x80, 0x03, 0xFB,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x80,
  0x7F, 0xF7, 0xF0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xF7, 0xF0, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0x0F, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x01,
  0xFF, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0x3C, 0x7F, 0x80, 0x02,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xA0, 0x00, 0x1F, 0xEE,
  0x00, 0x07, 0xFB, 0xE0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFB, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xEF, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xBF,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF3, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x00,
  0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0x03,
  0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x78, 0x07, 0xF8, 0x18, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xF8,
  0x1F, 0xCF, 0xF0, 0x07, 0xF7, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xFD, 0xFC, 0x01,
  0xFF, 0x7F, 0xC1, 0xFF, 0xCF, 0xFF, 0xFB, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F,
  0xFF, 0x3F, 0x0F, 0xFF, 0x87, 0xC1, 0xFF, 0x81, 0xF0, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC3, 0xFF, 0x80, 0xFC, 0x7F, 0xFC, 0x0F,
  0xCF, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xCF, 0xF0, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF, 0x80,
  0x1F, 0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xE0, 0xF8, 0x7F, 0xFC, 0x0F, 0x81,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0x0E, 0x1F, 0xF0, 0x04, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x02, 0x1F, 0xF8, 0x3C, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0x07, 0xFF, 0xE7, 0xF0, 0xFF,
  0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F,
  0xF3, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xF3, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xFF, 0xBF, 0x0F,
  0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF, 0xE3, 0xF0, 0x1F, 0xF8,
  0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x10, 0xFF, 0x00, 0x0C, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0xC0,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0x07, 0xFF, 0xE3, 0xF0,
  0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0xBF, 0x3F, 0xE0,
  0x7F, 0xF3, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x1F, 0xF3, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x7F, 0x03, 0xFF, 0xC7, 0xF0, 0x1F,
  0xF8, 0x7F, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x20, 0x00, 0x1F, 0xE3, 0x80, 0x03,
  0xFC, 0x3F, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0xFF, 0xE0, 0xFC, 0x7F, 0xFE, 0x3F, 0x3F, 0xFF,
  0xCF, 0xDF, 0xFF, 0xF3, 0xF7, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xBF, 0xF0,
  0x0F, 0xEF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFB, 0x3F, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF8, 0x02, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFF,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xE0, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFF, 0x8F, 0xCF, 0xFF, 0xE3, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x3E, 0x0F, 0xFE, 0x0F, 0x87,
  0xFF, 0xE3, 0xF3, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFE, 0x0F, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0x83, 0xFF,
  0x80, 0xFC, 0x7F, 0xFC, 0x0F, 0xCF, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x0F,
  0xDF, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0xF0,
  0xFF, 0x8F, 0xDF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xE0,
  0xFC, 0x7F, 0xFC, 0x0F, 0xC1, 0xFF, 0x80, 0xFE, 0x03, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFC, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xF3,
  0xF1, 0xFF, 0xFF, 0xBF, 0x3F, 0xE0, 0x7F, 0xF3, 0xFC, 0x03, 0xFF, 0x3F,
  0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xF3, 0xFC, 0x03, 0xFF, 0x3F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE,
  0x7F, 0x03, 0xFF, 0xC7, 0xF0, 0x1F, 0xF8, 0x7F, 0x00, 0x38, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xF0, 0x0F, 0x3F, 0x80, 0x08, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE8, 0x00, 0x3F, 0xB8,
  0x00, 0xFE, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC3, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3C, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xF9, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0xF7, 0xE3, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xFF,
  0xE3, 0xF0, 0x3F, 0xF0, 0x7E, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xBE, 0x00,
  0xFE, 0x3F, 0x00, 0x7D, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xEF, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xF3, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xE0, 0x7F,
  0x07, 0xE3, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x1F, 0x83, 0xF8, 0x0F, 0xC1,
  0xF0, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x03, 0xF8, 0xFC,
  0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0xF8,
  0xFC, 0x00, 0xFC, 0xFC, 0x07, 0xCF, 0xE0, 0x07, 0xF7, 0xE0, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x07, 0xDF, 0x80,
  0x07, 0xEF, 0x80, 0x3E, 0xFC, 0x00, 0x3F, 0x7C, 0x01, 0xF7, 0xE0, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0x9F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8,
  0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x18, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xDC, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0xFF, 0x84, 0x00, 0x00, 0x00,
  0x00,
};

const GFXglyph NotoSans_Condensed_Medium69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 50, 17, 4, -49 },
  { 58, 20, 18, 28, 4, -49 },
  { 103, 34, 49, 36, 1, -49 },
  { 312, 27, 56, 33, 3, -52 },
  { 501, 46, 51, 51, 3, -50 },
  { 795, 37, 51, 39, 2, -50 },
  { 1031, 7, 18, 15, 4, -49 },
  { 1047, 16, 60, 21, 3, -49 },
  { 1167, 16, 60, 21, 2, -49 },
  { 1287, 27, 27, 31, 2, -53 },
  { 1379, 29, 33, 33, 2, -41 },
  { 1499, 11, 17, 17, 2, -8 },
  { 1523, 16, 7, 20, 2, -22 },
  { 1537, 9, 10, 17, 4, -9 },
  { 1549, 25, 50, 26, 1, -50 },
  { 1706, 27, 51, 33, 3, -50 },
  { 1879, 19, 49, 33, 4, -49 },
  { 1996, 27, 50, 33, 3, -50 },
  { 2165, 27, 51, 33, 3, -50 },
  { 2338, 31, 50, 33, 1, -50 },
  { 2532, 26, 50, 33, 4, -49 },
  { 2695, 27, 51, 33, 3, -50 },
  { 2868, 28, 49, 33, 2, -49 },
  { 3040, 29, 51, 33, 2, -50 },
  { 3225, 27, 51, 33, 3, -50 },
  { 3398, 9, 39, 17, 4, -38 },
  { 3442, 11, 47, 17, 2, -38 },
  { 3507, 29, 33, 33, 2, -41 },
  { 3627, 29, 20, 33, 2, -34 },
  { 3700, 29, 33, 33, 2, -41 },
  { 3820, 23, 51, 25, 1, -50 },
  { 3967, 45, 56, 51, 3, -50 },
  { 4282, 36, 49, 36, 0, -49 },
  { 4503, 29, 49, 37, 5, -49 },
  { 4681, 29, 51, 35, 4, -50 },
  { 4866, 32, 49, 41, 5, -49 },
  { 5062, 23, 49, 31, 5, -49 },
  { 5203, 23, 49, 30, 5, -49 },
  { 5344, 33, 51, 42, 4, -50 },
  { 5555, 32, 49, 42, 5, -49 },
  { 5751, 17, 49, 21, 2, -49 },
  { 5856, 16, 63, 18, -4, -49 },
  { 5982, 31, 49, 36, 5, -49 },
  { 6172, 23, 49, 29, 5, -49 },
  { 6313, 44, 49, 54, 5, -49 },
  { 6583, 34, 49, 44, 5, -49 },
  { 6792, 36, 51, 43, 4, -50 },
  { 7022, 27, 49, 35, 5, -49 },
  { 7188, 36, 62, 43, 4, -50 },
  { 7467, 30, 49, 36, 5, -49 },
  { 7651, 26, 51, 31, 3, -50 },
  { 7817, 29, 49, 31, 1, -49 },
  { 7995, 31, 50, 41, 5, -49 },
  { 8189, 35, 49, 35, 0, -49 },
  { 8404, 54, 49, 55, 0, -49 },
  { 8735, 33, 49, 33, 0, -49 },
  { 8938, 32, 49, 32, 0, -49 },
  { 9134, 26, 49, 30, 2, -49 },
  { 9294, 15, 60, 22, 5, -49 },
  { 9407, 25, 50, 26, 1, -50 },
  { 9564, 15, 60, 22, 2, -49 },
  { 9677, 31, 28, 34, 2, -49 },
  { 9786, 30, 4, 30, 0, 6 },
  { 9801, 14, 11, 20, 3, -53 },
  { 9821, 26, 39, 33, 2, -38 },
  { 9948, 28, 53, 36, 5, -52 },
  { 10134, 23, 39, 28, 3, -38 },
  { 10247, 28, 53, 36, 3, -52 },
  { 10433, 27, 39, 33, 3, -38 },
  { 10565, 21, 53, 20, 1, -53 },
  { 10705, 28, 55, 36, 3, -38 },
  { 10898, 26, 52, 36, 5, -52 },
  { 11067, 8, 51, 16, 4, -51 },
  { 11118, 14, 68, 16, -2, -51 },
  { 11237, 27, 52, 32, 5, -52 },
  { 11413, 7, 52, 16, 5, -52 },
  { 11459, 44, 38, 53, 5, -38 },
  { 11668, 26, 38, 36, 5, -38 },
  { 11792, 29, 39, 35, 3, -38 },
  { 11934, 28, 55, 36, 5, -38 },
  { 12127, 28, 55, 36, 3, -38 },
  { 12320, 18, 38, 24, 5, -38 },
  { 12406, 22, 39, 27, 3, -38 },
  { 12514, 19, 46, 21, 1, -45 },
  { 12624, 27, 38, 36, 4, -37 },
  { 12753, 30, 37, 30, 0, -37 },
  { 12892, 45, 37, 47, 1, -37 },
  { 13101, 28, 37, 30, 1, -37 },
  { 13231, 30, 54, 30, 0, -37 },
  { 13434, 22, 37, 25, 2, -37 },
  { 13536, 21, 60, 25, 2, -49 },
  { 13694, 6, 69, 31, 13, -53 },
  { 13746, 20, 60, 25, 3, -49 },
  { 13896, 29, 10, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_Medium69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_MEDIUM69PT7B_H_
