#ifndef _NOTOSANS_CONDENSED_MEDIUM46PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xFB, 0xFF,
  0xFF, 0x78, 0x80, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC1,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x83, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1C, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE,
  0x7C, 0xC1, 0x3E, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00, 0xF0, 0xC0, 0x3E,
  0x30, 0x07, 0xCC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x37, 0xE0, 0x0C, 0x7C, 0x03, 0x0F,
  0x00, 0xC3, 0xC0, 0x30, 0xF0, 0x0C, 0x3F, 0x03, 0x1F, 0xF0, 0xDF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x0F, 0x00,
  0xFF, 0x00, 0x78, 0x07, 0xFC, 0x01, 0xE0, 0x1E, 0x78, 0x07, 0x00, 0xF0,
  0xE0, 0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0x0F, 0x0F, 0x07, 0x80, 0x3C, 0x3C,
  0x1E, 0x00, 0xF0, 0xF0, 0x70, 0x03, 0x83, 0xC3, 0xC0, 0x0E, 0x0F, 0x0E,
  0x00, 0x38, 0x3C, 0x78, 0x00, 0xF0, 0xF1, 0xE0, 0x03, 0xC3, 0xCF, 0x0F,
  0x8F, 0x0F, 0x3C, 0xFF, 0x3C, 0x38, 0xE3, 0xFE, 0x79, 0xE7, 0x9E, 0x79,
  0xFF, 0x9E, 0x70, 0xF3, 0xFC, 0xF1, 0xC3, 0xC7, 0xE3, 0xCF, 0x0F, 0x00,
  0x0E, 0x3C, 0x1C, 0x00, 0x78, 0xF0, 0x70, 0x01, 0xC3, 0xC1, 0xC0, 0x0F,
  0x0F, 0x07, 0x00, 0x3C, 0x3C, 0x1C, 0x01, 0xE0, 0xF0, 0x70, 0x07, 0x83,
  0xC3, 0xC0, 0x1C, 0x07, 0x0F, 0x00, 0xF0, 0x1C, 0x3C, 0x03, 0x80, 0x79,
  0xE0, 0x1E, 0x00, 0xFF, 0x80, 0x78, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3E, 0x7E, 0xF8, 0x3E, 0x7C, 0x7C, 0x3C,
  0xF8, 0x7E, 0x3C, 0xF8, 0x3E, 0x7C, 0xF0, 0x1F, 0x78, 0xF0, 0x0F, 0xF8,
  0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xF0,
  0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0x7C, 0x3F, 0xFC, 0x3E,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x03,
  0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x06,
  0x0E, 0x0F, 0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xF7, 0x80, 0xF3, 0xE0, 0xF8, 0xF8, 0x78, 0x7C, 0x1C,
  0x18, 0x02, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E,
  0x7C, 0xF1, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xEF,
  0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x1F, 0x03, 0xE7,
  0xC0, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x3E, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF3, 0xFF, 0x7E, 0xFF,
  0xCF, 0x78, 0xF7, 0x0F, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC,
  0x78, 0x1F, 0x18, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x70, 0x1F, 0x98, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0xC0, 0x1F, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0E, 0xF8, 0x01, 0xEF, 0x80, 0x1C, 0xF8, 0x03, 0xCF,
  0x80, 0x38, 0xF8, 0x07, 0x8F, 0x80, 0x70, 0xF8, 0x0F, 0x0F, 0x81, 0xE0,
  0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0x78,
  0x0F, 0x8F, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFA, 0x00, 0x3E, 0xC0,
  0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0xF8, 0x3E, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFE, 0xFE,
  0x1F, 0xBF, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1E, 0x3E, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFF, 0x83, 0xF3, 0xF1, 0xF0, 0x7E, 0x78, 0x0F, 0xBE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xDF, 0xCF, 0xE7, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0x7C, 0x1F, 0xDF, 0xFE, 0xF3, 0xFF, 0xFC, 0x7F, 0xDF, 0x0F, 0xC7, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x1E, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFB, 0xFF, 0xFE, 0xF8, 0x80, 0x3C,
  0xF9, 0xFB, 0xF7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x9F, 0x3E, 0x78, 0xF1, 0xE7, 0x8F,
  0x1E, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x30, 0x3E, 0x20, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x1F, 0xE1, 0xE3, 0x81, 0xFF, 0xC3,
  0x9E, 0x0F, 0xFF, 0x0E, 0x78, 0x7C, 0x3C, 0x3D, 0xC1, 0xE0, 0xE0, 0xF7,
  0x07, 0x03, 0x83, 0xFC, 0x3C, 0x0E, 0x0F, 0xF0, 0xF0, 0x38, 0x3F, 0xC3,
  0xC0, 0xE0, 0xFF, 0x0F, 0x07, 0x83, 0xFC, 0x3C, 0x1E, 0x0F, 0xF0, 0xF0,
  0x78, 0x3F, 0xC3, 0xC1, 0xE0, 0xEF, 0x0F, 0x07, 0x83, 0xBC, 0x1C, 0x3E,
  0x1E, 0x70, 0x7D, 0xDC, 0xF1, 0xE0, 0xFF, 0x7F, 0xC7, 0x83, 0xF8, 0xFE,
  0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1F,
  0xE1, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0x81, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80, 0x3E,
  0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0xF9,
  0xE0, 0x3F, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3,
  0xC0, 0x3F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xEF,
  0x01, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xC0,
  0x61, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x20, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x07, 0xFC,
  0x78, 0x07, 0xE3, 0xC0, 0x1F, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xF7, 0x80,
  0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xF0, 0x03, 0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xF9, 0xE0, 0x1F,
  0x8F, 0x03, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x03, 0xC3, 0xF0, 0x01, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8,
  0xFC, 0x01, 0xF1, 0xFC, 0x03, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xC0,
  0xF0, 0x03, 0xFF, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x0F,
  0x8F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F,
  0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xF0, 0x0F, 0x3E, 0x00, 0xF7,
  0xC0, 0x0F, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xE0,
  0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F,
  0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xF0, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0x80, 0x0F, 0xFF, 0xBC, 0x00,
  0xF7, 0xFD, 0xE0, 0x07, 0xBF, 0xE7, 0x80, 0x3D, 0xFF, 0x3C, 0x03, 0xCF,
  0xF9, 0xE0, 0x1E, 0x7F, 0xCF, 0x80, 0xF3, 0xFE, 0x3C, 0x0F, 0x1F, 0xF1,
  0xE0, 0x78, 0xFF, 0x8F, 0x03, 0xC7, 0xFC, 0x3C, 0x3C, 0x3F, 0xE1, 0xE1,
  0xE1, 0xFF, 0x0F, 0x0F, 0x0F, 0xF8, 0x3C, 0x78, 0x7F, 0xC1, 0xE7, 0x83,
  0xFE, 0x0F, 0x3C, 0x1F, 0xF0, 0x7D, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x0F,
  0xC0, 0x7F, 0xC0, 0x7E, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00,
  0xF8, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xF7,
  0x80, 0x3F, 0xDF, 0x00, 0xFF, 0x3C, 0x03, 0xFC, 0xF8, 0x0F, 0xF3, 0xE0,
  0x3F, 0xC7, 0xC0, 0xFF, 0x1F, 0x03, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F,
  0xC1, 0xF0, 0xFF, 0x07, 0xC3, 0xFC, 0x0F, 0x8F, 0xF0, 0x3E, 0x3F, 0xC0,
  0x7C, 0xFF, 0x01, 0xF3, 0xFC, 0x03, 0xEF, 0xF0, 0x0F, 0xBF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE7, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0x07, 0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x7F,
  0x8F, 0x01, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0,
  0x1F, 0x0F, 0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xE0,
  0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F,
  0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xF0, 0x07,
  0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xE7, 0xE0, 0x73, 0xE0, 0x0B,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFE, 0x03,
  0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x3C, 0x01,
  0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0xC0,
  0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00,
  0xF9, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07,
  0xBC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0x1F, 0x78, 0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x80,
  0x1F, 0x7C, 0x01, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0xC0, 0x3E, 0x7C, 0x01,
  0xFC, 0x03, 0xE3, 0xC0, 0x3F, 0xC0, 0x3E, 0x3E, 0x03, 0xFC, 0x03, 0xC3,
  0xE0, 0x3D, 0xC0, 0x3C, 0x3E, 0x03, 0xDE, 0x07, 0xC1, 0xE0, 0x79, 0xE0,
  0x7C, 0x1E, 0x07, 0x9E, 0x07, 0xC1, 0xF0, 0x79, 0xE0, 0x78, 0x1F, 0x07,
  0x8F, 0x07, 0x81, 0xF0, 0x78, 0xF0, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x80,
  0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x8F, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x79,
  0xF0, 0x07, 0x9E, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x79, 0xF0, 0x07, 0x9E,
  0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x3D, 0xE0, 0x07, 0xDE, 0x03, 0xDE, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0x3C,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFB, 0xC0, 0x07,
  0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x78,
  0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0,
  0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0E, 0x0F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xEF, 0xE1, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC1, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xFB, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xE3, 0xFD, 0xFF, 0xDE, 0xFF, 0xCF, 0x1F, 0xC7, 0x80, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE3,
  0xF0, 0x7D, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x83, 0xE7, 0xE0,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x7D, 0xF8, 0x0F, 0xBF, 0x83,
  0xE7, 0xF8, 0xFC, 0xF7, 0xFF, 0x1E, 0x7F, 0xE3, 0xC7, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0xE0, 0x4F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x27, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x8F,
  0x8F, 0xFD, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0x83, 0xFB, 0xE0, 0x3F,
  0x7C, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x7E, 0xF8, 0x0F, 0xDF, 0x83, 0xF9,
  0xF9, 0xFF, 0x3F, 0xFD, 0xE3, 0xFF, 0x3C, 0x3F, 0xC7, 0x80, 0x03, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x3C, 0x0F, 0x9F, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x8F, 0xE3, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x07, 0xE1, 0xE3, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF7, 0xE0,
  0xFE, 0xF8, 0x0F, 0xDF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x03,
  0xF7, 0xE0, 0xFE, 0x7F, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xDF, 0x0F, 0xF3,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x90, 0x01, 0xF3, 0x80, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x9F, 0xC3, 0xEF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xE0,
  0xFB, 0xF0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0xF7, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x7F, 0xBF, 0xDF, 0xCF, 0x80, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F,
  0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8,
  0xF8, 0x3E, 0x3C, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xFC, 0x0F, 0xC3, 0xCF, 0xF8, 0xFF, 0xCF,
  0x7F, 0xF7, 0xFF, 0x3F, 0xFF, 0xDF, 0xFE, 0xFE, 0x1F, 0xE0, 0xFB, 0xF0,
  0x3F, 0x03, 0xEF, 0x80, 0xFC, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07,
  0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0,
  0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07,
  0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF,
  0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0,
  0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07,
  0x80, 0x7C, 0xF1, 0xFC, 0x3C, 0xFF, 0xCF, 0x7F, 0xF3, 0xDF, 0xFE, 0xFE,
  0x0F, 0xBF, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8,
  0x0F, 0x9F, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x7F, 0x7F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xF1,
  0xFC, 0x1E, 0x7F, 0xC3, 0xDF, 0xFC, 0x7B, 0xFF, 0xCF, 0xE0, 0xF9, 0xF8,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x7E, 0x03, 0xEF, 0xE0,
  0xF9, 0xFF, 0x7F, 0x3D, 0xFF, 0xC7, 0xDF, 0xF8, 0xF9, 0xFC, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE1, 0xE3, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF7, 0xE0,
  0xFE, 0xF8, 0x0F, 0xDF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0xBE, 0x03,
  0xF7, 0xE0, 0xFE, 0x7F, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xDF, 0x0F, 0xF3,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0xF0, 0xFF, 0x9F, 0xBC, 0xFD, 0xEF, 0xEF, 0xF9, 0x7F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBE, 0xF8, 0x0B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0xE7, 0xFF, 0xFF,
  0xBF, 0xFC, 0x7F, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0xB1, 0xFF, 0x0F, 0xF0,
  0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F,
  0xDF, 0xFF, 0xF7, 0xFF, 0xBC, 0xFF, 0xCF, 0x1F, 0xE3, 0xC0, 0xF8, 0x01,
  0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0,
  0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F,
  0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x7D, 0xE0, 0x1F, 0x80,
  0xF3, 0xE0, 0x7F, 0x01, 0xE7, 0xC0, 0xFE, 0x07, 0xC7, 0x81, 0xDC, 0x0F,
  0x8F, 0x03, 0xBC, 0x1E, 0x1F, 0x0F, 0x78, 0x3C, 0x3E, 0x1E, 0xF0, 0x78,
  0x3C, 0x3C, 0xE1, 0xF0, 0x78, 0x79, 0xE3, 0xC0, 0xF0, 0xE3, 0xC7, 0x81,
  0xF3, 0xC7, 0x8F, 0x01, 0xE7, 0x8F, 0x3E, 0x03, 0xCF, 0x0E, 0x7C, 0x07,
  0x9C, 0x1E, 0xF0, 0x0F, 0x38, 0x3D, 0xE0, 0x1F, 0xF0, 0x7B, 0xC0, 0x1F,
  0xE0, 0xF7, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x3C, 0x3E,
  0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xCF, 0x01, 0xF3, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0xF8,
  0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3,
  0xC0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9F,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x0F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0xE0, 0x3F,
  0x81, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0x81, 0xFC, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F,
  0xFD, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 34, 12, 3, -33 },
  { 27, 13, 12, 19, 3, -33 },
  { 47, 22, 33, 24, 1, -33 },
  { 138, 18, 38, 22, 2, -35 },
  { 224, 30, 33, 34, 2, -33 },
  { 348, 24, 33, 26, 2, -33 },
  { 447, 5, 12, 10, 3, -33 },
  { 455, 11, 40, 14, 2, -33 },
  { 510, 11, 40, 14, 1, -33 },
  { 565, 17, 18, 21, 2, -35 },
  { 604, 18, 22, 22, 2, -27 },
  { 654, 7, 11, 11, 2, -5 },
  { 664, 11, 4, 14, 1, -14 },
  { 670, 6, 7, 11, 3, -6 },
  { 676, 16, 33, 18, 1, -33 },
  { 742, 18, 33, 22, 2, -33 },
  { 817, 12, 33, 22, 3, -33 },
  { 867, 18, 33, 22, 2, -33 },
  { 942, 18, 33, 22, 2, -33 },
  { 1017, 20, 33, 22, 1, -33 },
  { 1100, 18, 33, 22, 2, -33 },
  { 1175, 18, 33, 22, 2, -33 },
  { 1250, 19, 33, 22, 1, -33 },
  { 1329, 18, 33, 22, 2, -33 },
  { 1404, 18, 33, 22, 2, -33 },
  { 1479, 6, 26, 11, 3, -25 },
  { 1499, 7, 31, 11, 2, -25 },
  { 1527, 18, 21, 22, 2, -27 },
  { 1575, 18, 13, 22, 2, -23 },
  { 1605, 19, 21, 22, 2, -27 },
  { 1655, 16, 34, 17, 0, -33 },
  { 1723, 30, 37, 34, 2, -33 },
  { 1862, 24, 33, 24, 0, -33 },
  { 1961, 19, 33, 25, 4, -33 },
  { 2040, 20, 33, 23, 2, -33 },
  { 2123, 21, 33, 27, 4, -33 },
  { 2210, 15, 33, 21, 4, -33 },
  { 2272, 15, 33, 20, 4, -33 },
  { 2334, 23, 33, 28, 2, -33 },
  { 2429, 20, 33, 28, 4, -33 },
  { 2512, 11, 33, 14, 2, -33 },
  { 2558, 11, 42, 12, -3, -33 },
  { 2616, 20, 33, 24, 4, -33 },
  { 2699, 15, 33, 20, 4, -33 },
  { 2761, 29, 33, 36, 4, -33 },
  { 2881, 22, 33, 30, 4, -33 },
  { 2972, 25, 33, 29, 2, -33 },
  { 3076, 17, 33, 23, 4, -33 },
  { 3147, 25, 41, 29, 2, -33 },
  { 3276, 20, 33, 24, 4, -33 },
  { 3359, 17, 33, 21, 2, -33 },
  { 3430, 19, 33, 20, 1, -33 },
  { 3509, 21, 33, 27, 3, -33 },
  { 3596, 23, 33, 23, 0, -33 },
  { 3691, 36, 33, 36, 0, -33 },
  { 3840, 22, 33, 22, 0, -33 },
  { 3931, 21, 33, 21, 0, -33 },
  { 4018, 18, 33, 20, 1, -33 },
  { 4093, 10, 40, 15, 3, -33 },
  { 4143, 16, 33, 18, 1, -33 },
  { 4209, 10, 40, 15, 1, -33 },
  { 4259, 21, 19, 23, 1, -33 },
  { 4309, 20, 3, 20, 0, 4 },
  { 4317, 9, 7, 13, 2, -35 },
  { 4325, 17, 25, 22, 2, -25 },
  { 4379, 19, 35, 24, 3, -35 },
  { 4463, 15, 25, 18, 2, -25 },
  { 4510, 19, 35, 24, 2, -35 },
  { 4594, 18, 25, 22, 2, -25 },
  { 4651, 15, 35, 14, 0, -35 },
  { 4717, 19, 36, 24, 2, -25 },
  { 4803, 18, 35, 24, 3, -35 },
  { 4882, 5, 34, 11, 3, -34 },
  { 4904, 9, 45, 11, -1, -34 },
  { 4955, 18, 35, 21, 3, -35 },
  { 5034, 5, 35, 11, 3, -35 },
  { 5056, 30, 25, 36, 3, -25 },
  { 5150, 18, 25, 24, 3, -25 },
  { 5207, 19, 25, 23, 2, -25 },
  { 5267, 19, 36, 24, 3, -25 },
  { 5353, 19, 36, 24, 2, -25 },
  { 5439, 13, 25, 16, 3, -25 },
  { 5480, 14, 25, 18, 2, -25 },
  { 5524, 12, 30, 14, 1, -30 },
  { 5569, 18, 25, 24, 3, -25 },
  { 5626, 20, 25, 20, 0, -25 },
  { 5689, 31, 25, 31, 0, -25 },
  { 5786, 18, 25, 20, 1, -25 },
  { 5843, 20, 36, 20, 0, -25 },
  { 5933, 15, 25, 17, 1, -25 },
  { 5980, 14, 40, 17, 1, -33 },
  { 6050, 3, 46, 21, 9, -35 },
  { 6068, 13, 40, 17, 2, -33 },
  { 6133, 19, 6, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Medium46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_MEDIUM46PT7B_H_
