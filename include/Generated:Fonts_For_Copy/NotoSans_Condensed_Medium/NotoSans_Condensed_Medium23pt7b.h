#ifndef _NOTOSANS_CONDENSED_MEDIUM23PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0xFB, 0xE7, 0xCD, 0x9B, 0x34, 0x68,
  0xC0, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x19, 0x81,
  0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0x10, 0x33, 0x03, 0x30, 0x33, 0x03,
  0x30, 0x08, 0x0E, 0x1F, 0xFD, 0x6C, 0x86, 0x43, 0xA0, 0xF0, 0x3E, 0x07,
  0x82, 0xE1, 0x30, 0x9C, 0x5F, 0xFC, 0xF8, 0x08, 0x04, 0x00, 0x30, 0x00,
  0xF0, 0x63, 0x31, 0x86, 0x63, 0x0C, 0xCC, 0x19, 0x98, 0x33, 0x20, 0x66,
  0xDE, 0xCD, 0xBE, 0xF6, 0xCC, 0xCD, 0x98, 0x33, 0x30, 0x66, 0x60, 0x8C,
  0xC3, 0x19, 0x86, 0x1F, 0x18, 0x3C, 0x1C, 0x03, 0xE0, 0x77, 0x06, 0x30,
  0x63, 0x07, 0x70, 0x36, 0x03, 0xC0, 0x3C, 0x07, 0xC6, 0xEE, 0x6C, 0x7E,
  0xC3, 0xCC, 0x1C, 0xE3, 0xCF, 0xFE, 0x7E, 0x70, 0xFD, 0xB4, 0x80, 0x19,
  0x8C, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x71, 0x86, 0x30,
  0xC3, 0x18, 0x63, 0x18, 0xE3, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x63, 0x31,
  0x80, 0x18, 0x0C, 0x06, 0x1B, 0x6F, 0xF8, 0xE0, 0xF0, 0xEC, 0x67, 0x00,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFF, 0xFE, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x6D, 0xFD, 0x80, 0xFF, 0xC0, 0x7D, 0x80, 0x03, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0xE0, 0x00, 0x1C, 0x1F, 0x1D, 0xCC, 0x6E, 0x3E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x3F, 0x1D, 0x8C, 0xFE, 0x3E, 0x00,
  0x0E, 0x3D, 0xFF, 0x74, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x1C, 0x3F, 0x39, 0xC8, 0x60, 0x38, 0x1C, 0x0C, 0x06, 0x06,
  0x07, 0x03, 0x03, 0x03, 0x03, 0x83, 0x81, 0xFF, 0xFF, 0x80, 0x1C, 0x7F,
  0x39, 0xD0, 0x60, 0x38, 0x18, 0x0C, 0x1C, 0x3C, 0x1F, 0x80, 0xE0, 0x70,
  0x38, 0x1E, 0x0F, 0xFE, 0xFE, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0xD8, 0x1B, 0x06, 0x60, 0xCC, 0x31, 0x84, 0x31, 0x86, 0x7F, 0xFF, 0xFE,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x03,
  0x03, 0xF8, 0xFE, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x3C, 0x1B, 0xFD, 0xFC,
  0x07, 0x0F, 0x8E, 0x4E, 0x06, 0x07, 0x03, 0x01, 0xBE, 0xF7, 0x71, 0xF0,
  0x78, 0x3C, 0x1F, 0x0D, 0x8E, 0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0xE0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0xE0, 0x1C, 0x3F, 0x98, 0xDC, 0x7C, 0x1F, 0x1D, 0x8C, 0x7C, 0x1C,
  0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x8E, 0xFE, 0x3E, 0x00, 0x18, 0x3F,
  0x1D, 0xDC, 0x6C, 0x3E, 0x0F, 0x07, 0x87, 0xE3, 0xBE, 0xCF, 0x60, 0x30,
  0x30, 0x18, 0x1C, 0xFC, 0x7C, 0x00, 0x5F, 0xB0, 0x00, 0x01, 0xF6, 0x5F,
  0xB0, 0x00, 0x01, 0xB7, 0xB6, 0x00, 0x80, 0xC1, 0xE3, 0xC7, 0x87, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x80, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x1E, 0x3C, 0x78, 0x70,
  0x20, 0x00, 0x18, 0xFE, 0x67, 0x03, 0x03, 0x03, 0x06, 0x0E, 0x1C, 0x18,
  0x18, 0x10, 0x00, 0x00, 0x38, 0x38, 0x38, 0x01, 0x80, 0x1F, 0xE0, 0x70,
  0xE1, 0x80, 0x66, 0x00, 0xCC, 0x7C, 0x91, 0x99, 0xE6, 0x33, 0xCC, 0x67,
  0x98, 0xCF, 0x31, 0x9E, 0x67, 0x3C, 0xCE, 0xD8, 0xF7, 0x98, 0x00, 0x30,
  0x00, 0x30, 0x10, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x19, 0x81, 0x98, 0x19, 0x83, 0x9C, 0x30, 0xC3, 0xFC, 0x3F, 0xE7,
  0x0E, 0x60, 0x66, 0x06, 0xE0, 0x7E, 0x07, 0xFF, 0x7F, 0xF0, 0xF8, 0x3C,
  0x1E, 0x1F, 0xFD, 0xFC, 0xC7, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xFD,
  0xFC, 0x07, 0x07, 0xF3, 0xCD, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x84, 0xFF, 0x1F, 0xC0, 0xFE,
  0x3F, 0xEC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0xC1, 0xB0, 0xEF, 0xF3, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x18,
  0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x03,
  0x83, 0xFC, 0xF3, 0xB8, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFC,
  0x3F, 0x81, 0xF0, 0x36, 0x06, 0xE0, 0xCE, 0x19, 0xFF, 0x0F, 0xE0, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFB, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x3B, 0xFF, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x19, 0xFF, 0xE4, 0x00, 0xC1, 0xF0, 0xEC, 0x73, 0x18,
  0xCE, 0x37, 0x0D, 0x83, 0xE0, 0xFC, 0x3B, 0x0C, 0xE3, 0x1C, 0xC7, 0x30,
  0xEC, 0x1B, 0x07, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xD8, 0x3F, 0x61, 0xBD, 0x86, 0xF6, 0x1B, 0xCC, 0xCF, 0x33, 0x3C, 0xCC,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x30, 0xF0, 0xC3, 0xE0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x3D, 0x87, 0xB8, 0xF3, 0x1E, 0x63, 0xC6, 0x78, 0xCF, 0x0D,
  0xE1, 0xBC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x07, 0x01, 0xFC, 0x3D, 0xE7,
  0x06, 0x60, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0x60, 0x77, 0x07, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xFE, 0x7F, 0xB0,
  0xD8, 0x7C, 0x3E, 0x1F, 0x0D, 0x8E, 0xFE, 0x7C, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x07, 0x01, 0xFC, 0x3D, 0xE7, 0x06, 0x60, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x77, 0x07,
  0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0xFE,
  0x3F, 0xCC, 0x3B, 0x0E, 0xC3, 0xB0, 0xEC, 0x33, 0xFC, 0xFC, 0x33, 0x8C,
  0x63, 0x1C, 0xC3, 0x30, 0xEC, 0x3B, 0x07, 0x1C, 0x3F, 0x9D, 0xDC, 0x0C,
  0x07, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xC0, 0x70, 0x38, 0x1E, 0x0D,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF8, 0x77, 0xF8, 0xFC, 0xE0, 0x76, 0x06, 0x60, 0x66,
  0x0E, 0x70, 0xC3, 0x0C, 0x31, 0xC3, 0x18, 0x39, 0x81, 0x98, 0x1B, 0x81,
  0xB0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xE0, 0xC0, 0xF8, 0x38, 0x76,
  0x1E, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x9C, 0x6C, 0x63, 0x33, 0x38, 0xCC,
  0xCC, 0x33, 0x33, 0x0C, 0xCC, 0xC3, 0xB1, 0xF0, 0x78, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE0, 0xE0, 0x30, 0x38, 0xE0, 0xEE, 0x38, 0xC6, 0x1D,
  0xC1, 0xB0, 0x3E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xE0, 0x6C, 0x1D, 0xC3,
  0x18, 0xE3, 0x98, 0x37, 0x07, 0xE0, 0xEC, 0x19, 0xC7, 0x18, 0xC3, 0x38,
  0x76, 0x06, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x30, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xC0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x06, 0x01, 0xC0, 0x3C, 0x0D, 0x81, 0x98,
  0x63, 0x0C, 0x33, 0x06, 0xE0, 0x60, 0xFF, 0xC0, 0xE3, 0x0C, 0x30, 0x1C,
  0x7E, 0x67, 0x03, 0x03, 0x0F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC7, 0xFF, 0x79,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0xC7, 0xF3, 0x9D, 0x87, 0xC3, 0xE0, 0xF0,
  0x78, 0x3C, 0x3E, 0x1F, 0x8D, 0xFE, 0x9E, 0x00, 0x0C, 0x3F, 0x72, 0x60,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x7E, 0x3E, 0x01, 0x80, 0xC0,
  0x60, 0x31, 0x9B, 0xFD, 0xCF, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0D, 0x8E, 0xFF, 0x3D, 0x80, 0x1C, 0x1F, 0x1C, 0xCC, 0x7C, 0x1E, 0x0F,
  0xFF, 0x80, 0xC0, 0x70, 0x18, 0x2F, 0xE3, 0xF0, 0x0C, 0x3C, 0xE9, 0x83,
  0x06, 0x3F, 0x98, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x18, 0x3F, 0xDC, 0xFC, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xD8,
  0xEF, 0xF3, 0xD8, 0x0C, 0x06, 0x03, 0x67, 0xBF, 0x82, 0x00, 0xC0, 0xC0,
  0xC0, 0xC0, 0xCC, 0xFF, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x7D, 0x80, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x19, 0xC6,
  0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7B, 0xF9,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x3B, 0x19, 0x98, 0xD8, 0x7C,
  0x3E, 0x1F, 0x8C, 0xC6, 0x73, 0x19, 0x8E, 0xC3, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x33, 0xFB, 0xFE, 0x79, 0xF0, 0xE3, 0xC3, 0x0F, 0x0C,
  0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3,
  0x0C, 0x0C, 0xFF, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x1C, 0x0F, 0xC7, 0x3B, 0x86, 0xE1, 0xB0, 0x7C, 0x1F, 0x07,
  0xC1, 0xB8, 0x66, 0x39, 0xFC, 0x3E, 0x00, 0x0C, 0x7F, 0x39, 0xD8, 0x7C,
  0x3E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF8, 0xDF, 0xED, 0xE6, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x00, 0x18, 0x3F, 0xDC, 0xFC, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0xD8, 0xEF, 0xF3, 0xD8, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x0E, 0x7F, 0xF8, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x38, 0xFF, 0x9E, 0x0C, 0x1E, 0x1E, 0x0F, 0x0E, 0x0E, 0x1F, 0xFF,
  0xC0, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0xC7, 0x80, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0x61, 0xB1, 0xDF, 0xE7, 0xB0, 0xE1, 0xD8, 0x66, 0x19, 0x8E, 0x33, 0x0C,
  0xC3, 0x30, 0xDC, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0xE3, 0x86, 0xC7, 0x8D,
  0x8F, 0x1B, 0x16, 0x77, 0x6C, 0xC6, 0xC9, 0x8D, 0x9B, 0x1B, 0x3E, 0x34,
  0x78, 0x38, 0xF0, 0x70, 0xE0, 0xE1, 0xC0, 0xE1, 0xDC, 0xE3, 0x30, 0x7C,
  0x1E, 0x03, 0x01, 0xE0, 0x78, 0x33, 0x0C, 0xC6, 0x1B, 0x87, 0xE1, 0xD8,
  0x66, 0x19, 0xCE, 0x33, 0x0C, 0xC3, 0x30, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0x82, 0xE0, 0xF0, 0x10, 0x00, 0xFE, 0x1C, 0x30,
  0xE1, 0x87, 0x0C, 0x38, 0x61, 0xC3, 0xFF, 0xF0, 0x1E, 0x70, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x71, 0x83, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70,
  0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x38, 0x1C, 0x79, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xE3,
  0xC6, 0x00, 0x70, 0xFE, 0x63, 0xF0, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 12, 16, 12, 0, -16 },
  { 37, 9, 18, 11, 1, -17 },
  { 58, 15, 17, 17, 1, -17 },
  { 90, 12, 17, 13, 1, -17 },
  { 116, 3, 6, 5, 1, -16 },
  { 119, 5, 20, 7, 1, -16 },
  { 132, 5, 20, 7, 1, -16 },
  { 145, 9, 9, 10, 1, -18 },
  { 156, 9, 11, 11, 1, -14 },
  { 169, 3, 6, 6, 1, -3 },
  { 172, 5, 2, 7, 1, -7 },
  { 174, 3, 3, 6, 1, -3 },
  { 176, 9, 17, 9, 0, -17 },
  { 196, 9, 17, 11, 1, -17 },
  { 216, 7, 16, 11, 1, -16 },
  { 230, 9, 17, 11, 1, -17 },
  { 250, 9, 17, 11, 1, -17 },
  { 270, 11, 17, 11, 0, -17 },
  { 294, 9, 16, 11, 1, -16 },
  { 312, 9, 17, 11, 1, -17 },
  { 332, 9, 16, 11, 1, -16 },
  { 350, 9, 17, 11, 1, -17 },
  { 370, 9, 17, 11, 1, -17 },
  { 390, 3, 13, 6, 1, -13 },
  { 395, 3, 16, 6, 1, -13 },
  { 401, 9, 11, 11, 1, -14 },
  { 414, 9, 6, 11, 1, -11 },
  { 421, 9, 11, 11, 1, -14 },
  { 434, 8, 17, 8, 0, -17 },
  { 451, 15, 19, 17, 1, -17 },
  { 487, 12, 16, 12, 0, -16 },
  { 511, 9, 16, 12, 2, -16 },
  { 529, 10, 17, 12, 1, -17 },
  { 551, 10, 16, 14, 2, -16 },
  { 571, 7, 16, 10, 2, -16 },
  { 585, 7, 16, 10, 2, -16 },
  { 599, 11, 17, 14, 1, -17 },
  { 623, 10, 16, 14, 2, -16 },
  { 643, 5, 16, 7, 1, -16 },
  { 653, 5, 21, 6, -1, -16 },
  { 667, 10, 16, 12, 2, -16 },
  { 687, 7, 16, 10, 2, -16 },
  { 701, 14, 16, 18, 2, -16 },
  { 729, 11, 16, 15, 2, -16 },
  { 751, 12, 17, 14, 1, -17 },
  { 777, 9, 16, 12, 2, -16 },
  { 795, 12, 21, 14, 1, -17 },
  { 827, 10, 16, 12, 2, -16 },
  { 847, 9, 17, 10, 1, -17 },
  { 867, 10, 16, 10, 0, -16 },
  { 887, 10, 16, 14, 2, -16 },
  { 907, 12, 16, 12, 0, -16 },
  { 931, 18, 16, 18, 0, -16 },
  { 967, 11, 16, 11, 0, -16 },
  { 989, 11, 16, 11, 0, -16 },
  { 1011, 8, 16, 10, 1, -16 },
  { 1027, 5, 20, 7, 2, -16 },
  { 1040, 9, 17, 9, 0, -17 },
  { 1060, 5, 20, 7, 1, -16 },
  { 1073, 11, 9, 11, 0, -16 },
  { 1086, 10, 1, 10, 0, 2 },
  { 1088, 5, 4, 7, 1, -18 },
  { 1091, 8, 13, 11, 1, -13 },
  { 1104, 9, 17, 12, 2, -17 },
  { 1124, 8, 13, 9, 1, -13 },
  { 1137, 9, 17, 12, 1, -17 },
  { 1157, 9, 13, 11, 1, -13 },
  { 1172, 7, 18, 7, 0, -18 },
  { 1188, 9, 19, 12, 1, -13 },
  { 1210, 8, 17, 12, 2, -17 },
  { 1227, 3, 17, 5, 1, -17 },
  { 1234, 5, 23, 5, -1, -17 },
  { 1249, 9, 17, 11, 2, -17 },
  { 1269, 2, 17, 5, 2, -17 },
  { 1274, 14, 13, 18, 2, -13 },
  { 1297, 8, 13, 12, 2, -13 },
  { 1310, 10, 13, 12, 1, -13 },
  { 1327, 9, 19, 12, 2, -13 },
  { 1349, 9, 19, 12, 1, -13 },
  { 1371, 6, 13, 8, 2, -13 },
  { 1381, 7, 13, 9, 1, -13 },
  { 1393, 7, 15, 7, 0, -15 },
  { 1407, 9, 12, 12, 1, -12 },
  { 1421, 10, 12, 10, 0, -12 },
  { 1436, 15, 12, 16, 0, -12 },
  { 1459, 10, 12, 10, 0, -12 },
  { 1474, 10, 18, 10, 0, -12 },
  { 1497, 7, 12, 8, 1, -12 },
  { 1508, 7, 20, 8, 1, -16 },
  { 1526, 2, 23, 10, 4, -18 },
  { 1532, 7, 20, 8, 1, -16 },
  { 1550, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Medium23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_MEDIUM23PT7B_H_
