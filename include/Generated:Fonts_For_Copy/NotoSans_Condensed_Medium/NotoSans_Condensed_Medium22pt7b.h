#ifndef _NOTOSANS_CONDENSED_MEDIUM22PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xDB, 0x6D, 0x80, 0xFB, 0xEF, 0xDF, 0x3E, 0x24, 0x48,
  0x80, 0x0C, 0xC1, 0x98, 0x32, 0x04, 0x40, 0x98, 0xFF, 0xC6, 0x60, 0xCC,
  0x19, 0x02, 0x23, 0xFF, 0x89, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x90, 0x08,
  0x04, 0x0F, 0x8F, 0xEC, 0x96, 0x43, 0x21, 0xD0, 0x7C, 0x0F, 0x03, 0xC1,
  0x70, 0x9C, 0x5B, 0xFC, 0xF8, 0x08, 0x04, 0x00, 0x70, 0x61, 0xE1, 0x8C,
  0x84, 0x33, 0x30, 0xCC, 0xC3, 0x36, 0x0C, 0xD9, 0x32, 0x5F, 0x7B, 0x6D,
  0xC9, 0x10, 0x64, 0x41, 0x91, 0x0C, 0x44, 0x31, 0x90, 0x86, 0xC6, 0x0E,
  0x1C, 0x07, 0xE0, 0x66, 0x06, 0x30, 0x66, 0x07, 0x60, 0x3C, 0x03, 0x80,
  0x7C, 0x6E, 0xEE, 0xC6, 0xCC, 0x3C, 0xC3, 0x8C, 0x3C, 0xFF, 0xC7, 0xE7,
  0xFF, 0x64, 0x80, 0x19, 0x8C, 0xC6, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x71,
  0x8C, 0x61, 0x8E, 0xC6, 0x18, 0xC3, 0x18, 0xC6, 0x38, 0xC6, 0x73, 0x18,
  0xC6, 0x63, 0x30, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3C, 0x3C, 0x66, 0x24,
  0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00,
  0x6F, 0xED, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x3C,
  0x3F, 0x19, 0xDC, 0x6C, 0x36, 0x1B, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x6E, 0x33, 0x19, 0xF8, 0x78, 0x0C, 0x73, 0xFF, 0x4C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3C, 0x7F, 0x31, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0x3C,
  0x7F, 0x31, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x78, 0x3E, 0x03, 0x80, 0xC0,
  0x70, 0x34, 0x1B, 0xFD, 0xF8, 0x03, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x06,
  0xC1, 0xB0, 0xCC, 0x33, 0x18, 0xC4, 0x33, 0xFF, 0xFF, 0xC0, 0xC0, 0x30,
  0x0C, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0x07, 0x01,
  0x80, 0xE0, 0x70, 0x34, 0x3B, 0xF9, 0xF8, 0x0F, 0x1F, 0x9C, 0x0C, 0x0E,
  0x06, 0x03, 0x79, 0xFE, 0xE3, 0x61, 0xF0, 0xF8, 0x7C, 0x3B, 0x19, 0xFC,
  0x7C, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x3C, 0x3F, 0xB8, 0xD8, 0x6C,
  0x33, 0x19, 0xD8, 0x78, 0x3E, 0x33, 0xB0, 0xD8, 0x3C, 0x1E, 0x1B, 0xFC,
  0xFC, 0x3C, 0x3F, 0x39, 0xD8, 0x6C, 0x36, 0x1B, 0x0F, 0x87, 0x7F, 0x3F,
  0x80, 0xC0, 0x60, 0x30, 0x31, 0xF8, 0xF0, 0x7D, 0x80, 0x00, 0x0F, 0xF0,
  0x7D, 0x80, 0x00, 0x0D, 0xFD, 0xB0, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x1C, 0x38, 0xF0, 0xE0, 0x40,
  0x00, 0x3C, 0xFE, 0x46, 0x07, 0x07, 0x06, 0x0E, 0x0C, 0x18, 0x10, 0x30,
  0x00, 0x00, 0x30, 0x38, 0x38, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x06,
  0x61, 0x8D, 0x1F, 0x3C, 0xCC, 0xF3, 0x31, 0xCC, 0xC7, 0x33, 0x3C, 0xCC,
  0xF3, 0x33, 0xC7, 0x79, 0x88, 0x46, 0x00, 0x0C, 0x08, 0x1F, 0xE0, 0x1F,
  0x00, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1B, 0x01, 0xB8, 0x19, 0x83,
  0x98, 0x31, 0x83, 0xFC, 0x3F, 0xC7, 0x0C, 0x60, 0xE6, 0x06, 0xE0, 0x6E,
  0x07, 0xFC, 0x7F, 0xB1, 0xD8, 0x7C, 0x3E, 0x1B, 0x1D, 0xFC, 0xFF, 0x61,
  0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0xFD, 0xFC, 0x0F, 0x8F, 0xF3, 0x89, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0xF8, 0x7E, 0xF8, 0x3F, 0x8C, 0x73, 0x0E, 0xC1, 0xB0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x06, 0xC3, 0xB1, 0xEF, 0xF3, 0xF0, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x0F, 0xC3, 0xFC, 0xE1, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC3, 0xFC, 0x7F, 0x81, 0xB0, 0x36, 0x06, 0xE0, 0xCF, 0xF8,
  0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xDC, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xDF, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xFD, 0xE0, 0xC1, 0xE1, 0xB1, 0xD8,
  0xCC, 0xE6, 0xE3, 0x61, 0xF0, 0xF8, 0x7E, 0x33, 0x98, 0xCC, 0x76, 0x1B,
  0x0F, 0x83, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x3F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0B, 0xF0,
  0x6F, 0xC1, 0xBD, 0x85, 0xF6, 0x37, 0xD8, 0xDF, 0x33, 0x7C, 0xD9, 0xF3,
  0x67, 0xC7, 0x9F, 0x1C, 0x7C, 0x71, 0xF1, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF1, 0xBC, 0x6F, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x03, 0x0F, 0x03, 0xFC, 0x70, 0xC6, 0x0E, 0x60, 0x6E,
  0x06, 0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0x60, 0x67,
  0x0E, 0x3F, 0xC1, 0xF8, 0xF8, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7,
  0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0x03, 0xFC, 0x70,
  0xC6, 0x0E, 0x60, 0x6E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x76, 0x06, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0xF8, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x8E, 0xFE,
  0x7E, 0x33, 0x98, 0xCC, 0x76, 0x1B, 0x0F, 0x83, 0x3E, 0x7F, 0xE2, 0xC0,
  0xC0, 0xE0, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xB8, 0x67, 0xF8, 0xF8, 0xC0, 0x7C, 0x0D, 0x83, 0xB0, 0x66, 0x0C, 0xE1,
  0x8C, 0x61, 0x8C, 0x31, 0x83, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x1C, 0x03,
  0x80, 0x70, 0xC0, 0xC1, 0xF0, 0xE0, 0xD8, 0x70, 0x6C, 0x38, 0x76, 0x1E,
  0x33, 0x1B, 0x19, 0xCD, 0x8C, 0x66, 0xC6, 0x33, 0x37, 0x19, 0x1B, 0x0D,
  0x8D, 0x83, 0xC6, 0xC1, 0xE1, 0x60, 0xF0, 0xE0, 0x70, 0x70, 0x38, 0x38,
  0xE0, 0xD8, 0x73, 0x18, 0xCE, 0x3B, 0x06, 0xC1, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xB0, 0xEC, 0x33, 0x9C, 0x66, 0x1F, 0x83, 0xC0, 0xF8, 0x76, 0x19,
  0xC6, 0x33, 0x8C, 0xC1, 0xB0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30,
  0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0xFF, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x04, 0x01, 0xC0, 0x38,
  0x0D, 0x81, 0xB0, 0x63, 0x0C, 0x63, 0x06, 0xE0, 0xE0, 0xFF, 0xC0, 0xE6,
  0x31, 0x7E, 0x7E, 0x03, 0x03, 0x03, 0x7F, 0xE3, 0xC3, 0xC3, 0xC7, 0xFF,
  0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xC7, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFE, 0xCF, 0x00, 0x3E, 0xFD, 0x87,
  0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC1, 0xF9, 0xF0, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x19, 0xED, 0xFF, 0xC7, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x8E, 0xFF, 0x3D, 0x80, 0x3C, 0x3F, 0x18, 0xD8, 0x6C, 0x37, 0xFF, 0xFF,
  0x80, 0xC0, 0x30, 0x1F, 0xC7, 0xE0, 0x1E, 0x7C, 0xC1, 0x83, 0x0F, 0xBF,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x3D, 0xBF, 0xD8,
  0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xDF, 0xE7, 0xB0, 0x18,
  0x0C, 0x0E, 0xFE, 0x7E, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x7B,
  0xFD, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0x80, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xC0, 0x03, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xEF, 0x00, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC7, 0xC6, 0xCC, 0xD8, 0xF8, 0xF8, 0xF8, 0xDC, 0xCC, 0xCE,
  0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xCE, 0x79, 0xBE,
  0xFB, 0x8E, 0x37, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7,
  0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x70, 0xCF, 0x6F, 0xB8, 0xFC,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x30, 0x3E, 0x3F,
  0x98, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0xDF, 0xC7, 0xC0,
  0xCF, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF,
  0xDD, 0xEE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x3D, 0xBF, 0xD8, 0xF8,
  0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xDF, 0xE7, 0xB0, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xCF, 0x7F, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0x7F, 0xFB, 0x06, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x0F, 0xF7, 0xE0,
  0x30, 0xC3, 0x1F, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xF3, 0xC0,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xB1, 0xDF,
  0xE7, 0xB0, 0xC1, 0xF0, 0xD8, 0x6C, 0x66, 0x31, 0x98, 0xDC, 0x6C, 0x16,
  0x0F, 0x07, 0x03, 0x80, 0xC3, 0x86, 0xC7, 0x19, 0x8A, 0x33, 0x14, 0x66,
  0x6C, 0xCE, 0xDB, 0x8D, 0xB6, 0x1A, 0x2C, 0x3C, 0x58, 0x78, 0xF0, 0x71,
  0xC0, 0xE3, 0x80, 0xE1, 0xB1, 0x8C, 0xC6, 0xC1, 0xE0, 0xE0, 0x70, 0x3C,
  0x36, 0x19, 0x98, 0xFC, 0x30, 0xC1, 0xF0, 0xD8, 0x6C, 0x67, 0x31, 0x98,
  0xDC, 0x6C, 0x1E, 0x0F, 0x07, 0x01, 0x80, 0xC0, 0xE0, 0x61, 0xF0, 0xF0,
  0x00, 0xFD, 0xF8, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0xFF, 0xF0,
  0x0C, 0x73, 0x8C, 0x30, 0xC3, 0x0C, 0x33, 0x8E, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xE1, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x87, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x71, 0xCC, 0x30, 0xC3, 0x0C, 0x31, 0xCE, 0x20,
  0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_Condensed_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 11, 16, 12, 0, -16 },
  { 35, 9, 18, 11, 1, -17 },
  { 56, 14, 16, 16, 1, -16 },
  { 84, 12, 16, 13, 1, -16 },
  { 108, 3, 6, 5, 1, -16 },
  { 111, 5, 19, 7, 1, -16 },
  { 123, 5, 19, 7, 1, -16 },
  { 135, 8, 9, 10, 1, -17 },
  { 144, 9, 10, 11, 1, -13 },
  { 156, 3, 6, 5, 1, -3 },
  { 159, 5, 2, 6, 1, -7 },
  { 161, 3, 3, 5, 1, -3 },
  { 163, 8, 16, 8, 0, -16 },
  { 179, 9, 16, 11, 1, -16 },
  { 197, 6, 16, 11, 1, -16 },
  { 209, 9, 16, 11, 1, -16 },
  { 227, 9, 16, 11, 1, -16 },
  { 245, 10, 16, 11, 0, -16 },
  { 265, 9, 16, 11, 1, -16 },
  { 283, 9, 16, 11, 1, -16 },
  { 301, 9, 16, 11, 1, -16 },
  { 319, 9, 16, 11, 1, -16 },
  { 337, 9, 16, 11, 1, -16 },
  { 355, 3, 12, 5, 1, -12 },
  { 360, 3, 15, 5, 1, -12 },
  { 366, 9, 10, 11, 1, -13 },
  { 378, 9, 6, 11, 1, -11 },
  { 385, 9, 10, 11, 1, -13 },
  { 397, 8, 16, 8, 0, -16 },
  { 413, 14, 18, 16, 1, -16 },
  { 445, 12, 16, 12, 0, -16 },
  { 469, 9, 16, 12, 2, -16 },
  { 487, 10, 16, 11, 1, -16 },
  { 507, 10, 16, 13, 2, -16 },
  { 527, 7, 16, 10, 2, -16 },
  { 541, 7, 16, 10, 2, -16 },
  { 555, 11, 16, 13, 1, -16 },
  { 577, 10, 16, 13, 2, -16 },
  { 597, 5, 16, 7, 1, -16 },
  { 607, 5, 20, 6, -1, -16 },
  { 620, 9, 16, 11, 2, -16 },
  { 638, 7, 16, 9, 2, -16 },
  { 652, 14, 16, 17, 2, -16 },
  { 680, 10, 16, 14, 2, -16 },
  { 700, 12, 16, 14, 1, -16 },
  { 724, 8, 16, 11, 2, -16 },
  { 740, 12, 20, 14, 1, -16 },
  { 770, 9, 16, 12, 2, -16 },
  { 788, 8, 16, 10, 1, -16 },
  { 804, 10, 16, 10, 0, -16 },
  { 824, 10, 16, 13, 2, -16 },
  { 844, 11, 16, 11, 0, -16 },
  { 866, 17, 16, 17, 0, -16 },
  { 900, 10, 16, 11, 0, -16 },
  { 920, 10, 16, 10, 0, -16 },
  { 940, 8, 16, 10, 1, -16 },
  { 956, 4, 20, 7, 2, -16 },
  { 966, 8, 16, 8, 0, -16 },
  { 982, 4, 20, 7, 1, -16 },
  { 992, 11, 9, 11, 0, -16 },
  { 1005, 10, 1, 9, 0, 2 },
  { 1007, 4, 4, 6, 1, -17 },
  { 1009, 8, 12, 10, 1, -12 },
  { 1021, 9, 17, 11, 1, -17 },
  { 1041, 7, 12, 9, 1, -12 },
  { 1052, 9, 17, 11, 1, -17 },
  { 1072, 9, 12, 10, 1, -12 },
  { 1086, 7, 17, 6, 0, -17 },
  { 1101, 9, 17, 11, 1, -12 },
  { 1121, 9, 17, 11, 1, -17 },
  { 1141, 3, 16, 5, 1, -16 },
  { 1147, 5, 21, 5, -1, -16 },
  { 1161, 8, 17, 10, 2, -17 },
  { 1178, 3, 17, 5, 1, -17 },
  { 1185, 15, 12, 17, 1, -12 },
  { 1208, 9, 12, 11, 1, -12 },
  { 1222, 9, 12, 11, 1, -12 },
  { 1236, 9, 17, 11, 1, -12 },
  { 1256, 9, 17, 11, 1, -12 },
  { 1276, 6, 12, 8, 1, -12 },
  { 1285, 7, 12, 9, 1, -12 },
  { 1296, 6, 15, 7, 0, -15 },
  { 1308, 9, 12, 11, 1, -12 },
  { 1322, 9, 12, 10, 0, -12 },
  { 1336, 15, 12, 15, 0, -12 },
  { 1359, 9, 12, 10, 0, -12 },
  { 1373, 9, 17, 10, 0, -12 },
  { 1393, 7, 12, 8, 1, -12 },
  { 1404, 6, 20, 8, 1, -16 },
  { 1419, 2, 22, 10, 4, -17 },
  { 1425, 6, 20, 8, 1, -16 },
  { 1440, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_Medium22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_MEDIUM22PT7B_H_
