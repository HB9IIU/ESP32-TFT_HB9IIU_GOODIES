#ifndef _NOTOSANS_CONDENSED_MEDIUM9PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x57, 0xD5, 0xE6, 0x30, 0x27, 0xA6, 0x3B, 0x62, 0x42,
  0xAB, 0x2F, 0x5C, 0xB2, 0xC0, 0x22, 0x98, 0xCA, 0xC9, 0xA0, 0xC0, 0x5A,
  0x94, 0xD5, 0x5C, 0x2F, 0x66, 0x2F, 0x22, 0x60, 0xC0, 0x80, 0x25, 0x25,
  0x00, 0x25, 0x99, 0x99, 0x60, 0xF5, 0x50, 0x69, 0x12, 0x24, 0xF0, 0x69,
  0x16, 0x11, 0xE0, 0x25, 0x59, 0xF1, 0x74, 0x61, 0x1E, 0x34, 0x8F, 0x99,
  0x60, 0xF1, 0x22, 0x44, 0x25, 0x96, 0x59, 0x70, 0x25, 0x99, 0x71, 0x60,
  0x88, 0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x54, 0xB4, 0x10, 0x7D,
  0x7A, 0xEB, 0xBD, 0x03, 0x80, 0x22, 0x94, 0xE9, 0x44, 0xF7, 0xDB, 0xC0,
  0x25, 0x48, 0x84, 0x70, 0xE9, 0x99, 0x9E, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9,
  0x00, 0x13, 0x51, 0x28, 0xA5, 0xE0, 0x99, 0xF9, 0x99, 0xE9, 0x25, 0xC0,
  0x24, 0x92, 0x4E, 0xBC, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0x8E, 0xF7, 0xBA,
  0xD4, 0x9D, 0xDB, 0xB9, 0x22, 0xD3, 0x18, 0xA5, 0xC0, 0xF6, 0xE9, 0x00,
  0x22, 0xD3, 0x18, 0xA5, 0xC2, 0x08, 0xEA, 0xAC, 0xAB, 0x25, 0x86, 0x31,
  0xE0, 0xF4, 0x44, 0x44, 0x99, 0x99, 0x9E, 0x9C, 0x94, 0xA6, 0x10, 0x93,
  0x25, 0xB3, 0x66, 0xCC, 0x80, 0xD6, 0x26, 0x59, 0x96, 0x62, 0x22, 0xF2,
  0x24, 0x4F, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x25, 0x90, 0xF0,
  0xD0, 0x61, 0x79, 0x70, 0x93, 0xDB, 0x78, 0x72, 0x46, 0x11, 0x79, 0x99,
  0x70, 0x69, 0xF8, 0x70, 0x6B, 0xA4, 0x90, 0x79, 0x99, 0x71, 0x70, 0x93,
  0xDB, 0x68, 0xBE, 0x45, 0x55, 0x80, 0x92, 0xED, 0xA8, 0xFE, 0xFD, 0x6B,
  0x5A, 0x80, 0xF6, 0xDA, 0x69, 0x99, 0x70, 0xF6, 0xDF, 0x20, 0x79, 0x99,
  0x71, 0x10, 0xEA, 0x80, 0x71, 0x9E, 0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0x99,
  0x66, 0x60, 0xB6, 0xD7, 0x5A, 0x48, 0x96, 0x66, 0x90, 0x99, 0x66, 0x64,
  0xC0, 0xE5, 0x2E, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 6, 7, 7, 0, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 1, -6 },
  { 23, 2, 7, 3, 0, -6 },
  { 25, 2, 7, 3, 0, -6 },
  { 27, 4, 4, 4, 0, -7 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 2, 2, 2, 0, -1 },
  { 32, 2, 1, 3, 0, -3 },
  { 33, 1, 1, 2, 1, -1 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 4, 7, 4, 0, -7 },
  { 41, 2, 6, 4, 1, -6 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 1, 5, 2, 1, -5 },
  { 73, 2, 6, 2, 0, -5 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 4, 2, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 3, 7, 3, 0, -7 },
  { 83, 6, 7, 7, 0, -6 },
  { 89, 5, 6, 5, 0, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 4, 7, 5, 0, -7 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 3, 6, 4, 1, -6 },
  { 106, 3, 6, 4, 1, -6 },
  { 109, 5, 7, 5, 0, -7 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 3, 6, 3, 0, -6 },
  { 120, 3, 8, 2, -1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 3, 6, 4, 1, -6 },
  { 129, 5, 6, 7, 1, -6 },
  { 133, 4, 6, 6, 1, -6 },
  { 136, 5, 7, 6, 0, -7 },
  { 141, 3, 6, 5, 1, -6 },
  { 144, 5, 9, 6, 0, -7 },
  { 150, 4, 6, 5, 1, -6 },
  { 153, 4, 7, 4, 0, -7 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 4, 6, 5, 1, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 7, 6, 7, 0, -6 },
  { 173, 4, 6, 4, 0, -6 },
  { 176, 4, 6, 4, 0, -6 },
  { 179, 4, 6, 4, 0, -6 },
  { 182, 2, 7, 3, 1, -6 },
  { 184, 3, 6, 3, 0, -6 },
  { 187, 2, 7, 3, 0, -6 },
  { 189, 4, 3, 4, 0, -6 },
  { 191, 4, 1, 4, 0, 1 },
  { 192, 2, 2, 3, 0, -7 },
  { 193, 4, 5, 4, 0, -5 },
  { 196, 3, 7, 5, 1, -7 },
  { 199, 3, 5, 4, 0, -5 },
  { 201, 4, 7, 5, 0, -7 },
  { 205, 4, 5, 4, 0, -5 },
  { 208, 3, 7, 3, 0, -7 },
  { 211, 4, 7, 5, 0, -5 },
  { 215, 3, 7, 5, 1, -7 },
  { 218, 1, 7, 2, 1, -7 },
  { 219, 2, 9, 2, 0, -7 },
  { 222, 3, 7, 4, 1, -7 },
  { 225, 1, 7, 2, 1, -7 },
  { 226, 5, 5, 7, 1, -5 },
  { 230, 3, 5, 5, 1, -5 },
  { 232, 4, 5, 5, 0, -5 },
  { 235, 3, 7, 5, 1, -5 },
  { 238, 4, 7, 5, 0, -5 },
  { 242, 2, 5, 3, 1, -5 },
  { 244, 3, 5, 4, 0, -5 },
  { 246, 3, 6, 3, 0, -6 },
  { 249, 3, 5, 5, 1, -5 },
  { 251, 4, 5, 4, 0, -5 },
  { 254, 6, 5, 6, 0, -5 },
  { 258, 4, 5, 4, 0, -5 },
  { 261, 4, 7, 4, 0, -5 },
  { 265, 3, 5, 3, 0, -5 },
  { 267, 3, 7, 3, 0, -6 },
  { 270, 1, 9, 4, 2, -7 },
  { 272, 3, 7, 3, 0, -6 },
  { 275, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_Medium9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_MEDIUM9PT7B_H_
