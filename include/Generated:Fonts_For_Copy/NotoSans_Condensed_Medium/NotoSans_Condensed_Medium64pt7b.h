#ifndef _NOTOSANS_CONDENSED_MEDIUM64PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xF9, 0xF0, 0x1E,
  0x7C, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x8F, 0xF3, 0x87, 0xC7, 0xE1, 0xC0, 0x47, 0xE0, 0xE0, 0x03, 0xF0, 0x70,
  0x01, 0xF8, 0x38, 0x00, 0xFC, 0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x3F, 0x07,
  0x00, 0x1F, 0xC3, 0x80, 0x07, 0xF1, 0xC0, 0x03, 0xFE, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x73, 0xFC, 0x00, 0x38, 0xFE, 0x00, 0x1C, 0x3F, 0x80, 0x0E, 0x0F,
  0xC0, 0x07, 0x07, 0xE0, 0x03, 0x83, 0xF0, 0x01, 0xC1, 0xF8, 0x00, 0xE1,
  0xFF, 0x00, 0x70, 0xFD, 0xE0, 0x38, 0xFE, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F,
  0x83, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0xFC, 0x00,
  0x01, 0xF0, 0x3E, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xC3, 0xE1, 0xFF, 0x07,
  0xC0, 0xF8, 0xF8, 0x7F, 0xF0, 0xF8, 0x3F, 0x1F, 0x1F, 0xFF, 0x0F, 0x87,
  0xC7, 0xE3, 0xF7, 0xE1, 0xF9, 0xF8, 0xF8, 0xFC, 0x7E, 0x1F, 0xFE, 0x1F,
  0x1F, 0x07, 0xC3, 0xFF, 0xC7, 0xC3, 0xE0, 0xF8, 0x3F, 0xF0, 0xF8, 0xFC,
  0x1F, 0x81, 0xFC, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x3E,
  0x00, 0x01, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0x83, 0xFF, 0xFC, 0x07, 0xE0, 0xFF, 0x3F, 0x80, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0xFE, 0x07, 0xF8, 0xFC,
  0x1F, 0x80, 0x7F, 0x3F, 0x87, 0xF0, 0x07, 0xF7, 0xF0, 0xFE, 0x00, 0x7F,
  0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0x00,
  0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xFE,
  0x3F, 0xC0, 0x7F, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0xC0, 0x7C, 0x06, 0x7C, 0x3E, 0x1F, 0x3F, 0xDF, 0x7F,
  0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xFB,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3E, 0x03, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x7F,
  0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xEF,
  0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0x9F, 0xCF, 0xDF, 0xC7,
  0xFF, 0xC3, 0xF7, 0xC1, 0xF9, 0xC0, 0xFC, 0x40, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x83, 0xE0,
  0x0F, 0xF0, 0x70, 0x01, 0xFC, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xC0, 0x0F, 0xF0, 0x60, 0x01, 0xFC, 0x10,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE8, 0x00, 0x07, 0xFB, 0x80, 0x03, 0xFC, 0xFC, 0x01, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x3E,
  0xFE, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x1F, 0x3F, 0x80, 0x01, 0xF1, 0xFC,
  0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7C, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3E, 0x07, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x38, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFA, 0x00, 0x03, 0xF9, 0xC0, 0x03, 0xFC, 0xF8, 0x07,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x20, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0x1F, 0xFC, 0x1F, 0x9F, 0xFF, 0x0F, 0xDF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xF9, 0xFF, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07,
  0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x01,
  0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F,
  0xC3, 0xF8, 0x07, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xEF, 0xC7,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFD, 0xF8, 0x1F, 0xFE, 0x7E, 0x01, 0xFE, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x20, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x0F,
  0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7E, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x0F, 0xF9, 0xC0, 0x1F, 0xE4, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xFF, 0xE0, 0xF8, 0xF8, 0x07, 0xFF, 0xF0, 0x7C,
  0x7C, 0x07, 0xFF, 0xF8, 0x3E, 0x3E, 0x03, 0xFD, 0xFC, 0x0F, 0xBE, 0x03,
  0xF0, 0x3E, 0x07, 0xDF, 0x01, 0xF0, 0x1F, 0x03, 0xEF, 0x81, 0xF8, 0x1F,
  0x81, 0xF7, 0xC0, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0xFC, 0x07, 0xE0, 0x7F,
  0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0xF8, 0x1F,
  0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xFE, 0x07, 0xC0, 0x3E,
  0x03, 0xFF, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0x80, 0xFF,
  0xC0, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x07, 0xE0, 0x3D, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0xF8, 0x0F, 0x81, 0xFC, 0x1F, 0x7E, 0x07, 0xE1, 0xFE,
  0x1F, 0x1F, 0x03, 0xFF, 0xEF, 0xFF, 0x8F, 0x80, 0xFF, 0xF3, 0xFF, 0x87,
  0xC0, 0x3F, 0xF1, 0xFF, 0x83, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xF8, 0x01,
  0xE0, 0x0F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xC0,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0xE7, 0xF0, 0x03, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE7,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F,
  0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0xFE, 0x07, 0xFC, 0x01, 0xC0, 0xFF, 0x00,
  0x04, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x06, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0x80, 0x1F, 0xF0,
  0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC3,
  0xFC, 0x07, 0xFE, 0x00, 0x3C, 0x0F, 0xF8, 0x00, 0x08, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x7F, 0x0F, 0xF8, 0x00, 0x7F, 0x07, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF1, 0xFF, 0x80, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xEF, 0xFF, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xBF, 0x00,
  0x01, 0xF7, 0xFF, 0xDF, 0x80, 0x00, 0xFB, 0xFF, 0xEF, 0xC0, 0x00, 0xFD,
  0xFF, 0xF3, 0xE0, 0x00, 0x7E, 0xFF, 0xF9, 0xF8, 0x00, 0x3E, 0x7F, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0xFE, 0x3E, 0x00, 0x1F, 0x9F, 0xFF, 0x1F, 0x80,
  0x0F, 0x8F, 0xFF, 0x8F, 0xC0, 0x0F, 0xC7, 0xFF, 0xC3, 0xE0, 0x07, 0xE3,
  0xFF, 0xE1, 0xF8, 0x03, 0xE1, 0xFF, 0xF0, 0xFC, 0x01, 0xF0, 0xFF, 0xF8,
  0x7E, 0x01, 0xF8, 0x7F, 0xFC, 0x1F, 0x80, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0,
  0x7C, 0x1F, 0xFF, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0x81, 0xF0, 0x3F, 0x07,
  0xFF, 0xC0, 0xFC, 0x1F, 0x03, 0xFF, 0xE0, 0x7E, 0x1F, 0x81, 0xFF, 0xF0,
  0x1F, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0x7F, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xFF, 0x00, 0xFD, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xC0, 0x03, 0xFF, 0xDF, 0xC0, 0x07, 0xFF,
  0x9F, 0x80, 0x0F, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0x3F, 0x00, 0x3F, 0xFC,
  0x7F, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0,
  0xFC, 0x03, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03,
  0xF8, 0x1F, 0xFE, 0x03, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0x7F, 0xF8, 0x0F,
  0xE0, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0xE0, 0x1F, 0xC3, 0xFF, 0xC0, 0x1F,
  0xC7, 0xFF, 0x80, 0x3F, 0x8F, 0xFF, 0x00, 0x3F, 0x9F, 0xFE, 0x00, 0x7F,
  0x3F, 0xFC, 0x00, 0x7F, 0x7F, 0xF8, 0x00, 0xFE, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xF8,
  0x0F, 0xF9, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F,
  0xF3, 0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0x80, 0x3C, 0x7F, 0x00, 0x08,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x80, 0x00, 0xFE, 0xE0, 0x01, 0xFC,
  0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xE8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFB,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xCF, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xF9, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFC, 0x7C, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0x83, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC0, 0x07, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x81, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x03,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0x80, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF0,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x1F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8,
  0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x81,
  0xFE, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFC, 0x3F, 0x3F, 0xC0, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0x7F, 0x01,
  0xFF, 0x7F, 0xEF, 0xFF, 0x3F, 0xFF, 0x9F, 0x3F, 0xFF, 0x1F, 0x1F, 0xFE,
  0x1F, 0x07, 0xFC, 0x1F, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0xFF, 0xE0, 0xFE,
  0x7F, 0xFC, 0x3F, 0xBF, 0xFF, 0x8F, 0xDF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFC,
  0xFF, 0xC0, 0x7F, 0x3F, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xBF, 0xC0, 0x0F, 0xEF,
  0xF8, 0x07, 0xFB, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF,
  0x8F, 0xCF, 0xFF, 0xC3, 0xF1, 0xFF, 0xE0, 0xF8, 0x3F, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xF8, 0xF8, 0xFF, 0x00, 0x87, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x9F, 0xF0, 0x1C, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F,
  0xE1, 0xFC, 0x1F, 0xFC, 0x3F, 0x0F, 0xFF, 0xCF, 0xC7, 0xFF, 0xF3, 0xF1,
  0xFF, 0xFE, 0xFC, 0xFF, 0x8F, 0xFF, 0x3F, 0x80, 0xFF, 0xDF, 0xC0, 0x1F,
  0xF7, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xFC, 0xFF, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB, 0xF0, 0xFF, 0xFC, 0xFC, 0x1F, 0xFE,
  0x3F, 0x03, 0xFF, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x21, 0xFF, 0x00, 0x70, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xDC, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0xE3, 0xF0, 0xFF,
  0xFC, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0xFF, 0xEF, 0xCF, 0xF8, 0xFF, 0xF3,
  0xF8, 0x0F, 0xFD, 0xFC, 0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x7F, 0xCF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xBF,
  0x0F, 0xFF, 0xCF, 0xC1, 0xFF, 0xE7, 0xF0, 0x3F, 0xF1, 0xFC, 0x00, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE4, 0x00, 0x03, 0xF8,
  0xC0, 0x01, 0xFC, 0x3E, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x7F,
  0xF0, 0xFE, 0xFF, 0xFC, 0x7E, 0x7F, 0xFF, 0x3F, 0x7F, 0xFF, 0x9F, 0xFF,
  0x7F, 0xEF, 0xFC, 0x07, 0xF7, 0xFC, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x38, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF4,
  0x3F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFB, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x80, 0x0F,
  0xDF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xE0,
  0x0F, 0xF9, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7E, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0x3F, 0xFE, 0x1F, 0xFF,
  0x9F, 0xBF, 0xFF, 0x9F, 0xFF, 0xEF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFB, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x1F, 0xE0,
  0x7E, 0x1F, 0xFC, 0x3F, 0x3F, 0xFF, 0x1F, 0xBF, 0xFF, 0xCF, 0xDF, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFB, 0xFF, 0x01, 0xFD, 0xFF, 0x00, 0xFE, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7,
  0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x1F, 0xE0, 0x3F,
  0x0F, 0xFE, 0x0F, 0xC7, 0xFF, 0xC3, 0xF3, 0xFF, 0xF8, 0xFD, 0xFF, 0xFE,
  0x3F, 0xF8, 0x7F, 0xCF, 0xFC, 0x07, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0x3F, 0xBF, 0xC0, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFB,
  0xFC, 0x00, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF,
  0xF3, 0xF7, 0xFF, 0xF8, 0xFE, 0xFF, 0xFC, 0x3F, 0x9F, 0xFE, 0x0F, 0xE1,
  0xFF, 0x03, 0xF8, 0x0E, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0xE3, 0xF0, 0xFF, 0xFC,
  0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0xFF, 0xEF, 0xCF, 0xF8, 0xFF, 0xF3, 0xF8,
  0x0F, 0xFD, 0xFC, 0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x7F, 0xCF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xBF, 0x0F,
  0xFF, 0xCF, 0xC1, 0xFF, 0xE3, 0xF0, 0x3F, 0xF1, 0xFC, 0x00, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xF8, 0x1F,
  0xFE, 0x0F, 0xEF, 0xC7, 0xFB, 0xF3, 0xFE, 0xFD, 0xFF, 0xBF, 0x7F, 0xEF,
  0xFF, 0x0B, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xC0, 0xF1, 0xF8, 0x01, 0x9F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x7C, 0x03, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x43, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xEF, 0xC0, 0x0F, 0xF7, 0xF0, 0x0F, 0xFB,
  0xFC, 0x1F, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x1F, 0xFF, 0x9F,
  0x87, 0xFF, 0x8F, 0xC1, 0xFF, 0x83, 0xE0, 0x0E, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9,
  0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x3F, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xFC,
  0x03, 0xF9, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x7F, 0x01, 0xF7, 0xC0, 0x3F,
  0x0F, 0xC0, 0x7D, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0xFC,
  0x07, 0xCF, 0x81, 0xF8, 0x3F, 0x83, 0xF3, 0xE0, 0x7E, 0x07, 0xE0, 0xF8,
  0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0x87, 0xC3,
  0xF0, 0x1F, 0x83, 0xE1, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x7C, 0x3F, 0x00,
  0xFC, 0x7C, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0x0F, 0xC7,
  0xC0, 0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x3E, 0x7E, 0x00, 0x7E, 0xFC, 0x0F,
  0x9F, 0x80, 0x1F, 0xBE, 0x03, 0xE7, 0xE0, 0x07, 0xEF, 0x80, 0xF9, 0xF0,
  0x01, 0xFB, 0xE0, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xBC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x07,
  0xF3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x43, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x00, 0x0D, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xF6, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 47, 16, 4, -46 },
  { 48, 18, 17, 26, 4, -46 },
  { 87, 31, 46, 34, 1, -46 },
  { 266, 25, 53, 31, 3, -49 },
  { 432, 43, 47, 48, 2, -46 },
  { 685, 35, 47, 37, 2, -46 },
  { 891, 7, 17, 14, 4, -46 },
  { 906, 15, 56, 19, 3, -46 },
  { 1011, 14, 56, 19, 2, -46 },
  { 1109, 25, 25, 29, 2, -49 },
  { 1188, 26, 31, 31, 2, -38 },
  { 1289, 10, 15, 16, 2, -7 },
  { 1308, 15, 6, 19, 2, -20 },
  { 1320, 8, 9, 16, 4, -8 },
  { 1329, 23, 46, 24, 1, -46 },
  { 1462, 25, 47, 31, 3, -46 },
  { 1609, 17, 46, 31, 4, -46 },
  { 1707, 26, 46, 31, 2, -46 },
  { 1857, 26, 47, 31, 2, -46 },
  { 2010, 29, 46, 31, 1, -46 },
  { 2177, 25, 47, 31, 3, -46 },
  { 2324, 25, 47, 31, 3, -46 },
  { 2471, 26, 46, 31, 2, -46 },
  { 2621, 26, 47, 31, 2, -46 },
  { 2774, 26, 47, 31, 2, -46 },
  { 2927, 8, 36, 16, 4, -35 },
  { 2963, 10, 43, 16, 2, -35 },
  { 3017, 26, 30, 31, 2, -38 },
  { 3115, 26, 19, 31, 2, -32 },
  { 3177, 27, 30, 31, 2, -38 },
  { 3279, 21, 47, 23, 1, -46 },
  { 3403, 41, 51, 47, 3, -46 },
  { 3665, 34, 46, 34, 0, -46 },
  { 3861, 27, 46, 35, 5, -46 },
  { 4017, 28, 47, 33, 3, -46 },
  { 4182, 30, 46, 38, 5, -46 },
  { 4355, 21, 46, 29, 5, -46 },
  { 4476, 21, 46, 28, 5, -46 },
  { 4597, 32, 47, 39, 3, -46 },
  { 4785, 29, 46, 39, 5, -46 },
  { 4952, 16, 46, 20, 2, -46 },
  { 5044, 15, 59, 16, -4, -46 },
  { 5155, 28, 46, 33, 5, -46 },
  { 5316, 21, 46, 27, 5, -46 },
  { 5437, 41, 46, 51, 5, -46 },
  { 5673, 31, 46, 41, 5, -46 },
  { 5852, 34, 47, 40, 3, -46 },
  { 6052, 25, 46, 32, 5, -46 },
  { 6196, 34, 57, 40, 3, -46 },
  { 6439, 28, 46, 33, 5, -46 },
  { 6600, 24, 47, 29, 3, -46 },
  { 6741, 27, 46, 28, 1, -46 },
  { 6897, 29, 47, 38, 5, -46 },
  { 7068, 32, 46, 32, 0, -46 },
  { 7252, 51, 46, 51, 0, -46 },
  { 7546, 30, 46, 31, 0, -46 },
  { 7719, 30, 46, 30, 0, -46 },
  { 7892, 24, 46, 28, 2, -46 },
  { 8030, 15, 56, 20, 4, -46 },
  { 8135, 23, 46, 24, 1, -46 },
  { 8268, 14, 56, 20, 2, -46 },
  { 8366, 30, 27, 32, 1, -46 },
  { 8468, 28, 5, 28, 0, 5 },
  { 8486, 13, 10, 18, 3, -49 },
  { 8503, 24, 36, 30, 2, -35 },
  { 8611, 26, 50, 33, 4, -49 },
  { 8774, 21, 36, 26, 3, -35 },
  { 8869, 26, 50, 33, 3, -49 },
  { 9032, 25, 36, 30, 3, -35 },
  { 9145, 20, 49, 19, 1, -49 },
  { 9268, 26, 50, 33, 3, -35 },
  { 9431, 25, 49, 33, 4, -49 },
  { 9585, 7, 48, 15, 4, -48 },
  { 9627, 13, 63, 15, -2, -48 },
  { 9730, 26, 49, 30, 4, -49 },
  { 9890, 7, 49, 15, 4, -49 },
  { 9933, 41, 35, 50, 4, -35 },
  { 10113, 25, 35, 33, 4, -35 },
  { 10223, 26, 36, 32, 3, -35 },
  { 10340, 26, 50, 33, 4, -35 },
  { 10503, 26, 50, 33, 3, -35 },
  { 10666, 18, 35, 22, 4, -35 },
  { 10745, 21, 36, 25, 2, -35 },
  { 10840, 18, 43, 20, 1, -42 },
  { 10937, 25, 36, 33, 4, -35 },
  { 11050, 28, 35, 28, 0, -35 },
  { 11173, 42, 35, 44, 1, -35 },
  { 11357, 26, 35, 28, 1, -35 },
  { 11471, 28, 50, 28, 0, -35 },
  { 11646, 20, 35, 23, 2, -35 },
  { 11734, 19, 56, 23, 2, -46 },
  { 11867, 5, 64, 29, 12, -49 },
  { 11907, 19, 56, 23, 2, -46 },
  { 12040, 27, 9, 31, 2, -27 },
};

const GFXfont NotoSans_Condensed_Medium64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_MEDIUM64PT7B_H_
