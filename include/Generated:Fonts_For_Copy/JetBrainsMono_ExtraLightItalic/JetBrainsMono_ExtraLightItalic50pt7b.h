#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC50PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xC3,
  0xF8, 0x7E, 0x07, 0x80, 0x3C, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7C,
  0xEF, 0xC0, 0x78, 0x61, 0xE0, 0x78, 0x30, 0x78, 0x38, 0x18, 0x3C, 0x1C,
  0x0C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0E, 0x07, 0x07, 0x87, 0x03, 0x00, 0x03,
  0xC1, 0x80, 0x01, 0xE0, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0x3C, 0x70, 0x00,
  0x1F, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xCF, 0x80, 0x00, 0xE1,
  0xE0, 0x00, 0x60, 0xF0, 0x00, 0x30, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x1C,
  0x0E, 0x04, 0x0E, 0x07, 0x1C, 0x07, 0x03, 0x8E, 0x03, 0x01, 0xC7, 0x81,
  0x81, 0xE3, 0xC0, 0xC1, 0xE0, 0xF0, 0x60, 0xE0, 0x7C, 0x71, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x3F, 0xE0, 0x00, 0xE0, 0x1F, 0xF8, 0x00, 0x70, 0x0F, 0x0F, 0x00, 0x38,
  0x03, 0x81, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x03,
  0x80, 0x1C, 0x07, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x70,
  0x70, 0x00, 0xE0, 0x18, 0x38, 0x00, 0x38, 0x0E, 0x1C, 0x00, 0x0E, 0x03,
  0x87, 0x00, 0x03, 0xC1, 0xC3, 0x80, 0x00, 0x7F, 0xF1, 0xC0, 0x00, 0x0F,
  0xF8, 0xE0, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x81, 0x00,
  0x00, 0x01, 0xC3, 0xF8, 0x00, 0x00, 0xE3, 0xFF, 0x00, 0x00, 0x71, 0xE1,
  0xE0, 0x00, 0x38, 0x70, 0x38, 0x00, 0x1C, 0x38, 0x0E, 0x00, 0x07, 0x0E,
  0x03, 0x80, 0x03, 0x83, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0xE0,
  0x30, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x0C,
  0x01, 0xC0, 0x70, 0x07, 0x00, 0x78, 0x3C, 0x03, 0x80, 0x0F, 0xBE, 0x01,
  0xC0, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x71, 0xC0, 0xE0, 0x1C, 0x78, 0x1E, 0x07, 0x8E,
  0x01, 0xE1, 0xE1, 0xC0, 0x3C, 0x38, 0x38, 0x03, 0xCE, 0x07, 0x00, 0x3B,
  0xC1, 0xE0, 0x07, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0xE0,
  0x01, 0xF0, 0x1C, 0x00, 0x3E, 0x03, 0x80, 0x0F, 0xE0, 0x78, 0x03, 0xDC,
  0x0F, 0x81, 0xF3, 0xC0, 0xFD, 0xFC, 0x3C, 0x1F, 0xFE, 0x03, 0x80, 0xFF,
  0x80, 0x78, 0x02, 0x00, 0x00, 0x00, 0x3B, 0xDE, 0xF7, 0xBD, 0xFE, 0xF7,
  0xBD, 0xCE, 0x73, 0x9C, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x9F, 0x03, 0x81,
  0xFF, 0xF0, 0xC3, 0xFD, 0xFF, 0x33, 0xFE, 0x0F, 0xEF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00,
  0xE0, 0x02, 0x00, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF,
  0x7F, 0x7E, 0x10, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x3C,
  0x1E, 0x0F, 0x1E, 0x1F, 0x07, 0x0F, 0x0F, 0xC3, 0x87, 0x07, 0xC1, 0xC3,
  0x81, 0xE0, 0xE1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0xE0, 0x78, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF9, 0xC0, 0x07, 0xC7,
  0x00, 0x7C, 0x1C, 0x03, 0xE0, 0xF0, 0x0E, 0x03, 0xC0, 0x30, 0x0E, 0x00,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00,
  0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x01,
  0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x0F, 0x07, 0x80,
  0x38, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x39,
  0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x3F, 0x80, 0x1C,
  0xFF, 0xE0, 0x1D, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x78, 0x3E,
  0x00, 0x78, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x7F,
  0xBF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xCF, 0xF0, 0x07, 0x7F, 0xF0,
  0x1D, 0xFF, 0xF0, 0x7E, 0x01, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xE7,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x78, 0x07,
  0xC0, 0xFF, 0x7F, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1E,
  0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83,
  0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0xE0,
  0x0F, 0x01, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3E,
  0x00, 0xF0, 0x0F, 0xF7, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x3E, 0x07, 0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x03, 0x8F, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x38, 0x00,
  0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xF0, 0x07, 0xC1, 0xF8, 0x3F,
  0x81, 0xFF, 0xEE, 0x01, 0xFF, 0xB8, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x78,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x7F, 0x38, 0x70, 0x0F, 0xFD, 0xC3, 0x80, 0xFC, 0xEE, 0x1C, 0x07, 0x81,
  0xF0, 0xE0, 0x78, 0x07, 0x07, 0x03, 0x80, 0x38, 0x78, 0x1C, 0x01, 0xC3,
  0x80, 0xE0, 0x0E, 0x1C, 0x0F, 0x00, 0x70, 0xE0, 0x70, 0x03, 0x87, 0x03,
  0x80, 0x38, 0x38, 0x1C, 0x01, 0xC3, 0xC0, 0xE0, 0x0E, 0x1C, 0x07, 0x00,
  0x70, 0xE0, 0x78, 0x03, 0x87, 0x03, 0xC0, 0x3C, 0x38, 0x1E, 0x01, 0xE1,
  0xC0, 0x70, 0x1E, 0x1E, 0x03, 0xF7, 0xF0, 0xE0, 0x0F, 0xFB, 0x87, 0x00,
  0x3F, 0x9C, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x3C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x1E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x70, 0x01, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x1E, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0x1E,
  0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0x7C, 0x03, 0xC0, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x70, 0x03, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38,
  0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E,
  0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03,
  0xC1, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x03, 0xE0, 0x78, 0x07,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x0F,
  0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x1F, 0xFC, 0x78, 0x1F, 0xFC, 0x70, 0x3F, 0xFC, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x3F,
  0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x3C, 0x00,
  0x1C, 0x1E, 0x00, 0x0E, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F,
  0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x07,
  0x80, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x3C, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x6E,
  0x0E, 0xC0, 0x1D, 0xC1, 0xDC, 0x03, 0x30, 0x3B, 0x80, 0xEE, 0x06, 0x70,
  0x19, 0xC1, 0xCE, 0x07, 0x38, 0x38, 0xC0, 0xC7, 0x07, 0x18, 0x39, 0xE0,
  0xE3, 0x86, 0x38, 0x1C, 0x71, 0xC7, 0x03, 0x8E, 0x30, 0xE0, 0x70, 0xCE,
  0x1C, 0x1E, 0x19, 0x83, 0x83, 0x83, 0xF0, 0xF0, 0x70, 0x7C, 0x1C, 0x0E,
  0x0F, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x7E, 0x00, 0x38, 0x1F, 0x80,
  0x0E, 0x07, 0xE0, 0x03, 0x81, 0xF8, 0x01, 0xE0, 0x76, 0x00, 0x78, 0x1D,
  0xC0, 0x1C, 0x0F, 0x70, 0x07, 0x03, 0x9C, 0x01, 0xC0, 0xE7, 0x00, 0x70,
  0x38, 0xE0, 0x1C, 0x0E, 0x38, 0x0F, 0x03, 0x8E, 0x03, 0x81, 0xE3, 0x80,
  0xE0, 0x78, 0x60, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC1,
  0xC1, 0xE0, 0x70, 0x70, 0x70, 0x1C, 0x0E, 0x1C, 0x0F, 0x03, 0x87, 0x03,
  0x80, 0xE1, 0xC0, 0xE0, 0x38, 0x70, 0x38, 0x06, 0x3C, 0x0E, 0x01, 0xCF,
  0x03, 0x80, 0x73, 0x81, 0xE0, 0x1C, 0xE0, 0x70, 0x07, 0x38, 0x1C, 0x00,
  0xEE, 0x07, 0x00, 0x3B, 0x81, 0xC0, 0x0E, 0xE0, 0x70, 0x03, 0xF0, 0x3C,
  0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x01,
  0xE0, 0x70, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0xF8,
  0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x38, 0x1E, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xE0,
  0xF0, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x7F, 0xBF, 0x80, 0x3F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0x00, 0x0F, 0x81, 0xC0,
  0x01, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1C, 0x00,
  0x1E, 0x07, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1E, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x78, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x02, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x70, 0x3E, 0x00, 0xF8, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1C,
  0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x3C, 0x03, 0xE0,
  0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x78, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C,
  0x00, 0x38, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x77, 0x00, 0xF8, 0x07, 0x70,
  0x0F, 0x80, 0xE7, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x00, 0xE7, 0x01, 0xF0,
  0x1E, 0x70, 0x1B, 0x01, 0xC7, 0x01, 0xB0, 0x1C, 0x70, 0x3B, 0x01, 0xC7,
  0x03, 0x30, 0x38, 0x70, 0x33, 0x03, 0x87, 0x07, 0x30, 0x38, 0x70, 0x73,
  0x03, 0x87, 0x06, 0x30, 0x70, 0x70, 0x63, 0x07, 0x07, 0x0E, 0x30, 0x70,
  0x70, 0xC3, 0x0E, 0x07, 0x0C, 0x30, 0xE0, 0x71, 0xC3, 0x0E, 0x07, 0x18,
  0x30, 0xE0, 0x61, 0x83, 0x1C, 0x0E, 0x18, 0x31, 0xC0, 0xE3, 0x83, 0x1C,
  0x0E, 0x30, 0x31, 0x80, 0xE3, 0x03, 0x38, 0x0E, 0x70, 0x33, 0x80, 0xE6,
  0x03, 0x38, 0x0E, 0x60, 0x37, 0x00, 0xEE, 0x07, 0x70, 0x0E, 0xC0, 0x77,
  0x00, 0xEC, 0x07, 0x60, 0x0E, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xB0, 0x00, 0x39, 0xC0, 0x03, 0xCE, 0x00, 0x1C, 0x70,
  0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70,
  0x0E, 0x07, 0x80, 0x70, 0x78, 0x03, 0x83, 0x80, 0x1E, 0x3C, 0x00, 0x71,
  0xC0, 0x03, 0x9E, 0x00, 0x1D, 0xE0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x0F, 0x00, 0x7E, 0x0E, 0x03, 0xFF, 0x1C, 0x1F, 0xFF, 0x78, 0x7C, 0x07,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x38, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70,
  0x00, 0x79, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x01, 0xF0, 0x78, 0x07,
  0xE0, 0xFE, 0x7D, 0xC0, 0xFF, 0xF3, 0x80, 0xFF, 0x8F, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x80, 0x38, 0xFF, 0xC0, 0x73, 0xFF, 0xC0,
  0xEE, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xF1, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x8F, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x7C, 0x00, 0xF1,
  0xF8, 0x03, 0xC3, 0xDE, 0x7F, 0x07, 0xBF, 0xFC, 0x0E, 0x1F, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3E, 0x07, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1E,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x03,
  0xCE, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x38, 0x00, 0xF0,
  0x7C, 0x03, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x07, 0x00, 0x7F,
  0xE3, 0x80, 0xFF, 0xFB, 0xC0, 0xF8, 0x0F, 0xE0, 0x78, 0x03, 0xE0, 0x78,
  0x00, 0xF0, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x3C, 0x03,
  0xF0, 0x1F, 0xCF, 0xB8, 0x07, 0xFF, 0x9C, 0x01, 0xFF, 0x1E, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xE0,
  0x3E, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x03, 0xCF, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x78, 0x03, 0xC0, 0xFC,
  0x7E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0E, 0x03,
  0xFF, 0x1C, 0x1F, 0xFF, 0x78, 0x7C, 0x07, 0xF0, 0xF0, 0x07, 0xC3, 0xC0,
  0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00,
  0x78, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00, 0xE3,
  0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x1F, 0x0F, 0x00, 0x7E, 0x1F,
  0x01, 0xFC, 0x1F, 0xFF, 0x70, 0x1F, 0xFC, 0xE0, 0x0F, 0xE1, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x80,
  0x38, 0xFF, 0xC0, 0x73, 0xFF, 0xC0, 0xEE, 0x07, 0xC1, 0xF0, 0x07, 0x83,
  0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70,
  0x00, 0x78, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E,
  0x38, 0x00, 0x3C, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7,
  0x80, 0x03, 0x8E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0x3E, 0x0F, 0x00, 0xEF, 0xE7, 0xF8, 0x1B, 0xFC,
  0xFF, 0x07, 0x43, 0xE0, 0xE0, 0xF0, 0x38, 0x1E, 0x1C, 0x07, 0x03, 0xC3,
  0x80, 0xE0, 0x70, 0x70, 0x18, 0x0E, 0x0E, 0x07, 0x01, 0xC3, 0xC0, 0xE0,
  0x38, 0x70, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x3C, 0x38,
  0x0E, 0x07, 0x07, 0x03, 0x80, 0xE1, 0xE0, 0x70, 0x1C, 0x38, 0x0E, 0x03,
  0x87, 0x01, 0xC0, 0x70, 0xE0, 0x38, 0x1E, 0x1C, 0x07, 0x03, 0x83, 0x80,
  0xC0, 0x70, 0x70, 0x38, 0x0E, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38,
  0x70, 0x1C, 0x07, 0x0E, 0x03, 0x81, 0xE1, 0xC0, 0x60, 0x38, 0x78, 0x1C,
  0x07, 0x00, 0x0F, 0x0F, 0xC0, 0x1C, 0x7F, 0xE0, 0x39, 0xFF, 0xE0, 0x77,
  0x03, 0xE0, 0xF8, 0x03, 0xC3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E,
  0x38, 0x00, 0x3C, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0xF0,
  0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x00,
  0x78, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x03, 0xCF,
  0x00, 0x1E, 0x1C, 0x00, 0x78, 0x78, 0x07, 0xC0, 0xFE, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC3, 0xF0, 0x01, 0xC7,
  0xFE, 0x00, 0xE7, 0xFF, 0x80, 0x77, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x3E,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70,
  0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x3E, 0x00, 0x78, 0x3F, 0x00,
  0x78, 0x1E, 0xF3, 0xF8, 0x0F, 0x7F, 0xF8, 0x07, 0x0F, 0xF0, 0x03, 0x80,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x00, 0xFF, 0xC7, 0x03, 0xFF, 0xEF,
  0x07, 0xC0, 0x7F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8,
  0x78, 0x01, 0xF0, 0x3C, 0x03, 0xF0, 0x3F, 0x1F, 0x70, 0x1F, 0xFE, 0x70,
  0x0F, 0xF8, 0xF0, 0x00, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x0F, 0xC0, 0x0E, 0x3F, 0xF0,
  0x0E, 0xFF, 0xF8, 0x0E, 0xE0, 0x7C, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E,
  0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3E, 0x01, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x01, 0xC7,
  0x80, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x3C, 0x00, 0x0E,
  0x38, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1E,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xF1, 0xC0,
  0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78,
  0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x1C, 0x3C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xCF, 0x00,
  0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x01,
  0xE0, 0xE0, 0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x1C, 0x1E, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0xCE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xF8,
  0x07, 0x80, 0x7E, 0x01, 0xE0, 0x3B, 0x80, 0xF8, 0x0E, 0xE0, 0x36, 0x03,
  0xB8, 0x0D, 0x81, 0xCE, 0x07, 0x60, 0x73, 0x81, 0x98, 0x1C, 0xE0, 0x66,
  0x0E, 0x38, 0x39, 0x83, 0x8E, 0x0C, 0x60, 0xE3, 0x83, 0x18, 0x70, 0xE1,
  0xC6, 0x1C, 0x38, 0x61, 0x87, 0x0E, 0x18, 0x61, 0x83, 0x8E, 0x18, 0xE0,
  0xE3, 0x06, 0x38, 0x38, 0xC1, 0x8C, 0x0E, 0x70, 0x67, 0x03, 0x98, 0x19,
  0xC0, 0xE6, 0x06, 0x60, 0x1B, 0x81, 0xB8, 0x06, 0xC0, 0x6E, 0x01, 0xB0,
  0x1B, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xE0,
  0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38,
  0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x87,
  0x00, 0x1F, 0x0F, 0x00, 0x7E, 0x1F, 0x01, 0xB8, 0x1F, 0xFF, 0x70, 0x1F,
  0xF8, 0xE0, 0x0F, 0xC1, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x0E, 0x7F, 0xC0, 0x1D, 0xE3, 0xC0, 0x3B, 0x83, 0xC0,
  0x7F, 0x03, 0xC0, 0xFC, 0x03, 0x83, 0xB8, 0x07, 0xFF, 0x70, 0x07, 0xFC,
  0xE0, 0x07, 0xF0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 11, 37, 30, 10, -37 },
  { 52, 16, 16, 30, 10, -37 },
  { 84, 29, 37, 30, 1, -37 },
  { 219, 25, 51, 30, 3, -44 },
  { 379, 34, 37, 30, -1, -37 },
  { 537, 27, 38, 30, 1, -37 },
  { 666, 5, 16, 30, 15, -37 },
  { 676, 21, 48, 30, 8, -42 },
  { 802, 19, 48, 30, 3, -42 },
  { 916, 26, 26, 30, 3, -31 },
  { 1001, 23, 23, 30, 4, -28 },
  { 1068, 12, 16, 30, 5, -8 },
  { 1092, 17, 3, 30, 7, -18 },
  { 1099, 8, 8, 30, 9, -7 },
  { 1107, 29, 48, 30, 1, -42 },
  { 1281, 25, 38, 30, 3, -37 },
  { 1400, 22, 37, 30, 3, -37 },
  { 1502, 26, 37, 30, 2, -37 },
  { 1623, 25, 38, 30, 3, -37 },
  { 1742, 22, 36, 30, 4, -36 },
  { 1841, 24, 38, 30, 4, -37 },
  { 1955, 23, 38, 30, 3, -37 },
  { 2065, 24, 37, 30, 6, -37 },
  { 2176, 25, 38, 30, 3, -37 },
  { 2295, 23, 37, 30, 5, -37 },
  { 2402, 12, 29, 30, 9, -28 },
  { 2446, 15, 36, 30, 6, -28 },
  { 2514, 23, 25, 30, 5, -29 },
  { 2586, 23, 15, 30, 4, -24 },
  { 2630, 23, 25, 30, 3, -29 },
  { 2702, 20, 37, 30, 8, -37 },
  { 2795, 29, 46, 30, 1, -37 },
  { 2962, 24, 37, 30, 1, -37 },
  { 3073, 25, 37, 30, 3, -37 },
  { 3189, 24, 38, 30, 4, -37 },
  { 3303, 25, 37, 30, 3, -37 },
  { 3419, 26, 37, 30, 3, -37 },
  { 3540, 27, 37, 30, 3, -37 },
  { 3665, 24, 38, 30, 4, -37 },
  { 3779, 25, 37, 30, 3, -37 },
  { 3895, 25, 37, 30, 3, -37 },
  { 4011, 26, 38, 30, 2, -37 },
  { 4135, 28, 37, 30, 3, -37 },
  { 4265, 21, 37, 30, 4, -37 },
  { 4363, 27, 37, 30, 2, -37 },
  { 4488, 26, 37, 30, 3, -37 },
  { 4609, 24, 38, 30, 4, -37 },
  { 4723, 27, 37, 30, 3, -37 },
  { 4848, 24, 46, 30, 4, -37 },
  { 4986, 26, 37, 30, 3, -37 },
  { 5107, 25, 38, 30, 3, -37 },
  { 5226, 25, 37, 30, 6, -37 },
  { 5342, 25, 38, 30, 4, -37 },
  { 5461, 24, 37, 30, 7, -37 },
  { 5572, 28, 37, 30, 4, -37 },
  { 5702, 31, 37, 30, 0, -37 },
  { 5846, 25, 37, 30, 6, -37 },
  { 5962, 27, 37, 30, 2, -37 },
  { 6087, 19, 48, 30, 8, -42 },
  { 6201, 14, 48, 30, 9, -42 },
  { 6285, 19, 48, 30, 5, -42 },
  { 6399, 21, 20, 30, 5, -37 },
  { 6452, 25, 3, 30, 0, 1 },
  { 6462, 8, 7, 30, 14, -39 },
  { 6469, 23, 29, 30, 4, -28 },
  { 6553, 23, 38, 30, 3, -37 },
  { 6663, 23, 29, 30, 4, -28 },
  { 6747, 25, 38, 30, 4, -37 },
  { 6866, 22, 29, 30, 4, -28 },
  { 6946, 33, 46, 30, -2, -37 },
  { 7136, 23, 37, 30, 4, -28 },
  { 7243, 23, 37, 30, 3, -37 },
  { 7350, 23, 39, 30, 2, -39 },
  { 7463, 25, 48, 30, 1, -39 },
  { 7613, 26, 37, 30, 3, -37 },
  { 7734, 20, 37, 30, 5, -37 },
  { 7827, 27, 28, 30, 1, -28 },
  { 7922, 23, 28, 30, 3, -28 },
  { 8003, 22, 29, 30, 4, -28 },
  { 8083, 25, 37, 30, 1, -28 },
  { 8199, 24, 37, 30, 3, -28 },
  { 8310, 24, 28, 30, 4, -28 },
  { 8394, 23, 29, 30, 3, -28 },
  { 8478, 23, 35, 30, 5, -35 },
  { 8579, 23, 29, 30, 4, -28 },
  { 8663, 23, 28, 30, 6, -28 },
  { 8744, 26, 28, 30, 4, -28 },
  { 8835, 27, 28, 30, 1, -28 },
  { 8930, 23, 37, 30, 4, -28 },
  { 9037, 24, 28, 30, 3, -28 },
  { 9121, 25, 48, 30, 5, -42 },
  { 9271, 11, 48, 30, 10, -42 },
  { 9337, 24, 48, 30, 2, -42 },
  { 9481, 23, 9, 30, 4, -22 },
};

const GFXfont JetBrainsMono_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC50PT7B_H_
