#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC72PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x7E, 0x00,
  0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x1C, 0xFF, 0x00, 0x07, 0xE0, 0xE1,
  0xFC, 0x00, 0x7E, 0x0F, 0x07, 0xE0, 0x07, 0xE0, 0x78, 0x1F, 0x80, 0x3E,
  0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x3F, 0x01, 0xC0,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0x3F,
  0x87, 0x80, 0x00, 0x00, 0xFF, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0xFF, 0x80, 0x00, 0x00, 0x70, 0xFE, 0x00, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0x0E, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x3E,
  0x00, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x03, 0x80, 0x3E, 0x0F,
  0x80, 0x1C, 0x01, 0xF0, 0x3E, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x7E, 0x03, 0xC0, 0xFC, 0x01, 0xF8,
  0x1C, 0x0F, 0xC0, 0x0F, 0xF0, 0xE1, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x03,
  0xC1, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x3C, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xC0,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0xF8, 0x00, 0x7E, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x7C, 0x03, 0xE0, 0x00,
  0xFD, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0x80,
  0x3E, 0x00, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xE0,
  0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x7F, 0x00, 0xFE, 0x0F,
  0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x0E, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xFF, 0x01, 0xE0,
  0x1F, 0xE7, 0xFF, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x1E, 0x3F, 0xFF, 0x1F,
  0xFE, 0x73, 0xFF, 0xE0, 0x0F, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x03, 0xF8, 0x0F,
  0x87, 0xC0, 0x7F, 0x81, 0xF0, 0xF8, 0x0F, 0xF0, 0x3E, 0x1F, 0x01, 0xFE,
  0x07, 0xC3, 0xE0, 0x3F, 0x80, 0xF8, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x0F, 0xE3, 0xE0,
  0x00, 0x3F, 0xC3, 0xC0, 0x00, 0x7F, 0x07, 0xC0, 0x01, 0xFE, 0x07, 0xC0,
  0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x02, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x20, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x7C, 0x7F, 0xFF,
  0x00, 0x0F, 0x3F, 0xFF, 0xF0, 0x01, 0xEF, 0xFF, 0xFF, 0x00, 0x7D, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xF0, 0x00,
  0x0F, 0x9F, 0xFF, 0x00, 0x07, 0xDF, 0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x7C,
  0x00, 0x3F, 0xFF, 0x3E, 0x00, 0x07, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x07, 0xF0, 0x78, 0x1F, 0x00, 0x07, 0xFF, 0x3E, 0x07, 0x80, 0x07,
  0xFF, 0xEF, 0x81, 0xE0, 0x03, 0xFF, 0xFB, 0xC0, 0x78, 0x01, 0xFC, 0x07,
  0xF0, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x1F, 0x00,
  0x07, 0x81, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x81, 0xE0,
  0x0F, 0x80, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0x78, 0x1F, 0x00, 0x3F, 0xFF,
  0xDE, 0x07, 0x80, 0x07, 0xFF, 0xE7, 0x81, 0xE0, 0x00, 0xFF, 0xE3, 0xC0,
  0x78, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x02, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0x81, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0x70,
  0x00, 0x0F, 0xF0, 0x0E, 0xF0, 0x00, 0x3D, 0xE0, 0x1D, 0xE0, 0x00, 0x7B,
  0x80, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x01, 0xE7,
  0x00, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0x79,
  0xF0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C,
  0x70, 0x07, 0x8F, 0x00, 0xF0, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C,
  0x7C, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x1F,
  0x0F, 0x07, 0x83, 0xC0, 0x3E, 0x0E, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x3C,
  0x1F, 0x00, 0xF8, 0x3C, 0x78, 0x3E, 0x01, 0xE0, 0x79, 0xE0, 0x7C, 0x03,
  0xC0, 0xF3, 0xC0, 0xF8, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0x1F, 0x01, 0xDE,
  0x03, 0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x80, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0x3C, 0x00, 0x0F,
  0x80, 0x79, 0xE0, 0x00, 0x78, 0x03, 0xCF, 0x00, 0x03, 0xC0, 0x1E, 0x7C,
  0x00, 0x1E, 0x01, 0xF1, 0xE0, 0x01, 0xF0, 0x0F, 0x8F, 0x00, 0x0F, 0x80,
  0x7C, 0x78, 0x00, 0x7C, 0x03, 0xE3, 0xC0, 0x03, 0xE0, 0x1E, 0x1F, 0x00,
  0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x80, 0x7C,
  0x1E, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x3C, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0xF8,
  0x01, 0xE0, 0xF8, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x7C, 0x3C,
  0x01, 0xE0, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0xF8, 0x00,
  0x78, 0xF8, 0x07, 0xC0, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x0F, 0x3E, 0x01,
  0xF0, 0x00, 0x79, 0xF0, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0x78, 0x00, 0x1F,
  0x78, 0x03, 0xC0, 0x00, 0xFB, 0xC0, 0x3E, 0x00, 0x03, 0xDE, 0x01, 0xF0,
  0x00, 0x1E, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xF8,
  0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0x00,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x0F,
  0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x3C, 0x00, 0x7F, 0x00, 0x1E,
  0x7C, 0x00, 0x7F, 0x00, 0x1E, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0xFE, 0x00, 0x3C, 0x7C, 0x00, 0xEE, 0x00,
  0x3C, 0x7C, 0x00, 0xEE, 0x00, 0x7C, 0x7C, 0x01, 0xEE, 0x00, 0x78, 0x7C,
  0x01, 0xEE, 0x00, 0x78, 0x7C, 0x01, 0xCE, 0x00, 0xF8, 0x78, 0x01, 0xCE,
  0x00, 0xF8, 0x78, 0x03, 0xCE, 0x00, 0xF0, 0x78, 0x03, 0x8E, 0x00, 0xF0,
  0x78, 0x03, 0x8E, 0x01, 0xF0, 0x78, 0x07, 0x8E, 0x01, 0xE0, 0x78, 0x07,
  0x0E, 0x01, 0xE0, 0x78, 0x07, 0x0E, 0x01, 0xE0, 0x78, 0x0F, 0x0E, 0x03,
  0xE0, 0x78, 0x0F, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x0E, 0x07, 0xC0, 0x78, 0x1E, 0x0E, 0x07, 0x80, 0x78, 0x1C, 0x0E,
  0x07, 0x80, 0x78, 0x1C, 0x0E, 0x07, 0x80, 0x78, 0x3C, 0x0E, 0x0F, 0x80,
  0x78, 0x38, 0x0E, 0x0F, 0x00, 0x78, 0x38, 0x0E, 0x0F, 0x00, 0xF8, 0x38,
  0x0E, 0x0F, 0x00, 0xF8, 0x78, 0x1E, 0x1F, 0x00, 0xF8, 0x70, 0x1E, 0x1E,
  0x00, 0xF8, 0x70, 0x1E, 0x1E, 0x00, 0xF8, 0xF0, 0x1E, 0x1E, 0x00, 0xF8,
  0xE0, 0x1E, 0x3C, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x00,
  0xF1, 0xC0, 0x1C, 0x78, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x00, 0xF3, 0x80,
  0x1C, 0xF0, 0x00, 0xF3, 0x80, 0x1C, 0xF0, 0x00, 0xF7, 0x80, 0x1C, 0xF0,
  0x00, 0xF7, 0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x00, 0x1D, 0xE0, 0x00, 0xF7,
  0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x00, 0x07, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xE1, 0xF0, 0x03, 0xFF,
  0xFC, 0x7C, 0x03, 0xFF, 0xFF, 0x9E, 0x01, 0xFE, 0x01, 0xE7, 0x80, 0x7E,
  0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07,
  0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0xF9,
  0xFD, 0xF0, 0x03, 0xFF, 0xFE, 0x7C, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x0F,
  0xFF, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x80,
  0x0F, 0x8F, 0xFF, 0xF0, 0x03, 0xE7, 0xFF, 0xFE, 0x00, 0xFB, 0xC0, 0x3F,
  0xC0, 0x3D, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x3E, 0x07,
  0xF0, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0,
  0x1F, 0x7F, 0x1F, 0xF0, 0x07, 0x8F, 0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0xFC,
  0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x1F, 0xFF, 0x87,
  0xC0, 0x03, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xFF, 0xE7, 0xC0, 0x1F, 0xE0,
  0x1E, 0x78, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x9F,
  0xDF, 0x00, 0x0F, 0xFF, 0xF9, 0xF0, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x03,
  0xFF, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x1F,
  0xFF, 0x87, 0xC0, 0x1F, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0xF9, 0xE0, 0x3F,
  0xC0, 0x3C, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x7D, 0xF0, 0x0F, 0xFF,
  0xFC, 0xF8, 0x03, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xFC, 0x3C, 0x00, 0x1F,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xF8, 0x00, 0x3E, 0x1F, 0xFF,
  0x80, 0x0F, 0x8F, 0xFF, 0xF0, 0x03, 0xE7, 0xFF, 0xFE, 0x00, 0xFB, 0xC0,
  0x3F, 0xC0, 0x3D, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xE3,
  0xF8, 0x0F, 0xE0, 0x0F, 0x1F, 0xF0, 0xFF, 0xC0, 0x3C, 0xFF, 0xE7, 0xFF,
  0x80, 0xF7, 0xFF, 0x9F, 0xFE, 0x03, 0xF0, 0x3E, 0xC0, 0xFC, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x3E, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F,
  0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0,
  0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0x80,
  0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xE0,
  0x00, 0xF8, 0x7F, 0xFE, 0x00, 0x3E, 0x3F, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF,
  0xF8, 0x03, 0xEF, 0x00, 0xFF, 0x00, 0xF7, 0x00, 0x0F, 0xC0, 0x3D, 0x80,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0x87, 0xFF, 0xE0, 0x00, 0xF8, 0xFF,
  0xFF, 0x00, 0x0F, 0x9F, 0xFF, 0xF8, 0x00, 0xFB, 0xC0, 0x3F, 0xC0, 0x0F,
  0x70, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0xC0, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x7F, 0x1F, 0xF0, 0x01, 0xE3,
  0xFF, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0xFF, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xE1, 0xF0, 0x03, 0xFF, 0xFC, 0x7C,
  0x03, 0xFF, 0xFF, 0x9E, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F,
  0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xC0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xEF, 0x00, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0xF9, 0xFD, 0xF0,
  0x03, 0xFF, 0xFE, 0x7C, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x0F, 0xFF, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xFF,
  0xC0, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0x7C, 0x7F, 0xFF, 0xC0, 0x1F, 0x3F,
  0xFF, 0xF8, 0x07, 0xDE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x01, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x3D, 0xE0, 0x03,
  0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x80, 0x0F, 0x78, 0x00, 0xFC, 0x00, 0xF3,
  0xC0, 0x0E, 0xE0, 0x07, 0x9E, 0x00, 0x77, 0x00, 0x3C, 0xF0, 0x07, 0xB8,
  0x03, 0xC7, 0x80, 0x39, 0xC0, 0x1E, 0x3C, 0x01, 0xCE, 0x00, 0xF1, 0xE0,
  0x1E, 0x70, 0x0F, 0x8F, 0x00, 0xE3, 0x80, 0x78, 0x78, 0x07, 0x1C, 0x03,
  0xC3, 0xC0, 0x78, 0xE0, 0x3E, 0x1E, 0x03, 0x87, 0x01, 0xE0, 0xF0, 0x1C,
  0x38, 0x0F, 0x07, 0x81, 0xE1, 0xC0, 0xF8, 0x3C, 0x0E, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x70, 0x3C, 0x0F, 0x07, 0x83, 0x83, 0xE0, 0x78, 0x38, 0x1C,
  0x1E, 0x03, 0xC1, 0xC0, 0xE0, 0xF0, 0x1E, 0x1E, 0x07, 0x8F, 0x80, 0xF0,
  0xE0, 0x3C, 0x78, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x1E,
  0x01, 0xE3, 0x80, 0x79, 0xE0, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x1E, 0x78, 0x03, 0xCE, 0x00, 0xF7, 0x80, 0x1E, 0x70, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x03, 0xB8, 0x01, 0xFE, 0x00, 0x1D, 0xC0, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3B, 0xE0, 0x1F, 0xE0, 0x3E, 0xF8,
  0x03, 0xFF, 0xFF, 0x3C, 0x00, 0xFF, 0xFF, 0x9F, 0x00, 0x0F, 0xFF, 0x87,
  0xC0, 0x00, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x23, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x78, 0x3F, 0xFE, 0x00,
  0x0F, 0x0F, 0xFF, 0xE0, 0x01, 0xE3, 0xF0, 0x7E, 0x00, 0x7C, 0x7C, 0x07,
  0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0xC0, 0x3C, 0x7C,
  0x00, 0xFC, 0x0F, 0x8F, 0x00, 0x0F, 0xEF, 0xE1, 0xE0, 0x00, 0xFF, 0xF8,
  0x3C, 0x00, 0x0F, 0xFE, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 16, 53, 43, 14, -53 },
  { 107, 23, 22, 43, 14, -53 },
  { 171, 41, 53, 43, 2, -53 },
  { 443, 37, 73, 43, 4, -63 },
  { 781, 49, 53, 43, -2, -53 },
  { 1106, 39, 54, 43, 2, -53 },
  { 1370, 8, 22, 43, 21, -53 },
  { 1392, 29, 70, 43, 12, -61 },
  { 1646, 28, 70, 43, 4, -61 },
  { 1891, 38, 37, 43, 4, -44 },
  { 2067, 34, 34, 43, 5, -41 },
  { 2212, 17, 23, 43, 8, -11 },
  { 2261, 24, 4, 43, 10, -26 },
  { 2273, 12, 11, 43, 13, -10 },
  { 2290, 41, 68, 43, 2, -60 },
  { 2639, 35, 54, 43, 5, -53 },
  { 2876, 32, 53, 43, 4, -53 },
  { 3088, 36, 53, 43, 4, -53 },
  { 3327, 36, 54, 43, 4, -53 },
  { 3570, 33, 52, 43, 5, -52 },
  { 3785, 35, 54, 43, 5, -53 },
  { 4022, 34, 54, 43, 4, -53 },
  { 4252, 34, 53, 43, 9, -53 },
  { 4478, 36, 54, 43, 4, -53 },
  { 4721, 34, 53, 43, 7, -53 },
  { 4947, 17, 41, 43, 13, -40 },
  { 5035, 22, 52, 43, 8, -40 },
  { 5178, 33, 37, 43, 7, -42 },
  { 5331, 34, 21, 43, 5, -34 },
  { 5421, 34, 37, 43, 4, -42 },
  { 5579, 29, 53, 43, 11, -53 },
  { 5772, 42, 66, 43, 1, -53 },
  { 6119, 35, 53, 43, 1, -53 },
  { 6351, 36, 53, 43, 4, -53 },
  { 6590, 36, 54, 43, 5, -53 },
  { 6833, 36, 53, 43, 4, -53 },
  { 7072, 37, 53, 43, 5, -53 },
  { 7318, 38, 53, 43, 5, -53 },
  { 7570, 36, 54, 43, 5, -53 },
  { 7813, 37, 53, 43, 4, -53 },
  { 8059, 35, 53, 43, 5, -53 },
  { 8291, 38, 54, 43, 2, -53 },
  { 8548, 40, 53, 43, 4, -53 },
  { 8813, 31, 53, 43, 5, -53 },
  { 9019, 39, 53, 43, 3, -53 },
  { 9278, 37, 53, 43, 4, -53 },
  { 9524, 35, 54, 43, 5, -53 },
  { 9761, 38, 53, 43, 4, -53 },
  { 10013, 35, 66, 43, 5, -53 },
  { 10302, 38, 53, 43, 4, -53 },
  { 10554, 37, 54, 43, 4, -53 },
  { 10804, 35, 53, 43, 9, -53 },
  { 11036, 36, 54, 43, 5, -53 },
  { 11279, 34, 53, 43, 10, -53 },
  { 11505, 40, 53, 43, 6, -53 },
  { 11770, 44, 53, 43, 0, -53 },
  { 12062, 37, 53, 43, 8, -53 },
  { 12308, 38, 53, 43, 3, -53 },
  { 12560, 27, 68, 43, 11, -60 },
  { 12790, 20, 68, 43, 13, -60 },
  { 12960, 27, 68, 43, 7, -60 },
  { 13190, 30, 29, 43, 7, -53 },
  { 13299, 35, 4, 43, 0, 2 },
  { 13317, 11, 11, 43, 20, -57 },
  { 13333, 34, 41, 43, 5, -40 },
  { 13508, 34, 54, 43, 4, -53 },
  { 13738, 34, 41, 43, 5, -40 },
  { 13913, 36, 54, 43, 5, -53 },
  { 14156, 33, 41, 43, 5, -40 },
  { 14326, 46, 66, 43, -2, -53 },
  { 14706, 33, 53, 43, 6, -40 },
  { 14925, 34, 53, 43, 4, -53 },
  { 15151, 33, 55, 43, 3, -55 },
  { 15378, 37, 68, 43, 1, -55 },
  { 15693, 38, 53, 43, 4, -53 },
  { 15945, 29, 53, 43, 8, -53 },
  { 16138, 38, 40, 43, 2, -40 },
  { 16328, 34, 40, 43, 4, -40 },
  { 16498, 33, 41, 43, 5, -40 },
  { 16668, 36, 53, 43, 2, -40 },
  { 16907, 34, 53, 43, 5, -40 },
  { 17133, 34, 40, 43, 6, -40 },
  { 17303, 33, 41, 43, 5, -40 },
  { 17473, 33, 50, 43, 7, -50 },
  { 17680, 34, 41, 43, 5, -40 },
  { 17855, 33, 40, 43, 8, -40 },
  { 18020, 37, 40, 43, 6, -40 },
  { 18205, 39, 40, 43, 2, -40 },
  { 18400, 34, 53, 43, 5, -40 },
  { 18626, 34, 40, 43, 4, -40 },
  { 18796, 36, 68, 43, 7, -60 },
  { 19102, 15, 68, 43, 15, -60 },
  { 19230, 36, 68, 43, 2, -60 },
  { 19536, 35, 14, 43, 5, -32 },
};

const GFXfont JetBrainsMono_ExtraLightItalic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC72PT7B_H_
