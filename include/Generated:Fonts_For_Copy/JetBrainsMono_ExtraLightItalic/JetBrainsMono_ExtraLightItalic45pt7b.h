#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC45PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x78, 0x3D, 0xE0, 0xF7, 0x83,
  0xDC, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x1E, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x70,
  0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00,
  0xE0, 0x38, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0x80, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03,
  0x80, 0x07, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0x60, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xFC, 0x07, 0x8E,
  0x78, 0x0E, 0x18, 0x78, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xC1,
  0xC3, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x18, 0x00,
  0x1E, 0x30, 0x00, 0x3E, 0x60, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1B, 0xE0, 0x00, 0x31, 0xE0, 0x00,
  0x61, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00, 0x0C,
  0x0E, 0x38, 0x18, 0x1C, 0x70, 0x30, 0x70, 0xE0, 0x60, 0xE1, 0xE1, 0xC3,
  0x81, 0xE3, 0x0F, 0x03, 0xF6, 0x7C, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x07, 0xF8,
  0x00, 0x60, 0x3C, 0xF0, 0x03, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x03, 0x00,
  0xE0, 0x18, 0x0C, 0x07, 0x00, 0xE0, 0x30, 0x38, 0x03, 0x80, 0xC0, 0xC0,
  0x0E, 0x07, 0x06, 0x00, 0x30, 0x1C, 0x30, 0x00, 0xC0, 0x71, 0xC0, 0x03,
  0x83, 0x8E, 0x00, 0x0F, 0x3C, 0x70, 0x00, 0x1F, 0xE3, 0x80, 0x00, 0x3F,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x1F, 0xE0, 0x00, 0x38, 0xFF,
  0xC0, 0x00, 0xC7, 0x07, 0x00, 0x06, 0x18, 0x0C, 0x00, 0x38, 0x60, 0x30,
  0x01, 0xC3, 0x80, 0xC0, 0x0E, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x1C, 0x03,
  0x80, 0xC0, 0x70, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x0E, 0x0E, 0x03, 0x80,
  0x3C, 0x78, 0x1C, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0x38, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x1C, 0x38, 0x07, 0x38, 0x1C, 0x0E, 0x38, 0x1E, 0x1E, 0x38, 0x0E,
  0x1C, 0x38, 0x0F, 0x38, 0x70, 0x07, 0x70, 0x70, 0x03, 0xF0, 0x70, 0x03,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x07,
  0xF0, 0x78, 0x1E, 0x70, 0x7C, 0x3C, 0x38, 0x3F, 0xF8, 0x38, 0x1F, 0xE0,
  0x1C, 0x39, 0xCE, 0xF7, 0xBD, 0xCE, 0x73, 0xBD, 0xCE, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x10, 0x0E, 0x00,
  0xFC, 0x1C, 0x0F, 0xFE, 0x38, 0xFE, 0xFF, 0x67, 0xF8, 0x7F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x77, 0x00, 0x01,
  0xCF, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x1C, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x3C, 0x06, 0x00, 0x70, 0x04, 0x00, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x08, 0x3E, 0x7E, 0x7F, 0xFE,
  0x7E, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xBF, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1,
  0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x83, 0x83,
  0x8E, 0x1F, 0x0E, 0x38, 0x7C, 0x39, 0xE1, 0xE1, 0xE7, 0x03, 0x87, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00,
  0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x3C, 0x00, 0x70,
  0x70, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xB8,
  0x01, 0xF3, 0x80, 0x3C, 0x38, 0x07, 0x83, 0x80, 0x60, 0x38, 0x0C, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xE7, 0xF0, 0x1E, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xF0, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0xE3,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0xF0,
  0x0E, 0x0F, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x38, 0x70, 0x01, 0xC7,
  0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x1C, 0xFF, 0x80, 0x77, 0xFF,
  0x01, 0xF8, 0x3E, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x1E,
  0x3C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x9F, 0x80, 0x3B, 0xFF, 0x03, 0xBD, 0xFC, 0x1E,
  0x01, 0xE1, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x03, 0xC7, 0x00, 0x3C, 0x3C, 0x03, 0xC0,
  0xF8, 0x7C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x73,
  0x80, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0x3F, 0x81, 0xE0, 0x1E, 0x07, 0x00,
  0x3C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x07, 0x00, 0xE0, 0x1E,
  0x0F, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x3C,
  0x00, 0xF0, 0x78, 0x07, 0x80, 0x70, 0x38, 0x01, 0xE1, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xF0, 0x01, 0xC1, 0xE0, 0x0F, 0x07, 0xE1, 0xF8,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xF1, 0xF0, 0x3C, 0x03, 0xC3, 0xC0, 0x0F, 0x1C, 0x00, 0x39, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x9E, 0x00, 0x78,
  0x78, 0x07, 0xC3, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xCE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x70, 0x07, 0xCE, 0x1C,
  0x07, 0xFB, 0x86, 0x03, 0xFF, 0xE3, 0x81, 0xE0, 0x78, 0xE0, 0x70, 0x1E,
  0x38, 0x1C, 0x07, 0x0E, 0x0E, 0x01, 0xC3, 0x83, 0x80, 0x70, 0xE0, 0xE0,
  0x1C, 0x30, 0x38, 0x07, 0x1C, 0x0E, 0x01, 0xC7, 0x03, 0x00, 0x61, 0xC1,
  0xC0, 0x18, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x03, 0x86, 0x07, 0x01, 0xE3,
  0x80, 0xE0, 0xF8, 0xE0, 0x3F, 0xEE, 0x38, 0x07, 0xF3, 0x0E, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00,
  0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x98, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x38, 0x0C, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x06, 0x00, 0xE0, 0x70, 0x07, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0x87, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0x80, 0x3E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C,
  0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x70, 0x70, 0x03, 0x81, 0xC0, 0x7C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xE0, 0x3F, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xC7, 0x00, 0x0E, 0x18, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x1E, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xE0, 0x1E, 0x07, 0x00, 0x3C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0x80, 0x7C, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x1C, 0x18, 0x00, 0xF0, 0xE0, 0x07, 0x83, 0x80,
  0x3C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xE0, 0x1E, 0x07,
  0x00, 0x3C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0xFF, 0xE3, 0x83, 0xFF, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xE0, 0x1E, 0x03, 0xE1,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x1C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x70, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03,
  0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x3F, 0x0E, 0xC0, 0x3F, 0x0E, 0xC0, 0x77, 0x0E, 0xC0, 0x66, 0x0E,
  0xE0, 0xE6, 0x0C, 0xE0, 0xCE, 0x0C, 0x61, 0xCE, 0x1C, 0x61, 0x8E, 0x1C,
  0x63, 0x8E, 0x1C, 0x63, 0x0C, 0x1C, 0x77, 0x1C, 0x1C, 0x36, 0x1C, 0x1C,
  0x36, 0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x00, 0x18, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x18, 0x3E,
  0x00, 0x70, 0x7E, 0x00, 0xE0, 0xFC, 0x01, 0xC1, 0xF8, 0x03, 0x83, 0xB0,
  0x07, 0x06, 0x60, 0x0E, 0x1C, 0xE0, 0x38, 0x39, 0xC0, 0x70, 0x73, 0x80,
  0xE0, 0xE3, 0x01, 0xC1, 0xC7, 0x03, 0x83, 0x8E, 0x07, 0x06, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE1, 0xC1,
  0xC1, 0xC3, 0x83, 0x01, 0x86, 0x0E, 0x03, 0x9C, 0x1C, 0x07, 0x38, 0x38,
  0x0E, 0x70, 0x70, 0x0C, 0xE0, 0xE0, 0x19, 0xC1, 0xC0, 0x3B, 0x07, 0x00,
  0x76, 0x0E, 0x00, 0xFC, 0x1C, 0x00, 0xF8, 0x38, 0x01, 0xF0, 0x70, 0x03,
  0xE0, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xBF,
  0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1,
  0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0E, 0x00, 0x3C, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xBF, 0x01, 0xE0,
  0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xE0, 0x1E,
  0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x70, 0x03, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x3C,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x3C, 0x1C, 0x01, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFD, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x3C, 0x01, 0xE0,
  0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x0F, 0x87,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0x00, 0xE0,
  0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x06, 0x1C,
  0x00, 0x18, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x60, 0x1E, 0x03, 0xB0, 0x0E, 0x01, 0x98, 0x0F, 0x01, 0xCC,
  0x07, 0x80, 0xE6, 0x03, 0xC0, 0x73, 0x03, 0xE0, 0x71, 0x81, 0xB0, 0x39,
  0xC0, 0xD8, 0x1C, 0xE0, 0x6C, 0x0C, 0x70, 0x66, 0x0E, 0x38, 0x33, 0x07,
  0x1C, 0x19, 0x83, 0x8E, 0x1C, 0xC1, 0x87, 0x0C, 0x61, 0xC3, 0x86, 0x30,
  0xE1, 0xC3, 0x18, 0x60, 0xE3, 0x0C, 0x70, 0x71, 0x86, 0x38, 0x38, 0xC3,
  0x1C, 0x1C, 0xC1, 0x8C, 0x0E, 0x60, 0xCE, 0x07, 0x30, 0x67, 0x03, 0xB8,
  0x33, 0x01, 0x98, 0x19, 0x80, 0xCC, 0x0D, 0xC0, 0x66, 0x06, 0xE0, 0x36,
  0x03, 0x60, 0x1B, 0x01, 0xF0, 0x0D, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7,
  0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xB0, 0x00, 0xEE, 0x00, 0x73,
  0x80, 0x38, 0xE0, 0x0E, 0x18, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x70,
  0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x19, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x38, 0x38, 0x1C, 0x0E, 0x0F, 0x00, 0xFE, 0x38, 0x1F, 0xF9,
  0xC1, 0xF9, 0xEE, 0x1E, 0x01, 0xF1, 0xE0, 0x0F, 0x8E, 0x00, 0x3C, 0x70,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x3C, 0x3C, 0x03, 0xE0, 0xF8, 0x77, 0x07, 0xFF, 0x38, 0x0F, 0xF3,
  0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x3F,
  0x80, 0xE7, 0xFE, 0x07, 0x79, 0xF8, 0x3E, 0x01, 0xE1, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x7C, 0x03, 0xC3, 0xB8, 0x7C, 0x1D, 0xFF,
  0xC0, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x3C, 0x70, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x3C,
  0x03, 0xC0, 0xFC, 0x7C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x38,
  0x07, 0xFE, 0x70, 0x1F, 0x9E, 0xE0, 0x78, 0x07, 0xC1, 0xE0, 0x0F, 0x83,
  0x80, 0x0F, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0xF8,
  0x0F, 0x87, 0x70, 0x1F, 0xFC, 0xE0, 0x0F, 0xF3, 0xC0, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x01, 0xF9, 0xF8, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x08, 0xE0,
  0x03, 0x87, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0xF8, 0x7C, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x70, 0x7F, 0xE7, 0x0F, 0xCF, 0x71, 0xE0, 0x1F, 0x1C,
  0x01, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xF0, 0x07,
  0x87, 0x00, 0xF8, 0x7E, 0x7B, 0x83, 0xFF, 0x38, 0x1F, 0xE3, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x3F, 0x80,
  0xE7, 0xFE, 0x07, 0x79, 0xF8, 0x3E, 0x01, 0xE1, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38,
  0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE0, 0xE0,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x03,
  0xC0, 0x38, 0x0F, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x0F,
  0x00, 0x78, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0E, 0x7C, 0x7C, 0x0E, 0xFC, 0xFE, 0x0F,
  0x1E, 0x8F, 0x0E, 0x0F, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x0E, 0x07, 0x1C,
  0x0E, 0x07, 0x1C, 0x0E, 0x06, 0x1C, 0x0C, 0x0E, 0x1C, 0x0C, 0x0E, 0x18,
  0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38,
  0x1C, 0x0C, 0x38, 0x18, 0x1C, 0x38, 0x18, 0x1C, 0x30, 0x38, 0x1C, 0x70,
  0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x18, 0x70, 0x30, 0x38, 0x70,
  0x30, 0x38, 0x60, 0x70, 0x38, 0xE0, 0x70, 0x38, 0x0E, 0x3F, 0x80, 0xE7,
  0xFE, 0x07, 0x79, 0xF8, 0x3E, 0x01, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFD, 0xF8, 0x1E, 0x01,
  0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x07,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x3C, 0x03, 0xC0,
  0xF8, 0x7C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0x8F, 0xE0, 0x0E,
  0x7F, 0xE0, 0x1D, 0xE7, 0xE0, 0x3E, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0xC0, 0x3C, 0x0E,
  0xE1, 0xF0, 0x1D, 0xFF, 0xC0, 0x38, 0xFF, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x38, 0x1F, 0xF9,
  0xC1, 0xF9, 0xEE, 0x1E, 0x01, 0xF1, 0xE0, 0x0F, 0x8E, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x3C, 0x3C, 0x03, 0xE0, 0xF8, 0x77, 0x07, 0xFF, 0x38, 0x0F, 0xF3,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x3F,
  0xC0, 0x39, 0xFF, 0x80, 0xEF, 0x3F, 0x03, 0xE0, 0x1E, 0x0F, 0x00, 0x38,
  0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xF8, 0xFC, 0x1E, 0x00, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x1C, 0x78, 0x01, 0xE1, 0xF0, 0x1E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x3C, 0x03, 0xC0, 0xF8,
  0x7C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xB8, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x70, 0x30, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x19, 0xC0, 0x00,
  0xCE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x1F, 0x81, 0xE0, 0x37, 0x03, 0xC0,
  0xEE, 0x0D, 0x81, 0xDC, 0x1B, 0x03, 0x38, 0x36, 0x0E, 0x70, 0xCC, 0x1C,
  0xE1, 0x98, 0x31, 0xC3, 0x30, 0xE3, 0x8C, 0x61, 0xC7, 0x18, 0xC3, 0x0E,
  0x31, 0x8E, 0x1C, 0xC3, 0x1C, 0x39, 0x86, 0x30, 0x73, 0x0C, 0xE0, 0xEC,
  0x19, 0xC1, 0xD8, 0x33, 0x03, 0x30, 0x6E, 0x06, 0xC0, 0xDC, 0x0D, 0x81,
  0xB0, 0x1B, 0x03, 0x60, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x1E, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE1,
  0xC0, 0x00, 0x73, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7,
  0x00, 0x01, 0xE7, 0x80, 0x03, 0xC3, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x01,
  0xC0, 0x0E, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x78, 0x00,
  0x70, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01,
  0xE3, 0x80, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x83, 0xF3, 0xDC, 0x0F,
  0xFC, 0xE0, 0x3F, 0x87, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x7F, 0x80, 0x63,
  0x8F, 0x01, 0x9C, 0x1C, 0x0E, 0x70, 0x38, 0x39, 0xC0, 0xF1, 0xC6, 0x01,
  0xFF, 0x38, 0x03, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 10, 33, 27, 9, -33 },
  { 43, 14, 14, 27, 9, -33 },
  { 68, 26, 33, 27, 1, -33 },
  { 176, 23, 45, 27, 2, -39 },
  { 306, 30, 33, 27, -1, -33 },
  { 430, 24, 33, 27, 1, -33 },
  { 529, 5, 14, 27, 13, -33 },
  { 538, 18, 44, 27, 8, -38 },
  { 637, 18, 44, 27, 2, -38 },
  { 736, 23, 23, 27, 3, -27 },
  { 803, 21, 21, 27, 3, -25 },
  { 859, 11, 14, 27, 5, -7 },
  { 879, 15, 2, 27, 6, -16 },
  { 883, 8, 7, 27, 8, -7 },
  { 890, 26, 42, 27, 1, -37 },
  { 1027, 22, 33, 27, 3, -33 },
  { 1118, 20, 33, 27, 2, -33 },
  { 1201, 23, 33, 27, 2, -33 },
  { 1296, 22, 33, 27, 3, -33 },
  { 1387, 21, 33, 27, 3, -33 },
  { 1474, 22, 33, 27, 3, -33 },
  { 1565, 21, 33, 27, 3, -33 },
  { 1652, 21, 33, 27, 6, -33 },
  { 1739, 22, 33, 27, 3, -33 },
  { 1830, 21, 33, 27, 5, -33 },
  { 1917, 11, 25, 27, 8, -25 },
  { 1952, 14, 32, 27, 5, -25 },
  { 2008, 21, 23, 27, 4, -26 },
  { 2069, 21, 13, 27, 3, -21 },
  { 2104, 21, 23, 27, 3, -26 },
  { 2165, 18, 33, 27, 7, -33 },
  { 2240, 26, 41, 27, 1, -33 },
  { 2374, 21, 33, 27, 1, -33 },
  { 2461, 22, 33, 27, 3, -33 },
  { 2552, 22, 33, 27, 3, -33 },
  { 2643, 22, 33, 27, 3, -33 },
  { 2734, 23, 33, 27, 3, -33 },
  { 2829, 24, 33, 27, 3, -33 },
  { 2928, 22, 33, 27, 3, -33 },
  { 3019, 23, 33, 27, 3, -33 },
  { 3114, 22, 33, 27, 3, -33 },
  { 3205, 24, 33, 27, 1, -33 },
  { 3304, 24, 33, 27, 3, -33 },
  { 3403, 19, 33, 27, 3, -33 },
  { 3482, 24, 33, 27, 2, -33 },
  { 3581, 23, 33, 27, 3, -33 },
  { 3676, 22, 33, 27, 3, -33 },
  { 3767, 24, 33, 27, 3, -33 },
  { 3866, 22, 41, 27, 3, -33 },
  { 3979, 23, 33, 27, 3, -33 },
  { 4074, 24, 33, 27, 2, -33 },
  { 4173, 23, 33, 27, 5, -33 },
  { 4268, 23, 33, 27, 3, -33 },
  { 4363, 22, 33, 27, 6, -33 },
  { 4454, 25, 33, 27, 4, -33 },
  { 4558, 28, 33, 27, 0, -33 },
  { 4674, 23, 33, 27, 5, -33 },
  { 4769, 24, 33, 27, 2, -33 },
  { 4868, 17, 42, 27, 7, -37 },
  { 4958, 12, 42, 27, 8, -37 },
  { 5021, 17, 42, 27, 4, -37 },
  { 5111, 18, 18, 27, 5, -33 },
  { 5152, 22, 3, 27, 0, 1 },
  { 5161, 8, 6, 27, 12, -35 },
  { 5167, 21, 25, 27, 3, -25 },
  { 5233, 21, 33, 27, 3, -33 },
  { 5320, 21, 25, 27, 3, -25 },
  { 5386, 23, 33, 27, 3, -33 },
  { 5481, 21, 25, 27, 3, -25 },
  { 5547, 30, 41, 27, -2, -33 },
  { 5701, 20, 33, 27, 4, -25 },
  { 5784, 21, 33, 27, 3, -33 },
  { 5871, 21, 35, 27, 2, -35 },
  { 5963, 23, 43, 27, 1, -35 },
  { 6087, 23, 33, 27, 3, -33 },
  { 6182, 18, 33, 27, 5, -33 },
  { 6257, 24, 25, 27, 1, -25 },
  { 6332, 21, 25, 27, 3, -25 },
  { 6398, 21, 25, 27, 3, -25 },
  { 6464, 23, 33, 27, 1, -25 },
  { 6559, 21, 33, 27, 3, -25 },
  { 6646, 22, 25, 27, 3, -25 },
  { 6715, 21, 25, 27, 3, -25 },
  { 6781, 21, 32, 27, 4, -32 },
  { 6865, 21, 25, 27, 3, -25 },
  { 6931, 21, 25, 27, 5, -25 },
  { 6997, 23, 25, 27, 4, -25 },
  { 7069, 24, 25, 27, 1, -25 },
  { 7144, 21, 33, 27, 3, -25 },
  { 7231, 22, 25, 27, 2, -25 },
  { 7300, 22, 42, 27, 5, -37 },
  { 7416, 10, 42, 27, 9, -37 },
  { 7469, 23, 42, 27, 1, -37 },
  { 7590, 22, 8, 27, 3, -20 },
};

const GFXfont JetBrainsMono_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC45PT7B_H_
