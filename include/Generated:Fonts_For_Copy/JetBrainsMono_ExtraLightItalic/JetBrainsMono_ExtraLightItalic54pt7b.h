#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC54PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81,
  0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xBC, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xFB, 0xE0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0xDF, 0xC0, 0x1F, 0x1C, 0x7C, 0x03,
  0xE1, 0xC3, 0xE0, 0x3C, 0x1C, 0x1E, 0x07, 0x81, 0xC1, 0xE0, 0x78, 0x18,
  0x1E, 0x07, 0x01, 0x81, 0xE0, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x30, 0x00, 0x07, 0xC3,
  0x00, 0x00, 0x3E, 0x30, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x6F, 0xE0, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x1C, 0x07, 0x0F, 0x01, 0xC0, 0x70, 0xF0, 0x1C, 0x0F, 0x0F, 0x01, 0xC0,
  0xF0, 0x70, 0x18, 0x1E, 0x07, 0x81, 0x81, 0xE0, 0x7C, 0x18, 0x3C, 0x03,
  0xE3, 0x8F, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x1E, 0x1E, 0x00, 0x1C,
  0x03, 0xC0, 0xE0, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x3C, 0x00, 0x70,
  0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x0E, 0x0E, 0x00,
  0x0F, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0x1C, 0x38, 0x00, 0x07, 0x03, 0xC7,
  0x00, 0x00, 0x7C, 0xF8, 0xF0, 0x00, 0x03, 0xFF, 0x0E, 0x00, 0x00, 0x1F,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x38, 0x7F, 0xC0, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0x00,
  0xE1, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x0E, 0x00, 0x03, 0x83, 0x80, 0xE0,
  0x00, 0x78, 0x70, 0x0E, 0x00, 0x07, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x70,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x0F, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x3C, 0x03, 0x80, 0x07, 0xFF, 0x80, 0x70, 0x00, 0x3F,
  0xF0, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x8F, 0x0F,
  0x00, 0x78, 0xF0, 0x3C, 0x03, 0x87, 0x01, 0xE0, 0x3C, 0x78, 0x07, 0x83,
  0xC3, 0xC0, 0x1E, 0x3C, 0x1E, 0x00, 0xF1, 0xC0, 0xE0, 0x03, 0xDE, 0x07,
  0x00, 0x1F, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xFC, 0x07, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x7F,
  0x81, 0xE0, 0x0F, 0x9C, 0x07, 0x80, 0xF8, 0xF0, 0x3F, 0xFF, 0x83, 0xC0,
  0xFF, 0xF0, 0x1E, 0x03, 0xFF, 0x00, 0x78, 0x01, 0x00, 0x00, 0x00, 0x3C,
  0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0xFB, 0xCF, 0x3C, 0xF3, 0x8E, 0x38, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x20, 0x07, 0x00, 0x37, 0xC0, 0x70, 0x1F, 0x7F, 0x07, 0x0F, 0xFF,
  0xFC, 0x63, 0xFF, 0x1F, 0xF6, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x1E, 0x1F, 0x9F, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xF1, 0xFC, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x03, 0x01, 0xE3,
  0x81, 0xF0, 0x78, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x1E, 0x0F, 0xC3,
  0xC7, 0x81, 0xE0, 0xF1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x1C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0xFC, 0xF0, 0x01, 0xF0, 0xF0, 0x07, 0xE0, 0xF0,
  0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x04, 0x01, 0xE0, 0x08, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x88, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x04, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0xE0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x83, 0xF0, 0x01, 0xE7, 0xFF, 0x00, 0x7B, 0xFF, 0xF0,
  0x1F, 0xF1, 0xFC, 0x07, 0x60, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x8F, 0xE0, 0x07, 0xBF, 0xF8, 0x03,
  0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0x83, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF1,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x3F, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1C, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0xC0,
  0x1F, 0x81, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFB, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x7F, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0x10, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x03, 0xC3, 0x80, 0x0F, 0xC7, 0x07, 0x00, 0x7F, 0xEE, 0x1E,
  0x01, 0xFF, 0xDC, 0x3C, 0x07, 0x80, 0xB8, 0x70, 0x0E, 0x00, 0xF0, 0xE0,
  0x3C, 0x01, 0xE1, 0xC0, 0x70, 0x03, 0x83, 0x80, 0xE0, 0x07, 0x0F, 0x03,
  0xC0, 0x0E, 0x1E, 0x07, 0x80, 0x1C, 0x38, 0x0F, 0x00, 0x78, 0x70, 0x1C,
  0x00, 0xF0, 0xE0, 0x38, 0x01, 0xE1, 0xC0, 0x70, 0x03, 0x87, 0x80, 0xE0,
  0x07, 0x0F, 0x03, 0xC0, 0x0E, 0x1E, 0x07, 0x80, 0x3C, 0x38, 0x0F, 0x00,
  0x78, 0x70, 0x1E, 0x01, 0xF0, 0xE0, 0x1E, 0x07, 0xC1, 0xC0, 0x3F, 0xFB,
  0x87, 0x80, 0x3F, 0xE7, 0x0F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x07, 0xE0, 0x38, 0x00, 0x7C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0x0E, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xE0, 0x0F, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x81, 0xC0, 0x01, 0xF0, 0x38, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x0F, 0xC0, 0x38, 0x00,
  0xF8, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x01, 0xC0, 0x07, 0xC0, 0x38, 0x07, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0xFF, 0x0E, 0x03, 0xFF, 0xC3, 0x80,
  0xFF, 0xF0, 0xE0, 0x3F, 0xFC, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1C, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1E,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x7C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01,
  0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70,
  0x01, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xB8,
  0x0E, 0xC0, 0x0E, 0xE0, 0x73, 0x80, 0x77, 0x81, 0xCE, 0x01, 0xDC, 0x07,
  0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x71, 0x81, 0xC7, 0x01, 0xC7,
  0x07, 0x3C, 0x0F, 0x1C, 0x38, 0xF0, 0x3C, 0x70, 0xE3, 0x80, 0xF1, 0xC7,
  0x0E, 0x03, 0x83, 0x1C, 0x38, 0x0E, 0x0E, 0xE1, 0xE0, 0x38, 0x3B, 0x87,
  0x80, 0xE0, 0xFC, 0x1E, 0x07, 0x83, 0xF0, 0x70, 0x1E, 0x07, 0x81, 0xC0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x3F, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0xE0, 0x3F, 0x00, 0x0E, 0x03, 0xF0,
  0x00, 0xE0, 0x7F, 0x00, 0x1E, 0x07, 0xB8, 0x01, 0xE0, 0x73, 0x80, 0x1E,
  0x07, 0x38, 0x01, 0xC0, 0x73, 0x80, 0x1C, 0x07, 0x3C, 0x01, 0xC0, 0xF1,
  0xC0, 0x3C, 0x0F, 0x1C, 0x03, 0xC0, 0xF1, 0xC0, 0x3C, 0x0E, 0x1C, 0x03,
  0x80, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0xE0, 0xE0, 0x78, 0x1E,
  0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x07, 0x07, 0x01, 0xC0, 0x70,
  0x70, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x78, 0x70, 0x3C, 0x03, 0x8F, 0x03,
  0xC0, 0x38, 0xF0, 0x3C, 0x03, 0x8F, 0x03, 0x80, 0x38, 0xE0, 0x38, 0x03,
  0xCE, 0x03, 0x80, 0x1C, 0xE0, 0x78, 0x01, 0xCE, 0x07, 0x80, 0x1D, 0xE0,
  0x78, 0x01, 0xFE, 0x07, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0xFC, 0x07, 0x00,
  0x0F, 0xC0, 0x70, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78,
  0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x7E, 0x03,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x78, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x1E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x7E, 0x03,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x6F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x7C, 0x03, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xF8, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xE1, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x1F,
  0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x3C, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0xE0, 0x0F, 0x00, 0x73, 0x80, 0x7C, 0x03, 0xCE, 0x01,
  0xB0, 0x0E, 0x38, 0x06, 0xC0, 0x39, 0xE0, 0x3B, 0x01, 0xE7, 0x80, 0xEC,
  0x07, 0x9E, 0x03, 0x30, 0x1C, 0x78, 0x1C, 0xC0, 0x71, 0xE0, 0x77, 0x03,
  0xC7, 0x81, 0x9C, 0x0E, 0x1C, 0x06, 0x70, 0x38, 0x70, 0x39, 0xC0, 0xE1,
  0xC0, 0xE7, 0x07, 0x87, 0x03, 0x1C, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x70,
  0x71, 0xC1, 0xC1, 0xC1, 0x87, 0x0E, 0x07, 0x0E, 0x1C, 0x38, 0x1C, 0x38,
  0x70, 0xE0, 0x70, 0xC1, 0xC7, 0x81, 0xC3, 0x07, 0x1C, 0x07, 0x1C, 0x1C,
  0x70, 0x1C, 0x70, 0x61, 0xC0, 0x71, 0x81, 0x8E, 0x01, 0xCE, 0x06, 0x38,
  0x07, 0x38, 0x18, 0xE0, 0x1C, 0xC0, 0x63, 0x80, 0x73, 0x01, 0x9C, 0x01,
  0xDC, 0x06, 0x70, 0x07, 0x60, 0x19, 0xC0, 0x3D, 0x80, 0x6E, 0x00, 0xFE,
  0x01, 0xB8, 0x03, 0xB8, 0x06, 0xE0, 0x0E, 0xC0, 0x1B, 0x80, 0x3B, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x38, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x02, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x38, 0x0F,
  0x00, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1E, 0x3C, 0x00,
  0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x7F, 0x83, 0x80, 0xFF, 0xF3,
  0xC0, 0xFF, 0xFD, 0xE0, 0xFC, 0x0E, 0xF0, 0xF8, 0x01, 0xF8, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x7C, 0x1F, 0x00, 0xFE, 0x07, 0xFF, 0xEF, 0x01, 0xFF, 0xE7,
  0x80, 0x7F, 0xC3, 0xC0, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC1, 0xFE, 0x00, 0x71, 0xFF, 0xC0, 0x1C, 0xFF, 0xF8, 0x0F, 0x70,
  0x3F, 0x03, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x60, 0x07,
  0x81, 0xDC, 0x07, 0xC0, 0x77, 0xFF, 0xF0, 0x3C, 0xFF, 0xF0, 0x0F, 0x1F,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0x78, 0x01, 0xF0, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0xF0, 0x70, 0x07, 0xFF, 0x9E, 0x01, 0xFF, 0xFB, 0xC0, 0x7E,
  0x07, 0x78, 0x1F, 0x00, 0x3F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x01, 0xFC, 0x03, 0xFF, 0xF7, 0x80, 0x3F,
  0xFC, 0xF0, 0x03, 0xFE, 0x1E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xE0, 0x3E, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0x80, 0x7F, 0xF3, 0xC0,
  0xFF, 0xFD, 0xE0, 0xFC, 0x0E, 0xF0, 0xF8, 0x01, 0xF8, 0x78, 0x00, 0xF8,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x71, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x03, 0xE1, 0xE0, 0x03, 0xF0, 0x78, 0x03, 0xF8, 0x3F, 0x07, 0xB8, 0x0F,
  0xFF, 0x9C, 0x03, 0xFF, 0x8E, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC1, 0xFE, 0x00, 0x71, 0xFF, 0xC0, 0x1C, 0xFF,
  0xF8, 0x0F, 0x70, 0x1F, 0x03, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0E, 0x3E, 0x0F, 0xC0, 0xE7, 0xF1, 0xFE, 0x0E, 0xFF, 0xBF, 0xE0,
  0xF8, 0x7A, 0x0F, 0x0F, 0x03, 0xC0, 0xF1, 0xE0, 0x38, 0x0F, 0x1E, 0x03,
  0x80, 0xF1, 0xE0, 0x38, 0x0F, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x78, 0x0E,
  0x1C, 0x07, 0x80, 0xE1, 0xC0, 0x70, 0x0E, 0x3C, 0x07, 0x01, 0xE3, 0xC0,
  0x70, 0x1E, 0x38, 0x07, 0x01, 0xC3, 0x80, 0x70, 0x1C, 0x38, 0x0F, 0x01,
  0xC3, 0x80, 0xE0, 0x1C, 0x78, 0x0E, 0x03, 0xC7, 0x80, 0xE0, 0x3C, 0x70,
  0x0E, 0x03, 0xC7, 0x00, 0xE0, 0x38, 0x70, 0x1E, 0x03, 0x87, 0x01, 0xC0,
  0x38, 0xF0, 0x1C, 0x03, 0x8F, 0x01, 0xC0, 0x78, 0xF0, 0x1C, 0x07, 0x8E,
  0x01, 0xC0, 0x70, 0xE0, 0x3C, 0x07, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x07,
  0xF8, 0x01, 0xC7, 0xFF, 0x00, 0x73, 0xFF, 0xE0, 0x3D, 0xC0, 0x7C, 0x0F,
  0xC0, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F,
  0x38, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x03, 0x83, 0xFC,
  0x00, 0x71, 0xFF, 0xC0, 0x0E, 0xFF, 0xFC, 0x03, 0xDC, 0x07, 0xC0, 0x7E,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x60, 0x07,
  0x80, 0xEE, 0x03, 0xE0, 0x1D, 0xFF, 0xFC, 0x07, 0x9F, 0xFE, 0x00, 0xF1,
  0xFF, 0x80, 0x1E, 0x02, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x83, 0x80, 0xFF, 0xF3, 0xC0, 0xFF, 0xFD, 0xE0, 0xFC, 0x0E,
  0xF0, 0xF8, 0x01, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x38, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x5C, 0x1F, 0x00, 0xFE,
  0x07, 0xFF, 0xEF, 0x01, 0xFF, 0xE7, 0x80, 0x7F, 0xC3, 0xC0, 0x02, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x0F, 0xF8, 0x01, 0xC7, 0xFF, 0x00,
  0xF7, 0xFF, 0xE0, 0x3D, 0xC0, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01,
  0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x80,
  0x1C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x38,
  0x07, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00,
  0x1E, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x80, 0x78, 0x07, 0xF0, 0x0F, 0x00, 0xEE,
  0x03, 0xE0, 0x1D, 0xC0, 0x6C, 0x07, 0xB8, 0x0D, 0x80, 0xE7, 0x03, 0xB0,
  0x1C, 0xE0, 0x66, 0x03, 0x9C, 0x0C, 0xC0, 0xE3, 0x83, 0x98, 0x1C, 0x70,
  0x63, 0x83, 0x8E, 0x0C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x61, 0xC3,
  0x87, 0x0C, 0x38, 0xE0, 0xE3, 0x87, 0x1C, 0x1C, 0x60, 0xE3, 0x83, 0x8C,
  0x1C, 0xE0, 0x73, 0x83, 0x9C, 0x0E, 0x60, 0x73, 0x81, 0xCC, 0x0E, 0xE0,
  0x3B, 0x81, 0xDC, 0x07, 0x60, 0x3B, 0x80, 0xEC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03,
  0xC0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0x70,
  0x3F, 0x07, 0xB8, 0x0F, 0xFF, 0xBC, 0x03, 0xFF, 0x1E, 0x00, 0x7E, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xC7, 0xFC, 0x00, 0xE3,
  0xFF, 0x80, 0x39, 0xE0, 0xF0, 0x0E, 0x70, 0x1E, 0x03, 0x9C, 0x07, 0x81,
  0xE7, 0x00, 0xF0, 0xF3, 0xC0, 0x1F, 0xFC, 0xF0, 0x03, 0xFE, 0x38, 0x00,
  0x7E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 11, 39, 32, 11, -39 },
  { 55, 17, 16, 32, 11, -39 },
  { 89, 32, 39, 32, 1, -39 },
  { 245, 28, 55, 32, 3, -47 },
  { 438, 36, 40, 32, -1, -40 },
  { 618, 29, 41, 32, 2, -40 },
  { 767, 6, 16, 32, 16, -39 },
  { 779, 22, 53, 32, 9, -46 },
  { 925, 21, 53, 32, 3, -46 },
  { 1065, 28, 28, 32, 3, -33 },
  { 1163, 25, 26, 32, 4, -31 },
  { 1245, 13, 17, 32, 6, -8 },
  { 1273, 18, 3, 32, 8, -19 },
  { 1280, 9, 9, 32, 10, -8 },
  { 1291, 31, 51, 32, 1, -45 },
  { 1489, 26, 41, 32, 4, -40 },
  { 1623, 24, 39, 32, 3, -39 },
  { 1740, 27, 40, 32, 3, -40 },
  { 1875, 27, 40, 32, 3, -39 },
  { 2010, 25, 39, 32, 4, -39 },
  { 2132, 26, 40, 32, 4, -39 },
  { 2262, 25, 40, 32, 3, -39 },
  { 2387, 25, 39, 32, 7, -39 },
  { 2509, 27, 41, 32, 3, -40 },
  { 2648, 25, 40, 32, 6, -40 },
  { 2773, 12, 31, 32, 10, -30 },
  { 2820, 17, 39, 32, 6, -30 },
  { 2903, 25, 28, 32, 5, -32 },
  { 2991, 25, 16, 32, 4, -26 },
  { 3041, 25, 28, 32, 3, -32 },
  { 3129, 22, 39, 32, 8, -39 },
  { 3237, 31, 50, 32, 1, -40 },
  { 3431, 26, 39, 32, 1, -39 },
  { 3558, 27, 39, 32, 3, -39 },
  { 3690, 26, 41, 32, 4, -40 },
  { 3824, 27, 39, 32, 3, -39 },
  { 3956, 28, 39, 32, 4, -39 },
  { 4093, 29, 39, 32, 3, -39 },
  { 4235, 26, 41, 32, 4, -40 },
  { 4369, 28, 39, 32, 3, -39 },
  { 4506, 26, 39, 32, 4, -39 },
  { 4633, 28, 40, 32, 2, -39 },
  { 4773, 30, 39, 32, 3, -39 },
  { 4920, 23, 39, 32, 4, -39 },
  { 5033, 30, 39, 32, 2, -39 },
  { 5180, 28, 39, 32, 3, -39 },
  { 5317, 26, 41, 32, 4, -40 },
  { 5451, 29, 39, 32, 3, -39 },
  { 5593, 26, 50, 32, 4, -40 },
  { 5756, 28, 39, 32, 3, -39 },
  { 5893, 28, 41, 32, 3, -40 },
  { 6037, 27, 39, 32, 6, -39 },
  { 6169, 27, 40, 32, 4, -39 },
  { 6304, 26, 39, 32, 7, -39 },
  { 6431, 30, 39, 32, 4, -39 },
  { 6578, 33, 39, 32, 0, -39 },
  { 6739, 28, 39, 32, 6, -39 },
  { 6876, 29, 39, 32, 2, -39 },
  { 7018, 21, 51, 32, 8, -45 },
  { 7152, 15, 51, 32, 9, -45 },
  { 7248, 21, 51, 32, 5, -45 },
  { 7382, 22, 21, 32, 6, -39 },
  { 7440, 27, 3, 32, 0, 1 },
  { 7451, 8, 7, 32, 15, -42 },
  { 7458, 25, 31, 32, 4, -30 },
  { 7555, 26, 40, 32, 3, -39 },
  { 7685, 25, 31, 32, 4, -30 },
  { 7782, 27, 40, 32, 4, -39 },
  { 7917, 24, 31, 32, 4, -30 },
  { 8010, 35, 49, 32, -2, -39 },
  { 8225, 25, 40, 32, 4, -30 },
  { 8350, 26, 39, 32, 3, -39 },
  { 8477, 25, 42, 32, 2, -42 },
  { 8609, 27, 52, 32, 1, -42 },
  { 8785, 28, 39, 32, 3, -39 },
  { 8922, 21, 39, 32, 6, -39 },
  { 9025, 28, 30, 32, 2, -30 },
  { 9130, 26, 30, 32, 3, -30 },
  { 9228, 24, 31, 32, 4, -30 },
  { 9321, 27, 40, 32, 2, -30 },
  { 9456, 25, 40, 32, 4, -30 },
  { 9581, 26, 30, 32, 4, -30 },
  { 9679, 26, 31, 32, 3, -30 },
  { 9780, 25, 38, 32, 5, -38 },
  { 9899, 25, 31, 32, 4, -30 },
  { 9996, 25, 30, 32, 6, -30 },
  { 10090, 27, 30, 32, 5, -30 },
  { 10192, 30, 30, 32, 1, -30 },
  { 10305, 25, 40, 32, 4, -30 },
  { 10430, 26, 30, 32, 3, -30 },
  { 10528, 26, 51, 32, 6, -45 },
  { 10694, 12, 51, 32, 11, -45 },
  { 10771, 26, 51, 32, 2, -45 },
  { 10937, 26, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC54PT7B_H_
