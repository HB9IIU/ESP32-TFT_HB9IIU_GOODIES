#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC65PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x00,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x3F, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80,
  0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF0,
  0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xE7,
  0x1F, 0xC0, 0x07, 0xE1, 0xC1, 0xF0, 0x03, 0xE0, 0x70, 0x3E, 0x00, 0xF0,
  0x1C, 0x0F, 0x80, 0x7C, 0x07, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xE0, 0x1E, 0x03, 0xE0, 0x38, 0x07, 0x80, 0xF8, 0x0E, 0x00, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x03, 0xE0, 0x38, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x07, 0xC1, 0xC0,
  0x00, 0x01, 0xFC, 0x70, 0x00, 0x00, 0x3F, 0x9C, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xE3, 0xF0, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x1C, 0x0F, 0x80,
  0x00, 0x07, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x70, 0x1F,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x04, 0x03, 0xC0,
  0x3C, 0x1E, 0x00, 0xE0, 0x1F, 0x07, 0x80, 0x38, 0x07, 0xC1, 0xE0, 0x0E,
  0x01, 0xE0, 0x7C, 0x03, 0x80, 0xF8, 0x1F, 0x00, 0xE0, 0x3E, 0x03, 0xE0,
  0x78, 0x1F, 0x00, 0xF8, 0x1C, 0x0F, 0x80, 0x3F, 0x87, 0x0F, 0xC0, 0x07,
  0xF9, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC1, 0xE0,
  0x00, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x87,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x87, 0xC1,
  0xF0, 0x00, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x1E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x21, 0xF0, 0x7C, 0x00, 0x78, 0x7C, 0x0F, 0x80, 0x1E, 0x0F,
  0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3C,
  0x0F, 0x00, 0x1F, 0x0F, 0x81, 0xE0, 0x03, 0xE3, 0xE0, 0x3C, 0x00, 0x3E,
  0x78, 0x0F, 0x80, 0x03, 0xDF, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x3C, 0x00,
  0x07, 0xF0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0xE0,
  0x0F, 0x00, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xF3, 0xE0, 0x3F, 0x00, 0xFC,
  0x7C, 0x07, 0xF8, 0xFF, 0x07, 0xC0, 0x7F, 0xFF, 0xC0, 0x78, 0x07, 0xFF,
  0xE0, 0x0F, 0x80, 0x7F, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x19, 0xF0, 0x07, 0x80, 0x3E,
  0x7F, 0x81, 0xE0, 0x7F, 0xBF, 0xF8, 0x70, 0x7F, 0xF7, 0xFF, 0x9C, 0x7F,
  0xF8, 0x7F, 0xF7, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x1F, 0x87, 0xF9, 0xFF, 0x3F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xF3, 0xFC, 0x7F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xF0, 0x78, 0x1F,
  0xC0, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1E, 0x07, 0xF0, 0x3C, 0x1F, 0x03,
  0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x10, 0x0F, 0x83, 0xC0,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x0F, 0xC7, 0x80,
  0x01, 0xFC, 0x3C, 0x00, 0x1F, 0x81, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x06, 0x00, 0x3E, 0x00, 0x20, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00,
  0x78, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x07,
  0xFE, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0x00, 0x7B, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x79, 0xFF, 0xE0, 0x03, 0xDF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0xFE, 0xF0, 0x03, 0xFF, 0xF7, 0xC0, 0x03, 0xFF, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFE, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x60, 0x78, 0x1E, 0x00, 0x1F, 0xF1, 0xE0, 0xF0, 0x01, 0xFF,
  0xE7, 0x83, 0xC0, 0x0F, 0xFF, 0xDC, 0x0F, 0x00, 0x7E, 0x07, 0x70, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x3C, 0x00,
  0x7C, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0x07, 0xC1, 0xE0,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x78, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x01,
  0xE0, 0x78, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x78, 0x03, 0xF0, 0x3B, 0x81, 0xE0, 0x07,
  0xFF, 0xDE, 0x07, 0x80, 0x0F, 0xFE, 0x78, 0x1E, 0x00, 0x1F, 0xF1, 0xE0,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xF0,
  0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x0F, 0xFC, 0x01,
  0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF8, 0x0F,
  0x00, 0x03, 0xF0, 0x0F, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x1F,
  0x00, 0x07, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3F, 0xF8, 0x01,
  0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xFF, 0xF8, 0x3C, 0x03, 0xFF, 0xF8, 0x3C, 0x03, 0xFF,
  0xF8, 0x3C, 0x03, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x20,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3D, 0xC0,
  0x01, 0xDC, 0x07, 0xB8, 0x00, 0x7B, 0x80, 0xF7, 0x00, 0x0E, 0xF0, 0x1E,
  0xF0, 0x03, 0xDE, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x71, 0xC0, 0x1E, 0x78,
  0x0E, 0x38, 0x03, 0x8E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1C,
  0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xE1, 0xC0, 0xE1, 0xE0, 0x3C, 0x38,
  0x3C, 0x7C, 0x07, 0x87, 0x07, 0x0F, 0x01, 0xF0, 0xE1, 0xE1, 0xE0, 0x3C,
  0x1E, 0x38, 0x3C, 0x07, 0x83, 0xCF, 0x07, 0x80, 0xF0, 0x39, 0xC0, 0xF0,
  0x1E, 0x07, 0x78, 0x3E, 0x03, 0xC0, 0xEE, 0x07, 0x80, 0xF8, 0x1F, 0xC0,
  0xF0, 0x1E, 0x03, 0xF0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0xFC,
  0x00, 0x03, 0xC0, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x01, 0xE0, 0x1F,
  0xC0, 0x00, 0xF0, 0x1E, 0xE0, 0x00, 0x78, 0x0F, 0x78, 0x00, 0x3C, 0x07,
  0xBC, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x1F, 0x01, 0xEF, 0x00, 0x0F, 0x00,
  0xF3, 0x80, 0x07, 0x80, 0xF9, 0xE0, 0x03, 0xC0, 0x78, 0xF0, 0x01, 0xE0,
  0x3C, 0x78, 0x00, 0xF0, 0x1E, 0x1C, 0x00, 0x78, 0x0F, 0x0F, 0x00, 0x7C,
  0x07, 0x87, 0x80, 0x3C, 0x07, 0xC3, 0xC0, 0x1E, 0x03, 0xC1, 0xE0, 0x0F,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0x3C,
  0x1F, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x07, 0x87, 0x80, 0xF8, 0x03,
  0xC3, 0xC0, 0x78, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x70, 0xF0, 0x1E, 0x00,
  0x3C, 0x78, 0x0F, 0x00, 0x1E, 0x7C, 0x07, 0x80, 0x0F, 0x3C, 0x07, 0xC0,
  0x07, 0x9E, 0x03, 0xC0, 0x01, 0xEF, 0x01, 0xE0, 0x00, 0xF7, 0x80, 0xF0,
  0x00, 0x7B, 0xC0, 0x78, 0x00, 0x3D, 0xE0, 0x3C, 0x00, 0x0E, 0xE0, 0x3E,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x01, 0xFC, 0x07,
  0x80, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x0F, 0xFC, 0x01,
  0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7E, 0x03,
  0xC0, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0xF8,
  0x01, 0xE0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01,
  0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xFC,
  0x03, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x10, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0xF3,
  0xC0, 0x0F, 0xC0, 0x0F, 0x3C, 0x00, 0xFC, 0x00, 0xF3, 0xC0, 0x0F, 0xC0,
  0x1E, 0x3C, 0x01, 0xDC, 0x01, 0xE3, 0xC0, 0x1D, 0xC0, 0x1E, 0x3C, 0x01,
  0xDC, 0x01, 0xE3, 0x80, 0x39, 0x80, 0x3C, 0x38, 0x03, 0x98, 0x03, 0xC7,
  0x80, 0x39, 0x80, 0x3C, 0x78, 0x03, 0x98, 0x07, 0x87, 0x80, 0x73, 0x80,
  0x78, 0x78, 0x07, 0x38, 0x07, 0x87, 0x80, 0x73, 0x80, 0x78, 0x78, 0x0E,
  0x38, 0x0F, 0x07, 0x80, 0xE3, 0x80, 0xF0, 0x78, 0x0E, 0x38, 0x0F, 0x07,
  0x81, 0xE3, 0x80, 0xE0, 0x78, 0x1C, 0x38, 0x1E, 0x07, 0x81, 0xC3, 0x81,
  0xE0, 0x78, 0x1C, 0x38, 0x1E, 0x07, 0x83, 0x83, 0x83, 0xC0, 0x78, 0x38,
  0x38, 0x3C, 0x07, 0x83, 0x83, 0x83, 0xC0, 0x78, 0x70, 0x38, 0x38, 0x07,
  0x87, 0x03, 0x87, 0x80, 0x78, 0x70, 0x38, 0x78, 0x07, 0x87, 0x03, 0x87,
  0x80, 0x78, 0xE0, 0x38, 0x70, 0x07, 0x8E, 0x03, 0x8F, 0x00, 0x70, 0xE0,
  0x38, 0xF0, 0x07, 0x1C, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07,
  0x1C, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x39, 0xE0, 0x0F, 0x38, 0x03, 0x9C,
  0x00, 0xF3, 0x80, 0x3B, 0xC0, 0x0F, 0x38, 0x03, 0xBC, 0x00, 0xF7, 0x00,
  0x3B, 0xC0, 0x0F, 0x70, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0x78, 0x00, 0xFE, 0x00, 0x37, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0x00, 0x1F, 0xF8, 0x3C, 0x01, 0xFF, 0xF0, 0xF0, 0x0F, 0xFF, 0xE7,
  0xC0, 0x7F, 0x87, 0xDF, 0x03, 0xF0, 0x07, 0xFC, 0x1F, 0x00, 0x0F, 0xE0,
  0xF8, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x1D,
  0xE0, 0x3F, 0x81, 0xF7, 0x80, 0x7F, 0xFF, 0x9E, 0x00, 0xFF, 0xFC, 0xF8,
  0x01, 0xFF, 0xC3, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x7F, 0xE0, 0x07, 0xC7, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF,
  0x80, 0x79, 0xF0, 0xFF, 0x01, 0xEE, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xF0, 0x01,
  0xF0, 0x3E, 0xF0, 0x3F, 0xC0, 0xFB, 0xFF, 0xFE, 0x03, 0xC7, 0xFF, 0xE0,
  0x0F, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xF8, 0x3C, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0xFF, 0xFE, 0x7C, 0x01,
  0xFE, 0x1F, 0x7C, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x03, 0xF8, 0x0F,
  0x80, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x77, 0x80, 0x3F, 0x81, 0xF7, 0x80, 0x1F,
  0xFF, 0xE7, 0x80, 0x0F, 0xFF, 0xCF, 0x80, 0x07, 0xFF, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x20, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x01, 0xFF, 0xF0, 0xF0,
  0x0F, 0xFF, 0xE7, 0xC0, 0x7F, 0x87, 0xDF, 0x03, 0xF0, 0x07, 0xFC, 0x1F,
  0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x06,
  0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xFF, 0x07, 0xDF, 0x01, 0xFF, 0xFE, 0x78,
  0x03, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x7F,
  0xC0, 0x07, 0xC7, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0x80, 0x79, 0xF0, 0xFF,
  0x01, 0xEE, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0x8F, 0xE0, 0x7F, 0x01, 0xE7,
  0xFC, 0x7F, 0xE0, 0x7B, 0xFF, 0xBF, 0xF8, 0x1F, 0xC3, 0xEC, 0x3F, 0x07,
  0xC0, 0x7E, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x3C,
  0x3E, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x01,
  0xF0, 0xF0, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0xF0,
  0x07, 0x87, 0xC0, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x38, 0x03, 0xC1, 0xE0,
  0x0E, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x78,
  0x3C, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x3E, 0x1E, 0x00, 0xF0,
  0x0F, 0x07, 0x80, 0x38, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0xF8, 0x07,
  0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x01, 0xE0, 0x07, 0xC1, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0x00, 0x78,
  0xFF, 0xFE, 0x01, 0xE7, 0xC3, 0xFC, 0x07, 0xB8, 0x01, 0xF8, 0x1F, 0xC0,
  0x03, 0xE0, 0xFE, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x7F,
  0xE0, 0x01, 0xF1, 0xFF, 0xF0, 0x01, 0xE7, 0xFF, 0xF8, 0x01, 0xEF, 0xC3,
  0xFC, 0x01, 0xEE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x03,
  0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x3E, 0xF0, 0x3F, 0xC0, 0x3E, 0xFF, 0xFF,
  0x80, 0x3C, 0x7F, 0xFE, 0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x3C, 0x01, 0xFF, 0xF0, 0xF0, 0x0F, 0xFF, 0xE7, 0xC0, 0x7F, 0x87, 0xDF,
  0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x1D, 0xE0, 0x3F, 0x81, 0xF7,
  0x80, 0xFF, 0xFF, 0x9E, 0x01, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xC3, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC1, 0xFF,
  0x80, 0x0F, 0x8F, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0xC0, 0x3C, 0xF8, 0x7F,
  0x80, 0x7B, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xF8,
  0x01, 0xF0, 0x03, 0xDC, 0x00, 0xF8, 0x01, 0xEE, 0x00, 0x7C, 0x00, 0xF7,
  0x00, 0x76, 0x00, 0xF3, 0x80, 0x3B, 0x80, 0x79, 0xC0, 0x1D, 0xC0, 0x3C,
  0xE0, 0x1C, 0xE0, 0x3C, 0x70, 0x0E, 0x70, 0x1E, 0x38, 0x07, 0x38, 0x0F,
  0x1C, 0x07, 0x1C, 0x0F, 0x0E, 0x03, 0x8E, 0x07, 0x87, 0x01, 0xC7, 0x03,
  0xC3, 0x81, 0xC3, 0x81, 0xC1, 0xC0, 0xE1, 0xC1, 0xE0, 0xE0, 0x70, 0xE0,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x78, 0x1C, 0x1C, 0x1C,
  0x3C, 0x0E, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x1E, 0x03, 0x87, 0x03,
  0x8F, 0x01, 0xC7, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE7, 0x80, 0x71, 0xC0,
  0x73, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x1D, 0xE0, 0x0E, 0x70,
  0x0E, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xB8, 0x01, 0xDC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F,
  0x00, 0x77, 0x80, 0xFF, 0x07, 0xDE, 0x01, 0xFF, 0xFE, 0x78, 0x03, 0xFF,
  0xE1, 0xE0, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x1F, 0xF8, 0x00,
  0x78, 0x7F, 0xF8, 0x00, 0xF1, 0xFB, 0xF8, 0x01, 0xE3, 0xC0, 0xF8, 0x03,
  0xCF, 0x01, 0xF0, 0x07, 0x9E, 0x01, 0xF0, 0x1F, 0x3C, 0x01, 0xF0, 0x3C,
  0xF0, 0x01, 0xF1, 0xF9, 0xE0, 0x03, 0xFF, 0xE3, 0xC0, 0x03, 0xFF, 0x87,
  0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 14, 47, 39, 13, -47 },
  { 84, 20, 19, 39, 13, -47 },
  { 132, 37, 47, 39, 2, -47 },
  { 350, 34, 66, 39, 3, -57 },
  { 631, 45, 48, 39, -2, -48 },
  { 901, 35, 49, 39, 2, -48 },
  { 1116, 8, 19, 39, 19, -47 },
  { 1135, 26, 63, 39, 11, -55 },
  { 1340, 26, 63, 39, 3, -55 },
  { 1545, 34, 34, 39, 4, -40 },
  { 1690, 30, 31, 39, 5, -37 },
  { 1807, 15, 20, 39, 7, -10 },
  { 1845, 22, 3, 39, 9, -23 },
  { 1854, 11, 10, 39, 12, -9 },
  { 1868, 37, 61, 39, 2, -54 },
  { 2151, 33, 49, 39, 4, -48 },
  { 2354, 29, 47, 39, 3, -47 },
  { 2525, 34, 48, 39, 3, -48 },
  { 2729, 32, 48, 39, 4, -47 },
  { 2921, 29, 47, 39, 5, -47 },
  { 3092, 31, 48, 39, 5, -47 },
  { 3278, 30, 48, 39, 4, -47 },
  { 3458, 31, 47, 39, 8, -47 },
  { 3641, 32, 49, 39, 4, -48 },
  { 3837, 30, 48, 39, 7, -48 },
  { 4017, 15, 37, 39, 12, -36 },
  { 4087, 20, 46, 39, 7, -36 },
  { 4202, 30, 33, 39, 6, -38 },
  { 4326, 30, 19, 39, 5, -31 },
  { 4398, 30, 33, 39, 4, -38 },
  { 4522, 26, 47, 39, 10, -47 },
  { 4675, 38, 60, 39, 1, -48 },
  { 4960, 31, 47, 39, 1, -47 },
  { 5143, 32, 47, 39, 4, -47 },
  { 5331, 32, 49, 39, 5, -48 },
  { 5527, 32, 47, 39, 4, -47 },
  { 5715, 34, 47, 39, 4, -47 },
  { 5915, 35, 47, 39, 4, -47 },
  { 6121, 32, 49, 39, 5, -48 },
  { 6317, 33, 47, 39, 4, -47 },
  { 6511, 31, 48, 39, 5, -48 },
  { 6697, 34, 48, 39, 2, -47 },
  { 6901, 36, 48, 39, 4, -48 },
  { 7117, 27, 47, 39, 5, -47 },
  { 7276, 35, 47, 39, 3, -47 },
  { 7482, 33, 47, 39, 4, -47 },
  { 7676, 31, 49, 39, 5, -48 },
  { 7866, 34, 47, 39, 4, -47 },
  { 8066, 31, 60, 39, 5, -48 },
  { 8299, 34, 47, 39, 4, -47 },
  { 8499, 34, 49, 39, 3, -48 },
  { 8708, 32, 47, 39, 8, -47 },
  { 8896, 32, 48, 39, 5, -47 },
  { 9088, 31, 47, 39, 9, -47 },
  { 9271, 36, 47, 39, 5, -47 },
  { 9483, 40, 47, 39, 0, -47 },
  { 9718, 33, 47, 39, 8, -47 },
  { 9912, 34, 47, 39, 3, -47 },
  { 10112, 25, 61, 39, 10, -54 },
  { 10303, 18, 61, 39, 11, -54 },
  { 10441, 25, 61, 39, 6, -54 },
  { 10632, 27, 25, 39, 7, -47 },
  { 10717, 32, 3, 39, 0, 2 },
  { 10729, 10, 9, 39, 18, -51 },
  { 10741, 30, 37, 39, 5, -36 },
  { 10880, 30, 48, 39, 4, -47 },
  { 11060, 30, 37, 39, 5, -36 },
  { 11199, 32, 48, 39, 5, -47 },
  { 11391, 29, 37, 39, 5, -36 },
  { 11526, 42, 59, 39, -2, -47 },
  { 11836, 30, 48, 39, 5, -36 },
  { 12016, 30, 47, 39, 4, -47 },
  { 12193, 30, 50, 39, 3, -50 },
  { 12381, 33, 62, 39, 1, -50 },
  { 12637, 34, 47, 39, 4, -47 },
  { 12837, 26, 47, 39, 7, -47 },
  { 12990, 34, 36, 39, 2, -36 },
  { 13143, 30, 36, 39, 4, -36 },
  { 13278, 29, 37, 39, 5, -36 },
  { 13413, 32, 48, 39, 2, -36 },
  { 13605, 30, 48, 39, 5, -36 },
  { 13785, 31, 36, 39, 5, -36 },
  { 13925, 30, 37, 39, 4, -36 },
  { 14064, 30, 46, 39, 6, -46 },
  { 14237, 30, 37, 39, 5, -36 },
  { 14376, 30, 36, 39, 7, -36 },
  { 14511, 33, 36, 39, 6, -36 },
  { 14660, 36, 36, 39, 1, -36 },
  { 14822, 30, 48, 39, 5, -36 },
  { 15002, 31, 36, 39, 4, -36 },
  { 15142, 32, 61, 39, 7, -54 },
  { 15386, 14, 61, 39, 13, -54 },
  { 15493, 32, 61, 39, 2, -54 },
  { 15737, 31, 12, 39, 5, -29 },
};

const GFXfont JetBrainsMono_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC65PT7B_H_
