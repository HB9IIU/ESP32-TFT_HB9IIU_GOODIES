#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC38PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0xF8, 0xF0, 0xF0, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70,
  0x77, 0x07, 0x70, 0x66, 0x0E, 0x60, 0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0x00,
  0x38, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x60,
  0x70, 0x03, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0x18, 0x1C, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x0E, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x18,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03,
  0x81, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0xE0, 0x06, 0x03,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3D, 0xBC,
  0x07, 0x18, 0xE0, 0xE1, 0x8E, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x1C, 0x30,
  0x81, 0xC3, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x00, 0x0F, 0x20, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x06, 0x78, 0x00,
  0x63, 0x80, 0x0C, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0xE0, 0xC1, 0x8E,
  0x0C, 0x38, 0xE0, 0xC3, 0x07, 0x08, 0x70, 0x79, 0x9E, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0xFE, 0x00, 0x60, 0x71, 0xC0,
  0x30, 0x38, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0x03, 0x06, 0x00, 0xC0,
  0xC3, 0x80, 0x30, 0x71, 0xC0, 0x1C, 0x18, 0x60, 0x07, 0x06, 0x30, 0x00,
  0xE3, 0x98, 0x00, 0x3F, 0xCC, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0xF8, 0x00, 0x18,
  0xEF, 0x00, 0x0C, 0x60, 0xC0, 0x06, 0x18, 0x30, 0x03, 0x8C, 0x0C, 0x00,
  0xC3, 0x03, 0x00, 0x60, 0xC0, 0xC0, 0x30, 0x30, 0x30, 0x18, 0x0C, 0x1C,
  0x0C, 0x03, 0x06, 0x07, 0x00, 0xFF, 0x03, 0x80, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xFC, 0x00, 0x70, 0xF0, 0x07, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xF3,
  0x80, 0xE7, 0x0C, 0x0E, 0x30, 0x70, 0xE3, 0x81, 0xC6, 0x1C, 0x0E, 0x70,
  0xE0, 0x3F, 0x06, 0x00, 0xF0, 0x30, 0x07, 0x01, 0x80, 0x3C, 0x1C, 0x03,
  0xE0, 0x60, 0x3B, 0x83, 0x83, 0x8C, 0x1F, 0xF8, 0x70, 0x7F, 0x81, 0xC0,
  0x3B, 0x9C, 0xE7, 0x39, 0xDC, 0xE7, 0x39, 0x80, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x03, 0x00,
  0x07, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x03, 0xF0, 0x07, 0x80, 0x08, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x04, 0x07, 0x01, 0x70,
  0x60, 0xFF, 0xE6, 0x3F, 0x3F, 0x6F, 0xC0, 0x7F, 0xE0, 0x00, 0xE0, 0x00,
  0x1B, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x80, 0x0E, 0x1C, 0x01, 0xE1, 0xC0,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x10, 0x04, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x18, 0x1C,
  0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0x11, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xF8, 0xF8, 0x38, 0x0F, 0x1C,
  0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0xCC, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x06, 0x70, 0xC1, 0x9C, 0x78, 0xE6, 0x1E, 0x39,
  0x87, 0x8E, 0xE0, 0x03, 0xB8, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xC0,
  0x07, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x1C, 0x1E, 0x0F,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x79, 0x80, 0x79, 0xC0, 0x70, 0xE0, 0x30, 0x70, 0x20, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x0F,
  0x07, 0x00, 0xF0, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x31, 0xC0, 0x06, 0x38, 0x01, 0xC3, 0x00, 0x38, 0x70, 0x0E, 0x0F,
  0x03, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x70,
  0x18, 0x70, 0x0C, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDF,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x9F, 0xC0, 0xEF, 0xF8, 0x36, 0x0F,
  0x0E, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xCC, 0x00, 0x63, 0x80,
  0x38, 0xE0, 0x1C, 0x1C, 0x0E, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39,
  0xF0, 0x0D, 0xFF, 0x07, 0xC3, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x01,
  0xDC, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xB8, 0x00, 0xE6,
  0x00, 0x39, 0x80, 0x1C, 0x70, 0x0E, 0x0E, 0x07, 0x83, 0xFF, 0xC0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x01, 0xCE, 0x00, 0x63, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x0F, 0x03,
  0x80, 0x70, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x0C,
  0x00, 0xC1, 0x80, 0x38, 0x38, 0x0E, 0x03, 0x87, 0x80, 0x3F, 0xC0, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x78, 0xF0, 0x1C, 0x07, 0x07, 0x00, 0x70, 0xC0,
  0x0E, 0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00,
  0x18, 0x70, 0x07, 0x0F, 0x03, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x81, 0xF0, 0xF0, 0x70, 0x1E, 0x38, 0x03, 0x9C, 0x00,
  0x67, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x3B,
  0x80, 0x0C, 0xE0, 0x07, 0x1C, 0x03, 0xC7, 0x81, 0xE0, 0xFF, 0xB0, 0x1F,
  0xDC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x3F, 0x1F,
  0x87, 0x80, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x20, 0x3F, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x18, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x7C,
  0x07, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3C, 0x0F, 0x01,
  0xC0, 0x0E, 0x06, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x81, 0xFD, 0x8C, 0x0F, 0xF6,
  0x30, 0x70, 0x78, 0xC1, 0x80, 0xE3, 0x06, 0x03, 0x1C, 0x18, 0x0C, 0x70,
  0xE0, 0x31, 0xC3, 0x80, 0xC6, 0x0C, 0x07, 0x18, 0x30, 0x1C, 0x60, 0xC0,
  0x61, 0x83, 0x01, 0x8E, 0x0C, 0x0E, 0x38, 0x38, 0x58, 0xC0, 0x7F, 0x63,
  0x00, 0xF1, 0x8C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x60, 0x03, 0x9C, 0x00, 0xC7,
  0x00, 0x31, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xC0,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x83, 0x80, 0xE0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x70, 0x01,
  0x98, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x07, 0x0C, 0x01, 0xC1,
  0x81, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x86,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x1C,
  0x00, 0xE3, 0x00, 0x38, 0x60, 0x0F, 0x0C, 0x07, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38, 0x07, 0x1C,
  0x01, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0C, 0x1E, 0x0F,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0x01, 0xE0, 0xC0, 0x1C, 0x18, 0x01, 0x83, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C,
  0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC3,
  0x00, 0x70, 0x60, 0x1E, 0x0C, 0x1F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x78, 0x78, 0x38, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0xE0, 0x07, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x0F, 0xF9, 0xC3, 0xFE, 0x60, 0xFF, 0x98,
  0x00, 0xE6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x63, 0x80, 0x38, 0xE0, 0x0C, 0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0x80,
  0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00,
  0xE0, 0xC0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0xC0,
  0x0C, 0x1C, 0x01, 0xC1, 0x80, 0x1C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0x80, 0x18, 0x38, 0x01, 0x83, 0x00, 0x38, 0x30, 0x03, 0x83,
  0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x07, 0x00,
  0x70, 0x70, 0x0E, 0x07, 0x81, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x06,
  0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xC0, 0x0C,
  0x06, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0x00, 0x30, 0x38, 0x01, 0x83, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x18, 0x01, 0x80, 0xE0, 0x0C, 0x07,
  0x00, 0x60, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x18, 0x0C,
  0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x70,
  0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xB0, 0x1B, 0x1B, 0x01, 0xF1, 0xB0, 0x36,
  0x19, 0x83, 0x61, 0x98, 0x66, 0x19, 0x86, 0x61, 0x98, 0xCE, 0x39, 0x8C,
  0xE3, 0x8D, 0x8E, 0x30, 0xD8, 0xC3, 0x0F, 0x0C, 0x30, 0xF0, 0xC3, 0x0E,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x70, 0xF0, 0x06,
  0x0F, 0x00, 0x60, 0xF8, 0x06, 0x0D, 0x80, 0x60, 0xD8, 0x0E, 0x0D, 0x80,
  0xE1, 0xDC, 0x0E, 0x1C, 0xC0, 0xC1, 0xCC, 0x0C, 0x18, 0xC0, 0xC1, 0x8C,
  0x1C, 0x18, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x61, 0x83, 0x86, 0x18, 0x30,
  0x71, 0x83, 0x03, 0x38, 0x30, 0x33, 0x83, 0x03, 0x38, 0x70, 0x3B, 0x07,
  0x03, 0xB0, 0x70, 0x1B, 0x06, 0x01, 0xB0, 0x60, 0x1B, 0x06, 0x01, 0xF0,
  0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x78,
  0x38, 0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38, 0xE0,
  0x1C, 0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x0E, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C,
  0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x61,
  0x80, 0x0E, 0x18, 0x01, 0xC1, 0x80, 0x78, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78,
  0x78, 0x38, 0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x70, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x00, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38,
  0xE0, 0x1C, 0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xE0, 0x0E, 0x0C,
  0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x06, 0x1C, 0x00, 0xE1, 0x80, 0x1C, 0x18, 0x03, 0xC1, 0x81, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x38, 0x38, 0x03, 0x03, 0x80, 0x30, 0x18,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x70, 0x0E, 0x06, 0x00,
  0xE0, 0x60, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x00,
  0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0xE0,
  0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x08, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0x70,
  0x07, 0x07, 0x81, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x1C,
  0x30, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xC3,
  0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1C, 0x0E,
  0x07, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1B, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x71, 0x80,
  0x18, 0x60, 0x0E, 0x1C, 0x03, 0x07, 0x01, 0xC1, 0xC0, 0x60, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x38, 0x03,
  0x0C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x60, 0x03, 0xB8, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x60, 0x38,
  0x1B, 0x03, 0xC0, 0xD8, 0x1E, 0x0E, 0xC0, 0xF0, 0x66, 0x0D, 0x83, 0x30,
  0x68, 0x39, 0x83, 0x41, 0xCC, 0x12, 0x0C, 0x61, 0x90, 0x63, 0x0C, 0x87,
  0x18, 0x44, 0x30, 0xC6, 0x21, 0x86, 0x31, 0x0C, 0x31, 0x88, 0xE3, 0x88,
  0xC6, 0x1C, 0xC6, 0x30, 0xE6, 0x33, 0x87, 0x21, 0x98, 0x3B, 0x0C, 0xC1,
  0xD8, 0x66, 0x0C, 0xC3, 0x70, 0x6C, 0x1B, 0x03, 0x60, 0xD8, 0x1B, 0x06,
  0xC0, 0xD0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x00,
  0x07, 0x00, 0x0E, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x18, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0x80, 0x00, 0xC6, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x30,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x70, 0x01, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x76,
  0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00, 0x1C, 0x30, 0x03, 0x83, 0x80, 0x30,
  0x38, 0x07, 0x01, 0x80, 0xE0, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x0C, 0x18,
  0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x81, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xB0, 0x03, 0xB8, 0x03,
  0x18, 0x07, 0x18, 0x06, 0x1C, 0x0C, 0x1C, 0x1C, 0x0C, 0x18, 0x0C, 0x38,
  0x0E, 0x70, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE1, 0xC3, 0x86, 0x1C, 0x03, 0xF9, 0xC3, 0xFF, 0x61, 0xE0, 0xD8, 0x70,
  0x1E, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8E,
  0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x87, 0x03, 0xE1, 0xFF,
  0xB8, 0x3F, 0xCC, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x73, 0xF8, 0x1D, 0xFF,
  0x07, 0xC1, 0xE1, 0xE0, 0x38, 0x70, 0x07, 0x18, 0x01, 0xC6, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x06, 0x38, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x1C, 0x70, 0x0E,
  0x1E, 0x07, 0x8E, 0xFF, 0xC3, 0x9F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x07,
  0x83, 0xC3, 0x80, 0x73, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0x70, 0x0E, 0x1E, 0x0F, 0x07,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x1F, 0xCE, 0x0F,
  0xFD, 0x83, 0xC1, 0xB0, 0x70, 0x1E, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x1E, 0x0E, 0x07, 0xC1, 0xFF, 0xB8, 0x1F, 0xE6, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x3F, 0xFF, 0x9F, 0xFF, 0xCC, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x70,
  0x06, 0x1C, 0x0F, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x08, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xC3, 0xFF, 0x61, 0xE0, 0xD8,
  0x70, 0x1E, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x70,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0x8E, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x3E, 0x0F, 0xFB, 0x81, 0xFC, 0xE0,
  0x18, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x7E, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x73, 0xF8, 0x1D, 0xFF, 0x07, 0xC1, 0xE1, 0xE0, 0x38, 0x70, 0x07, 0x18,
  0x01, 0xC6, 0x00, 0x73, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x01, 0x8C, 0x00,
  0xE3, 0x00, 0x38, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x31,
  0x80, 0x1C, 0x60, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x7C, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0x1C,
  0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x01,
  0x81, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x30, 0x70, 0x03, 0x03, 0x00, 0x30, 0x38, 0x07, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00,
  0x38, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x1D, 0xF3, 0xE1, 0xBF, 0x7F, 0x1C,
  0x34, 0x71, 0xC3, 0x87, 0x18, 0x38, 0x71, 0x83, 0x07, 0x38, 0x30, 0x73,
  0x83, 0x06, 0x30, 0x30, 0x63, 0x07, 0x06, 0x30, 0x70, 0x63, 0x06, 0x0E,
  0x70, 0x60, 0xE7, 0x06, 0x0E, 0x70, 0x60, 0xC6, 0x0E, 0x0C, 0x60, 0xE0,
  0xC6, 0x0C, 0x1C, 0x60, 0xC1, 0xCE, 0x0C, 0x1C, 0xE0, 0xC1, 0x80, 0x1C,
  0xFE, 0x07, 0x7F, 0xC1, 0xF0, 0x78, 0x78, 0x0E, 0x1C, 0x01, 0xC6, 0x00,
  0x71, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x38,
  0xC0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x31, 0xC0, 0x0C, 0x60,
  0x07, 0x18, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x06, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x0E, 0x70,
  0x0E, 0x1C, 0x0E, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x7F, 0x01, 0xDF,
  0xF0, 0x3E, 0x0F, 0x07, 0x80, 0xE0, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00,
  0x38, 0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0xE1, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x03,
  0x87, 0x00, 0xE0, 0xF0, 0x3C, 0x3B, 0xFF, 0x07, 0x3F, 0x80, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xF9, 0xC3, 0xFF, 0x61, 0xE0, 0xD8, 0x70, 0x1E,
  0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x03, 0x18,
  0x01, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8E, 0x00,
  0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x87, 0x03, 0xE1, 0xFF, 0xB0,
  0x3F, 0xCC, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x1C, 0xFE, 0x06, 0x7F, 0xC1, 0xB0,
  0x78, 0x70, 0x0E, 0x1C, 0x01, 0x8E, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF0,
  0x3C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x60, 0x03, 0x1C, 0x01, 0xC7, 0x80,
  0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0x38, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x18, 0xC0,
  0x06, 0x30, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x03,
  0x1C, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x18, 0x07, 0x07, 0x83, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0xE6, 0x00, 0x39, 0x80,
  0x1C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x1C,
  0x0C, 0x06, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0x18, 0x70, 0x06, 0x18, 0x01,
  0x8E, 0x00, 0x63, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x60, 0x7E, 0x0E, 0x06, 0xE0, 0xE0, 0x6E,
  0x0A, 0x0E, 0xE1, 0xA0, 0xCE, 0x1A, 0x0C, 0xE1, 0x21, 0xCE, 0x32, 0x18,
  0xE3, 0x21, 0x8E, 0x22, 0x38, 0xE6, 0x23, 0x0C, 0x63, 0x30, 0xC4, 0x33,
  0x0C, 0xC3, 0x60, 0xCC, 0x36, 0x0C, 0x83, 0x60, 0xD8, 0x3C, 0x0D, 0x83,
  0xC0, 0xD0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0x70,
  0xE0, 0x0E, 0x07, 0x00, 0xC0, 0x70, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x01, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x00, 0x38, 0xE0,
  0x03, 0xC0, 0x38, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x73, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x30, 0x03, 0x98,
  0x01, 0xCC, 0x00, 0xEE, 0x00, 0x67, 0x00, 0x33, 0x80, 0x39, 0xC0, 0x3C,
  0x70, 0x3E, 0x3F, 0xF7, 0x0F, 0xF3, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60,
  0xE0, 0xE0, 0xE0, 0xC0, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x3E, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xCF, 0xE0, 0x77, 0x3C,
  0x1B, 0x87, 0x06, 0xE0, 0xE3, 0xB0, 0x1F, 0xCC, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 8, 28, 23, 8, -28 },
  { 29, 12, 12, 23, 7, -28 },
  { 47, 22, 28, 23, 1, -28 },
  { 124, 20, 38, 23, 2, -33 },
  { 219, 26, 28, 23, -1, -28 },
  { 310, 21, 28, 23, 1, -28 },
  { 384, 5, 12, 23, 11, -28 },
  { 392, 16, 37, 23, 6, -32 },
  { 466, 15, 37, 23, 2, -32 },
  { 536, 20, 19, 23, 2, -23 },
  { 584, 18, 17, 23, 3, -21 },
  { 623, 9, 12, 23, 4, -6 },
  { 637, 13, 3, 23, 5, -14 },
  { 642, 6, 6, 23, 7, -6 },
  { 647, 22, 36, 23, 1, -32 },
  { 746, 18, 28, 23, 3, -28 },
  { 809, 17, 28, 23, 2, -28 },
  { 869, 19, 28, 23, 2, -28 },
  { 936, 19, 28, 23, 2, -28 },
  { 1003, 17, 28, 23, 3, -28 },
  { 1063, 18, 28, 23, 3, -28 },
  { 1126, 18, 28, 23, 2, -28 },
  { 1189, 18, 28, 23, 5, -28 },
  { 1252, 19, 28, 23, 2, -28 },
  { 1319, 18, 28, 23, 4, -28 },
  { 1382, 9, 21, 23, 7, -21 },
  { 1406, 12, 27, 23, 4, -21 },
  { 1447, 18, 19, 23, 3, -22 },
  { 1490, 18, 11, 23, 3, -18 },
  { 1515, 18, 19, 23, 2, -22 },
  { 1558, 15, 28, 23, 6, -28 },
  { 1611, 22, 35, 23, 1, -28 },
  { 1708, 18, 28, 23, 1, -28 },
  { 1771, 19, 28, 23, 2, -28 },
  { 1838, 18, 28, 23, 3, -28 },
  { 1901, 19, 28, 23, 2, -28 },
  { 1968, 19, 28, 23, 3, -28 },
  { 2035, 21, 28, 23, 2, -28 },
  { 2109, 18, 28, 23, 3, -28 },
  { 2172, 20, 28, 23, 2, -28 },
  { 2242, 18, 28, 23, 3, -28 },
  { 2305, 20, 28, 23, 1, -28 },
  { 2375, 21, 28, 23, 2, -28 },
  { 2449, 16, 28, 23, 3, -28 },
  { 2505, 20, 28, 23, 2, -28 },
  { 2575, 20, 28, 23, 2, -28 },
  { 2645, 18, 28, 23, 3, -28 },
  { 2708, 20, 28, 23, 2, -28 },
  { 2778, 18, 35, 23, 3, -28 },
  { 2857, 20, 28, 23, 2, -28 },
  { 2927, 20, 28, 23, 2, -28 },
  { 2997, 18, 28, 23, 5, -28 },
  { 3060, 19, 28, 23, 3, -28 },
  { 3127, 18, 28, 23, 5, -28 },
  { 3190, 21, 28, 23, 3, -28 },
  { 3264, 23, 28, 23, 0, -28 },
  { 3345, 20, 28, 23, 4, -28 },
  { 3415, 20, 28, 23, 2, -28 },
  { 3485, 14, 36, 23, 6, -32 },
  { 3548, 10, 36, 23, 7, -32 },
  { 3593, 15, 36, 23, 3, -32 },
  { 3661, 16, 15, 23, 4, -28 },
  { 3691, 19, 2, 23, 0, 1 },
  { 3696, 6, 5, 23, 10, -30 },
  { 3700, 18, 21, 23, 3, -21 },
  { 3748, 18, 28, 23, 2, -28 },
  { 3811, 17, 21, 23, 3, -21 },
  { 3856, 19, 28, 23, 3, -28 },
  { 3923, 17, 21, 23, 3, -21 },
  { 3968, 24, 35, 23, -1, -28 },
  { 4073, 18, 28, 23, 3, -21 },
  { 4136, 18, 28, 23, 2, -28 },
  { 4199, 17, 29, 23, 2, -29 },
  { 4261, 19, 36, 23, 1, -29 },
  { 4347, 20, 28, 23, 2, -28 },
  { 4417, 15, 28, 23, 4, -28 },
  { 4470, 20, 21, 23, 1, -21 },
  { 4523, 18, 21, 23, 2, -21 },
  { 4571, 17, 21, 23, 3, -21 },
  { 4616, 19, 28, 23, 1, -21 },
  { 4683, 18, 28, 23, 3, -21 },
  { 4746, 18, 21, 23, 3, -21 },
  { 4794, 18, 21, 23, 2, -21 },
  { 4842, 17, 27, 23, 4, -27 },
  { 4900, 18, 21, 23, 3, -21 },
  { 4948, 18, 21, 23, 4, -21 },
  { 4996, 20, 21, 23, 3, -21 },
  { 5049, 20, 21, 23, 1, -21 },
  { 5102, 17, 28, 23, 3, -21 },
  { 5162, 18, 21, 23, 2, -21 },
  { 5210, 19, 36, 23, 4, -32 },
  { 5296, 8, 36, 23, 8, -32 },
  { 5332, 19, 36, 23, 1, -32 },
  { 5418, 18, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC38PT7B_H_
