#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC14PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x90, 0x98, 0x99, 0x99, 0x09, 0x11, 0x12, 0x7F, 0x22,
  0x24, 0xFE, 0x44, 0x48, 0x48, 0x08, 0x10, 0xD2, 0x95, 0x0A, 0x0C, 0x0E,
  0x15, 0x2A, 0x93, 0xC2, 0x04, 0x00, 0x38, 0xA4, 0x92, 0x8A, 0x82, 0x80,
  0xB0, 0x64, 0x52, 0x49, 0x47, 0x00, 0x1E, 0x22, 0x20, 0x20, 0x30, 0x49,
  0x4A, 0x44, 0x4C, 0x72, 0x6A, 0x04, 0x62, 0x08, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x20, 0x40, 0x20, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x44,
  0x40, 0x10, 0x20, 0x47, 0xF1, 0x05, 0x12, 0x44, 0x10, 0x20, 0x47, 0xF1,
  0x04, 0x08, 0x00, 0x6A, 0x40, 0xF8, 0xF0, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x3C, 0x85, 0x0A,
  0x19, 0x52, 0xA1, 0x42, 0x8C, 0xF0, 0x19, 0xA4, 0x82, 0x10, 0x41, 0x04,
  0x13, 0xF0, 0x3C, 0x85, 0x08, 0x20, 0x41, 0x04, 0x10, 0xC1, 0xF8, 0x7E,
  0x08, 0x20, 0x82, 0xC0, 0x81, 0x42, 0x88, 0xE0, 0x04, 0x21, 0x08, 0x25,
  0x18, 0x7F, 0x04, 0x20, 0x7E, 0x81, 0x02, 0xC6, 0x40, 0x81, 0x02, 0x88,
  0xF0, 0x0C, 0x42, 0x08, 0x7E, 0x18, 0x61, 0x85, 0xE0, 0xFE, 0x18, 0x82,
  0x10, 0x42, 0x08, 0x43, 0x00, 0x3C, 0x85, 0x0A, 0x23, 0x89, 0x21, 0x42,
  0x84, 0xF0, 0x3C, 0x85, 0x0A, 0x14, 0x4F, 0x82, 0x08, 0x20, 0xC0, 0x6C,
  0x00, 0x36, 0x33, 0x00, 0x00, 0x64, 0x88, 0x06, 0x31, 0x84, 0x06, 0x03,
  0x01, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x40, 0xC0, 0xC1, 0x19, 0x88, 0x00,
  0x78, 0x20, 0x42, 0x19, 0x84, 0x00, 0x43, 0x00, 0x1F, 0x21, 0x41, 0x47,
  0x49, 0x51, 0x51, 0x51, 0x9E, 0x80, 0x80, 0x60, 0x18, 0x0C, 0x18, 0x50,
  0xA1, 0x44, 0x8F, 0xA1, 0x43, 0x04, 0x7C, 0x85, 0x0A, 0x27, 0x90, 0xA1,
  0x42, 0x85, 0xF0, 0x3C, 0x85, 0x0A, 0x04, 0x10, 0x20, 0x42, 0x84, 0xF0,
  0x7C, 0x8D, 0x0A, 0x24, 0x50, 0xA1, 0x42, 0x89, 0xE0, 0x7E, 0x81, 0x02,
  0x07, 0xC8, 0x20, 0x40, 0x81, 0xF8, 0x7E, 0x81, 0x02, 0x07, 0xC8, 0x20,
  0x40, 0x81, 0x00, 0x3C, 0x85, 0x0A, 0x04, 0x13, 0xA1, 0x42, 0x84, 0xF0,
  0x42, 0x85, 0x0A, 0x27, 0xD0, 0xA1, 0x42, 0x85, 0x10, 0x7E, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x21, 0xF0, 0x0F, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x42, 0x44, 0x78, 0x43, 0x44, 0x44, 0x48, 0x70, 0x88, 0x88, 0x88,
  0x84, 0x84, 0x61, 0x04, 0x10, 0x41, 0x04, 0x20, 0x83, 0xF0, 0x62, 0xCD,
  0xAB, 0x5B, 0x50, 0xA1, 0x42, 0x85, 0x08, 0x62, 0xC5, 0x8A, 0xA5, 0x52,
  0xA5, 0x4A, 0x8D, 0x10, 0x3C, 0x85, 0x0A, 0x24, 0x50, 0xA1, 0x42, 0x88,
  0xF0, 0x7E, 0x85, 0x0A, 0x14, 0x4F, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x85,
  0x0A, 0x14, 0x50, 0xA1, 0x42, 0x88, 0xF0, 0x40, 0x40, 0x80, 0x7C, 0x85,
  0x0A, 0x14, 0xD6, 0x22, 0x44, 0x89, 0x08, 0x3C, 0x85, 0x02, 0x03, 0x01,
  0x81, 0x42, 0x84, 0xF0, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x80, 0x42, 0x85, 0x0A, 0x24, 0x50, 0xA1, 0x42, 0x88, 0xF0, 0x87, 0x0A,
  0x24, 0x48, 0x92, 0x14, 0x30, 0x60, 0x80, 0x99, 0x99, 0x9A, 0xAA, 0xAA,
  0xAC, 0xAC, 0xCC, 0xC8, 0x88, 0x21, 0x89, 0x04, 0x82, 0x80, 0x80, 0xC0,
  0x50, 0x48, 0x42, 0x41, 0x00, 0x87, 0x0A, 0x22, 0x85, 0x04, 0x08, 0x20,
  0x40, 0x80, 0x7E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0xF8, 0x39,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x09, 0x70, 0x84, 0x44, 0x42, 0x22,
  0x22, 0x11, 0x11, 0x3C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04,
  0x13, 0xC0, 0x18, 0x62, 0x51, 0xC4, 0xFE, 0x90, 0x3A, 0x89, 0x14, 0x28,
  0x50, 0xA3, 0x3C, 0x41, 0x07, 0x91, 0x46, 0x18, 0x61, 0x8B, 0xE0, 0x39,
  0x14, 0x60, 0x82, 0x18, 0x5E, 0x02, 0x04, 0xEA, 0x24, 0x50, 0xA1, 0x42,
  0x8C, 0xF0, 0x39, 0x14, 0x7F, 0x82, 0x08, 0x5E, 0x07, 0x84, 0x02, 0x0F,
  0xE1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x0C, 0x00, 0x3A,
  0x89, 0x14, 0x28, 0x50, 0x97, 0x14, 0x08, 0x33, 0x80, 0x41, 0x07, 0x91,
  0x46, 0x18, 0x61, 0x86, 0x20, 0x08, 0x60, 0x1E, 0x10, 0x41, 0x04, 0x10,
  0x4F, 0xC0, 0x02, 0x04, 0x01, 0xF0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x41, 0x9C, 0x00, 0x40, 0x81, 0x0A, 0x24, 0x8A, 0x2C, 0x44, 0x89, 0x08,
  0xE1, 0x08, 0x84, 0x21, 0x08, 0x43, 0xC0, 0x3E, 0x49, 0x49, 0x49, 0x4A,
  0x52, 0x52, 0x92, 0x79, 0x14, 0x61, 0x86, 0x18, 0x62, 0x39, 0x14, 0x61,
  0x86, 0x18, 0x9E, 0x3C, 0x44, 0x8A, 0x14, 0x28, 0x51, 0x3E, 0x40, 0x82,
  0x00, 0x3A, 0x89, 0x14, 0x28, 0x50, 0xA3, 0x3C, 0x08, 0x10, 0x20, 0x5C,
  0xC9, 0x0A, 0x24, 0x10, 0x20, 0x40, 0x3D, 0x14, 0x18, 0x1C, 0x18, 0x7E,
  0x10, 0x23, 0xF9, 0x02, 0x04, 0x08, 0x10, 0x20, 0x78, 0x42, 0x89, 0x14,
  0x28, 0x50, 0xA2, 0x3C, 0x86, 0x28, 0xA4, 0x92, 0x86, 0x10, 0x93, 0x26,
  0xCD, 0x6A, 0xD9, 0xB2, 0x64, 0x21, 0x22, 0x14, 0x18, 0x18, 0x24, 0x24,
  0xC2, 0x42, 0x89, 0x14, 0x28, 0x50, 0xB7, 0x14, 0x08, 0x33, 0x80, 0x7C,
  0x10, 0x84, 0x21, 0x0C, 0x3F, 0x02, 0x18, 0x20, 0x40, 0x81, 0x1C, 0x48,
  0x10, 0x20, 0x41, 0x01, 0x01, 0x00, 0x24, 0xA4, 0x92, 0x52, 0x49, 0x00,
  0x30, 0x10, 0x20, 0x40, 0x81, 0x03, 0x84, 0x10, 0x20, 0x40, 0x82, 0x18,
  0x00, 0x63, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 9, 10, 8, 0, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 8, 4, -10 },
  { 53, 6, 14, 8, 2, -12 },
  { 64, 5, 14, 8, 1, -12 },
  { 73, 7, 8, 8, 1, -9 },
  { 80, 7, 7, 8, 1, -8 },
  { 87, 3, 4, 8, 2, -2 },
  { 89, 5, 1, 8, 2, -5 },
  { 90, 2, 2, 8, 3, -2 },
  { 91, 8, 14, 8, 0, -12 },
  { 105, 7, 10, 8, 1, -10 },
  { 114, 6, 10, 8, 1, -10 },
  { 122, 7, 10, 8, 1, -10 },
  { 131, 7, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 7, 10, 8, 1, -10 },
  { 157, 6, 10, 8, 1, -10 },
  { 165, 6, 10, 8, 2, -10 },
  { 173, 7, 10, 8, 1, -10 },
  { 182, 7, 10, 8, 1, -10 },
  { 191, 3, 8, 8, 3, -8 },
  { 194, 4, 10, 8, 2, -8 },
  { 199, 7, 7, 8, 1, -8 },
  { 206, 7, 4, 8, 1, -7 },
  { 210, 6, 7, 8, 1, -8 },
  { 216, 6, 10, 8, 2, -10 },
  { 224, 8, 13, 8, 0, -10 },
  { 237, 7, 10, 8, 0, -10 },
  { 246, 7, 10, 8, 1, -10 },
  { 255, 7, 10, 8, 1, -10 },
  { 264, 7, 10, 8, 1, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 7, 10, 8, 1, -10 },
  { 300, 7, 10, 8, 1, -10 },
  { 309, 7, 10, 8, 1, -10 },
  { 318, 8, 10, 8, 0, -10 },
  { 328, 8, 10, 8, 1, -10 },
  { 338, 6, 10, 8, 1, -10 },
  { 346, 7, 10, 8, 1, -10 },
  { 355, 7, 10, 8, 1, -10 },
  { 364, 7, 10, 8, 1, -10 },
  { 373, 7, 10, 8, 1, -10 },
  { 382, 7, 13, 8, 1, -10 },
  { 394, 7, 10, 8, 1, -10 },
  { 403, 7, 10, 8, 1, -10 },
  { 412, 7, 10, 8, 2, -10 },
  { 421, 7, 10, 8, 1, -10 },
  { 430, 7, 10, 8, 2, -10 },
  { 439, 8, 10, 8, 1, -10 },
  { 449, 9, 10, 8, 0, -10 },
  { 461, 7, 10, 8, 2, -10 },
  { 470, 7, 10, 8, 1, -10 },
  { 479, 5, 14, 8, 2, -12 },
  { 488, 4, 14, 8, 2, -12 },
  { 495, 6, 14, 8, 1, -12 },
  { 506, 6, 5, 8, 1, -10 },
  { 510, 7, 1, 8, 0, 0 },
  { 511, 2, 2, 8, 4, -11 },
  { 512, 7, 8, 8, 1, -8 },
  { 519, 6, 10, 8, 1, -10 },
  { 527, 6, 8, 8, 1, -8 },
  { 533, 7, 10, 8, 1, -10 },
  { 542, 6, 8, 8, 1, -8 },
  { 548, 9, 13, 8, 0, -10 },
  { 563, 7, 11, 8, 1, -8 },
  { 573, 6, 10, 8, 1, -10 },
  { 581, 6, 11, 8, 1, -11 },
  { 590, 7, 14, 8, 0, -11 },
  { 603, 7, 10, 8, 1, -10 },
  { 612, 5, 10, 8, 2, -10 },
  { 619, 8, 8, 8, 0, -8 },
  { 627, 6, 8, 8, 1, -8 },
  { 633, 6, 8, 8, 1, -8 },
  { 639, 7, 11, 8, 0, -8 },
  { 649, 7, 11, 8, 1, -8 },
  { 659, 7, 8, 8, 1, -8 },
  { 666, 6, 8, 8, 1, -8 },
  { 672, 7, 10, 8, 1, -10 },
  { 681, 7, 8, 8, 1, -8 },
  { 688, 6, 8, 8, 2, -8 },
  { 694, 7, 8, 8, 1, -8 },
  { 701, 8, 8, 8, 0, -8 },
  { 709, 7, 11, 8, 1, -8 },
  { 719, 6, 8, 8, 1, -8 },
  { 725, 7, 14, 8, 1, -12 },
  { 738, 3, 14, 8, 3, -12 },
  { 744, 7, 14, 8, 0, -12 },
  { 757, 7, 2, 8, 1, -6 },
};

const GFXfont JetBrainsMono_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC14PT7B_H_
