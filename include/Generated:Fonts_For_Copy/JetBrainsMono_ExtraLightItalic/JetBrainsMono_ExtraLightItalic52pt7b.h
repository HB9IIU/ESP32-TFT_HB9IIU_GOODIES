#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC52PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xC1,
  0xF8, 0x7F, 0x07, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x03,
  0xCF, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C, 0x78,
  0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x1C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0x18, 0xF8, 0x0F, 0x06, 0x1E, 0x03, 0x83, 0x83, 0xC1, 0xE0, 0xE0,
  0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x0F, 0x03, 0x03, 0xC3, 0xC0,
  0xC0, 0x00, 0xF0, 0x30, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x7E, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0C,
  0x7C, 0x00, 0x03, 0x0F, 0x80, 0x00, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xE3, 0xC0, 0x60, 0x38,
  0xF0, 0x18, 0x0E, 0x3C, 0x0E, 0x07, 0x8F, 0x03, 0x81, 0xC1, 0xC0, 0xE0,
  0xF0, 0x78, 0x38, 0x78, 0x1F, 0x8C, 0x7C, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x1F, 0xF8, 0x00,
  0x38, 0x07, 0xDF, 0x00, 0x0E, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0x38, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x38,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x1C, 0x00,
  0x38, 0x07, 0x07, 0x00, 0x07, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x1C, 0x70,
  0x00, 0x0E, 0x07, 0x1E, 0x00, 0x01, 0xFF, 0xC3, 0x80, 0x00, 0x1F, 0xF0,
  0xE0, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x0F, 0xE0, 0x00, 0x01, 0xC7, 0xFE, 0x00, 0x00, 0x71, 0xFF,
  0xE0, 0x00, 0x1C, 0x38, 0x1C, 0x00, 0x07, 0x0E, 0x03, 0x80, 0x01, 0xE1,
  0xC0, 0x70, 0x00, 0x38, 0x30, 0x0E, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x81,
  0xE0, 0x1C, 0x00, 0x7F, 0xF8, 0x07, 0x00, 0x07, 0xFE, 0x01, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x73, 0xC1,
  0xE0, 0x1E, 0x70, 0x1C, 0x07, 0x9E, 0x03, 0xC0, 0xE3, 0xC0, 0x3C, 0x38,
  0x70, 0x07, 0x8F, 0x0E, 0x00, 0x79, 0xC1, 0xC0, 0x0F, 0x70, 0x38, 0x00,
  0xFE, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0xC0, 0xF0, 0x03, 0xFC, 0x1E, 0x00, 0xF3, 0x83, 0xE0, 0x3C,
  0x78, 0x3F, 0xFF, 0x07, 0x83, 0xFF, 0xC0, 0xF0, 0x3F, 0xE0, 0x0F, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0xF3, 0xCF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x1C,
  0xF3, 0xCF, 0x38, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x60, 0x0F, 0x00, 0x6F, 0x81, 0xC0, 0x7F, 0xFC,
  0x38, 0x7F, 0xBF, 0xE7, 0x3F, 0xF1, 0xFF, 0x5F, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF8, 0x03, 0x80, 0x0E, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF8, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x10, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x87,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x0E, 0x07,
  0x87, 0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x70, 0xF0, 0x7C, 0x1C, 0x3C, 0x1F,
  0x07, 0x0E, 0x03, 0x83, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xF7, 0x00,
  0x0F, 0xCE, 0x00, 0x3E, 0x3C, 0x01, 0xF8, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x20, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0x80, 0x3E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x3E, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xE1, 0xE0,
  0x01, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00,
  0x39, 0xE0, 0x00, 0x73, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x79,
  0xFF, 0xC0, 0x39, 0xFF, 0xF0, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x0F, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xCF, 0xE0, 0x07, 0xBF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1C, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x20, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xC0, 0x3E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x3C,
  0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xFF,
  0xF7, 0x00, 0x7F, 0xF7, 0x80, 0x0F, 0xE7, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x0F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFC, 0x01, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x01, 0xFC, 0xE1,
  0xE0, 0x1F, 0xFB, 0x87, 0x00, 0xFF, 0xEE, 0x1C, 0x07, 0x80, 0xF8, 0x70,
  0x1C, 0x01, 0xE1, 0xC0, 0x70, 0x07, 0x07, 0x03, 0xC0, 0x1C, 0x3C, 0x0E,
  0x00, 0x70, 0xF0, 0x38, 0x01, 0xC3, 0x80, 0xE0, 0x07, 0x0E, 0x03, 0x80,
  0x3C, 0x38, 0x1E, 0x00, 0xF0, 0xE0, 0x78, 0x03, 0x87, 0x81, 0xC0, 0x0E,
  0x1E, 0x07, 0x00, 0x38, 0x70, 0x1C, 0x01, 0xE1, 0xC0, 0x70, 0x07, 0x87,
  0x01, 0xE0, 0x3E, 0x1C, 0x07, 0x81, 0xB0, 0x70, 0x0F, 0xFF, 0xC3, 0xC0,
  0x3F, 0xF7, 0x0F, 0x00, 0x3F, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x1E, 0x00,
  0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x3C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3C, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0E, 0x00, 0xFC, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1E, 0x00, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1C, 0x00, 0x7C, 0x07,
  0x00, 0x0F, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x07, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x70, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x01, 0xF8, 0x07, 0x80,
  0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0x81, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x07,
  0x00, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x03, 0xFF, 0xC3, 0x81, 0xFF, 0xE3,
  0xC0, 0xFF, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x1E,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x70, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0,
  0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0x60, 0x03, 0xF0, 0x37, 0x00, 0x3F, 0x07, 0x70, 0x07,
  0x70, 0x77, 0x00, 0x77, 0x07, 0x70, 0x0E, 0x60, 0x73, 0x00, 0xEE, 0x07,
  0x30, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xF3, 0x83,
  0x9E, 0x0E, 0x18, 0x71, 0xC0, 0xE1, 0x87, 0x1C, 0x0E, 0x1C, 0xE1, 0xC0,
  0xE1, 0xCE, 0x1C, 0x0E, 0x1D, 0xC1, 0xC1, 0xE1, 0xDC, 0x3C, 0x1E, 0x0F,
  0x83, 0xC1, 0xC0, 0xF8, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x7C, 0x00, 0x38, 0x0F, 0x80, 0x07, 0x03, 0xF0, 0x00, 0xE0, 0x77, 0x00,
  0x1C, 0x0E, 0xE0, 0x07, 0x81, 0xDC, 0x00, 0xF0, 0x3B, 0x80, 0x1C, 0x07,
  0x78, 0x03, 0x80, 0xE7, 0x00, 0x70, 0x3C, 0xE0, 0x0E, 0x07, 0x9C, 0x03,
  0xC0, 0xE3, 0x80, 0x78, 0x1C, 0x38, 0x0F, 0x03, 0x87, 0x01, 0xC0, 0x70,
  0xE0, 0x38, 0x1E, 0x1C, 0x07, 0x03, 0xC3, 0xC0, 0xE0, 0x70, 0x38, 0x3C,
  0x0E, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0xE0, 0x38, 0x1C, 0x1C, 0x0F, 0x01,
  0xC3, 0x81, 0xE0, 0x38, 0x70, 0x38, 0x07, 0x1E, 0x07, 0x00, 0xE3, 0xC0,
  0xE0, 0x1E, 0x70, 0x1C, 0x01, 0xCE, 0x03, 0x80, 0x39, 0xC0, 0xF0, 0x07,
  0x38, 0x1E, 0x00, 0xE7, 0x03, 0x80, 0x0E, 0xE0, 0x70, 0x01, 0xF8, 0x0E,
  0x00, 0x3F, 0x01, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0xFC, 0x0F, 0x00, 0x0F,
  0x81, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7C, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0xFC, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x1E, 0x01,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x03, 0xC0, 0x78, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x0F,
  0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x38, 0x0F,
  0x00, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x70,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x07,
  0x80, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0xE0,
  0x0F, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07,
  0x80, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x01,
  0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x73, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x3B, 0xC0, 0x3C, 0x01, 0xDE, 0x01, 0xE0, 0x1E,
  0xE0, 0x1F, 0x00, 0xE7, 0x00, 0xF8, 0x07, 0x38, 0x06, 0xC0, 0x79, 0xC0,
  0x36, 0x03, 0x8E, 0x03, 0xB0, 0x1C, 0x70, 0x19, 0x80, 0xE3, 0x80, 0xCC,
  0x0F, 0x1C, 0x0E, 0x60, 0x70, 0xE0, 0x63, 0x03, 0x87, 0x03, 0x18, 0x1C,
  0x38, 0x38, 0xC1, 0xC1, 0xC1, 0xC6, 0x0E, 0x0E, 0x0C, 0x30, 0x70, 0x70,
  0x61, 0x87, 0x83, 0x87, 0x0C, 0x38, 0x1C, 0x30, 0x61, 0xC0, 0xE1, 0x87,
  0x0E, 0x07, 0x1C, 0x38, 0xE0, 0x38, 0xE1, 0xC7, 0x01, 0xC6, 0x0E, 0x38,
  0x0E, 0x30, 0x71, 0xC0, 0x73, 0x83, 0x9C, 0x03, 0x98, 0x1C, 0xE0, 0x3C,
  0xC0, 0xE7, 0x01, 0xCE, 0x07, 0x30, 0x0E, 0x60, 0x3B, 0x80, 0x73, 0x01,
  0x9C, 0x03, 0xB8, 0x0C, 0xE0, 0x1D, 0xC0, 0x6E, 0x00, 0xEC, 0x03, 0x70,
  0x07, 0x60, 0x1B, 0x80, 0x3F, 0x00, 0xDC, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x3C,
  0x70, 0x00, 0xE1, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x38,
  0x07, 0x80, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1E, 0x1C,
  0x00, 0x38, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x70, 0x3E, 0x00, 0x7F, 0x07, 0x01, 0xFF, 0xC7, 0x03, 0xFF,
  0xEF, 0x07, 0xC0, 0xFF, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00,
  0x1E, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00,
  0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0x70, 0x3F, 0xBF,
  0x70, 0x3F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0, 0x00, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x87, 0xF8, 0x03, 0xCF, 0xFE, 0x01, 0xEF, 0xFF, 0x80,
  0xFE, 0x03, 0xE0, 0x76, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01,
  0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x70, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x1F, 0x80, 0x7C, 0x1E,
  0xF9, 0xFC, 0x0F, 0x3F, 0xFC, 0x07, 0x8F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0x3E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x04,
  0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x1F, 0xC1, 0xC0, 0x1F, 0xFC, 0xF0, 0x0F, 0xFF, 0xBC, 0x07, 0xC0, 0xFF,
  0x03, 0xC0, 0x0F, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x37, 0x00,
  0xFE, 0xFD, 0xC0, 0x3F, 0xFC, 0xF0, 0x03, 0xFE, 0x3C, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03,
  0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF8, 0x07, 0xC0, 0xFE, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x07, 0x01, 0xFF, 0xC7, 0x03, 0xFF, 0xEF, 0x07, 0xC0, 0xFF,
  0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3E, 0x07, 0x70,
  0x3F, 0xFE, 0x70, 0x1F, 0xFC, 0x70, 0x07, 0xF0, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x0F, 0xF0,
  0x0F, 0x3F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0F, 0xE0, 0x3E, 0x0E, 0xC0, 0x1E,
  0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E,
  0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x80, 0x70, 0x01, 0xE0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01,
  0xC0, 0x78, 0x00, 0x38, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xC0,
  0x01, 0xE0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x0E, 0x3E, 0x1F, 0x81, 0xDF, 0xE7, 0xF8, 0x3F, 0xFD, 0xFF, 0x07, 0x83,
  0xA0, 0xF1, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC7, 0x01, 0xC0, 0x78,
  0xE0, 0x38, 0x0E, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0xF0, 0x1C,
  0x07, 0x1E, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x3C, 0x70, 0x1C, 0x07, 0x8E,
  0x03, 0x80, 0xE1, 0xC0, 0x70, 0x1C, 0x38, 0x0E, 0x03, 0x8F, 0x01, 0xC0,
  0x71, 0xC0, 0x70, 0x1E, 0x38, 0x0E, 0x03, 0xC7, 0x01, 0xC0, 0x70, 0xE0,
  0x38, 0x0E, 0x1C, 0x07, 0x01, 0xC7, 0x80, 0xE0, 0x38, 0xF0, 0x3C, 0x07,
  0x1C, 0x07, 0x01, 0xE3, 0x80, 0xE0, 0x38, 0x70, 0x1C, 0x07, 0x0E, 0x03,
  0x80, 0xE0, 0x07, 0x0F, 0xF0, 0x0F, 0x3F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0F,
  0xE0, 0x3E, 0x0E, 0xC0, 0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C,
  0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00,
  0x79, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x78,
  0x00, 0x78, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0x87, 0xF8, 0x01,
  0xE7, 0xFF, 0x00, 0x7B, 0xFF, 0xE0, 0x1F, 0xC0, 0x7C, 0x07, 0x60, 0x0F,
  0x01, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C,
  0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0xC0, 0x3E, 0x07, 0xBE, 0x7F, 0x01,
  0xE7, 0xFF, 0x80, 0x78, 0xFF, 0x80, 0x1C, 0x06, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x07, 0x01, 0xFF, 0xCF, 0x03, 0xFF, 0xEF, 0x07, 0xC0, 0xFF,
  0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x7C, 0x03, 0x70, 0x3F, 0xBE, 0x70, 0x3F, 0xFC, 0xF0,
  0x0F, 0xF8, 0xF0, 0x00, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x0F, 0xE0, 0x07, 0x9F, 0xFC,
  0x03, 0xDF, 0xFF, 0x01, 0xDC, 0x07, 0xC0, 0xFC, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00,
  0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00,
  0x3C, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00,
  0x70, 0x78, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01,
  0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x1C, 0x07,
  0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x1C,
  0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x03,
  0xE0, 0x3B, 0x80, 0xF8, 0x0E, 0xE0, 0x3E, 0x03, 0xB8, 0x1F, 0x81, 0xCE,
  0x06, 0xE0, 0x73, 0x81, 0xB8, 0x1C, 0xE0, 0xEE, 0x0F, 0x38, 0x33, 0x83,
  0x8E, 0x0C, 0xE0, 0xE3, 0x87, 0x18, 0x38, 0xE1, 0x86, 0x1C, 0x38, 0x61,
  0x87, 0x0E, 0x38, 0x61, 0xC3, 0x8C, 0x18, 0xE0, 0xE3, 0x06, 0x38, 0x39,
  0xC1, 0x8E, 0x0E, 0x60, 0x67, 0x03, 0x98, 0x19, 0xC0, 0xEE, 0x06, 0x70,
  0x33, 0x01, 0xB8, 0x0C, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x80, 0xD8, 0x07,
  0xC0, 0x36, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x00, 0x70, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x70, 0x00, 0xF8,
  0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x3E, 0x07, 0x70, 0x3F, 0xFE, 0x70,
  0x1F, 0xFC, 0x70, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0x8F,
  0xF8, 0x03, 0x8F, 0xFE, 0x01, 0xCF, 0x0F, 0x00, 0xE7, 0x03, 0xC0, 0x77,
  0x80, 0xF0, 0x73, 0xC0, 0x3C, 0x79, 0xC0, 0x1F, 0xF8, 0xE0, 0x07, 0xF8,
  0x70, 0x00, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 38, 31, 10, -38 },
  { 54, 17, 16, 31, 10, -38 },
  { 88, 30, 38, 31, 1, -38 },
  { 231, 26, 52, 31, 3, -45 },
  { 400, 35, 38, 31, -1, -38 },
  { 567, 27, 39, 31, 2, -38 },
  { 699, 6, 16, 31, 15, -38 },
  { 711, 21, 51, 31, 9, -44 },
  { 845, 20, 51, 31, 3, -44 },
  { 973, 27, 27, 31, 3, -32 },
  { 1065, 24, 24, 31, 4, -29 },
  { 1137, 12, 16, 31, 6, -8 },
  { 1161, 18, 3, 31, 7, -19 },
  { 1168, 8, 9, 31, 10, -8 },
  { 1177, 30, 49, 31, 1, -43 },
  { 1361, 26, 39, 31, 3, -38 },
  { 1488, 23, 38, 31, 3, -38 },
  { 1598, 26, 38, 31, 3, -38 },
  { 1722, 26, 39, 31, 3, -38 },
  { 1849, 23, 38, 31, 4, -38 },
  { 1959, 25, 39, 31, 4, -38 },
  { 2081, 24, 39, 31, 3, -38 },
  { 2198, 25, 38, 31, 6, -38 },
  { 2317, 26, 39, 31, 3, -38 },
  { 2444, 25, 38, 31, 5, -38 },
  { 2563, 12, 30, 31, 10, -29 },
  { 2608, 16, 37, 31, 6, -29 },
  { 2682, 24, 26, 31, 5, -30 },
  { 2760, 24, 15, 31, 4, -25 },
  { 2805, 24, 26, 31, 3, -30 },
  { 2883, 21, 38, 31, 8, -38 },
  { 2983, 30, 47, 31, 1, -38 },
  { 3160, 25, 38, 31, 1, -38 },
  { 3279, 26, 38, 31, 3, -38 },
  { 3403, 25, 39, 31, 4, -38 },
  { 3525, 26, 38, 31, 3, -38 },
  { 3649, 26, 38, 31, 4, -38 },
  { 3773, 28, 38, 31, 3, -38 },
  { 3906, 25, 39, 31, 4, -38 },
  { 4028, 27, 38, 31, 3, -38 },
  { 4157, 25, 38, 31, 4, -38 },
  { 4276, 27, 39, 31, 2, -38 },
  { 4408, 29, 38, 31, 3, -38 },
  { 4546, 22, 38, 31, 4, -38 },
  { 4651, 28, 38, 31, 2, -38 },
  { 4784, 27, 38, 31, 3, -38 },
  { 4913, 25, 39, 31, 4, -38 },
  { 5035, 28, 38, 31, 3, -38 },
  { 5168, 25, 47, 31, 4, -38 },
  { 5315, 27, 38, 31, 3, -38 },
  { 5444, 26, 39, 31, 3, -38 },
  { 5571, 26, 38, 31, 6, -38 },
  { 5695, 26, 39, 31, 4, -38 },
  { 5822, 25, 38, 31, 7, -38 },
  { 5941, 29, 38, 31, 4, -38 },
  { 6079, 32, 38, 31, 0, -38 },
  { 6231, 27, 38, 31, 6, -38 },
  { 6360, 28, 38, 31, 2, -38 },
  { 6493, 20, 49, 31, 8, -43 },
  { 6616, 15, 49, 31, 9, -43 },
  { 6708, 20, 49, 31, 5, -43 },
  { 6831, 22, 20, 31, 5, -38 },
  { 6886, 26, 3, 31, 0, 1 },
  { 6896, 9, 7, 31, 14, -41 },
  { 6904, 24, 30, 31, 4, -29 },
  { 6994, 25, 39, 31, 3, -38 },
  { 7116, 24, 30, 31, 4, -29 },
  { 7206, 26, 39, 31, 4, -38 },
  { 7333, 23, 30, 31, 4, -29 },
  { 7420, 34, 47, 31, -2, -38 },
  { 7620, 24, 38, 31, 4, -29 },
  { 7734, 24, 38, 31, 3, -38 },
  { 7848, 24, 40, 31, 2, -40 },
  { 7968, 26, 49, 31, 1, -40 },
  { 8128, 27, 38, 31, 3, -38 },
  { 8257, 20, 38, 31, 6, -38 },
  { 8352, 27, 29, 31, 2, -29 },
  { 8450, 24, 29, 31, 3, -29 },
  { 8537, 23, 30, 31, 4, -29 },
  { 8624, 26, 38, 31, 2, -29 },
  { 8748, 24, 38, 31, 4, -29 },
  { 8862, 25, 29, 31, 4, -29 },
  { 8953, 24, 30, 31, 3, -29 },
  { 9043, 24, 36, 31, 5, -36 },
  { 9151, 24, 30, 31, 4, -29 },
  { 9241, 24, 29, 31, 6, -29 },
  { 9328, 26, 29, 31, 5, -29 },
  { 9423, 28, 29, 31, 1, -29 },
  { 9525, 24, 38, 31, 4, -29 },
  { 9639, 25, 29, 31, 3, -29 },
  { 9730, 26, 49, 31, 5, -43 },
  { 9890, 11, 49, 31, 11, -43 },
  { 9958, 25, 49, 31, 2, -43 },
  { 10112, 25, 10, 31, 4, -23 },
};

const GFXfont JetBrainsMono_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC52PT7B_H_
