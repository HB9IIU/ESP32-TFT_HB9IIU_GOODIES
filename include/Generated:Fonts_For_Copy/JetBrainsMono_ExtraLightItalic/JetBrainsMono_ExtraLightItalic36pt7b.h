#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC36PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xF8, 0xF8, 0x70, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x76, 0x0E, 0xC1, 0xB8,
  0x37, 0x06, 0xE1, 0xD8, 0x3B, 0x06, 0x00, 0x00, 0x70, 0x30, 0x03, 0x03,
  0x80, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06,
  0x03, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x18, 0x0C, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x81,
  0xC0, 0x0C, 0x0C, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x30, 0x30, 0x03,
  0x81, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1C, 0xCF, 0x0E, 0x31,
  0xC3, 0x0C, 0x31, 0xC3, 0x0C, 0x70, 0x80, 0x1C, 0x60, 0x07, 0x18, 0x01,
  0xC6, 0x00, 0x3D, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0x78, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x30, 0x02, 0x0C, 0xE0, 0x83,
  0x38, 0x60, 0xCE, 0x18, 0x71, 0x86, 0x38, 0x79, 0x9C, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xF0, 0x03, 0x83, 0x9C, 0x03, 0x03, 0x86, 0x03, 0x01, 0x83,
  0x03, 0x00, 0xC1, 0x83, 0x00, 0x60, 0xC3, 0x80, 0x60, 0x61, 0x80, 0x30,
  0x31, 0x80, 0x1C, 0x31, 0x80, 0x06, 0x39, 0x80, 0x03, 0xF9, 0x80, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC7, 0x80,
  0x00, 0xCF, 0xF0, 0x00, 0xC6, 0x18, 0x00, 0xC6, 0x0C, 0x00, 0xE3, 0x06,
  0x00, 0x61, 0x83, 0x00, 0x61, 0xC1, 0x80, 0x60, 0xC0, 0xC0, 0x60, 0x60,
  0xE0, 0x60, 0x38, 0x60, 0x60, 0x0F, 0xE0, 0x70, 0x03, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xE0, 0x0F, 0xBC, 0x01, 0xC1, 0xC0, 0x70, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0E, 0x30, 0x19, 0x87,
  0x06, 0x70, 0x71, 0xCC, 0x0E, 0x71, 0x80, 0xEC, 0x30, 0x0F, 0x86, 0x01,
  0xE1, 0xC0, 0x18, 0x38, 0x07, 0x87, 0x01, 0xF8, 0x70, 0xF3, 0x0F, 0xFC,
  0x70, 0xFE, 0x07, 0x00, 0x76, 0xEE, 0xEE, 0xEC, 0xCC, 0xC0, 0x00, 0x0E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x80, 0xC0, 0x5C, 0x18, 0x7F, 0xF2,
  0x7F, 0x3F, 0x5F, 0x80, 0xFF, 0x00, 0x03, 0x00, 0x01, 0xB0, 0x00, 0x77,
  0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE0, 0xE0, 0x78, 0x1E, 0x06, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF,
  0xFF, 0x7B, 0xEF, 0xBE, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3C, 0x0E, 0x0E, 0x01, 0xC7, 0x00,
  0x71, 0x80, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18,
  0xC0, 0x06, 0x30, 0xE1, 0x8C, 0x78, 0x63, 0x0E, 0x39, 0xC3, 0x0E, 0x70,
  0x03, 0x9C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01,
  0xC6, 0x00, 0xE1, 0xC0, 0x38, 0x78, 0x3C, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xD8, 0x07, 0x18, 0x1E, 0x18, 0x18, 0x38,
  0x10, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x38,
  0x0E, 0x0C, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x0C, 0xE0, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x73,
  0x80, 0x18, 0xE0, 0x06, 0x38, 0x03, 0x86, 0x01, 0xC1, 0xC0, 0xE0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x01, 0x0E, 0x06, 0x1C, 0x06, 0x38, 0x06, 0x70, 0x06, 0x60, 0x0E,
  0xE0, 0x0E, 0xC0, 0x0C, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x19, 0xFC, 0x0D, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xE3,
  0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x61, 0xE0, 0xF0, 0x7F,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0xBE, 0x03, 0xFF, 0xC1, 0xE0, 0xF1, 0xC0, 0x38, 0xC0, 0x0C,
  0xE0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0x6E, 0x00,
  0x73, 0x00, 0x31, 0xC0, 0x38, 0xF0, 0x78, 0x3F, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x07, 0x18,
  0x01, 0x8E, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0x83, 0x00, 0xE0, 0xE0, 0x70,
  0x1C, 0x78, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x38, 0x70, 0x18,
  0x0E, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x01,
  0xCE, 0x00, 0x61, 0x80, 0x38, 0x70, 0x1C, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x3C, 0x0E, 0x30, 0x07, 0x70, 0x03,
  0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06,
  0xE0, 0x0E, 0x70, 0x1C, 0x7C, 0x7C, 0x3F, 0xD8, 0x0F, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x1F, 0x3F, 0x3E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0xF8, 0xF0, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0x10, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x1F, 0xC0, 0x7E, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xE3, 0xE0, 0x70, 0x0E,
  0x06, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x33, 0x80, 0x03, 0x30, 0x3F, 0xB3, 0x07, 0xDB, 0x30, 0x60, 0x73, 0x0E,
  0x06, 0x70, 0xC0, 0x67, 0x0C, 0x06, 0x60, 0xC0, 0x66, 0x0C, 0x06, 0x60,
  0xC0, 0xE6, 0x1C, 0x0C, 0xE1, 0x80, 0xCE, 0x1C, 0x1C, 0xC1, 0xC3, 0xCC,
  0x0F, 0xEC, 0xC0, 0x7C, 0xCC, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x07, 0x70, 0x03, 0x38, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1,
  0x80, 0x60, 0xC0, 0x70, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x18, 0x0E, 0x0C,
  0x03, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19,
  0xC0, 0x0C, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x70, 0xFF, 0xF8,
  0x3F, 0xF8, 0x0C, 0x1F, 0x83, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x1C,
  0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x86, 0x00,
  0xE1, 0x80, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x70, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xC0, 0xE1, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x06, 0x60,
  0x03, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x31, 0xC0, 0x38, 0x70,
  0x38, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xC0,
  0x78, 0x30, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x8C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x03, 0x86, 0x01, 0xC1, 0x81, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xC0, 0xE1, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x06,
  0x60, 0x03, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x83, 0xFC, 0xC3, 0xFE, 0x60, 0x07, 0x70, 0x03, 0x38,
  0x01, 0x9C, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x31, 0xC0, 0x38,
  0x70, 0x38, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x1C, 0x03, 0x83, 0xC0, 0xE0, 0x3F,
  0xF8, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0,
  0xC0, 0x18, 0x0C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x18, 0x1C, 0x01, 0x81, 0xC0, 0x18, 0x38, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0x07, 0x00, 0x30, 0x30, 0x03, 0x03, 0x80, 0x30, 0x38, 0x07, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xE0, 0x60,
  0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x01,
  0xE3, 0xC0, 0x3C, 0x68, 0x0D, 0x8D, 0x81, 0xB1, 0xB0, 0x6C, 0x36, 0x0D,
  0x86, 0xC3, 0x31, 0xC8, 0x66, 0x39, 0x99, 0xC6, 0x33, 0x38, 0xC6, 0xC6,
  0x18, 0xD8, 0xC3, 0x1E, 0x18, 0xE1, 0xC3, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC0,
  0x0F, 0x00, 0xE1, 0xE0, 0x18, 0x3C, 0x03, 0x07, 0x80, 0x61, 0xF8, 0x1C,
  0x3B, 0x03, 0x86, 0x60, 0x60, 0xCC, 0x0C, 0x19, 0x81, 0x83, 0x18, 0x30,
  0x63, 0x0E, 0x1C, 0x61, 0xC3, 0x8C, 0x38, 0x61, 0xC6, 0x0C, 0x18, 0xC1,
  0x83, 0x18, 0x30, 0x63, 0x0E, 0x0C, 0xE1, 0xC0, 0xDC, 0x30, 0x1B, 0x06,
  0x03, 0x60, 0xC0, 0x6C, 0x18, 0x0F, 0x87, 0x00, 0xF0, 0xE0, 0x1E, 0x18,
  0x03, 0x80, 0x00, 0x70, 0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xC0, 0xE1, 0xC0,
  0x30, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xCE, 0x00, 0x67, 0x00, 0x73, 0x00, 0x39, 0x80, 0x18, 0xC0, 0x0C,
  0x60, 0x06, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0xE6, 0x00,
  0x63, 0x00, 0x71, 0xC0, 0x30, 0x70, 0x78, 0x3F, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x07, 0x06, 0x00, 0x70, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x18,
  0x60, 0x07, 0x1C, 0x01, 0xC3, 0x83, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xC0, 0xE1, 0xC0,
  0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x98, 0x01, 0x9C,
  0x00, 0xCE, 0x00, 0x67, 0x00, 0x33, 0x00, 0x39, 0x80, 0x1C, 0xC0, 0x0C,
  0xE0, 0x06, 0x70, 0x03, 0x38, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xE6, 0x00,
  0x63, 0x00, 0x71, 0xC0, 0x30, 0x70, 0x78, 0x3F, 0xF8, 0x0F, 0xF0, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x0F, 0x06, 0x00, 0xE0, 0xC0,
  0x0C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x38, 0x60, 0x0E, 0x1C, 0x03, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0C, 0x1C,
  0x01, 0x81, 0x80, 0x30, 0x30, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C,
  0x06, 0x01, 0xC0, 0xC0, 0x38, 0x18, 0x03, 0x03, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1C, 0x0F,
  0x0E, 0x01, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0xE0, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x71, 0x80, 0x38, 0x78, 0x1C, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x30,
  0xC0, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0x81, 0xC1, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xDC, 0x00, 0xCE, 0x00,
  0x67, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x38, 0x60, 0x18, 0x30, 0x1C, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xE1, 0x80,
  0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x01, 0xB8,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x70,
  0x36, 0x07, 0x06, 0x60, 0xF0, 0x66, 0x0F, 0x06, 0x60, 0xB0, 0xE6, 0x1B,
  0x0C, 0x61, 0xB0, 0xCE, 0x13, 0x0C, 0xE3, 0x31, 0xCE, 0x33, 0x18, 0xE3,
  0x21, 0x8C, 0x22, 0x18, 0xC6, 0x23, 0x0C, 0x62, 0x30, 0xC4, 0x23, 0x0C,
  0xC2, 0x70, 0xCC, 0x26, 0x0C, 0x82, 0x60, 0xC8, 0x26, 0x0D, 0x82, 0xC0,
  0xD8, 0x2C, 0x0D, 0x02, 0xC0, 0xF0, 0x2C, 0x0F, 0x07, 0x80, 0xE0, 0x78,
  0x0E, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x07, 0x00,
  0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0xC0, 0x00, 0xE7, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x33, 0x00, 0x01,
  0xCC, 0x00, 0x0E, 0x38, 0x00, 0x30, 0x60, 0x01, 0x81, 0xC0, 0x0E, 0x03,
  0x00, 0x70, 0x0C, 0x01, 0x80, 0x38, 0x0E, 0x00, 0x60, 0x70, 0x01, 0xC3,
  0x80, 0x03, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x31, 0x80, 0x0E, 0x38, 0x01,
  0x83, 0x00, 0x70, 0x60, 0x1C, 0x0E, 0x03, 0x00, 0xC0, 0xE0, 0x18, 0x38,
  0x03, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x70, 0x00, 0xEC, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xC3, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x03, 0xFC,
  0x1F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x19, 0x80, 0x73, 0x00, 0xC6, 0x03, 0x8E, 0x0E,
  0x0C, 0x18, 0x18, 0x70, 0x30, 0xC0, 0x73, 0x80, 0x6E, 0x00, 0xD8, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE1, 0xC3, 0x0E, 0x1C, 0x03, 0xF3,
  0x0F, 0xFB, 0x1C, 0x1B, 0x38, 0x0F, 0x30, 0x07, 0x70, 0x07, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x1C, 0xF0, 0x7C, 0x7F, 0xDC,
  0x3F, 0x98, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x73, 0xF0, 0x33, 0xFC, 0x1B, 0x07, 0x0E, 0x01, 0x86,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE6, 0x00, 0x63, 0x80,
  0x71, 0xC0, 0x30, 0xF0, 0x38, 0xEF, 0xF8, 0x73, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xFC, 0x1E, 0x0E, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x02, 0xC0, 0x0C, 0xC0, 0x0C, 0xE0, 0x1C, 0x70, 0x38, 0x7F, 0xF0,
  0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x3F, 0x30, 0x3F, 0xEC, 0x1C, 0x1B, 0x0E, 0x03,
  0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x30, 0xC0,
  0x0C, 0x30, 0x07, 0x0E, 0x01, 0xC3, 0xC1, 0xF0, 0x7F, 0xDC, 0x0F, 0xE6,
  0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x06, 0x30, 0x07, 0x70,
  0x07, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x7F, 0xFE, 0xFF, 0xFE, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0xE0, 0x1C, 0x70,
  0x38, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF3, 0x0F, 0xFB, 0x1C, 0x1B, 0x38, 0x0F, 0x30, 0x07, 0x70,
  0x07, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x70, 0x3C, 0x7D, 0xEC, 0x3F,
  0xDC, 0x06, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x7F, 0xE0, 0xFF, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x73, 0xF0, 0x33, 0xFC, 0x1B, 0x07,
  0x0E, 0x01, 0x86, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0xE0, 0x0E, 0x18, 0x03, 0x83,
  0x00, 0xE0, 0x60, 0x38, 0x0C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0C,
  0x1C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x06, 0x0C, 0x01, 0xC1, 0xC0, 0x38,
  0x18, 0x07, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x07, 0x03, 0x00, 0x60, 0xE0,
  0x0E, 0x1C, 0x00, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x19, 0xE7, 0xC3, 0x7E, 0xFC, 0x71, 0xE3, 0x8C, 0x18, 0x31,
  0x83, 0x06, 0x70, 0xE1, 0xCC, 0x18, 0x31, 0x83, 0x06, 0x30, 0x60, 0xC6,
  0x0C, 0x18, 0xC1, 0x83, 0x38, 0x70, 0xE7, 0x0C, 0x1C, 0xC1, 0x83, 0x18,
  0x30, 0x63, 0x06, 0x0C, 0x60, 0xC1, 0x9C, 0x18, 0x73, 0x87, 0x0E, 0x60,
  0xC1, 0x80, 0x1C, 0xFC, 0x0C, 0xFF, 0x06, 0xC1, 0xC3, 0x80, 0x61, 0x80,
  0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C,
  0x60, 0x06, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x80, 0x03, 0xF8, 0x0F,
  0xFC, 0x1C, 0x0E, 0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xC0,
  0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x18, 0x70, 0x78, 0x7F, 0xF0, 0x3F,
  0xC0, 0x0E, 0x7E, 0x03, 0x3F, 0xC0, 0xD8, 0x38, 0x38, 0x06, 0x0C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x30, 0xE0,
  0x1C, 0x38, 0x06, 0x1F, 0x03, 0x87, 0x7F, 0xC1, 0xCF, 0xC0, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF3, 0x0F, 0xFB, 0x1C, 0x1B, 0x38, 0x0F, 0x30, 0x07, 0x70, 0x07,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x1C, 0xF0, 0x7C,
  0x7F, 0xDC, 0x3F, 0x98, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x18, 0xFC, 0x0D, 0xFF, 0x07, 0x83, 0xC7, 0x80,
  0xE3, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x83, 0x81, 0xC3, 0x80, 0x71, 0x80, 0x19, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x06, 0x38,
  0x0F, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x38, 0x03, 0x98, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE6,
  0x00, 0x63, 0x00, 0x31, 0xC0, 0x38, 0xE0, 0x18, 0x38, 0x3C, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0xC0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xCC, 0x00, 0xC6,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xE0, 0x30, 0x30, 0x38, 0x18, 0x18,
  0x0C, 0x1C, 0x06, 0x0C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0x67, 0x00, 0x33,
  0x00, 0x1B, 0x80, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0xE0,
  0xF8, 0x1C, 0x1B, 0x07, 0x83, 0x60, 0xF0, 0xEC, 0x16, 0x19, 0x86, 0xC3,
  0x30, 0xD8, 0xE6, 0x13, 0x18, 0xC6, 0x63, 0x18, 0xCC, 0xE3, 0x11, 0x98,
  0x66, 0x33, 0x0C, 0xC6, 0xE1, 0x90, 0xD8, 0x36, 0x1B, 0x06, 0xC3, 0x60,
  0xD0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x00, 0x1C, 0x00,
  0xE1, 0xC0, 0x38, 0x18, 0x06, 0x03, 0x81, 0xC0, 0x30, 0x70, 0x07, 0x1C,
  0x00, 0x67, 0x00, 0x0E, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3B, 0x80, 0x0E, 0x30, 0x03, 0x87, 0x00, 0x60, 0x60,
  0x1C, 0x0E, 0x07, 0x00, 0xC1, 0xC0, 0x1C, 0x70, 0x01, 0xC0, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x2C, 0x7D, 0xFC, 0x3F, 0x9C, 0x0C, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0x03,
  0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xBF, 0x81, 0xD8, 0xE0, 0xD8, 0x38, 0x6C, 0x0E, 0x76,
  0x03, 0xF3, 0x00, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 26, 22, 7, -26 },
  { 27, 11, 11, 22, 7, -26 },
  { 43, 21, 26, 22, 1, -26 },
  { 112, 18, 36, 22, 2, -31 },
  { 193, 25, 26, 22, -1, -26 },
  { 275, 19, 27, 22, 1, -27 },
  { 340, 4, 11, 22, 11, -26 },
  { 346, 15, 35, 22, 6, -30 },
  { 412, 14, 35, 22, 2, -30 },
  { 474, 19, 18, 22, 2, -22 },
  { 517, 17, 16, 22, 3, -20 },
  { 551, 8, 11, 22, 4, -5 },
  { 562, 12, 2, 22, 5, -13 },
  { 565, 6, 5, 22, 7, -5 },
  { 569, 21, 34, 22, 1, -30 },
  { 659, 18, 27, 22, 2, -27 },
  { 720, 16, 26, 22, 2, -26 },
  { 772, 18, 27, 22, 2, -27 },
  { 833, 18, 26, 22, 2, -26 },
  { 892, 16, 26, 22, 3, -26 },
  { 944, 17, 26, 22, 3, -26 },
  { 1000, 17, 26, 22, 2, -26 },
  { 1056, 18, 26, 22, 4, -26 },
  { 1115, 18, 27, 22, 2, -27 },
  { 1176, 16, 27, 22, 4, -27 },
  { 1230, 8, 20, 22, 7, -20 },
  { 1250, 11, 26, 22, 4, -20 },
  { 1286, 17, 18, 22, 3, -21 },
  { 1325, 16, 10, 22, 3, -17 },
  { 1345, 17, 18, 22, 2, -21 },
  { 1384, 14, 26, 22, 6, -26 },
  { 1430, 20, 33, 22, 1, -27 },
  { 1513, 17, 26, 22, 1, -26 },
  { 1569, 18, 26, 22, 2, -26 },
  { 1628, 17, 27, 22, 3, -27 },
  { 1686, 18, 26, 22, 2, -26 },
  { 1745, 19, 26, 22, 2, -26 },
  { 1807, 19, 26, 22, 2, -26 },
  { 1869, 17, 27, 22, 3, -27 },
  { 1927, 18, 26, 22, 2, -26 },
  { 1986, 17, 26, 22, 3, -26 },
  { 2042, 19, 26, 22, 1, -26 },
  { 2104, 20, 26, 22, 2, -26 },
  { 2169, 15, 26, 22, 3, -26 },
  { 2218, 19, 26, 22, 2, -26 },
  { 2280, 19, 26, 22, 2, -26 },
  { 2342, 17, 27, 22, 3, -27 },
  { 2400, 19, 26, 22, 2, -26 },
  { 2462, 17, 33, 22, 3, -27 },
  { 2533, 19, 26, 22, 2, -26 },
  { 2595, 18, 27, 22, 2, -27 },
  { 2656, 18, 26, 22, 4, -26 },
  { 2715, 18, 26, 22, 3, -26 },
  { 2774, 17, 26, 22, 5, -26 },
  { 2830, 20, 26, 22, 3, -26 },
  { 2895, 22, 26, 22, 0, -26 },
  { 2967, 19, 26, 22, 4, -26 },
  { 3029, 19, 26, 22, 2, -26 },
  { 3091, 13, 34, 22, 6, -30 },
  { 3147, 10, 34, 22, 6, -30 },
  { 3190, 14, 34, 22, 3, -30 },
  { 3250, 15, 14, 22, 4, -26 },
  { 3277, 18, 2, 22, 0, 1 },
  { 3282, 6, 5, 22, 10, -28 },
  { 3286, 16, 20, 22, 3, -20 },
  { 3326, 17, 26, 22, 2, -26 },
  { 3382, 16, 20, 22, 3, -20 },
  { 3422, 18, 26, 22, 3, -26 },
  { 3481, 16, 20, 22, 3, -20 },
  { 3521, 23, 32, 22, -1, -26 },
  { 3613, 16, 26, 22, 3, -20 },
  { 3665, 17, 26, 22, 2, -26 },
  { 3721, 16, 28, 22, 2, -28 },
  { 3777, 18, 34, 22, 1, -28 },
  { 3854, 19, 26, 22, 2, -26 },
  { 3916, 14, 26, 22, 4, -26 },
  { 3962, 19, 20, 22, 1, -20 },
  { 4010, 17, 20, 22, 2, -20 },
  { 4053, 16, 20, 22, 3, -20 },
  { 4093, 18, 26, 22, 1, -20 },
  { 4152, 16, 26, 22, 3, -20 },
  { 4204, 17, 20, 22, 3, -20 },
  { 4247, 17, 20, 22, 2, -20 },
  { 4290, 16, 25, 22, 4, -25 },
  { 4340, 17, 20, 22, 3, -20 },
  { 4383, 17, 20, 22, 4, -20 },
  { 4426, 19, 20, 22, 3, -20 },
  { 4474, 19, 20, 22, 1, -20 },
  { 4522, 16, 26, 22, 3, -20 },
  { 4574, 17, 20, 22, 2, -20 },
  { 4617, 17, 34, 22, 4, -30 },
  { 4690, 8, 34, 22, 7, -30 },
  { 4724, 18, 34, 22, 1, -30 },
  { 4801, 17, 7, 22, 3, -16 },
};

const GFXfont JetBrainsMono_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC36PT7B_H_
