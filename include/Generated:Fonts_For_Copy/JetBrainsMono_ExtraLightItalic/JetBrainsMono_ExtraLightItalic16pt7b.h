#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC16PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x22, 0x44, 0x40, 0x4C, 0x4A, 0x73, 0x19, 0x00, 0x04,
  0x82, 0x20, 0x88, 0x24, 0x37, 0xC4, 0x41, 0x20, 0x88, 0xFF, 0x09, 0x04,
  0x41, 0x30, 0x04, 0x04, 0x1E, 0x2B, 0x69, 0x48, 0x68, 0x38, 0x0C, 0x12,
  0x12, 0x92, 0x96, 0x7C, 0x10, 0x20, 0x18, 0x4A, 0x24, 0x89, 0x24, 0x4A,
  0x0D, 0x00, 0x80, 0x5E, 0x14, 0x89, 0x24, 0x4A, 0x1C, 0x0E, 0x08, 0x84,
  0x46, 0x01, 0x01, 0xC1, 0xA2, 0x8A, 0x46, 0x21, 0x11, 0x8F, 0x20, 0xEA,
  0x80, 0x04, 0x31, 0x08, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x83, 0x06,
  0x0C, 0x20, 0xC0, 0x81, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x18, 0x46,
  0x20, 0x08, 0x08, 0x08, 0xEB, 0x3C, 0x18, 0x2C, 0xC4, 0x08, 0x08, 0x08,
  0xFF, 0x10, 0x10, 0x10, 0x74, 0x48, 0x80, 0xFC, 0xF8, 0x00, 0xC0, 0x20,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x0C, 0x00, 0x1E, 0x23, 0x41, 0x41, 0x41, 0x5B, 0x5A, 0x82,
  0x82, 0x82, 0xC4, 0x78, 0x0C, 0x29, 0x92, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x30, 0x47, 0xF0, 0x1E, 0x23, 0x41, 0x41, 0x03, 0x02, 0x04, 0x08, 0x10,
  0x20, 0xC0, 0xFE, 0x3F, 0x03, 0x06, 0x08, 0x10, 0x1C, 0x02, 0x02, 0x02,
  0x82, 0x84, 0x78, 0x02, 0x0C, 0x10, 0x41, 0x04, 0x58, 0xE1, 0xFE, 0x0C,
  0x10, 0x20, 0x3F, 0x20, 0x20, 0x40, 0x5C, 0x66, 0x42, 0x02, 0x02, 0x82,
  0xC4, 0x78, 0x06, 0x18, 0x20, 0x82, 0x0F, 0x90, 0xC1, 0x83, 0x07, 0x13,
  0xC0, 0xFF, 0x82, 0x82, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x1E, 0x23, 0x61, 0x41, 0x22, 0x3C, 0x3C, 0x42, 0x82, 0x82, 0x84,
  0x78, 0x3C, 0x8E, 0x0C, 0x18, 0x30, 0xBF, 0x04, 0x10, 0x60, 0x82, 0x00,
  0x67, 0x00, 0x00, 0x0E, 0xC0, 0x39, 0xC0, 0x00, 0x00, 0x4C, 0x42, 0x21,
  0x00, 0x03, 0x0C, 0x30, 0x40, 0xE0, 0x18, 0x0C, 0x02, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x60, 0x20, 0x30, 0x10, 0x63, 0x18, 0x40, 0x38, 0x88, 0x18,
  0x10, 0x41, 0x8C, 0x10, 0x60, 0x01, 0x03, 0x00, 0x0F, 0x04, 0x22, 0x08,
  0x82, 0x47, 0x93, 0x24, 0x89, 0x22, 0x48, 0x92, 0x48, 0xF2, 0x00, 0x40,
  0x10, 0x03, 0x80, 0x06, 0x06, 0x0A, 0x0A, 0x1A, 0x12, 0x12, 0x22, 0x3F,
  0x41, 0x41, 0xC1, 0x3C, 0x22, 0x41, 0x41, 0x42, 0x7C, 0x46, 0x42, 0xC2,
  0x82, 0x84, 0xF8, 0x1E, 0x23, 0x61, 0x41, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x82, 0xC4, 0x78, 0x3C, 0x22, 0x63, 0x41, 0x43, 0x42, 0x42, 0x42, 0xC2,
  0x82, 0x84, 0xF8, 0x3F, 0x20, 0x20, 0x40, 0x40, 0x7E, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0xFE, 0x3F, 0x90, 0x08, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x23, 0x61, 0x41, 0x40, 0x40, 0x4E,
  0x42, 0x82, 0x82, 0xC4, 0x78, 0x21, 0x21, 0x61, 0x41, 0x42, 0x7E, 0x42,
  0x42, 0xC2, 0x82, 0x84, 0x84, 0x3F, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x10, 0xFC, 0x0F, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x84, 0x84, 0x78, 0x21, 0x90, 0x98, 0x88, 0xC4, 0x43, 0xC1,
  0x20, 0x98, 0xC4, 0x42, 0x21, 0x90, 0x40, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x07, 0xF0, 0x21, 0x63, 0x63, 0x55, 0x55, 0x59,
  0x5A, 0x82, 0x82, 0x82, 0x82, 0x86, 0x21, 0x21, 0x51, 0x51, 0x52, 0x52,
  0x4A, 0x4A, 0xCA, 0x8A, 0x8A, 0x84, 0x1E, 0x22, 0x61, 0x41, 0x43, 0x42,
  0x42, 0x42, 0x82, 0x82, 0xC4, 0x78, 0x3E, 0x23, 0x61, 0x41, 0x41, 0x42,
  0x7C, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x1E, 0x22, 0x61, 0x41, 0x41, 0x42,
  0x42, 0x42, 0x82, 0x82, 0xC4, 0x78, 0x08, 0x08, 0x04, 0x3C, 0x23, 0x61,
  0x41, 0x41, 0x42, 0x7C, 0x48, 0xC4, 0x84, 0x84, 0x86, 0x1E, 0x23, 0x61,
  0x40, 0x60, 0x30, 0x0C, 0x02, 0x02, 0x82, 0x86, 0x7C, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x21, 0x21, 0x41,
  0x41, 0x42, 0x42, 0x42, 0x42, 0xC2, 0x82, 0xC4, 0x78, 0x81, 0x82, 0x82,
  0xC4, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x60, 0x4C, 0xA6, 0x53,
  0x2A, 0xA9, 0x54, 0xAA, 0x99, 0x54, 0xAA, 0x55, 0x31, 0x18, 0x80, 0x20,
  0xC4, 0x21, 0x10, 0x48, 0x0A, 0x03, 0x00, 0xC0, 0x50, 0x12, 0x08, 0x84,
  0x33, 0x04, 0x81, 0x82, 0x46, 0x44, 0x48, 0x28, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x3F, 0x41, 0x02, 0x04, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40,
  0x80, 0xFE, 0x1E, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x3C, 0x00, 0x88, 0x84, 0x44, 0x42, 0x22, 0x23, 0x11, 0x10,
  0x1E, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82,
  0x3C, 0x00, 0x18, 0x62, 0x8A, 0x46, 0x18, 0x40, 0xFF, 0xC8, 0x80, 0x3D,
  0x62, 0x42, 0x42, 0x42, 0x82, 0x82, 0xC6, 0x7C, 0x20, 0x41, 0x02, 0xE6,
  0x28, 0x50, 0xA1, 0xC3, 0x07, 0x15, 0xC0, 0x1C, 0x62, 0x42, 0x40, 0x40,
  0x80, 0x82, 0xC4, 0x78, 0x01, 0x01, 0x01, 0x3D, 0x62, 0x42, 0x42, 0x42,
  0x82, 0x82, 0xC6, 0x7C, 0x1C, 0xC5, 0x0A, 0x17, 0xF0, 0x20, 0xE2, 0x78,
  0x01, 0xE0, 0x40, 0x08, 0x02, 0x03, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x3C, 0x00, 0x1D, 0x62, 0x42,
  0x42, 0x42, 0xC2, 0xC6, 0x7C, 0x04, 0x04, 0x04, 0x78, 0x20, 0x41, 0x82,
  0xE6, 0x28, 0x50, 0xA1, 0xC3, 0x06, 0x1C, 0x20, 0x0C, 0x08, 0x03, 0xC0,
  0x81, 0x02, 0x04, 0x18, 0x20, 0x47, 0xF0, 0x03, 0x01, 0x00, 0x1F, 0x22,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0xF0, 0x20, 0x20,
  0x60, 0x41, 0x42, 0x44, 0x48, 0x78, 0x48, 0x8C, 0x84, 0x86, 0xF0, 0x82,
  0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x0F, 0x3B, 0x92, 0x49, 0x29, 0x14,
  0x92, 0x49, 0x24, 0x92, 0xC9, 0x00, 0x5C, 0xC5, 0x0A, 0x14, 0x38, 0x60,
  0xC3, 0x84, 0x1C, 0xC5, 0x0A, 0x14, 0x30, 0x60, 0xE2, 0x78, 0x2E, 0x31,
  0x21, 0x21, 0x21, 0x61, 0x41, 0x62, 0x5C, 0x40, 0x40, 0xC0, 0x3D, 0x62,
  0x42, 0x42, 0x42, 0x82, 0x82, 0xC4, 0x7C, 0x04, 0x04, 0x04, 0x3E, 0x62,
  0x41, 0x43, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x3E, 0xC5, 0x02, 0x03, 0xC0,
  0xC0, 0xC3, 0x7C, 0x10, 0x43, 0xF9, 0x02, 0x04, 0x08, 0x20, 0x40, 0x80,
  0xE0, 0x41, 0x42, 0x42, 0x42, 0x42, 0xC2, 0x82, 0xC4, 0x78, 0x83, 0x0E,
  0x14, 0x64, 0x8B, 0x14, 0x28, 0x60, 0x88, 0xCC, 0xA6, 0x53, 0x2A, 0xA5,
  0x52, 0xA9, 0x98, 0xCC, 0x00, 0x20, 0x88, 0x84, 0x81, 0x80, 0x80, 0xA0,
  0xD8, 0x44, 0xC3, 0x00, 0x43, 0x42, 0x42, 0x42, 0x42, 0x82, 0xC6, 0x7C,
  0x04, 0x04, 0x0C, 0xF8, 0x7F, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0,
  0xFC, 0x0E, 0x10, 0x20, 0x41, 0x82, 0x04, 0x70, 0x10, 0x20, 0xC1, 0x02,
  0x04, 0x06, 0x00, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x4C, 0x80, 0x38,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x07, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x30,
  0x00, 0x71, 0x8B, 0x8E,
};

const GFXglyph JetBrainsMono_ExtraLightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 8, 16, 10, 1, -14 },
  { 42, 10, 12, 10, 0, -12 },
  { 57, 9, 12, 10, 0, -12 },
  { 71, 2, 5, 10, 5, -12 },
  { 73, 6, 16, 10, 3, -14 },
  { 85, 6, 16, 10, 1, -14 },
  { 97, 8, 8, 10, 1, -10 },
  { 105, 8, 7, 10, 1, -9 },
  { 112, 4, 5, 10, 2, -2 },
  { 115, 6, 1, 10, 2, -6 },
  { 116, 3, 2, 10, 3, -2 },
  { 117, 10, 15, 10, 0, -13 },
  { 136, 8, 12, 10, 1, -12 },
  { 148, 7, 12, 10, 1, -12 },
  { 159, 8, 12, 10, 1, -12 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 7, 12, 10, 1, -12 },
  { 194, 8, 12, 10, 1, -12 },
  { 206, 7, 12, 10, 1, -12 },
  { 217, 8, 12, 10, 2, -12 },
  { 229, 8, 12, 10, 1, -12 },
  { 241, 7, 12, 10, 2, -12 },
  { 252, 4, 9, 10, 3, -9 },
  { 257, 5, 12, 10, 2, -9 },
  { 265, 8, 8, 10, 1, -9 },
  { 273, 8, 5, 10, 1, -8 },
  { 278, 7, 8, 10, 1, -9 },
  { 285, 7, 12, 10, 2, -12 },
  { 296, 10, 15, 10, 0, -12 },
  { 315, 8, 12, 10, 0, -12 },
  { 327, 8, 12, 10, 1, -12 },
  { 339, 8, 12, 10, 1, -12 },
  { 351, 8, 12, 10, 1, -12 },
  { 363, 8, 12, 10, 1, -12 },
  { 375, 9, 12, 10, 1, -12 },
  { 389, 8, 12, 10, 1, -12 },
  { 401, 8, 12, 10, 1, -12 },
  { 413, 8, 12, 10, 1, -12 },
  { 425, 8, 12, 10, 1, -12 },
  { 437, 9, 12, 10, 1, -12 },
  { 451, 7, 12, 10, 1, -12 },
  { 462, 8, 12, 10, 1, -12 },
  { 474, 8, 12, 10, 1, -12 },
  { 486, 8, 12, 10, 1, -12 },
  { 498, 8, 12, 10, 1, -12 },
  { 510, 8, 15, 10, 1, -12 },
  { 525, 8, 12, 10, 1, -12 },
  { 537, 8, 12, 10, 1, -12 },
  { 549, 8, 12, 10, 2, -12 },
  { 561, 8, 12, 10, 1, -12 },
  { 573, 8, 12, 10, 2, -12 },
  { 585, 9, 12, 10, 1, -12 },
  { 599, 10, 12, 10, 0, -12 },
  { 614, 8, 12, 10, 2, -12 },
  { 626, 8, 12, 10, 1, -12 },
  { 638, 7, 15, 10, 2, -13 },
  { 652, 4, 15, 10, 3, -13 },
  { 660, 7, 15, 10, 1, -13 },
  { 674, 6, 7, 10, 2, -12 },
  { 680, 8, 1, 10, 0, 0 },
  { 681, 3, 3, 10, 4, -13 },
  { 683, 8, 9, 10, 1, -9 },
  { 692, 7, 12, 10, 1, -12 },
  { 703, 8, 9, 10, 1, -9 },
  { 712, 8, 12, 10, 1, -12 },
  { 724, 7, 9, 10, 1, -9 },
  { 732, 11, 15, 10, -1, -12 },
  { 753, 8, 12, 10, 1, -9 },
  { 765, 7, 12, 10, 1, -12 },
  { 776, 7, 12, 10, 1, -12 },
  { 787, 8, 15, 10, 0, -12 },
  { 802, 8, 12, 10, 1, -12 },
  { 814, 6, 12, 10, 2, -12 },
  { 823, 9, 9, 10, 0, -9 },
  { 834, 7, 9, 10, 1, -9 },
  { 842, 7, 9, 10, 1, -9 },
  { 850, 8, 12, 10, 0, -9 },
  { 862, 8, 12, 10, 1, -9 },
  { 874, 8, 9, 10, 1, -9 },
  { 883, 7, 9, 10, 1, -9 },
  { 891, 7, 11, 10, 2, -11 },
  { 901, 8, 9, 10, 1, -9 },
  { 910, 7, 9, 10, 2, -9 },
  { 918, 9, 9, 10, 1, -9 },
  { 929, 9, 9, 10, 0, -9 },
  { 940, 8, 12, 10, 1, -9 },
  { 952, 8, 9, 10, 1, -9 },
  { 961, 7, 15, 10, 2, -13 },
  { 975, 4, 15, 10, 3, -13 },
  { 983, 7, 15, 10, 1, -13 },
  { 997, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_ExtraLightItalic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC16PT7B_H_
