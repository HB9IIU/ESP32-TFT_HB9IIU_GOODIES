#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC29PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0x82,
  0x00, 0x00, 0x0E, 0x3C, 0xE0, 0x63, 0xF1, 0xF8, 0xD8, 0x6C, 0x36, 0x1B,
  0x0D, 0x84, 0x86, 0x00, 0x01, 0x83, 0x00, 0xC1, 0x00, 0x41, 0x80, 0x60,
  0xC0, 0x30, 0x40, 0x10, 0x64, 0xFF, 0xFC, 0x0C, 0x10, 0x04, 0x18, 0x06,
  0x0C, 0x03, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x03, 0xFF, 0xF0,
  0x60, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x08, 0x30, 0x0C, 0x18,
  0x00, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xF0, 0x3A, 0xE1,
  0x88, 0xC6, 0x23, 0x31, 0x8C, 0xC6, 0x03, 0x18, 0x0E, 0x40, 0x1D, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0x30, 0x08, 0xE0, 0x21, 0x80, 0x86,
  0xC2, 0x13, 0x18, 0xCE, 0x67, 0x1F, 0xF8, 0x3F, 0x80, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x30, 0xC6, 0x06, 0x08, 0x60, 0xC1,
  0x86, 0x18, 0x18, 0x63, 0x01, 0x86, 0x60, 0x18, 0x44, 0x01, 0x8C, 0x80,
  0x0F, 0x98, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x20, 0x01, 0x9F,
  0x80, 0x13, 0x18, 0x02, 0x20, 0x80, 0x62, 0x08, 0x0C, 0x61, 0x81, 0x86,
  0x18, 0x30, 0x61, 0x82, 0x07, 0x30, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0E,
  0x70, 0x30, 0x70, 0x60, 0x61, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0xCC, 0x03, 0x1C, 0x36, 0x18, 0xCC, 0x1B, 0x10,
  0x36, 0x60, 0x38, 0xC0, 0x61, 0x81, 0xE3, 0x07, 0x63, 0xBC, 0xC7, 0xE0,
  0xC0, 0x77, 0x66, 0x66, 0x64, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x00, 0xE0,
  0x02, 0x00, 0x08, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x1C, 0x21, 0xFE, 0x5F, 0x9F,
  0xF8, 0x03, 0x00, 0x0B, 0x00, 0x36, 0x00, 0xC6, 0x03, 0x0E, 0x0E, 0x0C,
  0x18, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x1E, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0xC0, 0xFF, 0xC0,
  0x7B, 0xFE, 0xE0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x38,
  0xE1, 0x81, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60,
  0x0D, 0x8E, 0x66, 0x39, 0x98, 0xC6, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x0C, 0xC0, 0x33, 0x00, 0xCE, 0x06, 0x1F, 0xF0, 0x3F, 0x80, 0x01, 0xE0,
  0x3C, 0x0E, 0xC1, 0x8C, 0x30, 0xC2, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x0E, 0x38, 0x30, 0x38,
  0xC0, 0x31, 0x80, 0x66, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8E, 0x0E, 0x1E, 0xF0, 0x3F, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0xC6, 0x06, 0x60, 0x26, 0x03, 0x30, 0x1B, 0xFF, 0xDF,
  0xFE, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x1F, 0xFC,
  0x7F, 0xF1, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xF8,
  0x3F, 0xF0, 0xE0, 0xC3, 0x03, 0x98, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0xC0, 0x33, 0x00, 0xCE, 0x06, 0x1E, 0xF0, 0x3F, 0x80, 0x00,
  0x70, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x1B, 0xC1, 0xFF, 0x9C, 0x0C, 0xC0, 0x36, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x36, 0x01, 0xB8, 0x18, 0xF7, 0x83, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x30, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x38,
  0xE1, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x0E, 0x1C,
  0x60, 0x1F, 0x00, 0x7C, 0x07, 0x38, 0x30, 0x31, 0x80, 0xCC, 0x01, 0xB0,
  0x04, 0xC0, 0x33, 0x00, 0xCE, 0x06, 0x1E, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x71, 0xC3, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x3B, 0x80, 0xC7, 0x0F, 0x0F, 0xF8, 0x1E, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x1E,
  0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x3E,
  0x38, 0x07, 0x87, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x10, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x80, 0x7F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x20, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x60, 0x02, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x70, 0xFC, 0x1C, 0x03,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x01, 0xFE, 0x01, 0xC3, 0x81, 0x80, 0xE1, 0x80, 0x31, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x60, 0x7B, 0x30, 0xF7, 0x98, 0x61, 0xCC, 0x60, 0xC6,
  0x30, 0x63, 0x18, 0x31, 0x0C, 0x19, 0x86, 0x0C, 0xC2, 0x06, 0x61, 0x86,
  0x30, 0xC5, 0x18, 0x7F, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x0D, 0x00, 0x34, 0x00, 0x98, 0x06, 0x60, 0x19, 0x80, 0xC6, 0x03, 0x18,
  0x18, 0x60, 0x61, 0x81, 0x02, 0x0C, 0x08, 0x3F, 0xF1, 0xFF, 0xC6, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0xE0, 0x0C, 0x1F, 0xF0, 0x7F,
  0xE1, 0x81, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x30,
  0x30, 0xFF, 0x87, 0xFE, 0x18, 0x1C, 0x60, 0x39, 0x80, 0x66, 0x01, 0x98,
  0x06, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xF0,
  0x38, 0xE1, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x06, 0xC0, 0x33, 0x00, 0xC6, 0x06, 0x1E, 0xF0, 0x3F, 0x80, 0x1F,
  0xE0, 0x7F, 0xC1, 0x81, 0x8C, 0x07, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x06, 0x30, 0x18, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x46,
  0x03, 0x10, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x0E, 0x3F, 0xE0, 0xFF, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0xFF, 0xC3, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xF1, 0xFF,
  0xE3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x38, 0xE1,
  0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x1F, 0x98, 0xFE, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x04,
  0xC0, 0x33, 0x00, 0xC6, 0x06, 0x1E, 0xF0, 0x3F, 0x80, 0x18, 0x0E, 0x30,
  0x18, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x18, 0x0C,
  0x30, 0x18, 0x7F, 0xF1, 0xFF, 0xE3, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18,
  0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x0C, 0x06,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x3F, 0xF8,
  0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0x80, 0x61,
  0x81, 0x83, 0xDF, 0x03, 0xF8, 0x00, 0x18, 0x07, 0x18, 0x0E, 0x18, 0x0C,
  0x30, 0x18, 0x30, 0x38, 0x30, 0x30, 0x30, 0x60, 0x30, 0xE0, 0x30, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0x61, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0,
  0x60, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x38,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x1A, 0x12, 0x1A, 0x12, 0x36, 0x12, 0x36, 0x33, 0x66,
  0x33, 0x66, 0x31, 0xC4, 0x31, 0xCC, 0x31, 0x8C, 0x20, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x40, 0x18, 0xC0, 0x18,
  0xC0, 0x18, 0x1C, 0x06, 0x38, 0x18, 0x50, 0x31, 0xA0, 0x63, 0x60, 0xC6,
  0xC1, 0x8D, 0x82, 0x19, 0x0C, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x08,
  0xC6, 0x11, 0x8C, 0x32, 0x18, 0x6C, 0x20, 0xD8, 0xC0, 0xB1, 0x81, 0xE3,
  0x03, 0xC6, 0x07, 0x0C, 0x0E, 0x00, 0x07, 0xF0, 0x38, 0xE1, 0x81, 0xC6,
  0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x20, 0x19, 0x80, 0x66,
  0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x01, 0xC6, 0x06, 0x1E, 0xF0, 0x3F, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x60,
  0x31, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C,
  0x40, 0x71, 0xFF, 0xC3, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xF0, 0x38, 0xE1, 0x81, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x03, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x6C,
  0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC6, 0x06, 0x1E, 0xF0, 0x3F, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x1F, 0xF0, 0x3F,
  0xF8, 0x60, 0x31, 0x80, 0x63, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x18, 0x06,
  0x30, 0x18, 0x40, 0x71, 0xFF, 0xC3, 0xFC, 0x06, 0x18, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x8C, 0x03,
  0x00, 0x07, 0xF0, 0x38, 0xE1, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x06, 0xC0, 0x13, 0x00, 0xCE, 0x07, 0x1E, 0xF8,
  0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x06, 0x30, 0x18, 0x60, 0x31,
  0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x20, 0x18,
  0xC0, 0x31, 0xC0, 0xC1, 0x81, 0x83, 0xDE, 0x03, 0xF8, 0x00, 0xC0, 0x1F,
  0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x01, 0x84, 0x06, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x06, 0x20,
  0x09, 0x80, 0x26, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0xC1, 0xB0, 0xE1, 0x98, 0x50, 0xCC, 0x28, 0x46, 0x3C, 0x63, 0x16, 0x31,
  0x8B, 0x18, 0x8D, 0x88, 0x46, 0xCC, 0x22, 0x66, 0x11, 0x33, 0x09, 0x99,
  0x04, 0x8D, 0x82, 0x46, 0xC3, 0x63, 0x41, 0xA1, 0x60, 0xD0, 0xB0, 0x68,
  0x58, 0x3C, 0x28, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x0C, 0x01, 0xC1, 0x80,
  0xE0, 0x60, 0x30, 0x18, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x19, 0x80,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03,
  0x60, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x30, 0x40, 0x1C, 0x18, 0x06, 0x06,
  0x03, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0xC0, 0x19,
  0x80, 0x61, 0x80, 0xC3, 0x03, 0x06, 0x0E, 0x06, 0x18, 0x0C, 0x60, 0x18,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0F, 0xC3, 0xF8, 0x00, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x0F,
  0xE1, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xC3, 0xF8,
  0x00, 0x03, 0x80, 0x38, 0x06, 0xC0, 0x6C, 0x0C, 0xC1, 0x84, 0x18, 0x63,
  0x06, 0x30, 0x66, 0x03, 0xC0, 0x30, 0xFF, 0xFC, 0xC3, 0x18, 0x70, 0x0F,
  0xCC, 0x7B, 0xA3, 0x83, 0x8C, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98,
  0x06, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x71, 0x81, 0xC7,
  0xBE, 0x0F, 0xD8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x19,
  0xF0, 0xFB, 0xC7, 0x07, 0x30, 0x19, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x01,
  0xB0, 0x09, 0x80, 0xCC, 0x06, 0xC0, 0x37, 0x01, 0xB8, 0x19, 0xF3, 0x8D,
  0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0x81, 0x8C, 0x06, 0x60, 0x19, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0xC0,
  0x31, 0x81, 0x87, 0xBC, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC1, 0xF9, 0x87, 0xBA, 0x1C, 0x1C, 0x30, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0xE1, 0x81, 0xC3, 0xDF, 0x03, 0xF6, 0x00, 0x07, 0xE0,
  0xF7, 0x8E, 0x0E, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6F, 0xFF, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0x30, 0x31, 0xE7, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x7F, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xCC, 0x7B, 0xA3, 0x83, 0x8C, 0x06, 0x60, 0x19, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x1C, 0x70,
  0xF0, 0xFE, 0xC1, 0xE6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x1F,
  0xF0, 0x7F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x19,
  0xF0, 0xFB, 0xC7, 0x07, 0x30, 0x19, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x01,
  0xB0, 0x19, 0x80, 0xCC, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x4C,
  0x06, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x01, 0xCC, 0x06, 0x18, 0x1C, 0x30, 0x70, 0x60, 0xC1,
  0x83, 0x03, 0x0C, 0x07, 0xF0, 0x0F, 0xE0, 0x18, 0x60, 0x30, 0xC0, 0xC0,
  0xC1, 0x81, 0xC3, 0x01, 0x86, 0x03, 0x8C, 0x03, 0x00, 0xFE, 0x0F, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0xFF, 0x0F, 0xF0, 0x37, 0xBC, 0x73, 0x5C, 0xC7, 0x19, 0x84,
  0x32, 0x18, 0x64, 0x30, 0xD8, 0x61, 0x30, 0xC6, 0x61, 0x0C, 0xC2, 0x19,
  0x8C, 0x32, 0x18, 0x6C, 0x30, 0xD8, 0x61, 0x30, 0xC6, 0x61, 0x0C, 0x33,
  0xE1, 0xF7, 0x8E, 0x0E, 0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03,
  0x60, 0x33, 0x01, 0x98, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0x98,
  0x0C, 0x07, 0xE0, 0xF7, 0x8E, 0x0E, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80,
  0x6C, 0x03, 0x60, 0x13, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x30, 0x31,
  0xEF, 0x07, 0xF0, 0x19, 0xF0, 0x7D, 0xE1, 0xC1, 0xC6, 0x03, 0x18, 0x0C,
  0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x98, 0x06,
  0x70, 0x19, 0xC0, 0xC7, 0xCE, 0x1B, 0xF0, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x0F, 0xCC, 0x7B, 0xA3, 0x83, 0x8C, 0x06, 0x60,
  0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30,
  0x0C, 0xC0, 0x71, 0x81, 0xC7, 0xBE, 0x0F, 0xD8, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x1B, 0xF0, 0x5D, 0xE3, 0x81, 0x8E, 0x07,
  0x30, 0x0C, 0xC0, 0x33, 0x01, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0xF3,
  0xCC, 0x06, 0x60, 0x33, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x6C, 0x03, 0x60, 0x39, 0xC7, 0x87, 0xF8, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x30, 0x0C, 0xC0, 0x33,
  0x01, 0x8C, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x31,
  0x80, 0xCC, 0x03, 0x30, 0x0C, 0xE0, 0x61, 0x81, 0x87, 0xBC, 0x0F, 0xE0,
  0xC0, 0x1D, 0x00, 0x66, 0x03, 0x18, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x0C,
  0x08, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x12, 0x00, 0x58,
  0x01, 0xC0, 0x07, 0x00, 0x83, 0x06, 0x1C, 0x38, 0x50, 0xE1, 0x42, 0x8D,
  0x1A, 0x24, 0x68, 0x91, 0x26, 0x4C, 0x91, 0x32, 0x44, 0x8B, 0x16, 0x28,
  0x58, 0xA1, 0x43, 0x87, 0x0C, 0x1C, 0x30, 0x60, 0x18, 0x06, 0x30, 0x18,
  0x30, 0x60, 0x61, 0xC0, 0x63, 0x00, 0xCC, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0D, 0x80, 0x33, 0x00, 0xE3, 0x01, 0x86, 0x06, 0x06, 0x18, 0x0C,
  0x60, 0x0C, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x88, 0x06, 0x60, 0x19, 0x80,
  0x66, 0x01, 0x98, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x18, 0x1C, 0x60,
  0xB0, 0xFE, 0x81, 0xE6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x1F,
  0xF0, 0x7F, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x3C, 0x01, 0xF0, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18,
  0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC3,
  0x0C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x01, 0xF0, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x0D, 0xF8, 0x36, 0x30, 0xF0, 0xE6, 0xC1, 0xFB, 0x01,
  0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 21, 17, 6, -21 },
  { 17, 9, 9, 17, 6, -21 },
  { 28, 17, 21, 17, 1, -21 },
  { 73, 14, 29, 17, 2, -25 },
  { 124, 20, 21, 17, -1, -21 },
  { 177, 15, 21, 17, 1, -21 },
  { 217, 4, 9, 17, 8, -21 },
  { 222, 12, 29, 17, 5, -25 },
  { 266, 12, 29, 17, 1, -25 },
  { 310, 15, 15, 17, 2, -18 },
  { 339, 14, 13, 17, 2, -16 },
  { 362, 7, 9, 17, 3, -4 },
  { 370, 10, 1, 17, 4, -10 },
  { 372, 5, 4, 17, 5, -4 },
  { 375, 16, 27, 17, 1, -24 },
  { 429, 14, 21, 17, 2, -21 },
  { 466, 12, 21, 17, 2, -21 },
  { 498, 15, 21, 17, 1, -21 },
  { 538, 14, 21, 17, 2, -21 },
  { 575, 13, 21, 17, 2, -21 },
  { 610, 14, 21, 17, 2, -21 },
  { 647, 13, 21, 17, 2, -21 },
  { 682, 13, 21, 17, 4, -21 },
  { 717, 14, 21, 17, 2, -21 },
  { 754, 14, 21, 17, 3, -21 },
  { 791, 7, 16, 17, 5, -16 },
  { 805, 9, 21, 17, 3, -16 },
  { 829, 13, 15, 17, 3, -17 },
  { 854, 14, 9, 17, 2, -14 },
  { 870, 13, 15, 17, 2, -17 },
  { 895, 11, 21, 17, 5, -21 },
  { 924, 17, 26, 17, 0, -21 },
  { 980, 14, 21, 17, 0, -21 },
  { 1017, 14, 21, 17, 2, -21 },
  { 1054, 14, 21, 17, 2, -21 },
  { 1091, 14, 21, 17, 2, -21 },
  { 1128, 15, 21, 17, 2, -21 },
  { 1168, 15, 21, 17, 2, -21 },
  { 1208, 14, 21, 17, 2, -21 },
  { 1245, 15, 21, 17, 2, -21 },
  { 1285, 14, 21, 17, 2, -21 },
  { 1322, 15, 21, 17, 1, -21 },
  { 1362, 16, 21, 17, 2, -21 },
  { 1404, 12, 21, 17, 2, -21 },
  { 1436, 16, 21, 17, 1, -21 },
  { 1478, 15, 21, 17, 2, -21 },
  { 1518, 14, 21, 17, 2, -21 },
  { 1555, 15, 21, 17, 2, -21 },
  { 1595, 14, 26, 17, 2, -21 },
  { 1641, 15, 21, 17, 2, -21 },
  { 1681, 14, 21, 17, 2, -21 },
  { 1718, 15, 21, 17, 3, -21 },
  { 1758, 15, 21, 17, 2, -21 },
  { 1798, 14, 21, 17, 4, -21 },
  { 1835, 17, 21, 17, 2, -21 },
  { 1880, 18, 21, 17, 0, -21 },
  { 1928, 15, 21, 17, 3, -21 },
  { 1968, 16, 21, 17, 1, -21 },
  { 2010, 11, 27, 17, 4, -24 },
  { 2048, 8, 27, 17, 5, -24 },
  { 2075, 11, 27, 17, 3, -24 },
  { 2113, 12, 11, 17, 3, -21 },
  { 2130, 14, 1, 17, 0, 1 },
  { 2132, 5, 4, 17, 8, -23 },
  { 2135, 14, 16, 17, 2, -16 },
  { 2163, 13, 21, 17, 2, -21 },
  { 2198, 14, 16, 17, 2, -16 },
  { 2226, 15, 21, 17, 2, -21 },
  { 2266, 13, 16, 17, 2, -16 },
  { 2292, 19, 26, 17, -1, -21 },
  { 2354, 14, 21, 17, 2, -16 },
  { 2391, 13, 21, 17, 2, -21 },
  { 2426, 14, 22, 17, 1, -22 },
  { 2465, 14, 27, 17, 1, -22 },
  { 2513, 15, 21, 17, 2, -21 },
  { 2553, 12, 21, 17, 3, -21 },
  { 2585, 15, 16, 17, 1, -16 },
  { 2615, 13, 16, 17, 2, -16 },
  { 2641, 13, 16, 17, 2, -16 },
  { 2667, 14, 21, 17, 1, -16 },
  { 2704, 14, 21, 17, 2, -16 },
  { 2741, 14, 16, 17, 2, -16 },
  { 2769, 13, 16, 17, 2, -16 },
  { 2795, 13, 20, 17, 3, -20 },
  { 2828, 14, 16, 17, 2, -16 },
  { 2856, 14, 16, 17, 3, -16 },
  { 2884, 14, 16, 17, 3, -16 },
  { 2912, 15, 16, 17, 1, -16 },
  { 2942, 14, 21, 17, 2, -16 },
  { 2979, 13, 16, 17, 2, -16 },
  { 3005, 14, 27, 17, 3, -24 },
  { 3053, 6, 27, 17, 6, -24 },
  { 3074, 14, 27, 17, 1, -24 },
  { 3122, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC29PT7B_H_
