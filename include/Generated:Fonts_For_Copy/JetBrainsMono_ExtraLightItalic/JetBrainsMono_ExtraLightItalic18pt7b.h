#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC18PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB6, 0x92, 0x40, 0x6C, 0xCC, 0x67, 0x39, 0x00, 0x04, 0x60,
  0x88, 0x21, 0x04, 0x43, 0xFE, 0x23, 0x04, 0x40, 0x88, 0x7F, 0x94, 0x40,
  0x88, 0x22, 0x04, 0x40, 0x02, 0x02, 0x01, 0x03, 0xE3, 0x59, 0x24, 0x90,
  0x48, 0x38, 0x0F, 0x02, 0xC1, 0x20, 0x94, 0x4B, 0x48, 0xF8, 0x10, 0x08,
  0x04, 0x00, 0x3C, 0x32, 0x44, 0x44, 0xC4, 0x48, 0x4D, 0x03, 0xA0, 0x04,
  0x00, 0x9C, 0x12, 0x41, 0x44, 0x24, 0x44, 0x44, 0x83, 0x80, 0x1F, 0x18,
  0x88, 0x44, 0x02, 0x01, 0x81, 0x61, 0x13, 0x8D, 0x43, 0x21, 0x91, 0xCF,
  0x10, 0x57, 0x80, 0x06, 0x18, 0x41, 0x82, 0x0C, 0x10, 0x20, 0x40, 0x83,
  0x06, 0x0C, 0x08, 0x10, 0x10, 0x18, 0x10, 0x18, 0x10, 0x30, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x04, 0x10, 0xC0, 0x04, 0x02, 0x03,
  0x1D, 0x33, 0xF0, 0xC0, 0xD0, 0x4C, 0x42, 0x00, 0x04, 0x06, 0x02, 0x0F,
  0xFF, 0xF8, 0x40, 0x20, 0x30, 0x33, 0x64, 0x48, 0xFC, 0x7F, 0x80, 0x00,
  0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x1F,
  0x18, 0xC8, 0x2C, 0x14, 0x0A, 0x4D, 0x34, 0x82, 0x41, 0x60, 0xB0, 0xC8,
  0x47, 0xC0, 0x0E, 0x1E, 0x24, 0x44, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0x1F, 0x10, 0xD8, 0x20, 0x10, 0x18, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x0F, 0xF0, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xF0, 0x0C, 0x02, 0x01, 0x00, 0xA0, 0x98, 0xC7, 0xC0, 0x01, 0x81, 0x01,
  0x01, 0x81, 0x80, 0x88, 0x84, 0x82, 0x41, 0x7F, 0x80, 0x80, 0x40, 0x20,
  0x3F, 0x90, 0x08, 0x04, 0x02, 0xC3, 0x99, 0x84, 0x02, 0x01, 0x00, 0xB0,
  0xC8, 0x47, 0xC0, 0x02, 0x04, 0x08, 0x18, 0x10, 0x3E, 0x63, 0x41, 0xC1,
  0x81, 0x81, 0x42, 0x7C, 0x7F, 0xA0, 0xB0, 0x40, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x00, 0x1F, 0x18, 0xC8, 0x24, 0x12,
  0x10, 0xB0, 0x70, 0x44, 0x41, 0x60, 0xA0, 0x58, 0x47, 0xC0, 0x3E, 0x43,
  0xC1, 0x81, 0x81, 0x83, 0xC6, 0x7C, 0x0C, 0x08, 0x10, 0x20, 0x60, 0x33,
  0x20, 0x00, 0x00, 0xEE, 0x18, 0x61, 0x00, 0x00, 0x00, 0x0C, 0x31, 0x84,
  0x10, 0x80, 0x01, 0x03, 0x0C, 0x30, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x60, 0x18, 0x06, 0x03,
  0x03, 0x0E, 0x30, 0xC0, 0x80, 0x7C, 0x08, 0x18, 0x30, 0x41, 0x9E, 0x20,
  0x40, 0x00, 0x06, 0x0C, 0x00, 0x0F, 0xC2, 0x08, 0x81, 0x90, 0x32, 0x3C,
  0xC8, 0x91, 0x12, 0x62, 0x48, 0x49, 0x09, 0x23, 0x63, 0xCC, 0x00, 0x80,
  0x18, 0x01, 0xE0, 0x03, 0x02, 0x81, 0x41, 0xA0, 0x90, 0x48, 0x44, 0x22,
  0x3F, 0x10, 0xD8, 0x68, 0x1C, 0x08, 0x3F, 0x10, 0xC8, 0x24, 0x16, 0x12,
  0x19, 0xF8, 0x82, 0x41, 0x20, 0xB0, 0x50, 0x4F, 0xC0, 0x1F, 0x18, 0xC8,
  0x2C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xB0, 0xC8, 0x47, 0xC0,
  0x3F, 0x10, 0x88, 0x64, 0x16, 0x1A, 0x09, 0x04, 0x82, 0x41, 0x20, 0xB0,
  0x90, 0xCF, 0x80, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x18, 0x07, 0xF1,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xFF, 0x00, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x00, 0x1F, 0x18, 0xC8, 0x2C, 0x06, 0x02, 0x01, 0x3C, 0x9E, 0x41, 0x20,
  0xB0, 0xC8, 0x47, 0xC0, 0x20, 0x90, 0x48, 0x24, 0x36, 0x1A, 0x09, 0xFC,
  0x82, 0x41, 0x20, 0xB0, 0xD0, 0x48, 0x20, 0x3F, 0x82, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x0F, 0xE0, 0x0F, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x41, 0xA0, 0x98, 0xC7,
  0xC0, 0x20, 0xC8, 0x22, 0x10, 0x8C, 0x62, 0x11, 0x07, 0xC1, 0x10, 0x46,
  0x10, 0x8C, 0x22, 0x0C, 0x81, 0x00, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0xFF, 0x30, 0xCC, 0x65, 0x19, 0x4A,
  0x52, 0x93, 0x24, 0xD1, 0x04, 0xC1, 0x20, 0x48, 0x12, 0x04, 0x83, 0x00,
  0x30, 0x98, 0x4C, 0x27, 0x16, 0x9A, 0x49, 0x24, 0x92, 0x45, 0x22, 0xB1,
  0xD0, 0xC8, 0x60, 0x1F, 0x18, 0xC8, 0x2C, 0x16, 0x1A, 0x09, 0x04, 0x82,
  0x41, 0x20, 0xB0, 0xC8, 0x47, 0xC0, 0x3F, 0x08, 0x22, 0x0C, 0x82, 0x60,
  0x90, 0x67, 0xF1, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x00, 0x1F,
  0x18, 0xC8, 0x2C, 0x14, 0x1A, 0x09, 0x04, 0x82, 0x41, 0x60, 0xB0, 0xC8,
  0x47, 0xC0, 0x60, 0x10, 0x0C, 0x3F, 0x10, 0xC8, 0x24, 0x16, 0x0A, 0x09,
  0xF8, 0x88, 0x44, 0x23, 0x30, 0x90, 0x48, 0x30, 0x1F, 0x10, 0xC8, 0x24,
  0x02, 0x01, 0x80, 0x38, 0x06, 0x01, 0x00, 0xA0, 0x58, 0x47, 0xC0, 0xFF,
  0x84, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04,
  0x02, 0x00, 0x20, 0x90, 0x48, 0x24, 0x16, 0x1A, 0x09, 0x04, 0x82, 0x41,
  0x20, 0x90, 0xC8, 0x47, 0xC0, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x31,
  0x10, 0x88, 0x48, 0x34, 0x0C, 0x06, 0x03, 0x00, 0x44, 0x53, 0x14, 0xC5,
  0x32, 0x4C, 0x95, 0x25, 0x49, 0x54, 0x65, 0x19, 0x46, 0x62, 0x98, 0xC6,
  0x00, 0x30, 0x62, 0x18, 0x62, 0x04, 0x80, 0xB0, 0x0C, 0x01, 0x00, 0x50,
  0x1A, 0x02, 0x20, 0x84, 0x20, 0xCC, 0x08, 0x80, 0xA0, 0x90, 0xC8, 0x42,
  0x41, 0x60, 0xA0, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x00, 0x3F, 0x80,
  0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x0F,
  0xF0, 0x3E, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x40, 0xF0, 0x86, 0x10, 0x84, 0x30, 0x84, 0x21, 0x0C, 0x21,
  0x08, 0x61, 0x08, 0x3E, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x08, 0xF0, 0x0C, 0x28, 0x51, 0x26, 0x28, 0x60,
  0x80, 0xFF, 0x80, 0xCC, 0x1F, 0x90, 0xD8, 0x48, 0x24, 0x12, 0x09, 0x05,
  0x86, 0x46, 0x3D, 0x00, 0x20, 0x10, 0x08, 0x05, 0xC7, 0x13, 0x09, 0x04,
  0x82, 0x41, 0x20, 0xB0, 0xD8, 0x4B, 0xC0, 0x1E, 0x10, 0x98, 0x48, 0x04,
  0x02, 0x01, 0x01, 0x86, 0x42, 0x3E, 0x00, 0x00, 0x80, 0x40, 0x23, 0xF2,
  0x1B, 0x09, 0x04, 0x82, 0x41, 0x20, 0xB0, 0xC8, 0xC7, 0xA0, 0x1E, 0x21,
  0x41, 0x41, 0x7F, 0x40, 0x40, 0xC1, 0x42, 0x7C, 0x01, 0xF0, 0x30, 0x02,
  0x00, 0x20, 0x1F, 0xE0, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x0F, 0x80, 0x1F, 0x90, 0xD8, 0x48,
  0x24, 0x12, 0x09, 0x0C, 0x86, 0x7E, 0x01, 0x00, 0x80, 0xC7, 0xC0, 0x20,
  0x10, 0x08, 0x07, 0xC6, 0x13, 0x09, 0x04, 0x82, 0x41, 0x20, 0xB0, 0xD0,
  0x48, 0x20, 0x06, 0x06, 0x00, 0x00, 0x3C, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x08, 0xFF, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xF0, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0xF8, 0x00,
  0x20, 0x10, 0x08, 0x04, 0x16, 0x12, 0x11, 0x10, 0xF8, 0x4C, 0x22, 0x11,
  0x98, 0x48, 0x30, 0xF0, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x83, 0x03, 0xE0, 0x7B, 0xA6, 0x52, 0x29, 0x1C, 0x9C, 0x4A, 0x25, 0x32,
  0x91, 0x48, 0x80, 0x3E, 0x30, 0x98, 0x48, 0x24, 0x12, 0x09, 0x05, 0x86,
  0x82, 0x41, 0x00, 0x1E, 0x21, 0x61, 0x41, 0x41, 0x41, 0x41, 0xC3, 0x42,
  0x7C, 0x3E, 0x30, 0x98, 0x48, 0x24, 0x12, 0x09, 0x05, 0x86, 0xC2, 0x5E,
  0x20, 0x10, 0x08, 0x00, 0x1F, 0x90, 0x98, 0x48, 0x24, 0x12, 0x09, 0x05,
  0x86, 0x46, 0x3D, 0x00, 0x80, 0x40, 0x60, 0x2F, 0x18, 0xC8, 0x6C, 0x34,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x00, 0x1F, 0x10, 0x90, 0x0C, 0x03,
  0x80, 0x70, 0x04, 0x02, 0xC2, 0x3F, 0x00, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x21, 0xB0, 0xD0, 0x48,
  0x24, 0x12, 0x09, 0x04, 0x86, 0x42, 0x3E, 0x00, 0x81, 0x83, 0xC2, 0x46,
  0x44, 0x4C, 0x48, 0x58, 0x30, 0x30, 0x98, 0xCC, 0xA6, 0x55, 0x2A, 0xA5,
  0x53, 0x29, 0x98, 0xCC, 0x46, 0x00, 0x30, 0xC4, 0x21, 0x90, 0x28, 0x06,
  0x03, 0x01, 0xA0, 0x48, 0x21, 0x30, 0x60, 0x61, 0xA0, 0x90, 0x48, 0x24,
  0x12, 0x09, 0x0C, 0x84, 0x7E, 0x01, 0x00, 0x80, 0xC7, 0xC0, 0x3F, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0x00, 0x03, 0x82,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0xF0, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x20, 0x1C, 0x00, 0x32, 0x22, 0x22, 0x64, 0x44, 0x44,
  0xC8, 0x88, 0x80, 0x38, 0x0C, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x07,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x70, 0xA4, 0x71, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 4, -13 },
  { 10, 11, 13, 11, 0, -13 },
  { 28, 9, 19, 11, 1, -16 },
  { 50, 12, 13, 11, 0, -13 },
  { 70, 9, 13, 11, 1, -13 },
  { 85, 2, 5, 11, 5, -13 },
  { 87, 7, 17, 11, 3, -15 },
  { 102, 7, 17, 11, 1, -15 },
  { 117, 9, 9, 11, 1, -11 },
  { 128, 9, 8, 11, 1, -10 },
  { 137, 4, 6, 11, 2, -3 },
  { 140, 6, 1, 11, 3, -6 },
  { 141, 3, 3, 11, 3, -3 },
  { 143, 11, 17, 11, 0, -15 },
  { 167, 9, 13, 11, 1, -13 },
  { 182, 8, 13, 11, 1, -13 },
  { 195, 9, 13, 11, 1, -13 },
  { 210, 9, 13, 11, 1, -13 },
  { 225, 9, 13, 11, 1, -13 },
  { 240, 9, 13, 11, 1, -13 },
  { 255, 8, 13, 11, 1, -13 },
  { 268, 9, 13, 11, 2, -13 },
  { 283, 9, 13, 11, 1, -13 },
  { 298, 8, 13, 11, 2, -13 },
  { 311, 4, 10, 11, 3, -10 },
  { 316, 6, 13, 11, 2, -10 },
  { 326, 8, 10, 11, 2, -11 },
  { 336, 9, 6, 11, 1, -9 },
  { 343, 8, 10, 11, 1, -11 },
  { 353, 7, 13, 11, 3, -13 },
  { 365, 11, 16, 11, 0, -13 },
  { 387, 9, 13, 11, 0, -13 },
  { 402, 9, 13, 11, 1, -13 },
  { 417, 9, 13, 11, 1, -13 },
  { 432, 9, 13, 11, 1, -13 },
  { 447, 10, 13, 11, 1, -13 },
  { 464, 10, 13, 11, 1, -13 },
  { 481, 9, 13, 11, 1, -13 },
  { 496, 9, 13, 11, 1, -13 },
  { 511, 9, 13, 11, 1, -13 },
  { 526, 9, 13, 11, 1, -13 },
  { 541, 10, 13, 11, 1, -13 },
  { 558, 8, 13, 11, 1, -13 },
  { 571, 10, 13, 11, 1, -13 },
  { 588, 9, 13, 11, 1, -13 },
  { 603, 9, 13, 11, 1, -13 },
  { 618, 10, 13, 11, 1, -13 },
  { 635, 9, 16, 11, 1, -13 },
  { 653, 9, 13, 11, 1, -13 },
  { 668, 9, 13, 11, 1, -13 },
  { 683, 9, 13, 11, 2, -13 },
  { 698, 9, 13, 11, 1, -13 },
  { 713, 9, 13, 11, 2, -13 },
  { 728, 10, 13, 11, 1, -13 },
  { 745, 11, 13, 11, 0, -13 },
  { 763, 9, 13, 11, 2, -13 },
  { 778, 9, 13, 11, 1, -13 },
  { 793, 7, 17, 11, 3, -15 },
  { 808, 5, 17, 11, 3, -15 },
  { 819, 7, 17, 11, 2, -15 },
  { 834, 7, 7, 11, 2, -13 },
  { 841, 9, 1, 11, 0, 0 },
  { 843, 3, 2, 11, 5, -14 },
  { 844, 9, 10, 11, 1, -10 },
  { 856, 9, 13, 11, 1, -13 },
  { 871, 9, 10, 11, 1, -10 },
  { 883, 9, 13, 11, 1, -13 },
  { 898, 8, 10, 11, 1, -10 },
  { 908, 12, 16, 11, -1, -13 },
  { 932, 9, 13, 11, 1, -10 },
  { 947, 9, 13, 11, 1, -13 },
  { 962, 8, 14, 11, 1, -14 },
  { 976, 9, 17, 11, 0, -14 },
  { 996, 9, 13, 11, 1, -13 },
  { 1011, 7, 13, 11, 2, -13 },
  { 1023, 9, 10, 11, 1, -10 },
  { 1035, 9, 10, 11, 1, -10 },
  { 1047, 8, 10, 11, 1, -10 },
  { 1057, 9, 13, 11, 1, -10 },
  { 1072, 9, 13, 11, 1, -10 },
  { 1087, 9, 10, 11, 1, -10 },
  { 1099, 9, 10, 11, 1, -10 },
  { 1111, 8, 13, 11, 2, -13 },
  { 1124, 9, 10, 11, 1, -10 },
  { 1136, 8, 10, 11, 2, -10 },
  { 1146, 9, 10, 11, 2, -10 },
  { 1158, 10, 10, 11, 0, -10 },
  { 1171, 9, 13, 11, 1, -10 },
  { 1186, 9, 10, 11, 1, -10 },
  { 1198, 9, 17, 11, 2, -15 },
  { 1218, 4, 17, 11, 4, -15 },
  { 1227, 8, 17, 11, 1, -15 },
  { 1244, 9, 3, 11, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC18PT7B_H_
