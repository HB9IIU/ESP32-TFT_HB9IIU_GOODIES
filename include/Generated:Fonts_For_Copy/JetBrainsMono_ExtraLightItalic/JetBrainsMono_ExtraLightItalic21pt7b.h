#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC21PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x63, 0x18, 0x84, 0x21, 0x08, 0x00, 0x73, 0x80, 0x66,
  0x8B, 0x16, 0x2C, 0xD1, 0x80, 0x02, 0x10, 0x11, 0x81, 0x08, 0x08, 0x43,
  0xFF, 0x84, 0x20, 0x21, 0x03, 0x18, 0x10, 0x80, 0x84, 0x3F, 0xF8, 0x42,
  0x02, 0x10, 0x31, 0x01, 0x08, 0x00, 0x01, 0x00, 0x20, 0x0C, 0x07, 0xE1,
  0x24, 0x64, 0xC8, 0x99, 0x10, 0x34, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x4C,
  0x09, 0xB1, 0x36, 0x44, 0x69, 0x87, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x1F,
  0x06, 0x22, 0x10, 0x44, 0x41, 0x89, 0x03, 0x16, 0x03, 0xC8, 0x03, 0x20,
  0x00, 0x80, 0x02, 0x70, 0x09, 0x30, 0x36, 0x20, 0xC8, 0x41, 0x11, 0x84,
  0x22, 0x30, 0x38, 0x00, 0x02, 0x01, 0xF0, 0x43, 0x18, 0x63, 0x00, 0x60,
  0x04, 0x01, 0xC0, 0x6C, 0x78, 0x8B, 0x1A, 0x41, 0xC8, 0x31, 0x06, 0x31,
  0x23, 0xC6, 0x6B, 0x6D, 0x00, 0x01, 0x07, 0x0C, 0x10, 0x30, 0x20, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60,
  0x38, 0x08, 0x10, 0x1C, 0x06, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x03,
  0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x0C, 0x08, 0x30, 0xE0, 0x80, 0x02,
  0x00, 0x40, 0x18, 0x23, 0x1F, 0x4E, 0x3F, 0x03, 0x00, 0xD0, 0x33, 0x0C,
  0x21, 0x06, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x30,
  0x18, 0x08, 0x00, 0x19, 0x8C, 0xC6, 0x60, 0xFF, 0xFC, 0x7F, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x00, 0x03, 0x01, 0xF8, 0x41, 0x18, 0x32, 0x06, 0x40,
  0x98, 0x13, 0x32, 0x6E, 0x48, 0x19, 0x03, 0x20, 0x64, 0x08, 0x83, 0x18,
  0xC1, 0xF0, 0x07, 0x06, 0x8C, 0xC4, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x23, 0xFE, 0x03, 0x03, 0xF8, 0xC1, 0x10,
  0x36, 0x06, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x07, 0xFC, 0x1F, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x60, 0x4C, 0x18, 0xC6,
  0x0F, 0x80, 0x01, 0x81, 0x81, 0x81, 0x80, 0x80, 0x80, 0xC6, 0xC3, 0xC1,
  0x40, 0xBF, 0xDF, 0xE0, 0x30, 0x18, 0x08, 0x1F, 0xE2, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x5F, 0x0C, 0x61, 0x06, 0x40, 0xC0, 0x18, 0x02, 0x00, 0x44,
  0x18, 0xC6, 0x0F, 0x80, 0x01, 0x80, 0x80, 0x60, 0x30, 0x08, 0x04, 0x03,
  0xF9, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x02, 0x40, 0x98, 0xC3, 0xE0, 0xFF,
  0xE0, 0x28, 0x1A, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x0C, 0x00, 0x03, 0x01, 0xF8, 0x41, 0x18, 0x32,
  0x04, 0x60, 0x84, 0x20, 0x78, 0x0F, 0x06, 0x31, 0x82, 0x20, 0x6C, 0x09,
  0x81, 0x18, 0x41, 0xF0, 0x06, 0x07, 0xE2, 0x09, 0x03, 0x40, 0xF0, 0x3C,
  0x0B, 0x06, 0x63, 0x8F, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x01, 0x80,
  0x33, 0xDC, 0x00, 0x00, 0x00, 0x03, 0x39, 0xC0, 0x0C, 0x3C, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0xC1, 0x82, 0x0C, 0x30, 0x00, 0x00, 0xC0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x20, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x30, 0x30, 0x30, 0x70, 0x30, 0x00, 0x3E, 0x01, 0x80, 0x40, 0x20,
  0x10, 0x18, 0x18, 0x78, 0x20, 0x10, 0x08, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x01, 0x80, 0x3F, 0x02, 0x0C, 0x20, 0x23, 0x01, 0x10, 0x08, 0x87, 0x44,
  0x46, 0x66, 0x13, 0x31, 0x91, 0x0C, 0x88, 0x44, 0x42, 0x23, 0x31, 0x0E,
  0x88, 0x00, 0x40, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xA0,
  0x28, 0x1A, 0x04, 0x83, 0x20, 0x88, 0x23, 0x18, 0xC4, 0x33, 0xFC, 0x81,
  0x60, 0x50, 0x1C, 0x04, 0x1F, 0xC6, 0x18, 0xC1, 0x90, 0x22, 0x04, 0x41,
  0x8F, 0xE3, 0xFC, 0x60, 0x88, 0x19, 0x03, 0x20, 0x64, 0x09, 0x86, 0x3F,
  0x80, 0x06, 0x07, 0xE2, 0x09, 0x83, 0x40, 0xD0, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x02, 0x81, 0x20, 0x4C, 0x61, 0xF0, 0x1F, 0x86, 0x18,
  0xC1, 0x10, 0x22, 0x04, 0x40, 0x88, 0x13, 0x06, 0x60, 0xC8, 0x11, 0x02,
  0x20, 0x44, 0x19, 0x8E, 0x3F, 0x00, 0x1F, 0xE2, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x0F, 0xF1, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x3F, 0xE0, 0x1F, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0xFC, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x00, 0x06, 0x07, 0xE2, 0x09, 0x83, 0x40, 0xD0, 0x04, 0x03, 0x00,
  0xCF, 0xB3, 0xE8, 0x1A, 0x06, 0x81, 0x20, 0x4C, 0x61, 0xF0, 0x10, 0x66,
  0x0C, 0xC1, 0x90, 0x22, 0x04, 0x40, 0x8F, 0xF3, 0xFE, 0x60, 0xC8, 0x11,
  0x02, 0x20, 0x44, 0x09, 0x83, 0x30, 0x60, 0x1F, 0xE0, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x3F, 0xC0, 0x07, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x40, 0xCC, 0x11, 0x86, 0x1F,
  0x80, 0x10, 0x33, 0x06, 0x30, 0xC2, 0x08, 0x21, 0x82, 0x30, 0x3E, 0x07,
  0xE0, 0x62, 0x04, 0x30, 0x41, 0x04, 0x10, 0x41, 0x8C, 0x08, 0xC0, 0xC0,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0xFF, 0x30, 0x67, 0x1C, 0xA2, 0x94, 0xF2, 0x96, 0xD6, 0x9A,
  0x92, 0x32, 0x40, 0x48, 0x19, 0x03, 0x60, 0x4C, 0x09, 0x01, 0x20, 0x20,
  0x18, 0x67, 0x0C, 0xA1, 0x94, 0x22, 0xC4, 0x48, 0x89, 0x13, 0x26, 0x64,
  0xC8, 0xD1, 0x0A, 0x21, 0x44, 0x29, 0x87, 0x30, 0x60, 0x06, 0x07, 0xE2,
  0x09, 0x82, 0x40, 0x90, 0x24, 0x0B, 0x02, 0xC1, 0xB0, 0x68, 0x12, 0x04,
  0x81, 0x20, 0xCC, 0x61, 0xF0, 0x1F, 0xC6, 0x0C, 0xC0, 0x90, 0x12, 0x02,
  0x40, 0xC8, 0x33, 0xFC, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x00, 0x06, 0x07, 0xE2, 0x09, 0x83, 0x40, 0xD0, 0x24, 0x0B, 0x02,
  0xC1, 0xA0, 0x68, 0x1A, 0x04, 0x81, 0x20, 0xCC, 0x61, 0xF0, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x1F, 0xC6, 0x0C, 0xC1, 0x90, 0x12, 0x06, 0x40, 0x88,
  0x33, 0xFC, 0x62, 0x0C, 0x41, 0x0C, 0x20, 0x84, 0x11, 0x83, 0x30, 0x20,
  0x03, 0x01, 0xF8, 0x41, 0x18, 0x32, 0x06, 0x40, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x6C, 0x0D, 0x81, 0x18, 0x61, 0xF0, 0xFF, 0xC2,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x20, 0xD8, 0x36, 0x0D, 0x02, 0x40, 0x90,
  0x24, 0x0B, 0x06, 0xC1, 0xA0, 0x48, 0x12, 0x04, 0x83, 0x31, 0x87, 0xC0,
  0x80, 0xE0, 0x28, 0x1B, 0x04, 0xC3, 0x30, 0x84, 0x21, 0x10, 0x44, 0x13,
  0x04, 0x81, 0x60, 0x50, 0x1C, 0x07, 0x00, 0x86, 0x31, 0x46, 0x29, 0xC5,
  0x28, 0xA5, 0x28, 0xA5, 0x24, 0xA4, 0xA4, 0x94, 0xB2, 0x94, 0x52, 0x8C,
  0x51, 0x8E, 0x31, 0x80, 0x18, 0x18, 0x41, 0x02, 0x18, 0x18, 0x80, 0x48,
  0x03, 0xC0, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x68, 0x06, 0x60, 0x21, 0x02,
  0x0C, 0x30, 0x23, 0x01, 0x80, 0xC0, 0x68, 0x09, 0x82, 0x10, 0xC2, 0x10,
  0x64, 0x05, 0x80, 0xA0, 0x18, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x3F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x20, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x3F, 0xE0, 0x1F,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xF8, 0x84, 0x30, 0x84, 0x21, 0x8C, 0x21,
  0x0C, 0x61, 0x08, 0x43, 0x18, 0x42, 0x1F, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0xF8, 0x06, 0x05, 0x06, 0x82, 0x63, 0x11, 0x09, 0x05, 0x83, 0xFF, 0xC0,
  0xCC, 0x0E, 0x46, 0x53, 0x0C, 0x83, 0x60, 0xD8, 0x34, 0x09, 0x02, 0x40,
  0x90, 0x66, 0x38, 0xF6, 0x10, 0x0C, 0x03, 0x00, 0x9C, 0x29, 0x8C, 0x32,
  0x0D, 0x83, 0x60, 0xD8, 0x24, 0x09, 0x02, 0x41, 0xB8, 0xCD, 0xE0, 0x0E,
  0x1F, 0x98, 0x68, 0x1C, 0x06, 0x02, 0x01, 0x00, 0x81, 0x41, 0xB1, 0x8F,
  0x80, 0x00, 0x60, 0x0C, 0x01, 0x87, 0x21, 0x94, 0x61, 0x88, 0x33, 0x06,
  0x60, 0xC8, 0x11, 0x02, 0x20, 0x44, 0x18, 0xC7, 0x0F, 0x60, 0x0E, 0x19,
  0x98, 0x68, 0x3C, 0x1F, 0xFF, 0xFD, 0x00, 0x80, 0x41, 0xB1, 0x8F, 0x80,
  0x00, 0xFC, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x7F, 0xE0, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x99,
  0x58, 0x68, 0x3C, 0x1E, 0x0E, 0x05, 0x02, 0x83, 0x62, 0x9E, 0xC0, 0x60,
  0x20, 0x10, 0x39, 0xF0, 0x10, 0x0C, 0x03, 0x00, 0x9C, 0x29, 0x8C, 0x32,
  0x0D, 0x83, 0x60, 0xD0, 0x24, 0x09, 0x02, 0x40, 0xB0, 0x6C, 0x18, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC3, 0xFF, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x38, 0x7C, 0x00, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x32, 0x04, 0x41, 0x08, 0x43, 0x18, 0x7E, 0x0F,
  0xC1, 0x18, 0x21, 0x84, 0x30, 0x83, 0x30, 0x60, 0xF8, 0x04, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x80,
  0x7E, 0x6C, 0xCE, 0xAD, 0x99, 0xA2, 0x24, 0x44, 0x88, 0xB1, 0x16, 0x62,
  0x8C, 0xD1, 0x1A, 0x22, 0x44, 0x40, 0x27, 0x0A, 0x63, 0x0C, 0x83, 0x60,
  0xD8, 0x34, 0x09, 0x02, 0x40, 0x90, 0x2C, 0x1B, 0x06, 0x0E, 0x19, 0x98,
  0x68, 0x3C, 0x1E, 0x0E, 0x05, 0x02, 0x81, 0x41, 0xB1, 0x8F, 0x80, 0x27,
  0x0A, 0x63, 0x0C, 0x83, 0x60, 0xD8, 0x34, 0x09, 0x02, 0x40, 0x90, 0x6E,
  0x33, 0x78, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x0E, 0x46, 0x53, 0x0C, 0x83,
  0x60, 0xD8, 0x34, 0x09, 0x02, 0x40, 0x90, 0x66, 0x38, 0xF6, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x6F, 0x1E, 0xE6, 0x09, 0x02, 0x40, 0x90, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x0F, 0x06, 0x72, 0x04, 0x80, 0x20,
  0x0F, 0x00, 0xF8, 0x02, 0x00, 0xB0, 0x24, 0x19, 0xFC, 0x08, 0x02, 0x00,
  0x83, 0xFF, 0xFF, 0x86, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0xF0, 0x40, 0xA0, 0x50, 0x28, 0x1C, 0x1E, 0x0E, 0x05,
  0x02, 0x81, 0x41, 0xB1, 0x8F, 0x80, 0xC0, 0x50, 0x34, 0x09, 0x06, 0x41,
  0x18, 0xC6, 0x20, 0x98, 0x24, 0x0B, 0x02, 0x80, 0xE0, 0x8C, 0x71, 0x8A,
  0x31, 0x4A, 0x69, 0x49, 0x29, 0x29, 0x65, 0x28, 0xA5, 0x18, 0xE3, 0x18,
  0x63, 0x00, 0x10, 0x31, 0x86, 0x08, 0x40, 0xC8, 0x05, 0x80, 0x70, 0x06,
  0x00, 0xF0, 0x19, 0x01, 0x18, 0x20, 0x8E, 0x0C, 0x40, 0xA0, 0x50, 0x38,
  0x3C, 0x1E, 0x0A, 0x05, 0x02, 0x83, 0x63, 0x9E, 0xC0, 0x60, 0x20, 0x10,
  0x31, 0xF0, 0x3F, 0xCF, 0xF0, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x03, 0xFE, 0x01, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x3E, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x00, 0xF0, 0x18, 0xC4, 0x21, 0x08, 0xC6, 0x21, 0x08,
  0x46, 0x31, 0x08, 0x42, 0x30, 0x1C, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x04, 0x00, 0xF0, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x0E, 0x00, 0x78, 0xE2, 0x28, 0xFA, 0x08,
};

const GFXglyph JetBrainsMono_ExtraLightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 7, 6, 13, 4, -15 },
  { 17, 13, 15, 13, 0, -15 },
  { 42, 11, 21, 13, 1, -18 },
  { 71, 15, 15, 13, -1, -15 },
  { 100, 11, 16, 13, 1, -16 },
  { 122, 3, 6, 13, 6, -15 },
  { 125, 8, 21, 13, 4, -18 },
  { 146, 8, 21, 13, 1, -18 },
  { 167, 11, 11, 13, 1, -13 },
  { 183, 9, 10, 13, 2, -12 },
  { 195, 5, 6, 13, 2, -3 },
  { 199, 7, 2, 13, 3, -8 },
  { 201, 3, 3, 13, 4, -3 },
  { 203, 12, 19, 13, 1, -17 },
  { 232, 11, 16, 13, 1, -16 },
  { 254, 9, 15, 13, 1, -15 },
  { 271, 11, 16, 13, 1, -16 },
  { 293, 11, 15, 13, 1, -15 },
  { 314, 9, 15, 13, 2, -15 },
  { 331, 11, 15, 13, 1, -15 },
  { 352, 10, 15, 13, 1, -15 },
  { 371, 10, 15, 13, 3, -15 },
  { 390, 11, 16, 13, 1, -16 },
  { 412, 10, 16, 13, 2, -16 },
  { 432, 5, 12, 13, 4, -12 },
  { 440, 7, 15, 13, 2, -12 },
  { 454, 10, 10, 13, 2, -12 },
  { 467, 9, 6, 13, 2, -10 },
  { 474, 10, 10, 13, 1, -12 },
  { 487, 9, 15, 13, 3, -15 },
  { 504, 13, 20, 13, 0, -16 },
  { 537, 10, 15, 13, 0, -15 },
  { 556, 11, 15, 13, 1, -15 },
  { 577, 10, 16, 13, 2, -16 },
  { 597, 11, 15, 13, 1, -15 },
  { 618, 11, 15, 13, 1, -15 },
  { 639, 12, 15, 13, 1, -15 },
  { 662, 10, 16, 13, 2, -16 },
  { 682, 11, 15, 13, 1, -15 },
  { 703, 11, 15, 13, 1, -15 },
  { 724, 11, 15, 13, 1, -15 },
  { 745, 12, 15, 13, 1, -15 },
  { 768, 8, 15, 13, 2, -15 },
  { 783, 11, 15, 13, 1, -15 },
  { 804, 11, 15, 13, 1, -15 },
  { 825, 10, 16, 13, 2, -16 },
  { 845, 11, 15, 13, 1, -15 },
  { 866, 10, 20, 13, 2, -16 },
  { 891, 11, 15, 13, 1, -15 },
  { 912, 11, 16, 13, 1, -16 },
  { 934, 10, 15, 13, 3, -15 },
  { 953, 10, 15, 13, 2, -15 },
  { 972, 10, 15, 13, 3, -15 },
  { 991, 11, 15, 13, 2, -15 },
  { 1012, 13, 15, 13, 0, -15 },
  { 1037, 11, 15, 13, 2, -15 },
  { 1058, 11, 15, 13, 1, -15 },
  { 1079, 8, 19, 13, 3, -17 },
  { 1098, 5, 19, 13, 4, -17 },
  { 1110, 8, 19, 13, 2, -17 },
  { 1129, 9, 8, 13, 2, -15 },
  { 1138, 10, 1, 13, 0, 1 },
  { 1140, 3, 2, 13, 6, -16 },
  { 1141, 10, 12, 13, 1, -12 },
  { 1156, 10, 15, 13, 1, -15 },
  { 1175, 9, 12, 13, 2, -12 },
  { 1189, 11, 15, 13, 1, -15 },
  { 1210, 9, 12, 13, 2, -12 },
  { 1224, 14, 19, 13, -1, -15 },
  { 1258, 9, 16, 13, 2, -12 },
  { 1276, 10, 15, 13, 1, -15 },
  { 1295, 10, 16, 13, 1, -16 },
  { 1315, 11, 20, 13, 0, -16 },
  { 1343, 11, 15, 13, 1, -15 },
  { 1364, 9, 15, 13, 2, -15 },
  { 1381, 11, 12, 13, 1, -12 },
  { 1398, 10, 12, 13, 1, -12 },
  { 1413, 9, 12, 13, 2, -12 },
  { 1427, 10, 16, 13, 1, -12 },
  { 1447, 10, 16, 13, 1, -12 },
  { 1467, 10, 12, 13, 2, -12 },
  { 1482, 10, 12, 13, 1, -12 },
  { 1497, 10, 15, 13, 2, -15 },
  { 1516, 9, 12, 13, 2, -12 },
  { 1530, 10, 12, 13, 2, -12 },
  { 1545, 11, 12, 13, 2, -12 },
  { 1562, 12, 12, 13, 0, -12 },
  { 1580, 9, 16, 13, 2, -12 },
  { 1598, 10, 12, 13, 1, -12 },
  { 1613, 10, 19, 13, 2, -17 },
  { 1637, 5, 19, 13, 4, -17 },
  { 1649, 10, 19, 13, 1, -17 },
  { 1673, 10, 4, 13, 2, -9 },
};

const GFXfont JetBrainsMono_ExtraLightItalic21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC21PT7B_H_
