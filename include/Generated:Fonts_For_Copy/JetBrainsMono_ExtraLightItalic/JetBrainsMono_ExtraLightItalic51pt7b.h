#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC51PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x7E, 0x0F, 0xC3,
  0xF8, 0x7E, 0x07, 0xC0, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C,
  0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x6F, 0xC0, 0x1E, 0x38, 0xF8, 0x0F, 0x0E, 0x1E, 0x07, 0x83, 0x83, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x3C, 0x0C, 0x0E, 0x0F, 0x07, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x86,
  0x00, 0x01, 0xF1, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x37, 0xE0,
  0x00, 0x0C, 0x7C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70,
  0x78, 0x00, 0x18, 0x1E, 0x00, 0x06, 0x07, 0x8F, 0x01, 0x81, 0xE3, 0xC0,
  0xE0, 0x78, 0xF0, 0x38, 0x1C, 0x3C, 0x0E, 0x0F, 0x0F, 0x03, 0x03, 0xC1,
  0xE0, 0xC1, 0xE0, 0x7C, 0x31, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x7F, 0xF0, 0x00, 0xE0,
  0x3E, 0x3C, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x30, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x70, 0x70, 0x00, 0xE0, 0x1C,
  0x38, 0x00, 0x38, 0x0E, 0x1C, 0x00, 0x0F, 0x03, 0x8F, 0x00, 0x01, 0xE1,
  0xC3, 0x80, 0x00, 0x7F, 0xF1, 0xC0, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC7, 0xFC,
  0x00, 0x00, 0xE3, 0xFF, 0x80, 0x00, 0x71, 0xE0, 0xE0, 0x00, 0x38, 0x70,
  0x1C, 0x00, 0x1C, 0x18, 0x07, 0x00, 0x07, 0x0E, 0x01, 0xC0, 0x03, 0x83,
  0x80, 0x70, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x70,
  0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0x38, 0x1C, 0x03, 0x80, 0x0F, 0xBE, 0x01, 0xC0, 0x01, 0xFF, 0x00,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xF1, 0xE0, 0x01, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0xF0, 0x1E, 0x3C, 0x07,
  0x03, 0xC3, 0xC0, 0x78, 0x38, 0x38, 0x03, 0xC7, 0x03, 0x80, 0x3C, 0xF0,
  0x38, 0x01, 0xEE, 0x03, 0x80, 0x0F, 0xC0, 0x78, 0x00, 0xFC, 0x07, 0x80,
  0x07, 0x80, 0x70, 0x00, 0x78, 0x07, 0x00, 0x0F, 0xC0, 0x78, 0x01, 0xFC,
  0x07, 0x80, 0x3D, 0xE0, 0x7C, 0x0F, 0x8E, 0x03, 0xFF, 0xF0, 0xF0, 0x1F,
  0xFC, 0x07, 0x80, 0xFF, 0x80, 0x38, 0x00, 0x80, 0x00, 0x00, 0x3C, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x73, 0xCF, 0x3C, 0xF3, 0x8E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x02, 0x00, 0x70, 0x02, 0x70, 0x0E, 0x01, 0xCF, 0xC1,
  0xC1, 0xFB, 0xFE, 0x39, 0xFF, 0x9F, 0xF6, 0x7F, 0x80, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0x3F, 0x9F, 0xEF, 0xF7, 0xF3, 0xF9, 0xF8, 0x20,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xF1,
  0xFC, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1C,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x1C, 0x1C, 0x04, 0x07, 0x0F, 0x07, 0x81, 0xC3, 0xC3,
  0xF0, 0xF0, 0xF0, 0xFC, 0x3C, 0x38, 0x1F, 0x0F, 0x0E, 0x07, 0x83, 0x83,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x1F,
  0x00, 0x3C, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0xF9, 0xE0, 0x0F, 0x87, 0x00,
  0x7C, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x20, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0xF0,
  0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0xF0,
  0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0xF0, 0x00, 0x79, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x7F, 0xE0, 0x1C, 0xFF, 0xF0,
  0x1D, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x07, 0xBF, 0xF0, 0x0F, 0x7F, 0xF8,
  0x0F, 0xE0, 0xFC, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C,
  0xF0, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x3E, 0x01, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x8F, 0xE0,
  0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x07, 0x80,
  0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x8E,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x7C,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xF0,
  0xFC, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x0E, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0x3E, 0x01,
  0xF8, 0x3F, 0x87, 0xF0, 0x1F, 0xFE, 0xE0, 0x07, 0xFD, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF0, 0x7E, 0x01, 0x00, 0x00, 0x10, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x78,
  0x07, 0xFC, 0xE3, 0x80, 0x7F, 0xFE, 0x1C, 0x07, 0xC1, 0xF0, 0xE0, 0x38,
  0x07, 0x87, 0x03, 0xC0, 0x3C, 0x38, 0x1C, 0x01, 0xE3, 0xC0, 0xE0, 0x0F,
  0x1C, 0x07, 0x00, 0x70, 0xE0, 0x38, 0x03, 0x87, 0x03, 0xC0, 0x1C, 0x38,
  0x1C, 0x00, 0xE1, 0xC0, 0xE0, 0x07, 0x1E, 0x07, 0x00, 0x38, 0xE0, 0x38,
  0x03, 0xC7, 0x01, 0xC0, 0x1C, 0x38, 0x0E, 0x00, 0xE1, 0xC0, 0x70, 0x0F,
  0x0E, 0x03, 0xC0, 0xF8, 0x70, 0x1F, 0xFD, 0xC7, 0x80, 0x7F, 0xCE, 0x38,
  0x01, 0xFC, 0x61, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0E, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1E, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x78, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0xF8, 0x1C, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x01,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x1F, 0x00, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xE0,
  0x38, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xC0,
  0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x81, 0xFF, 0xE3, 0xC0, 0xFF, 0xF1, 0xE0, 0x7F, 0xF0, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78,
  0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x76, 0x00, 0x76, 0x07,
  0x70, 0x07, 0xE0, 0x77, 0x00, 0xEE, 0x07, 0x70, 0x0E, 0xE0, 0x77, 0x01,
  0xCE, 0x07, 0x30, 0x1D, 0xE0, 0xF3, 0x03, 0x9C, 0x0E, 0x38, 0x39, 0xC0,
  0xE3, 0x87, 0x1C, 0x0E, 0x38, 0x71, 0xC0, 0xE1, 0x8E, 0x3C, 0x0E, 0x18,
  0xE3, 0xC0, 0xE1, 0xDC, 0x38, 0x1E, 0x1D, 0xC3, 0x81, 0xE1, 0xF8, 0x38,
  0x1C, 0x0F, 0x83, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0F,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0xF8,
  0x00, 0x70, 0x7E, 0x00, 0x3C, 0x1F, 0x80, 0x0E, 0x07, 0xE0, 0x03, 0x81,
  0xDC, 0x00, 0xE0, 0x77, 0x00, 0x38, 0x1D, 0xC0, 0x0E, 0x0F, 0x70, 0x07,
  0x83, 0xCE, 0x01, 0xE0, 0xE3, 0x80, 0x70, 0x38, 0xE0, 0x1C, 0x0E, 0x38,
  0x07, 0x03, 0x8E, 0x01, 0xC0, 0xE1, 0xC0, 0xF0, 0x78, 0x70, 0x3C, 0x1C,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x0E, 0x0F, 0x03, 0x87, 0x83, 0xC0, 0xE1, 0xC0, 0xE0, 0x1C,
  0x70, 0x38, 0x07, 0x1C, 0x0E, 0x01, 0xC7, 0x03, 0x80, 0x71, 0xC1, 0xE0,
  0x0E, 0xF0, 0x78, 0x03, 0xBC, 0x1C, 0x00, 0xEE, 0x07, 0x00, 0x3B, 0x81,
  0xC0, 0x0E, 0xE0, 0x70, 0x01, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x1F,
  0x83, 0x80, 0x07, 0xC0, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x0E, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x38,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78,
  0x00, 0x1C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0x78,
  0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x03, 0x80, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x7C, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00,
  0x0F, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x78, 0x00,
  0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00,
  0x3C, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x81,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x3E, 0x07, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0E,
  0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x01,
  0xC0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xE0, 0x0F,
  0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0xC0,
  0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x01,
  0xE0, 0x78, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x38, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x70, 0x07, 0x80, 0x7B, 0x80, 0x3C, 0x03, 0x9C, 0x03, 0xE0, 0x1C,
  0xE0, 0x1B, 0x01, 0xE7, 0x00, 0xD8, 0x0E, 0x38, 0x0E, 0xC0, 0x71, 0xC0,
  0x66, 0x03, 0x8E, 0x03, 0x70, 0x38, 0x70, 0x3B, 0x81, 0xC3, 0x81, 0xDC,
  0x0E, 0x1C, 0x0C, 0xE0, 0xF0, 0xE0, 0x67, 0x07, 0x07, 0x07, 0x38, 0x38,
  0x38, 0x31, 0xC1, 0xC1, 0xC1, 0x8E, 0x1C, 0x0E, 0x1C, 0x70, 0xE0, 0x70,
  0xE3, 0x07, 0x03, 0x86, 0x18, 0x38, 0x1C, 0x30, 0xC3, 0x80, 0xE3, 0x86,
  0x1C, 0x07, 0x18, 0x30, 0xE0, 0x38, 0xC1, 0x8E, 0x01, 0xCE, 0x0C, 0x70,
  0x1C, 0x60, 0x63, 0x80, 0xE3, 0x03, 0x1C, 0x07, 0x38, 0x19, 0xC0, 0x39,
  0xC0, 0xCE, 0x01, 0xCC, 0x06, 0x70, 0x0E, 0x60, 0x33, 0x00, 0x77, 0x01,
  0xB8, 0x03, 0xB0, 0x0D, 0xC0, 0x1D, 0x80, 0x6E, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00,
  0x39, 0xC0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x0F,
  0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x78, 0x78,
  0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDC, 0x00, 0x0F,
  0xE0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0x8F, 0x03, 0xFF, 0xCE, 0x07, 0xF1, 0xEE, 0x0F, 0x80, 0x6E, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x03, 0xF0, 0x3F, 0x3E, 0xF0, 0x3F, 0xFC, 0xE0, 0x0F, 0xF8, 0xE0, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x01, 0x00, 0x0F, 0x1F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0E,
  0xF8, 0xFC, 0x0E, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x7C, 0x00, 0xF0, 0x7E, 0x01, 0xE0, 0xF7, 0x9F, 0xC0, 0xF7,
  0xFF, 0x80, 0xE1, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x07, 0xC1, 0xE0,
  0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C,
  0x00, 0x1C, 0x78, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x08, 0x0F, 0x00, 0x7F, 0xC7, 0x80, 0xFF, 0xF3, 0x80, 0xFE, 0x3D,
  0xC0, 0xF8, 0x06, 0xE0, 0x78, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x38, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x03, 0xF8, 0x0F, 0xCF, 0xBC,
  0x07, 0xFF, 0x9C, 0x00, 0xFF, 0x8E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0xF8, 0x07,
  0x81, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0xFC, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0x8F, 0x03, 0xFF, 0xCE, 0x07, 0xF1, 0xEE, 0x0F,
  0x80, 0x6E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3E, 0x07, 0x70, 0x3F,
  0xFE, 0x70, 0x1F, 0xFC, 0xF0, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x03, 0x00, 0x0F, 0x1F, 0xF0, 0x0F,
  0x7F, 0xF8, 0x0E, 0xF1, 0xFC, 0x0E, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x0F, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x0F,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3C,
  0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0x10, 0x06, 0x01, 0xCF, 0xC7, 0xF0, 0x3B, 0xFD,
  0xFF, 0x07, 0xC7, 0xB1, 0xE1, 0xD0, 0x78, 0x1C, 0x3C, 0x0F, 0x03, 0x87,
  0x01, 0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0,
  0x78, 0xF0, 0x38, 0x0F, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0x70,
  0x1C, 0x07, 0x0E, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x1C, 0x78, 0x0E, 0x07,
  0x8F, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x1C, 0x38, 0x0E, 0x03, 0x87, 0x01,
  0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x1C, 0x07, 0x03, 0xC7, 0x81, 0xC0, 0x70,
  0xE0, 0x38, 0x0E, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0x70, 0x1C,
  0x07, 0x0E, 0x03, 0x81, 0xE0, 0x00, 0x01, 0x00, 0x0F, 0x1F, 0xF0, 0x0F,
  0x7F, 0xF8, 0x0E, 0xF1, 0xFC, 0x0E, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0xF8, 0x07, 0x81, 0xE0,
  0x07, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xCF, 0x00, 0x07,
  0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73,
  0xC0, 0x00, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0x80, 0xFE,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x03, 0xC7, 0xFC, 0x01, 0xEF, 0xFF, 0x00, 0xEF, 0x9F, 0xC0,
  0x76, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3E, 0x00, 0x78, 0x1F, 0x80, 0x78, 0x1E, 0xF3, 0xF8, 0x0F,
  0x3F, 0xF8, 0x07, 0x0F, 0xF8, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0x8F, 0x03, 0xFF, 0xCE, 0x07, 0xF1, 0xEE, 0x0F, 0x80,
  0x6E, 0x0E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x07, 0xF0, 0x7F, 0x3E, 0xE0, 0x3F, 0xFC, 0xE0, 0x0F, 0xF8,
  0xE0, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0x1F, 0xF0, 0x0E, 0x7F,
  0xF8, 0x0E, 0xF0, 0xFC, 0x0E, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x0E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x7C, 0x00,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x0F,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x07, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xE3, 0x80,
  0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x0E, 0x01,
  0xFC, 0x03, 0xC0, 0x3B, 0x80, 0x78, 0x07, 0x70, 0x0F, 0x01, 0xCE, 0x03,
  0x60, 0x39, 0xC0, 0x6C, 0x07, 0x38, 0x0D, 0x81, 0xC7, 0x03, 0xB0, 0x38,
  0x60, 0x66, 0x07, 0x0C, 0x0C, 0xC1, 0xC1, 0x83, 0x98, 0x38, 0x30, 0x63,
  0x07, 0x06, 0x0C, 0x60, 0xC0, 0xC3, 0x8C, 0x38, 0x18, 0x61, 0x87, 0x03,
  0x1C, 0x30, 0xC0, 0x63, 0x86, 0x38, 0x0C, 0x60, 0xE7, 0x01, 0x9C, 0x1C,
  0xE0, 0x33, 0x83, 0xB8, 0x06, 0x60, 0x77, 0x00, 0xDC, 0x0E, 0xE0, 0x1B,
  0x81, 0xF8, 0x03, 0x60, 0x3F, 0x00, 0x6C, 0x07, 0xE0, 0x0F, 0x80, 0xF8,
  0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x38, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x39, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x6E, 0x1F, 0x81, 0xFC, 0x1F, 0xFF, 0x78, 0x1F, 0xF8, 0xE0, 0x0F, 0xC1,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x1F, 0xE0, 0x07, 0x3F, 0xF0, 0x07,
  0x78, 0x78, 0x0F, 0x70, 0x38, 0x0E, 0xF0, 0x3C, 0x0E, 0xE0, 0x1E, 0x1E,
  0xE0, 0x0F, 0xFC, 0xE0, 0x07, 0xF8, 0xE0, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 37, 31, 10, -37 },
  { 52, 16, 15, 31, 10, -37 },
  { 82, 30, 37, 31, 1, -37 },
  { 221, 26, 51, 31, 3, -44 },
  { 387, 34, 37, 31, -1, -37 },
  { 545, 28, 39, 31, 1, -38 },
  { 682, 6, 15, 31, 15, -37 },
  { 694, 20, 49, 31, 9, -43 },
  { 817, 20, 49, 31, 3, -43 },
  { 940, 27, 26, 31, 3, -31 },
  { 1028, 24, 24, 31, 4, -29 },
  { 1100, 12, 16, 31, 6, -8 },
  { 1124, 17, 3, 31, 7, -18 },
  { 1131, 9, 8, 31, 9, -7 },
  { 1140, 30, 48, 31, 1, -42 },
  { 1320, 26, 39, 31, 3, -38 },
  { 1447, 22, 37, 31, 3, -37 },
  { 1549, 26, 38, 31, 3, -38 },
  { 1673, 25, 38, 31, 3, -37 },
  { 1792, 23, 37, 31, 4, -37 },
  { 1899, 24, 38, 31, 4, -37 },
  { 2013, 24, 38, 31, 3, -37 },
  { 2127, 25, 37, 31, 6, -37 },
  { 2243, 25, 39, 31, 3, -38 },
  { 2365, 24, 38, 31, 5, -38 },
  { 2479, 12, 30, 31, 9, -29 },
  { 2524, 15, 37, 31, 6, -29 },
  { 2594, 24, 26, 31, 5, -30 },
  { 2672, 24, 15, 31, 4, -24 },
  { 2717, 24, 26, 31, 3, -30 },
  { 2795, 20, 37, 31, 8, -37 },
  { 2888, 29, 47, 31, 1, -38 },
  { 3059, 24, 37, 31, 1, -37 },
  { 3170, 26, 37, 31, 3, -37 },
  { 3291, 25, 39, 31, 4, -38 },
  { 3413, 25, 37, 31, 3, -37 },
  { 3529, 27, 37, 31, 3, -37 },
  { 3654, 27, 37, 31, 3, -37 },
  { 3779, 25, 39, 31, 4, -38 },
  { 3901, 26, 37, 31, 3, -37 },
  { 4022, 24, 37, 31, 4, -37 },
  { 4133, 26, 38, 31, 2, -37 },
  { 4257, 28, 37, 31, 3, -37 },
  { 4387, 21, 37, 31, 4, -37 },
  { 4485, 28, 37, 31, 2, -37 },
  { 4615, 26, 37, 31, 3, -37 },
  { 4736, 24, 39, 31, 4, -38 },
  { 4853, 27, 37, 31, 3, -37 },
  { 4978, 24, 47, 31, 4, -38 },
  { 5119, 26, 37, 31, 3, -37 },
  { 5240, 26, 39, 31, 3, -38 },
  { 5367, 25, 37, 31, 6, -37 },
  { 5483, 25, 38, 31, 4, -37 },
  { 5602, 24, 37, 31, 7, -37 },
  { 5713, 29, 37, 31, 4, -37 },
  { 5848, 31, 37, 31, 0, -37 },
  { 5992, 26, 37, 31, 6, -37 },
  { 6113, 27, 37, 31, 2, -37 },
  { 6238, 19, 48, 31, 8, -42 },
  { 6352, 14, 48, 31, 9, -42 },
  { 6436, 19, 48, 31, 5, -42 },
  { 6550, 21, 20, 31, 5, -37 },
  { 6603, 25, 3, 31, 0, 1 },
  { 6613, 8, 7, 31, 14, -40 },
  { 6620, 24, 30, 31, 4, -29 },
  { 6710, 24, 38, 31, 3, -37 },
  { 6824, 23, 30, 31, 4, -29 },
  { 6911, 25, 38, 31, 4, -37 },
  { 7030, 23, 30, 31, 4, -29 },
  { 7117, 33, 46, 31, -2, -37 },
  { 7307, 24, 38, 31, 4, -29 },
  { 7421, 24, 37, 31, 3, -37 },
  { 7532, 24, 39, 31, 2, -39 },
  { 7649, 26, 48, 31, 1, -39 },
  { 7805, 26, 37, 31, 3, -37 },
  { 7926, 20, 37, 31, 6, -37 },
  { 8019, 27, 29, 31, 2, -29 },
  { 8117, 24, 29, 31, 3, -29 },
  { 8204, 23, 30, 31, 4, -29 },
  { 8291, 25, 38, 31, 2, -29 },
  { 8410, 24, 38, 31, 4, -29 },
  { 8524, 24, 29, 31, 4, -29 },
  { 8611, 24, 30, 31, 3, -29 },
  { 8701, 23, 36, 31, 5, -36 },
  { 8805, 24, 29, 31, 4, -28 },
  { 8892, 23, 28, 31, 6, -28 },
  { 8973, 27, 28, 31, 4, -28 },
  { 9068, 28, 28, 31, 1, -28 },
  { 9166, 23, 37, 31, 4, -28 },
  { 9273, 24, 28, 31, 3, -28 },
  { 9357, 25, 48, 31, 5, -42 },
  { 9507, 11, 48, 31, 10, -42 },
  { 9573, 25, 48, 31, 2, -42 },
  { 9723, 24, 10, 31, 4, -23 },
};

const GFXfont JetBrainsMono_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC51PT7B_H_
