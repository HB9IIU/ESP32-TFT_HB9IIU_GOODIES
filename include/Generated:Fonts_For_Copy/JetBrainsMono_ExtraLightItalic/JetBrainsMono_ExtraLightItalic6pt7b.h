#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC6PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x56, 0xEC, 0x2D, 0x3A, 0x80, 0xF4, 0x7F, 0x6A, 0xF0,
  0x80, 0x6A, 0x90, 0x44, 0x95, 0x00, 0x3D, 0x80, 0x5C, 0xC0, 0xC0, 0x80,
  0x12, 0x24, 0x88, 0x7E, 0xF0, 0x65, 0x70, 0xE5, 0x70, 0x6C, 0xF0, 0x2F,
  0x90, 0x6C, 0xF0, 0x6E, 0xF0, 0xEA, 0x40, 0x6E, 0xF0, 0xF6, 0xA0, 0x8A,
  0x69, 0x7C, 0x8D, 0xC0, 0xDA, 0xFE, 0xDA, 0xC0, 0x2D, 0xD0, 0x7E, 0xF0,
  0x72, 0x70, 0x76, 0xF0, 0x7E, 0x8E, 0x7E, 0x88, 0x72, 0xF0, 0x7E, 0xD0,
  0x69, 0x70, 0x24, 0xF0, 0x7E, 0xAA, 0x4A, 0x70, 0x7D, 0xAA, 0x7E, 0xD0,
  0x76, 0xF0, 0x7E, 0x88, 0x76, 0xF2, 0x7E, 0xD0, 0x68, 0xF0, 0xF2, 0x40,
  0x76, 0xF0, 0xBA, 0x40, 0xD5, 0xAA, 0x74, 0x4A, 0xFA, 0x40, 0x65, 0x70,
  0xEA, 0xA0, 0xA9, 0x50, 0xD5, 0xA0, 0x70, 0xE0, 0x80, 0xF7, 0x80, 0x56,
  0xF0, 0xF3, 0x80, 0x76, 0xF0, 0xFB, 0x80, 0x76, 0x44, 0xC0, 0xF5, 0xB0,
  0x56, 0xD0, 0x28, 0xAE, 0x28, 0x93, 0x80, 0x57, 0x50, 0xAB, 0xFF, 0x80,
  0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0x72, 0x00, 0xEF, 0x80,
  0xEB, 0xB7, 0x80, 0xF8, 0xBB, 0x00, 0x6A, 0x80, 0xB5, 0xB0, 0x6B, 0x80,
  0x69, 0x48, 0x80, 0x5A, 0xA0, 0x49, 0xA5, 0x00, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 3, 6, 4, 0, -5 },
  { 18, 3, 3, 4, 0, -4 },
  { 20, 3, 2, 4, 0, -3 },
  { 21, 1, 2, 4, 1, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 4, 6, 4, 0, -5 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 1, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 1, 3, 4, 1, -3 },
  { 47, 2, 4, 4, 1, -3 },
  { 48, 2, 4, 4, 1, -4 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 4, 5, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 3, 5, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 1, -4 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 3, 4, 4, 1, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 3, 4, 4, 1, -4 },
  { 106, 3, 4, 4, 0, -4 },
  { 108, 2, 6, 4, 1, -5 },
  { 110, 2, 6, 4, 1, -5 },
  { 112, 2, 6, 4, 1, -5 },
  { 114, 2, 2, 4, 1, -4 },
  { 115, 3, 1, 4, 0, 0 },
  { 116, 1, 1, 4, 2, -5 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 4, 4, 0, -4 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 4, 5, 4, 0, -4 },
  { 130, 3, 4, 4, 0, -3 },
  { 132, 3, 4, 4, 0, -4 },
  { 134, 3, 5, 4, 0, -5 },
  { 136, 3, 6, 4, 0, -5 },
  { 139, 3, 4, 4, 0, -4 },
  { 141, 2, 4, 4, 1, -4 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 3, 4, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -3 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 2, 4, 4, 1, -4 },
  { 157, 3, 3, 4, 0, -3 },
  { 159, 2, 3, 4, 1, -3 },
  { 160, 3, 3, 4, 1, -3 },
  { 162, 3, 3, 4, 0, -3 },
  { 164, 3, 4, 4, 0, -3 },
  { 166, 3, 3, 4, 0, -3 },
  { 168, 3, 6, 4, 1, -5 },
  { 171, 2, 6, 4, 1, -5 },
  { 173, 3, 6, 4, 0, -5 },
  { 176, 3, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_ExtraLightItalic6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC6PT7B_H_
