#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC26PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x20, 0x80,
  0x00, 0x63, 0xCE, 0x00, 0x63, 0x63, 0x63, 0x43, 0xC2, 0xC2, 0xC6, 0xC6,
  0x01, 0x0C, 0x06, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x87, 0xFF, 0xCF,
  0xFF, 0x86, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x80, 0x82, 0x0F, 0xFF,
  0x9F, 0xFF, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x80, 0x82, 0x03, 0x0C, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF0, 0x3A, 0xE1, 0x89,
  0x86, 0x22, 0x11, 0x88, 0x46, 0x01, 0x90, 0x07, 0x40, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0xCC, 0x02, 0x30, 0x08, 0xC4, 0x23, 0x10, 0x8C, 0x62,
  0x61, 0xFF, 0x03, 0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x07, 0x80, 0xC3, 0x30, 0x61, 0x8C, 0x30, 0x43, 0x18, 0x10, 0xC4, 0x04,
  0x32, 0x01, 0x09, 0x80, 0x7C, 0xC0, 0x04, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x80, 0x04, 0xF8, 0x02, 0x63, 0x01, 0x90, 0xC0, 0xC4, 0x20, 0x63, 0x08,
  0x30, 0xC2, 0x08, 0x19, 0x8C, 0x07, 0xC0, 0x07, 0xE0, 0x39, 0xC0, 0x83,
  0x06, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0xD8,
  0x16, 0x31, 0x90, 0xC4, 0xC1, 0xB3, 0x07, 0x8C, 0x0C, 0x30, 0x30, 0xC1,
  0xE3, 0x9C, 0xC7, 0xC3, 0x80, 0x7B, 0x6D, 0xA4, 0x00, 0x60, 0x3C, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xF0, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x0C, 0x21, 0xF9, 0x7C, 0xFF, 0x80, 0xC0, 0x0F, 0x00, 0xD8, 0x0C, 0x60,
  0xC3, 0x0E, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x1C, 0x63,
  0x8C, 0x71, 0x84, 0x30, 0xFF, 0x6F, 0xFE, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0xF7, 0x8C, 0x0C, 0x60,
  0x26, 0x01, 0x30, 0x09, 0x80, 0xCC, 0x06, 0x66, 0x32, 0x39, 0xB1, 0x8D,
  0x80, 0x4C, 0x06, 0x60, 0x33, 0x01, 0x98, 0x08, 0xC0, 0xC3, 0x9C, 0x0F,
  0xC0, 0x01, 0xC0, 0x3C, 0x0E, 0xC1, 0x8C, 0x10, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x38, 0xE1, 0x81, 0x84,
  0x02, 0x30, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x01,
  0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x78, 0x0F, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0xC0, 0x48, 0x0C, 0xC0, 0xCE, 0x38, 0x7F, 0x00, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x23, 0x06,
  0x60, 0x66, 0x06, 0xC0, 0x6F, 0xFE, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1F, 0xF1, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0xFC, 0x78, 0xE6, 0x06, 0x60, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x6C, 0x04, 0xC0, 0xC6, 0x38, 0x3F, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x10, 0x3F, 0xC7, 0x0E, 0x60, 0x6C,
  0x02, 0xC0, 0x2C, 0x02, 0x80, 0x6C, 0x06, 0xC0, 0xC7, 0x38, 0x3F, 0x00,
  0x7F, 0xFB, 0xFF, 0x90, 0x0D, 0x80, 0x4C, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x03, 0xF0, 0x71, 0xC6, 0x06,
  0x30, 0x11, 0x80, 0x8C, 0x0C, 0x60, 0x41, 0x8C, 0x07, 0xC0, 0x3C, 0x07,
  0x38, 0x60, 0xC6, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x63, 0x8E,
  0x0F, 0xE0, 0x0F, 0xC3, 0x8E, 0x60, 0x66, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x2C, 0x06, 0xC0, 0x6E, 0x1C, 0x7E, 0xC1, 0x98, 0x03, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0xF3, 0xCE, 0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60,
  0x40, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x30,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x8F, 0x83, 0x80, 0xC0,
  0x30, 0x08, 0x00, 0x00, 0x00, 0x60, 0x3C, 0x0E, 0x00, 0x01, 0xF8, 0x07,
  0x0C, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x02, 0x10, 0x02, 0x30, 0x22, 0x30,
  0xFA, 0x31, 0x86, 0x21, 0x06, 0x23, 0x06, 0x63, 0x04, 0x63, 0x04, 0x63,
  0x0C, 0x63, 0x0C, 0x63, 0x0C, 0x43, 0xFC, 0x40, 0x80, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x68, 0x03, 0x40, 0x12, 0x01, 0x90, 0x08, 0xC0, 0xC6, 0x06, 0x30,
  0x61, 0x83, 0x0C, 0x10, 0x61, 0xFF, 0x0F, 0xF8, 0xC0, 0x46, 0x02, 0x60,
  0x1B, 0x00, 0xF0, 0x06, 0x3F, 0xC1, 0xFF, 0x0C, 0x0C, 0x60, 0x63, 0x01,
  0x10, 0x19, 0x80, 0xCC, 0x0C, 0x7F, 0xC3, 0xFE, 0x18, 0x38, 0x80, 0xC4,
  0x02, 0x60, 0x13, 0x01, 0x98, 0x0C, 0xC0, 0xC7, 0xFC, 0x3F, 0x80, 0x07,
  0xE0, 0xE3, 0x86, 0x0C, 0x60, 0x22, 0x01, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x98,
  0x0C, 0xC0, 0xC3, 0x9C, 0x0F, 0xC0, 0x3F, 0xC3, 0xFE, 0x30, 0x73, 0x03,
  0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x02, 0x60, 0x24, 0x06,
  0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC1, 0x8F, 0xF0, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x7F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE3, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0x86,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0xE3, 0x86, 0x0C, 0x60, 0x22, 0x01,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0xFC, 0x88, 0x4C,
  0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xC3, 0x9C, 0x0F, 0xC0, 0x30,
  0x19, 0x80, 0xCC, 0x04, 0x60, 0x23, 0x03, 0x10, 0x19, 0x80, 0xCC, 0x06,
  0x7F, 0xE3, 0xFF, 0x18, 0x18, 0x80, 0xC4, 0x06, 0x60, 0x33, 0x01, 0x98,
  0x08, 0xC0, 0xC4, 0x06, 0x20, 0x30, 0x1F, 0xF8, 0xFF, 0x80, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x07, 0xFE, 0x3F,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0xC1, 0xCE, 0x03, 0xF0, 0x00, 0x30,
  0x0C, 0xC0, 0x63, 0x03, 0x0C, 0x0C, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18,
  0x60, 0x7F, 0x01, 0xFC, 0x06, 0x30, 0x10, 0x60, 0x41, 0x83, 0x06, 0x0C,
  0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x01, 0x88, 0x06, 0x00, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1C, 0x0C, 0x70, 0x71, 0x41, 0xC5, 0x0F, 0x34, 0x2C, 0xD1, 0xA3, 0x64,
  0x8C, 0xB6, 0x22, 0x98, 0x8C, 0x66, 0x31, 0x98, 0x04, 0x60, 0x11, 0x80,
  0xC4, 0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x02, 0x00, 0x38, 0x19,
  0xC0, 0xCE, 0x04, 0x78, 0x22, 0xC3, 0x12, 0x19, 0x90, 0xCC, 0x86, 0x66,
  0x23, 0x31, 0x18, 0x98, 0x84, 0xC4, 0x36, 0x61, 0xB3, 0x05, 0x98, 0x28,
  0xC1, 0xC4, 0x0E, 0x20, 0x70, 0x07, 0xE1, 0xC7, 0x18, 0x33, 0x03, 0x20,
  0x32, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x02, 0x40, 0x24, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xC7, 0x38, 0x3F, 0x00, 0x3F, 0xE1,
  0xFF, 0x8C, 0x06, 0x60, 0x33, 0x01, 0x90, 0x0D, 0x80, 0x6C, 0x06, 0x60,
  0x73, 0xFF, 0x1F, 0xE0, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x00, 0x07, 0xE1, 0xC7, 0x30, 0x33, 0x03, 0x20,
  0x16, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x40, 0x2C, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xC7, 0x38, 0x3F, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x3F, 0xE1, 0xFF, 0x8C, 0x0E, 0x60, 0x33,
  0x01, 0x90, 0x0D, 0x80, 0x4C, 0x06, 0x60, 0x63, 0xFE, 0x1F, 0xC0, 0x86,
  0x04, 0x10, 0x60, 0xC3, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x20, 0x18,
  0x03, 0xF0, 0x38, 0xE1, 0x81, 0x86, 0x02, 0x10, 0x08, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC4, 0x03, 0x10, 0x0C, 0x60, 0x61, 0xE3, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x19, 0x80, 0xCC, 0x04, 0x60, 0x23,
  0x03, 0x10, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18, 0x80,
  0xC4, 0x06, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0xC3, 0x9C, 0x0F, 0xC0,
  0xC0, 0x1A, 0x01, 0x90, 0x0C, 0xC0, 0x46, 0x06, 0x30, 0x31, 0x83, 0x0C,
  0x18, 0x60, 0x83, 0x0C, 0x08, 0x40, 0x46, 0x02, 0x30, 0x1B, 0x00, 0xD8,
  0x06, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x41, 0x86, 0x87, 0x09, 0x0E,
  0x32, 0x1C, 0x64, 0x78, 0x88, 0xB3, 0x31, 0x66, 0x66, 0x8C, 0xC9, 0x11,
  0x92, 0x63, 0x24, 0xC6, 0xC9, 0x0D, 0x12, 0x1A, 0x2C, 0x3C, 0x58, 0x70,
  0xA0, 0xE1, 0xC1, 0xC3, 0x83, 0x06, 0x00, 0x1C, 0x03, 0x0C, 0x06, 0x0C,
  0x0C, 0x06, 0x18, 0x06, 0x18, 0x02, 0x30, 0x03, 0x60, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x18,
  0x20, 0x18, 0x30, 0x30, 0x30, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x1A, 0x00,
  0x98, 0x0C, 0xC0, 0xC2, 0x04, 0x18, 0x60, 0xC6, 0x02, 0x20, 0x1B, 0x00,
  0xF0, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x0F, 0xC3, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0xF0, 0xFC, 0x00, 0x81, 0x83,
  0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x06, 0x04, 0x0C,
  0x18, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x02, 0x06, 0x0F, 0xC3, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x61, 0xF8, 0xFE, 0x00, 0x03, 0x01, 0xC0, 0xD0, 0x26, 0x19, 0x8C, 0x23,
  0x09, 0x83, 0x40, 0xF0, 0x10, 0xFF, 0xF8, 0xE6, 0x30, 0x02, 0x01, 0xFB,
  0x38, 0x72, 0x07, 0x60, 0x26, 0x02, 0x40, 0x64, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x6C, 0x0C, 0xC0, 0xC6, 0x3C, 0x3E, 0xC0, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x31, 0x02, 0xFC, 0x78, 0x67, 0x06, 0x60, 0x26, 0x02, 0x60,
  0x24, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCA, 0x38, 0x9F,
  0x00, 0x02, 0x01, 0xFC, 0x38, 0x63, 0x03, 0x60, 0x36, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x04, 0xC0, 0xC7, 0x38, 0x3F, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x23, 0x0F, 0xD8, 0xE1, 0xC4,
  0x0E, 0x60, 0x23, 0x01, 0x10, 0x18, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01,
  0x98, 0x18, 0xC0, 0xC3, 0x1E, 0x0F, 0xB0, 0x03, 0x01, 0xFC, 0x30, 0x62,
  0x02, 0x60, 0x26, 0x02, 0x40, 0x27, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x04, 0xC0, 0xC6, 0x38, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x02, 0x01, 0xFB,
  0x38, 0x72, 0x07, 0x60, 0x26, 0x02, 0x40, 0x64, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0xE6, 0x0C, 0x7F, 0xC3, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x7F, 0x07, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x31, 0x02, 0xFC,
  0x78, 0x67, 0x06, 0x60, 0x26, 0x02, 0x60, 0x64, 0x06, 0x40, 0x6C, 0x06,
  0xC0, 0x6C, 0x04, 0xC0, 0xC8, 0x0C, 0x80, 0xC0, 0x00, 0xC0, 0x1E, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x1F, 0xC0, 0xFC, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x90, 0x18, 0x81, 0x8C, 0x1C, 0x60,
  0xC3, 0x0C, 0x18, 0xC0, 0xFC, 0x04, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30,
  0xC0, 0xC6, 0x06, 0x20, 0x18, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xF1, 0xFC, 0x16, 0x30, 0xBD, 0xE3, 0x39, 0x88, 0x42,
  0x61, 0x09, 0x8C, 0x66, 0x31, 0x98, 0xC6, 0x42, 0x19, 0x08, 0x4C, 0x21,
  0x31, 0x8C, 0xC6, 0x33, 0x18, 0xC8, 0x63, 0x00, 0x11, 0x02, 0xFC, 0x78,
  0x67, 0x06, 0x60, 0x26, 0x02, 0x60, 0x64, 0x06, 0x40, 0x6C, 0x06, 0xC0,
  0x6C, 0x04, 0xC0, 0xC8, 0x0C, 0x80, 0xC0, 0x03, 0x01, 0xFC, 0x38, 0x63,
  0x06, 0x60, 0x26, 0x02, 0x40, 0x24, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x04, 0xC0, 0xC6, 0x38, 0x3F, 0x00, 0x08, 0x80, 0xBF, 0x0F, 0x0C, 0x70,
  0x23, 0x01, 0x18, 0x08, 0xC0, 0x44, 0x06, 0x20, 0x33, 0x01, 0x98, 0x0C,
  0xC0, 0x46, 0x06, 0x28, 0xE1, 0x3E, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x02, 0x01, 0xFB, 0x38, 0x72, 0x07, 0x60, 0x26, 0x02,
  0x40, 0x64, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xC6, 0x3C,
  0x7E, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x03, 0x7E,
  0x38, 0x73, 0x03, 0x20, 0x36, 0x03, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xFE, 0x30,
  0x66, 0x03, 0x60, 0x06, 0x00, 0x70, 0x03, 0xF8, 0x03, 0xC0, 0x06, 0x00,
  0x68, 0x06, 0xC0, 0xCE, 0x1C, 0x7F, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x0F, 0xFE, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0x83, 0xF0, 0x20, 0x36, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x26, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0,
  0xCC, 0x0C, 0x73, 0x83, 0xF0, 0xC0, 0x3C, 0x06, 0xC0, 0x64, 0x0C, 0x40,
  0xC6, 0x18, 0x61, 0x86, 0x30, 0x23, 0x02, 0x60, 0x26, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0xC3, 0x0F, 0x1C, 0x6C, 0x51, 0xB1, 0x44, 0xCD, 0x13, 0x24,
  0xCC, 0x92, 0x36, 0x48, 0xD1, 0x63, 0x45, 0x0F, 0x14, 0x38, 0x70, 0xE1,
  0x83, 0x86, 0x00, 0x38, 0x1C, 0x60, 0xC0, 0xC6, 0x03, 0x18, 0x04, 0xC0,
  0x1E, 0x00, 0x30, 0x01, 0xC0, 0x0D, 0x80, 0x62, 0x01, 0x8C, 0x0C, 0x10,
  0x60, 0x63, 0x00, 0xC0, 0x20, 0x36, 0x03, 0x60, 0x36, 0x02, 0x60, 0x64,
  0x06, 0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xE1, 0x47, 0xFC, 0x3C, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x87, 0xF0, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x10, 0x0F, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0xF8, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x0C, 0x00, 0xF8, 0x03, 0x80, 0x0C, 0x30,
  0xC2, 0x08, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x86,
  0x18, 0x61, 0x84, 0x10, 0xC0, 0x08, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x06,
  0x00, 0x1F, 0x81, 0xC0, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x1F, 0x00, 0xE0, 0x00, 0x10, 0x17,
  0xC1, 0xC6, 0x3C, 0x33, 0xC3, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 8, 8, 16, 5, -19 },
  { 24, 15, 19, 16, 1, -19 },
  { 60, 14, 27, 16, 1, -23 },
  { 108, 18, 19, 16, -1, -19 },
  { 151, 14, 19, 16, 1, -19 },
  { 185, 3, 8, 16, 8, -19 },
  { 188, 11, 25, 16, 4, -22 },
  { 223, 11, 25, 16, 1, -22 },
  { 258, 13, 13, 16, 2, -16 },
  { 280, 12, 12, 16, 2, -15 },
  { 298, 6, 8, 16, 3, -4 },
  { 304, 8, 1, 16, 4, -9 },
  { 305, 4, 4, 16, 5, -4 },
  { 307, 15, 25, 16, 1, -22 },
  { 354, 13, 19, 16, 2, -19 },
  { 385, 12, 19, 16, 1, -19 },
  { 414, 14, 19, 16, 1, -19 },
  { 448, 12, 19, 16, 2, -19 },
  { 477, 12, 19, 16, 2, -19 },
  { 506, 12, 19, 16, 2, -19 },
  { 535, 12, 19, 16, 2, -19 },
  { 564, 13, 19, 16, 3, -19 },
  { 595, 13, 19, 16, 1, -19 },
  { 626, 12, 19, 16, 3, -19 },
  { 655, 6, 15, 16, 5, -15 },
  { 667, 8, 19, 16, 3, -15 },
  { 686, 13, 13, 16, 2, -15 },
  { 708, 12, 7, 16, 2, -12 },
  { 719, 13, 13, 16, 1, -15 },
  { 741, 10, 19, 16, 4, -19 },
  { 765, 16, 24, 16, 0, -19 },
  { 813, 13, 19, 16, 0, -19 },
  { 844, 13, 19, 16, 2, -19 },
  { 875, 13, 19, 16, 2, -19 },
  { 906, 12, 19, 16, 2, -19 },
  { 935, 13, 19, 16, 2, -19 },
  { 966, 14, 19, 16, 2, -19 },
  { 1000, 13, 19, 16, 2, -19 },
  { 1031, 13, 19, 16, 2, -19 },
  { 1062, 13, 19, 16, 2, -19 },
  { 1093, 14, 19, 16, 1, -19 },
  { 1127, 14, 19, 16, 2, -19 },
  { 1161, 11, 19, 16, 2, -19 },
  { 1188, 14, 19, 16, 1, -19 },
  { 1222, 13, 19, 16, 2, -19 },
  { 1253, 12, 19, 16, 2, -19 },
  { 1282, 13, 19, 16, 2, -19 },
  { 1313, 12, 24, 16, 2, -19 },
  { 1349, 13, 19, 16, 2, -19 },
  { 1380, 14, 19, 16, 1, -19 },
  { 1414, 13, 19, 16, 3, -19 },
  { 1445, 13, 19, 16, 2, -19 },
  { 1476, 13, 19, 16, 3, -19 },
  { 1507, 15, 19, 16, 2, -19 },
  { 1543, 16, 19, 16, 0, -19 },
  { 1581, 13, 19, 16, 3, -19 },
  { 1612, 14, 19, 16, 1, -19 },
  { 1646, 10, 25, 16, 4, -22 },
  { 1678, 7, 25, 16, 5, -22 },
  { 1700, 10, 25, 16, 2, -22 },
  { 1732, 10, 10, 16, 3, -19 },
  { 1745, 13, 1, 16, 0, 1 },
  { 1747, 4, 3, 16, 7, -20 },
  { 1749, 12, 15, 16, 2, -15 },
  { 1772, 12, 19, 16, 2, -19 },
  { 1801, 12, 15, 16, 2, -15 },
  { 1824, 13, 19, 16, 2, -19 },
  { 1855, 12, 15, 16, 2, -15 },
  { 1878, 17, 24, 16, -1, -19 },
  { 1929, 12, 20, 16, 2, -15 },
  { 1959, 12, 19, 16, 2, -19 },
  { 1988, 12, 20, 16, 1, -20 },
  { 2018, 14, 25, 16, 0, -20 },
  { 2062, 13, 19, 16, 2, -19 },
  { 2093, 10, 19, 16, 3, -19 },
  { 2117, 14, 15, 16, 1, -15 },
  { 2144, 12, 15, 16, 2, -15 },
  { 2167, 12, 15, 16, 2, -15 },
  { 2190, 13, 20, 16, 1, -15 },
  { 2223, 12, 20, 16, 2, -15 },
  { 2253, 12, 15, 16, 2, -15 },
  { 2276, 12, 15, 16, 2, -15 },
  { 2299, 11, 18, 16, 3, -18 },
  { 2324, 12, 14, 16, 2, -14 },
  { 2345, 12, 14, 16, 3, -14 },
  { 2366, 14, 14, 16, 2, -14 },
  { 2391, 14, 14, 16, 1, -14 },
  { 2416, 12, 19, 16, 2, -14 },
  { 2445, 13, 14, 16, 1, -14 },
  { 2468, 12, 25, 16, 3, -22 },
  { 2506, 6, 25, 16, 5, -22 },
  { 2525, 13, 25, 16, 1, -22 },
  { 2566, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC26PT7B_H_
