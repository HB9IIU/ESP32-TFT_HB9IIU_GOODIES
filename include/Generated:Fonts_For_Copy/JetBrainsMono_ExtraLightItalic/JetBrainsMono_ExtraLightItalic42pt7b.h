#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC42PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0F, 0x87, 0xC7, 0xE1, 0xE0,
  0x38, 0x3C, 0xE0, 0xE7, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07,
  0x1C, 0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38, 0x18, 0xE0, 0x60, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x38, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x60, 0x01, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x03,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x06, 0x03, 0x80, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x06, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x30,
  0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFD, 0xF0, 0x0E, 0x31, 0xE0,
  0x70, 0xC3, 0x81, 0xC3, 0x0E, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0xE0, 0xE0,
  0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x3C, 0x60, 0x00, 0x79, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0D, 0xF0, 0x00, 0x31, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x18,
  0x38, 0x00, 0x60, 0xE1, 0xC1, 0x83, 0x86, 0x06, 0x0E, 0x1C, 0x18, 0x38,
  0x70, 0x61, 0xC1, 0xE1, 0x8F, 0x03, 0xEC, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x1F,
  0xC0, 0x06, 0x03, 0x9E, 0x00, 0xE0, 0x70, 0x60, 0x1C, 0x06, 0x06, 0x03,
  0x80, 0xE0, 0x60, 0x30, 0x0E, 0x06, 0x06, 0x00, 0xC0, 0x60, 0xC0, 0x0C,
  0x06, 0x1C, 0x00, 0xC0, 0xE3, 0x80, 0x0C, 0x0C, 0x70, 0x00, 0xE1, 0xCE,
  0x00, 0x0F, 0xF8, 0xC0, 0x00, 0x3F, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x18,
  0xFF, 0x00, 0x03, 0x1C, 0x70, 0x00, 0x63, 0x83, 0x80, 0x0C, 0x30, 0x38,
  0x01, 0xC3, 0x03, 0x80, 0x38, 0x70, 0x30, 0x07, 0x07, 0x03, 0x00, 0x60,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x70, 0x38, 0x07, 0x0E,
  0x07, 0x00, 0x3F, 0xC0, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xC7, 0x80, 0x0E, 0x07, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xB8, 0x00, 0x1C, 0x70, 0x1E, 0x70, 0x70, 0x38,
  0xE0, 0xF0, 0xE1, 0x80, 0xE3, 0x87, 0x00, 0xE7, 0x0E, 0x01, 0xDC, 0x1C,
  0x01, 0xF0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x0F, 0x81, 0xC0,
  0x3F, 0x03, 0x80, 0xE7, 0x07, 0x87, 0x8E, 0x07, 0xFE, 0x0E, 0x07, 0xF8,
  0x0E, 0x00, 0x39, 0xCE, 0xF7, 0xB9, 0xCE, 0x73, 0x99, 0xCE, 0x00, 0x00,
  0x03, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x1C, 0x0E, 0x07, 0x7E,
  0x38, 0xFF, 0xFE, 0xCF, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x70,
  0x00, 0x03, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00,
  0x3C, 0x3C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x40,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0xFB, 0xF7, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x18, 0x30, 0x31, 0xC3, 0xC3, 0x8E, 0x1F,
  0x1C, 0x70, 0xF0, 0xE3, 0x83, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0x87, 0x00, 0x1C, 0x3C, 0x01, 0xE0, 0xE0, 0x1E, 0x07, 0xC3, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0x7B, 0x80, 0x3E, 0x70, 0x0F, 0x0E, 0x03, 0xC1, 0x80, 0x60, 0x70,
  0x08, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0x3F, 0x01, 0xE0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xF0, 0x0E, 0x03, 0xC1,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x01, 0xC1, 0xC0, 0x30, 0x70, 0x0E, 0x1C, 0x01, 0xC7,
  0x00, 0x39, 0xE0, 0x07, 0x38, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xCF, 0xE0, 0x19, 0xFF, 0x81, 0xB8, 0xF8, 0x3E, 0x03, 0xC3, 0xC0,
  0x1C, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x07, 0x07, 0x00, 0xF0, 0x7C, 0x1E, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0, 0x1E, 0x1C, 0x00, 0xE3, 0x80, 0x0F,
  0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x67, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80,
  0x78, 0x3E, 0x0F, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x60, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7E, 0xFC, 0x07,
  0x00, 0xF0, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x0E, 0x01, 0xC0, 0x38,
  0x3C, 0x01, 0xF7, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x38, 0x3C, 0x03, 0x80, 0x70, 0x38, 0x03, 0xC3, 0x80, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x06, 0x1C,
  0x00, 0x70, 0xF0, 0x07, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xCF, 0xC0, 0xE0, 0x1E, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C,
  0x70, 0x03, 0xC7, 0x80, 0x78, 0x3E, 0x3F, 0x81, 0xFF, 0xF0, 0x07, 0xEE,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x07, 0xC7, 0xE3, 0xF1,
  0xF8, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0x00, 0x40,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x7C, 0x01, 0xC0, 0x1E, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x07, 0xE6, 0x38,
  0x0F, 0xF6, 0x38, 0x1C, 0x16, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x0E, 0x30,
  0x30, 0x0E, 0x30, 0x70, 0x0C, 0x70, 0x70, 0x0C, 0x70, 0x70, 0x1C, 0x70,
  0x70, 0x1C, 0x70, 0x60, 0x1C, 0x60, 0x60, 0x1C, 0x60, 0x60, 0x18, 0x60,
  0x60, 0x38, 0xE0, 0x70, 0x78, 0xE0, 0x7F, 0xD8, 0xE0, 0x3F, 0xB8, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00,
  0x39, 0x80, 0x03, 0x18, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1C,
  0x03, 0x80, 0xC0, 0x70, 0x0C, 0x07, 0x00, 0xC0, 0x60, 0x0E, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xC0,
  0x3C, 0x06, 0x00, 0x78, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0x70, 0x0F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1C, 0x0F,
  0xC0, 0x60, 0x07, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0,
  0x07, 0x87, 0x00, 0x1C, 0x1C, 0x01, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFD, 0xF8,
  0x0F, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x00, 0xC3, 0x80,
  0x06, 0x1C, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0xC1, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0E, 0x03,
  0xE0, 0x60, 0x07, 0x03, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x61, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0,
  0x03, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x86, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x01,
  0xE0, 0xE0, 0x1E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFD, 0xF8,
  0x0F, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x00, 0xC3, 0x80,
  0x06, 0x1C, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x7F,
  0xE3, 0x83, 0xFF, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0C, 0x38,
  0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0xC1, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1C, 0x00,
  0x60, 0x60, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C,
  0x1E, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x3C,
  0x06, 0x00, 0x38, 0x06, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x1E, 0x1F, 0x00,
  0x78, 0x36, 0x00, 0xF0, 0x6C, 0x03, 0x60, 0xD8, 0x06, 0xC1, 0xB0, 0x1B,
  0x83, 0x70, 0x37, 0x0E, 0x60, 0xCC, 0x1C, 0xC1, 0x98, 0x39, 0x86, 0x30,
  0x73, 0x0C, 0xE0, 0xC7, 0x31, 0xC1, 0x86, 0x63, 0x83, 0x0D, 0x87, 0x0E,
  0x1B, 0x0C, 0x1C, 0x3C, 0x18, 0x38, 0x78, 0x70, 0x70, 0x00, 0xE0, 0xC0,
  0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x07, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xF0, 0x06,
  0x06, 0xC0, 0x18, 0x3B, 0x00, 0xE0, 0xEC, 0x03, 0x83, 0xB8, 0x0E, 0x0E,
  0xE0, 0x38, 0x39, 0x80, 0xC0, 0xC6, 0x03, 0x03, 0x1C, 0x1C, 0x1C, 0x70,
  0x70, 0x70, 0xC1, 0xC1, 0xC3, 0x07, 0x07, 0x0C, 0x1C, 0x18, 0x38, 0x60,
  0x60, 0xE1, 0x83, 0x81, 0x8E, 0x0E, 0x06, 0x38, 0x38, 0x1C, 0xE0, 0xE0,
  0x73, 0x83, 0x01, 0xCC, 0x0C, 0x03, 0x30, 0x70, 0x0C, 0xC1, 0xC0, 0x3F,
  0x07, 0x00, 0xFC, 0x1C, 0x01, 0xF0, 0x70, 0x07, 0x81, 0x80, 0x1E, 0x0E,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x78,
  0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x73, 0x80, 0x06, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0C,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01,
  0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00,
  0xF0, 0x7C, 0x1E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x38, 0x03, 0xE0, 0x60, 0x01, 0xC0,
  0xC0, 0x03, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80,
  0x0F, 0x07, 0x00, 0x3C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x78,
  0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x06, 0x38, 0x00, 0x63,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xF0, 0x07, 0x07, 0x00,
  0xF0, 0x7C, 0x1E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xC0, 0x1E, 0x06, 0x00, 0x3C, 0x18, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC3,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x03, 0xC1, 0xC0, 0x1E, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x60, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xBF, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1E, 0x00, 0xF0,
  0x3E, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00, 0x18,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0x60, 0x03,
  0x83, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x1E, 0x07, 0xC1, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x06, 0x00, 0x70, 0x60, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07,
  0x03, 0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x03, 0xB8, 0x00, 0x3B, 0x80,
  0x01, 0xB0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x1C, 0x07, 0x70, 0x1C, 0x06, 0x70, 0x3C, 0x06, 0x70, 0x3C, 0x0E, 0x70,
  0x3C, 0x0E, 0x70, 0x3C, 0x0C, 0x70, 0x6C, 0x0C, 0x70, 0x6C, 0x1C, 0x70,
  0x6C, 0x1C, 0x70, 0xCC, 0x18, 0x70, 0xCC, 0x38, 0x70, 0xCC, 0x38, 0x61,
  0x8C, 0x30, 0x61, 0x8C, 0x30, 0x61, 0x8C, 0x70, 0x61, 0x8C, 0x70, 0x63,
  0x0C, 0x60, 0x63, 0x0C, 0x60, 0x63, 0x0C, 0xE0, 0x66, 0x0C, 0xC0, 0x66,
  0x0C, 0xC0, 0x66, 0x0D, 0xC0, 0x64, 0x0D, 0xC0, 0x6C, 0x0D, 0x80, 0x6C,
  0x0D, 0x80, 0xEC, 0x0F, 0x80, 0xF8, 0x0B, 0x00, 0xF8, 0x0B, 0x00, 0xF8,
  0x0B, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x18, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x18, 0x07,
  0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x18, 0x38, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x19, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x03, 0xB0, 0x00, 0xCC, 0x00, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x18, 0x07,
  0x06, 0x01, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x0C, 0x1C, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x39, 0xC0, 0x06, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0x20, 0x00, 0x1F, 0xC7,
  0x07, 0xFE, 0x60, 0xF0, 0x36, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x18, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x78, 0x70, 0x0F, 0x87,
  0x81, 0xB0, 0x3F, 0xF3, 0x01, 0xFE, 0x70, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x40, 0x0E, 0x7F, 0x80, 0xEF, 0xFC, 0x0D, 0x81, 0xE0, 0xF0,
  0x0E, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0x80, 0x06, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x80, 0x1C,
  0x78, 0x03, 0x87, 0x80, 0x78, 0x7E, 0x0F, 0x07, 0x7F, 0xE0, 0xE3, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1, 0xE1, 0xE0,
  0x1E, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x70, 0xF8, 0x3C, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x04, 0x0E, 0x01, 0xFC, 0x70, 0x3F, 0xF3,
  0x03, 0xC0, 0xD8, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x06, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x1F, 0x07,
  0x81, 0xB0, 0x1F, 0xF9, 0x80, 0x7F, 0x9C, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x1D, 0xC0, 0x03, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xF0, 0x3C,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xC7, 0x07, 0xFE,
  0x60, 0xF0, 0x36, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x78, 0x78, 0x07, 0x83, 0xC1, 0xB8, 0x3F, 0xFB, 0x80, 0xFE, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x40, 0x0E, 0x7F, 0x80,
  0xEF, 0xFC, 0x0D, 0x81, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0x71, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x00,
  0x0C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC6, 0x00, 0x18, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x08, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00,
  0x38, 0x30, 0x03, 0x81, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x03, 0xC0, 0x38, 0x3C, 0x01, 0xC1, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x01, 0xC3, 0x00, 0x0F, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0x20, 0x19,
  0xF1, 0xF0, 0x37, 0xF7, 0xF0, 0xF0, 0xF0, 0xE1, 0xC1, 0xC1, 0xC3, 0x83,
  0x83, 0x87, 0x07, 0x07, 0x0C, 0x0E, 0x0E, 0x18, 0x18, 0x1C, 0x30, 0x30,
  0x38, 0xE0, 0x60, 0x61, 0xC1, 0xC0, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x07,
  0x0C, 0x0C, 0x0E, 0x18, 0x18, 0x1C, 0x70, 0x30, 0x30, 0xE0, 0x60, 0x61,
  0xC1, 0xC1, 0xC3, 0x83, 0x83, 0x86, 0x07, 0x07, 0x0C, 0x0C, 0x0E, 0x38,
  0x18, 0x1C, 0x70, 0x30, 0x30, 0x00, 0x04, 0x00, 0xE7, 0xF8, 0x0E, 0xFF,
  0xC0, 0xF8, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x30, 0x00, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x60, 0x01, 0x8E, 0x00, 0x38, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x07, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0xE6, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x38, 0x03, 0x87, 0x00, 0xF0, 0xF8, 0x3C, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x02, 0x00, 0x39, 0xFE, 0x01, 0xDF, 0xF8, 0x0F, 0x81,
  0xE0, 0x78, 0x07, 0x07, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x61, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x1F, 0x83, 0xC0,
  0xCF, 0xFC, 0x06, 0x3F, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xC7, 0x07, 0xFE, 0x60, 0xF0, 0x3E,
  0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0xC6, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x87, 0x00, 0x78, 0x70, 0x0F, 0x87, 0x81, 0xB0, 0x3F, 0xF3, 0x01,
  0xFE, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xE7, 0xF8, 0x0C, 0xFF, 0xC1, 0xD8, 0x1E, 0x1F, 0x00, 0xE1, 0xE0,
  0x0F, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x06, 0x38,
  0x00, 0x83, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x80, 0xF1, 0xC0, 0x0E, 0x30, 0x01,
  0xCE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x39,
  0xF0, 0x1E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x63,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x30, 0x00, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00,
  0x38, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x7C, 0x1E, 0x03, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xC6,
  0x00, 0x38, 0xC0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x0E,
  0x1C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x98, 0x00, 0x77, 0x00, 0x0E,
  0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x70, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x0D, 0x81, 0xE0, 0x6C, 0x1B, 0x07, 0x60, 0xD8,
  0x33, 0x06, 0xC1, 0x98, 0x66, 0x1C, 0xC3, 0x30, 0xC6, 0x19, 0x86, 0x31,
  0x8C, 0x71, 0x8C, 0x63, 0x0C, 0x63, 0x18, 0x66, 0x19, 0xC3, 0x30, 0xCC,
  0x19, 0x86, 0x60, 0xD8, 0x37, 0x06, 0xC1, 0xB0, 0x36, 0x0D, 0x81, 0xE0,
  0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x00,
  0x1E, 0x0E, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x1C, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x1D, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x0F, 0x00,
  0x1C, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x71, 0x80, 0x06, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00,
  0x0C, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x00, 0xF8, 0x7C, 0x1B, 0x83, 0xFF, 0x30, 0x1F, 0xE3, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x73, 0xFC, 0x07, 0x3F, 0xC0, 0x77, 0x0E, 0x07, 0x60, 0x70,
  0x66, 0x07, 0x8E, 0xE0, 0x3F, 0xCE, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 31, 25, 8, -31 },
  { 36, 14, 13, 25, 8, -31 },
  { 59, 24, 31, 25, 1, -31 },
  { 152, 22, 43, 25, 2, -37 },
  { 271, 28, 31, 25, -1, -31 },
  { 380, 23, 31, 25, 1, -31 },
  { 470, 5, 13, 25, 12, -31 },
  { 479, 17, 40, 25, 7, -35 },
  { 564, 17, 40, 25, 2, -35 },
  { 649, 22, 22, 25, 2, -26 },
  { 710, 20, 20, 25, 3, -24 },
  { 760, 10, 13, 25, 5, -6 },
  { 777, 14, 2, 25, 6, -15 },
  { 781, 7, 6, 25, 8, -6 },
  { 787, 24, 40, 25, 1, -35 },
  { 907, 21, 31, 25, 3, -31 },
  { 989, 19, 31, 25, 2, -31 },
  { 1063, 22, 31, 25, 2, -31 },
  { 1149, 21, 31, 25, 2, -31 },
  { 1231, 19, 31, 25, 3, -31 },
  { 1305, 20, 31, 25, 3, -31 },
  { 1383, 20, 31, 25, 2, -31 },
  { 1461, 20, 31, 25, 5, -31 },
  { 1539, 21, 31, 25, 2, -31 },
  { 1621, 20, 31, 25, 4, -31 },
  { 1699, 9, 24, 25, 8, -24 },
  { 1726, 13, 31, 25, 5, -24 },
  { 1777, 20, 22, 25, 4, -25 },
  { 1832, 20, 12, 25, 3, -20 },
  { 1862, 20, 22, 25, 2, -25 },
  { 1917, 16, 31, 25, 7, -31 },
  { 1979, 24, 39, 25, 1, -31 },
  { 2096, 20, 31, 25, 1, -31 },
  { 2174, 22, 31, 25, 2, -31 },
  { 2260, 21, 31, 25, 3, -31 },
  { 2342, 21, 31, 25, 2, -31 },
  { 2424, 22, 31, 25, 3, -31 },
  { 2510, 22, 31, 25, 3, -31 },
  { 2596, 21, 31, 25, 3, -31 },
  { 2678, 22, 31, 25, 2, -31 },
  { 2764, 20, 31, 25, 3, -31 },
  { 2842, 22, 31, 25, 1, -31 },
  { 2928, 24, 31, 25, 2, -31 },
  { 3021, 18, 31, 25, 3, -31 },
  { 3091, 23, 31, 25, 2, -31 },
  { 3181, 22, 31, 25, 2, -31 },
  { 3267, 20, 31, 25, 3, -31 },
  { 3345, 23, 31, 25, 2, -31 },
  { 3435, 20, 39, 25, 3, -31 },
  { 3533, 22, 31, 25, 2, -31 },
  { 3619, 22, 31, 25, 2, -31 },
  { 3705, 21, 31, 25, 5, -31 },
  { 3787, 21, 31, 25, 3, -31 },
  { 3869, 20, 31, 25, 6, -31 },
  { 3947, 24, 31, 25, 3, -31 },
  { 4040, 26, 31, 25, 0, -31 },
  { 4141, 21, 31, 25, 5, -31 },
  { 4223, 22, 31, 25, 2, -31 },
  { 4309, 16, 40, 25, 6, -35 },
  { 4389, 12, 40, 25, 7, -35 },
  { 4449, 16, 40, 25, 4, -35 },
  { 4529, 18, 17, 25, 4, -31 },
  { 4568, 21, 2, 25, 0, 1 },
  { 4574, 6, 6, 25, 12, -33 },
  { 4579, 20, 24, 25, 3, -24 },
  { 4639, 20, 31, 25, 2, -31 },
  { 4717, 19, 24, 25, 3, -24 },
  { 4774, 21, 31, 25, 3, -31 },
  { 4856, 19, 24, 25, 3, -24 },
  { 4913, 27, 39, 25, -1, -31 },
  { 5045, 20, 32, 25, 3, -24 },
  { 5125, 20, 31, 25, 2, -31 },
  { 5203, 19, 32, 25, 2, -32 },
  { 5279, 21, 40, 25, 1, -32 },
  { 5384, 21, 31, 25, 3, -31 },
  { 5466, 16, 31, 25, 5, -31 },
  { 5528, 23, 24, 25, 1, -24 },
  { 5597, 20, 24, 25, 2, -24 },
  { 5657, 19, 24, 25, 3, -24 },
  { 5714, 21, 32, 25, 1, -24 },
  { 5798, 20, 32, 25, 3, -24 },
  { 5878, 20, 24, 25, 3, -24 },
  { 5938, 19, 24, 25, 3, -24 },
  { 5995, 19, 29, 25, 4, -29 },
  { 6064, 20, 23, 25, 3, -23 },
  { 6122, 19, 23, 25, 5, -23 },
  { 6177, 21, 23, 25, 4, -23 },
  { 6238, 23, 23, 25, 1, -23 },
  { 6305, 20, 31, 25, 3, -23 },
  { 6383, 20, 23, 25, 2, -23 },
  { 6441, 21, 40, 25, 4, -35 },
  { 6546, 9, 40, 25, 9, -35 },
  { 6591, 21, 40, 25, 1, -35 },
  { 6696, 20, 8, 25, 3, -19 },
};

const GFXfont JetBrainsMono_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC42PT7B_H_
