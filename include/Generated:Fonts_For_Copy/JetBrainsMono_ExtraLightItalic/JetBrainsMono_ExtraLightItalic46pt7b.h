#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC46PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x38, 0x1E, 0xF0, 0x39,
  0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x70,
  0x39, 0xE0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x01,
  0xC0, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xE3, 0x3E,
  0x03, 0xC3, 0x0E, 0x03, 0x87, 0x0E, 0x07, 0x06, 0x0F, 0x07, 0x06, 0x0F,
  0x07, 0x06, 0x0E, 0x0F, 0x06, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x8C, 0x00, 0x03, 0xEC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x19, 0xF0,
  0x00, 0x18, 0x78, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38,
  0x00, 0x38, 0x38, 0x70, 0x30, 0x38, 0x70, 0x30, 0x38, 0x70, 0x30, 0x38,
  0x70, 0x30, 0x70, 0x78, 0x30, 0xF0, 0x3C, 0x71, 0xE0, 0x3F, 0x77, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x0E, 0x03, 0xFC, 0x00, 0x38, 0x0F, 0xFC, 0x00, 0x60,
  0x1C, 0x1C, 0x01, 0x80, 0x70, 0x38, 0x07, 0x00, 0xC0, 0x70, 0x1C, 0x01,
  0x80, 0xE0, 0x70, 0x07, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x07, 0x00, 0x1C,
  0x06, 0x0C, 0x00, 0x38, 0x1C, 0x38, 0x00, 0x70, 0x38, 0xE0, 0x00, 0xE0,
  0xE3, 0x80, 0x00, 0xFF, 0x8E, 0x00, 0x00, 0xFE, 0x38, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x01, 0xC7, 0xFC, 0x00, 0x07, 0x1E,
  0x3C, 0x00, 0x0C, 0x70, 0x38, 0x00, 0x30, 0xE0, 0x70, 0x00, 0xE1, 0x80,
  0xE0, 0x03, 0x83, 0x01, 0xC0, 0x0E, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x06,
  0x00, 0xE0, 0x38, 0x0C, 0x01, 0x80, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x70,
  0x1C, 0x01, 0xE3, 0xC0, 0x70, 0x01, 0xFF, 0x01, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x07,
  0x80, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x1C, 0x01, 0xC7, 0x0F, 0x01, 0xC7,
  0x03, 0x81, 0xE3, 0x80, 0xE0, 0xE1, 0xC0, 0x78, 0xE0, 0xE0, 0x1C, 0xE0,
  0xF0, 0x0F, 0x70, 0x70, 0x03, 0xF0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78,
  0x0E, 0x00, 0x3C, 0x07, 0x00, 0x3F, 0x03, 0x80, 0x3B, 0x81, 0xE0, 0x38,
  0xE0, 0xFC, 0xF8, 0x70, 0x3F, 0xF8, 0x1C, 0x0F, 0xF8, 0x0F, 0x00, 0x3C,
  0xF3, 0x8E, 0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x73, 0x80, 0x00, 0x00,
  0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x60, 0x18, 0x06, 0xFC, 0x18, 0x3E, 0xFF, 0x19, 0xFF, 0x3F, 0xD3, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xDC, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x30, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x3E, 0x7F, 0x7F, 0x7F, 0x7E, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xE0, 0x78, 0x03, 0xC1,
  0xE0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x1E, 0x1C, 0x38, 0x7C, 0x38, 0x70, 0xF8,
  0x71, 0xE1, 0xF0, 0xE3, 0x80, 0x81, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1E,
  0x01, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFB, 0x80, 0x0F, 0x38,
  0x01, 0xF1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x04, 0x03, 0x80, 0x40,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78,
  0x1F, 0x8F, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x0F, 0x07, 0x00, 0x70, 0x78, 0x03, 0x87, 0x80, 0x1C, 0x78,
  0x00, 0xE3, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x20, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC3, 0xF8, 0x03, 0x9F, 0xF8, 0x07, 0x7F, 0xF8, 0x0F, 0xC0,
  0xF8, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x07,
  0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1E, 0x01, 0xE0, 0x1F, 0x0F, 0x80, 0x1F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3D, 0xFE, 0x01, 0xFF, 0xFC, 0x1F,
  0x83, 0xE1, 0xF0, 0x07, 0x8F, 0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x00, 0x03,
  0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCF, 0x00, 0x0E, 0x38, 0x00, 0xE1,
  0xE0, 0x1F, 0x07, 0xC3, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9C, 0x00, 0x0E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xF0, 0x07, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0x1E, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x1E,
  0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1E, 0x03, 0xE1, 0xE0, 0x0F,
  0x1E, 0x00, 0x38, 0xE0, 0x01, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B,
  0xC0, 0x03, 0xDE, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF7, 0x00, 0x7C, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xF7, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x03, 0xF9, 0xC7,
  0x01, 0xFF, 0x71, 0xC0, 0xF0, 0xD8, 0xE0, 0x78, 0x0E, 0x38, 0x1C, 0x03,
  0x8E, 0x07, 0x00, 0xE3, 0x81, 0x80, 0x38, 0xE0, 0xE0, 0x0E, 0x38, 0x38,
  0x03, 0x0C, 0x0E, 0x01, 0xC7, 0x03, 0x80, 0x71, 0xC0, 0xE0, 0x1C, 0x70,
  0x38, 0x07, 0x1C, 0x0C, 0x01, 0xC7, 0x07, 0x00, 0xF1, 0x80, 0xE0, 0x38,
  0xE0, 0x3C, 0x36, 0x38, 0x0F, 0xFF, 0x8E, 0x01, 0xFC, 0xE3, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x60, 0x01, 0xC1,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xC0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x06, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x38, 0x07, 0xC0, 0xE0, 0x03, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E,
  0x07, 0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xE0, 0x0F, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x01,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xE0, 0x78, 0x03,
  0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x38,
  0x1E, 0x00, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xC0, 0x7C, 0x0E,
  0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x0E, 0x00,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x08, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xE0, 0x78, 0x03,
  0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x3F, 0xF0, 0xE0, 0xFF, 0xE1, 0xC1, 0xFF, 0xC3, 0x80, 0x03, 0x8F, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x38,
  0x1E, 0x00, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x80, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x70, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x70,
  0x3C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xD8, 0x03, 0xE0, 0x6C, 0x01, 0xB0, 0x76, 0x01, 0xD8, 0x3B, 0x80,
  0xDC, 0x1D, 0xC0, 0xEE, 0x0E, 0x60, 0x67, 0x07, 0x30, 0x73, 0x83, 0x18,
  0x31, 0x83, 0x8C, 0x39, 0xC1, 0xC7, 0x18, 0xE0, 0xE3, 0x9C, 0x70, 0x70,
  0xCC, 0x38, 0x38, 0x6E, 0x1C, 0x1C, 0x36, 0x1C, 0x0E, 0x1F, 0x0E, 0x0E,
  0x0F, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1F, 0x00, 0x38, 0x7E,
  0x00, 0x70, 0xFC, 0x00, 0xE1, 0xD8, 0x03, 0x83, 0xB0, 0x07, 0x07, 0x70,
  0x0E, 0x0E, 0xE0, 0x1C, 0x19, 0xC0, 0x38, 0x71, 0x80, 0x70, 0xE3, 0x80,
  0xC1, 0xC7, 0x03, 0x83, 0x8E, 0x07, 0x07, 0x0C, 0x0E, 0x0E, 0x18, 0x1C,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC0, 0xC3, 0x83,
  0x81, 0xC7, 0x07, 0x03, 0x8E, 0x1C, 0x07, 0x1C, 0x38, 0x06, 0x38, 0x70,
  0x0C, 0xE0, 0xE0, 0x1D, 0xC1, 0xC0, 0x3B, 0x83, 0x80, 0x77, 0x06, 0x00,
  0x6E, 0x1C, 0x00, 0xFC, 0x38, 0x01, 0xF0, 0x70, 0x03, 0xE0, 0xE0, 0x03,
  0xC1, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1,
  0xC0, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0xC7, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07,
  0x00, 0x7C, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x1C,
  0x00, 0x78, 0x3C, 0x01, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xE0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1E, 0x01,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0x00, 0xFC, 0x0E, 0x00, 0x3E,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x3F, 0x8F, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0,
  0x1F, 0x8F, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x81,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xB8, 0x0F,
  0x01, 0xDC, 0x07, 0x80, 0xEE, 0x07, 0xC0, 0x76, 0x03, 0x60, 0x73, 0x01,
  0xB0, 0x39, 0x80, 0xD8, 0x1C, 0xC0, 0xCC, 0x0C, 0x60, 0x66, 0x0E, 0x30,
  0x33, 0x07, 0x38, 0x39, 0x83, 0x9C, 0x18, 0xC3, 0x8E, 0x0C, 0xE1, 0xC7,
  0x06, 0x70, 0xE3, 0x86, 0x38, 0x61, 0xC3, 0x18, 0x70, 0xE1, 0x8C, 0x38,
  0x71, 0xC6, 0x1C, 0x38, 0xC3, 0x0C, 0x1C, 0x61, 0x8E, 0x0E, 0x70, 0xC7,
  0x07, 0x30, 0x63, 0x03, 0x98, 0x31, 0x81, 0xCC, 0x19, 0xC0, 0xEC, 0x0C,
  0xE0, 0x76, 0x06, 0x60, 0x3B, 0x03, 0x70, 0x1B, 0x81, 0xB8, 0x0D, 0x80,
  0xD8, 0x06, 0xC0, 0x6C, 0x03, 0x60, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x71, 0x80, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0xE0, 0xE0, 0x3C, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x38,
  0x38, 0x03, 0x0E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0xE0, 0xE1, 0xE1,
  0xC1, 0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x70, 0x3F, 0xF9, 0xC1,
  0xE0, 0x7E, 0x0F, 0x00, 0xF8, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01,
  0xE1, 0xC0, 0x0F, 0x87, 0x80, 0x7C, 0x0F, 0x87, 0x70, 0x1F, 0xFD, 0xC0,
  0x3F, 0xC7, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x0F, 0x00, 0x73, 0xFE, 0x07, 0x3F, 0xF8, 0x3B, 0x83, 0xE1, 0xF0,
  0x07, 0x0F, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x7C, 0x00, 0xE3, 0xE0, 0x0E,
  0x1D, 0xC3, 0xF0, 0xE7, 0xFE, 0x07, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x78, 0x78,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x47, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C,
  0x0F, 0xC7, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x1C, 0x03,
  0xFE, 0x38, 0x0F, 0xFE, 0x70, 0x3C, 0x0F, 0xC0, 0xF0, 0x0F, 0x83, 0xC0,
  0x0F, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x7C, 0x1E,
  0x01, 0xF0, 0x1F, 0x0E, 0xE0, 0x1F, 0xFD, 0xC0, 0x1F, 0xE3, 0x80, 0x00,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xF0, 0x07,
  0x0F, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xE0, 0x0E, 0x07,
  0xC1, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xF1, 0xC1, 0xFF, 0xCE, 0x1E, 0x07, 0xE1, 0xE0, 0x1F, 0x1E,
  0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07,
  0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x87, 0x80, 0xDC, 0x3F, 0xBE, 0xE0, 0xFF, 0xEE, 0x01, 0xFC,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x1F, 0x00, 0x73, 0xFE, 0x07, 0x3F, 0xF8, 0x3B, 0x83, 0xE1,
  0xF0, 0x07, 0x0F, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00,
  0x39, 0xC0, 0x03, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x07, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1C, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x1E,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x38, 0x1C,
  0x07, 0x7F, 0x3F, 0x03, 0xFF, 0xBF, 0xC1, 0xE1, 0xD0, 0xE0, 0xE0, 0xF0,
  0x70, 0x70, 0x30, 0x38, 0x70, 0x18, 0x1C, 0x38, 0x1C, 0x0E, 0x1C, 0x0E,
  0x07, 0x0E, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC3, 0x81, 0x80, 0xC3, 0x80,
  0xC0, 0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x38,
  0x1C, 0x0E, 0x1C, 0x0C, 0x07, 0x0C, 0x06, 0x07, 0x0E, 0x07, 0x03, 0x87,
  0x03, 0x81, 0xC3, 0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x38,
  0x60, 0x30, 0x18, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x73, 0xFE,
  0x07, 0x3F, 0xF8, 0x3B, 0x83, 0xE1, 0xF0, 0x07, 0x0F, 0x00, 0x3C, 0x70,
  0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xC0, 0x03, 0xCE, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0x03, 0xE0, 0xF0, 0x07, 0x0F, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x3C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xE0, 0x1E, 0x07, 0xC3, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0x3F, 0xE0, 0x1C, 0xFF, 0xE0, 0x3B, 0x83,
  0xE0, 0x7C, 0x01, 0xC0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x87, 0xC0, 0x0E, 0x0E, 0x80, 0x38, 0x1D, 0xC3, 0xF0, 0x39, 0xFF,
  0x80, 0x71, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x70, 0x3F, 0xFB, 0xC1,
  0xE0, 0x7E, 0x0F, 0x00, 0xF8, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00,
  0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01,
  0xE1, 0xC0, 0x0F, 0x87, 0x80, 0x7C, 0x0F, 0x87, 0x70, 0x1F, 0xF9, 0xC0,
  0x3F, 0xC7, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x02, 0x0F, 0x00, 0xE3, 0xFE, 0x07, 0x7F, 0xF8, 0x3B, 0x03, 0xE1,
  0xF0, 0x07, 0x0F, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x01, 0xF0, 0xE0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xEE, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x0F, 0x81,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x78, 0x03,
  0xC0, 0xE0, 0x1E, 0x03, 0xF1, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xE0, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x01, 0x80, 0xE0, 0x0E, 0x0F,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x03,
  0x1C, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x0E,
  0xE0, 0x78, 0x0E, 0xE0, 0x78, 0x0C, 0xE0, 0x78, 0x1C, 0xE0, 0xD8, 0x1C,
  0xE0, 0xD8, 0x18, 0xE0, 0xD8, 0x38, 0xE1, 0x98, 0x38, 0xE1, 0x98, 0x30,
  0xE1, 0x98, 0x70, 0xE3, 0x0C, 0x70, 0xE3, 0x0C, 0x60, 0xE3, 0x0C, 0xE0,
  0xE6, 0x0C, 0xE0, 0xE6, 0x0C, 0xC0, 0xE6, 0x0D, 0xC0, 0xEC, 0x0D, 0xC0,
  0xEC, 0x0D, 0x80, 0xEC, 0x0D, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x81, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x38, 0x07, 0x80, 0x1C, 0x07,
  0x80, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x73,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01,
  0xE3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x3C, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x80, 0x3E, 0x0F, 0x01, 0xB8, 0x3F,
  0xBD, 0xC0, 0x7F, 0xE7, 0x00, 0x7F, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x20, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x7F, 0x00, 0x73, 0xFE, 0x01, 0xCE,
  0x1C, 0x07, 0x70, 0x78, 0x1D, 0xC0, 0xF0, 0xE7, 0x01, 0xE7, 0x9C, 0x03,
  0xFC, 0xE0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 34, 28, 9, -34 },
  { 44, 15, 14, 28, 9, -34 },
  { 71, 27, 34, 28, 1, -34 },
  { 186, 24, 46, 28, 2, -40 },
  { 324, 31, 34, 28, -1, -34 },
  { 456, 25, 34, 28, 1, -34 },
  { 563, 6, 14, 28, 13, -34 },
  { 574, 18, 45, 28, 8, -39 },
  { 676, 19, 45, 28, 2, -39 },
  { 783, 24, 23, 28, 3, -28 },
  { 852, 22, 21, 28, 3, -26 },
  { 910, 11, 14, 28, 5, -7 },
  { 930, 15, 3, 28, 7, -17 },
  { 936, 8, 7, 28, 8, -7 },
  { 943, 27, 43, 28, 1, -38 },
  { 1089, 23, 34, 28, 3, -34 },
  { 1187, 21, 34, 28, 2, -34 },
  { 1277, 24, 34, 28, 2, -34 },
  { 1379, 22, 34, 28, 3, -34 },
  { 1473, 21, 34, 28, 3, -34 },
  { 1563, 23, 34, 28, 3, -34 },
  { 1661, 21, 34, 28, 3, -34 },
  { 1751, 22, 34, 28, 6, -34 },
  { 1845, 23, 34, 28, 3, -34 },
  { 1943, 21, 34, 28, 5, -34 },
  { 2033, 11, 26, 28, 8, -26 },
  { 2069, 14, 33, 28, 5, -26 },
  { 2127, 22, 24, 28, 4, -27 },
  { 2193, 22, 13, 28, 3, -22 },
  { 2229, 21, 24, 28, 3, -27 },
  { 2292, 18, 34, 28, 7, -34 },
  { 2369, 26, 42, 28, 1, -34 },
  { 2506, 22, 34, 28, 1, -34 },
  { 2600, 23, 34, 28, 3, -34 },
  { 2698, 23, 34, 28, 3, -34 },
  { 2796, 22, 34, 28, 3, -34 },
  { 2890, 24, 34, 28, 3, -34 },
  { 2992, 24, 34, 28, 3, -34 },
  { 3094, 23, 34, 28, 3, -34 },
  { 3192, 23, 34, 28, 3, -34 },
  { 3290, 23, 34, 28, 3, -34 },
  { 3388, 25, 34, 28, 1, -34 },
  { 3495, 25, 34, 28, 3, -34 },
  { 3602, 20, 34, 28, 3, -34 },
  { 3687, 25, 34, 28, 2, -34 },
  { 3794, 23, 34, 28, 3, -34 },
  { 3892, 22, 34, 28, 3, -34 },
  { 3986, 24, 34, 28, 3, -34 },
  { 4088, 23, 42, 28, 3, -34 },
  { 4209, 24, 34, 28, 3, -34 },
  { 4311, 24, 34, 28, 2, -34 },
  { 4413, 22, 34, 28, 6, -34 },
  { 4507, 23, 34, 28, 3, -34 },
  { 4605, 22, 34, 28, 6, -34 },
  { 4699, 25, 34, 28, 4, -34 },
  { 4806, 28, 34, 28, 0, -34 },
  { 4925, 24, 34, 28, 5, -34 },
  { 5027, 24, 34, 28, 2, -34 },
  { 5129, 18, 43, 28, 7, -38 },
  { 5226, 13, 43, 28, 8, -38 },
  { 5296, 18, 43, 28, 4, -38 },
  { 5393, 19, 18, 28, 5, -34 },
  { 5436, 23, 3, 28, 0, 1 },
  { 5445, 7, 6, 28, 13, -36 },
  { 5451, 22, 26, 28, 3, -26 },
  { 5523, 21, 34, 28, 3, -34 },
  { 5613, 22, 26, 28, 3, -26 },
  { 5685, 23, 34, 28, 3, -34 },
  { 5783, 21, 26, 28, 3, -26 },
  { 5852, 30, 42, 28, -2, -34 },
  { 6010, 21, 34, 28, 4, -26 },
  { 6100, 21, 34, 28, 3, -34 },
  { 6190, 21, 35, 28, 2, -35 },
  { 6282, 23, 43, 28, 1, -35 },
  { 6406, 24, 34, 28, 3, -34 },
  { 6508, 18, 34, 28, 5, -34 },
  { 6585, 25, 26, 28, 1, -26 },
  { 6667, 21, 26, 28, 3, -26 },
  { 6736, 21, 26, 28, 3, -26 },
  { 6805, 23, 34, 28, 1, -26 },
  { 6903, 22, 34, 28, 3, -26 },
  { 6997, 21, 26, 28, 4, -26 },
  { 7066, 21, 26, 28, 3, -26 },
  { 7135, 20, 32, 28, 5, -32 },
  { 7215, 22, 25, 28, 3, -25 },
  { 7284, 21, 25, 28, 5, -25 },
  { 7350, 24, 25, 28, 4, -25 },
  { 7425, 25, 25, 28, 1, -25 },
  { 7504, 22, 33, 28, 3, -25 },
  { 7595, 23, 25, 28, 2, -25 },
  { 7667, 22, 43, 28, 5, -38 },
  { 7786, 10, 43, 28, 9, -38 },
  { 7840, 22, 43, 28, 2, -38 },
  { 7959, 22, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC46PT7B_H_
