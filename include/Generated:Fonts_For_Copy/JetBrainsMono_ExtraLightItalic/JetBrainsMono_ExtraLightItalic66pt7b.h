#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC66PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C,
  0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xCE,
  0x7F, 0x00, 0x0F, 0x83, 0x87, 0xE0, 0x07, 0xC1, 0xE0, 0xF8, 0x03, 0xE0,
  0x70, 0x3E, 0x00, 0xF0, 0x1C, 0x07, 0xC0, 0x7C, 0x07, 0x01, 0xF0, 0x1E,
  0x01, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x0E, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x03, 0xE0, 0x38, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x07, 0xE1, 0xC0, 0x00, 0x00, 0xFE, 0x70, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xBF, 0xC0, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x00, 0x38, 0x3E, 0x00,
  0x00, 0x0E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x38,
  0x03, 0xC1, 0xF0, 0x0E, 0x01, 0xF0, 0x7C, 0x03, 0x80, 0x78, 0x1F, 0x00,
  0xE0, 0x3E, 0x03, 0xE0, 0x38, 0x1F, 0x00, 0xFC, 0x0E, 0x0F, 0xC0, 0x1F,
  0x87, 0x87, 0xE0, 0x07, 0xFD, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0xC1,
  0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xC3, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x07, 0xC0, 0x00,
  0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x38, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xC0, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x3C, 0x7C, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0xF8,
  0x03, 0xE1, 0xE0, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0x1E, 0x0F, 0x00,
  0x1F, 0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x3C, 0x00, 0x3E, 0x3C, 0x07,
  0x80, 0x07, 0xCF, 0x81, 0xF0, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x07, 0xF8,
  0x07, 0x80, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x0F, 0x00,
  0x03, 0xFE, 0x01, 0xE0, 0x00, 0xFB, 0xC0, 0x3E, 0x00, 0x3E, 0x7C, 0x07,
  0xE0, 0x1F, 0x87, 0xC0, 0xFF, 0x1F, 0xE0, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F,
  0x80, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x3D, 0xF8, 0x07, 0x80,
  0x7F, 0xFF, 0xC0, 0xE0, 0x7F, 0xFF, 0xFC, 0x38, 0xFF, 0xF3, 0xFF, 0x8C,
  0x7F, 0xF0, 0x1F, 0xFB, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x02, 0x03, 0xF8, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0x7F, 0x8F, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x01, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x7C, 0x0F, 0xC0, 0x78, 0x3C,
  0x0F, 0xE0, 0x7C, 0x1E, 0x07, 0xF0, 0x3E, 0x0F, 0x03, 0xF8, 0x1F, 0x0F,
  0x80, 0xFC, 0x0F, 0x07, 0xC0, 0x7C, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0E,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x7F,
  0x1E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x01, 0xF8, 0x0F,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x60, 0x03, 0xC0,
  0x02, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x43, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x78, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x8F, 0xFF, 0x00, 0x0F, 0x1F, 0xFF, 0xC0, 0x0F,
  0x3F, 0xFF, 0xC0, 0x0F, 0x7C, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x3E, 0xFF, 0xFC, 0x00, 0x7B, 0xFF, 0xFC,
  0x01, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0x7C,
  0x00, 0x7F, 0xFD, 0xF0, 0x00, 0x3F, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFE, 0x03, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xE1, 0xE0, 0x78, 0x00, 0xFF, 0xE7,
  0x83, 0xE0, 0x07, 0xFF, 0xDE, 0x0F, 0x00, 0x3F, 0xDF, 0x78, 0x3C, 0x01,
  0xF8, 0x07, 0xE0, 0xF0, 0x07, 0xC0, 0x1F, 0x83, 0xC0, 0x3E, 0x00, 0x3C,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0xF0,
  0x78, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x1E,
  0x00, 0xF8, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x0F, 0xC1, 0xE0, 0x07, 0xE0,
  0xEF, 0x07, 0x80, 0x1F, 0xFF, 0x38, 0x1E, 0x00, 0x3F, 0xF8, 0xE0, 0x78,
  0x00, 0x7F, 0xC7, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1E, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFC, 0x3E, 0x03, 0xFF, 0xFC, 0x3C, 0x03,
  0xFF, 0xF8, 0x3C, 0x03, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1D, 0xC0, 0x00, 0xEE, 0x01,
  0xDC, 0x00, 0x1F, 0xE0, 0x1D, 0xC0, 0x01, 0xDE, 0x03, 0xDE, 0x00, 0x3D,
  0xE0, 0x3D, 0xE0, 0x03, 0x9C, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x3C, 0xE0,
  0x07, 0x3C, 0x03, 0xCE, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x7C, 0x07, 0x87, 0x03, 0xC7,
  0x80, 0x78, 0x70, 0x38, 0x78, 0x07, 0x87, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x70, 0x78, 0x0F, 0x87, 0x8F, 0x0F, 0x80, 0xF8, 0x38, 0xE0, 0xF8, 0x0F,
  0x03, 0x9E, 0x0F, 0x00, 0xF0, 0x39, 0xC0, 0xF0, 0x0F, 0x03, 0xFC, 0x0F,
  0x00, 0xF0, 0x3F, 0x80, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x00,
  0x01, 0xE0, 0x1F, 0xC0, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x1E, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x77, 0x80, 0x03, 0xE0, 0x3D, 0xE0, 0x00, 0xF8, 0x0F,
  0x78, 0x00, 0x3C, 0x03, 0xDE, 0x00, 0x0F, 0x00, 0xF3, 0x80, 0x03, 0xC0,
  0x3C, 0xF0, 0x00, 0xF0, 0x0F, 0x3C, 0x00, 0x3C, 0x07, 0xCF, 0x00, 0x1F,
  0x01, 0xE1, 0xC0, 0x07, 0x80, 0x78, 0x78, 0x01, 0xE0, 0x1E, 0x1E, 0x00,
  0x78, 0x07, 0x87, 0x80, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0xF8, 0x38,
  0x03, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0x80,
  0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x3C, 0x1E,
  0x01, 0xE0, 0x0F, 0x07, 0x80, 0xF8, 0x01, 0xC3, 0xE0, 0x3E, 0x00, 0x78,
  0xF0, 0x0F, 0x00, 0x1E, 0x3C, 0x03, 0xC0, 0x07, 0x8F, 0x00, 0xF0, 0x01,
  0xE3, 0xC0, 0x3C, 0x00, 0x3C, 0xF0, 0x1F, 0x00, 0x0F, 0x3C, 0x07, 0xC0,
  0x03, 0xDE, 0x01, 0xE0, 0x00, 0xF7, 0x80, 0x78, 0x00, 0x3D, 0xE0, 0x1E,
  0x00, 0x07, 0xF8, 0x07, 0x80, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0xFC,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x03, 0xF8, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00,
  0xFC, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x79,
  0xE0, 0x03, 0xE0, 0x03, 0xCF, 0x00, 0x3F, 0x00, 0x3C, 0x78, 0x01, 0xF8,
  0x01, 0xE3, 0xC0, 0x0F, 0xC0, 0x0F, 0x1E, 0x00, 0xFE, 0x00, 0xF8, 0xF0,
  0x07, 0x70, 0x07, 0x87, 0x80, 0x3B, 0x80, 0x3C, 0x3C, 0x01, 0xDC, 0x01,
  0xE1, 0xE0, 0x1C, 0xE0, 0x1E, 0x0F, 0x00, 0xE7, 0x00, 0xF0, 0x70, 0x07,
  0x38, 0x07, 0x87, 0x80, 0x71, 0xC0, 0x3C, 0x3C, 0x03, 0x8E, 0x03, 0xC1,
  0xE0, 0x1C, 0x70, 0x1E, 0x0F, 0x01, 0xE3, 0x80, 0xF0, 0x78, 0x0E, 0x1C,
  0x0F, 0x03, 0xC0, 0x70, 0xE0, 0x78, 0x1E, 0x03, 0x87, 0x03, 0xC0, 0xF0,
  0x38, 0x38, 0x1E, 0x07, 0x81, 0xC1, 0xC1, 0xE0, 0x3C, 0x0E, 0x0C, 0x0F,
  0x01, 0xE0, 0xE0, 0x60, 0x78, 0x0F, 0x07, 0x07, 0x03, 0x80, 0x78, 0x38,
  0x38, 0x3C, 0x03, 0xC1, 0xC1, 0xC1, 0xE0, 0x1E, 0x1C, 0x0E, 0x0F, 0x00,
  0xF0, 0xE0, 0x70, 0x70, 0x07, 0x87, 0x03, 0x87, 0x80, 0x3C, 0x70, 0x1C,
  0x3C, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0x0F, 0x1C, 0x07, 0x1E, 0x00, 0x79,
  0xE0, 0x38, 0xF0, 0x03, 0xCE, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x73, 0xC0, 0x07, 0x38, 0x03, 0x9E, 0x00, 0x39, 0xC0,
  0x1C, 0xF0, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x1E, 0xE0, 0x07, 0x78, 0x00,
  0xF7, 0x00, 0x3B, 0xC0, 0x07, 0xB8, 0x01, 0xDC, 0x00, 0x3D, 0xC0, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x01, 0xFF,
  0xF8, 0xF0, 0x0F, 0xFF, 0xF9, 0xE0, 0x3F, 0x80, 0x7B, 0xC0, 0xFC, 0x00,
  0x77, 0x81, 0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0xC0, 0x7F, 0x83,
  0xEF, 0x80, 0x7F, 0xFF, 0x9E, 0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x7F, 0xF0,
  0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x03, 0xF8, 0x00, 0x3C, 0x3F, 0xFC, 0x00, 0xF9, 0xFF, 0xFC,
  0x01, 0xF7, 0xFF, 0xFC, 0x03, 0xDE, 0x01, 0xFC, 0x07, 0xB0, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F,
  0x81, 0xFC, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xBE, 0x0F, 0xF0,
  0x1F, 0x3F, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0x00, 0x78, 0x3F, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0x80, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x07, 0xC0, 0x03, 0xFF, 0xC3, 0xE0, 0x03, 0xFF, 0xF1,
  0xE0, 0x07, 0xFF, 0xFC, 0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x07, 0xE0, 0x03,
  0xBC, 0x03, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0x7C, 0x00, 0xFF, 0xFF, 0x3C,
  0x00, 0x3F, 0xFF, 0x1E, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x3E, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7C,
  0x01, 0xFF, 0xF8, 0xF0, 0x0F, 0xFF, 0xF9, 0xE0, 0x3F, 0x80, 0x7B, 0xC0,
  0x7C, 0x00, 0x77, 0x81, 0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x7E, 0x0F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0x78,
  0x07, 0xF8, 0x7C, 0xF0, 0x0F, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xC7, 0xC0,
  0x07, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xF8,
  0x00, 0x3C, 0x3F, 0xFC, 0x00, 0xF9, 0xFF, 0xFC, 0x01, 0xF7, 0xFF, 0xFC,
  0x03, 0xDE, 0x01, 0xFC, 0x07, 0xB0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x47, 0xC0, 0x3E, 0x00, 0x71,
  0xFE, 0x1F, 0xF0, 0x1E, 0x7F, 0xE7, 0xFF, 0x03, 0xDF, 0xFC, 0xFF, 0xE0,
  0x7E, 0x0F, 0xB0, 0x7C, 0x0F, 0x80, 0xFC, 0x07, 0x81, 0xE0, 0x1F, 0x00,
  0xF0, 0x3C, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x0F, 0x83, 0xC0, 0x1C, 0x01, 0xE0,
  0xF8, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x07, 0xC1, 0xE0, 0x0E,
  0x00, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0xF0, 0x07, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x1E,
  0x00, 0xF0, 0x78, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x70, 0x07, 0x83, 0xC0,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0x87, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0x80,
  0x3E, 0xFF, 0xFF, 0x80, 0x7B, 0xC0, 0x3F, 0x80, 0xF6, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x7C, 0xFF, 0xFE, 0x00,
  0x3E, 0xFF, 0xFF, 0x80, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0x60, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F,
  0xE0, 0x07, 0xE0, 0x1F, 0x7C, 0x1F, 0xE0, 0x0F, 0x9F, 0xFF, 0xE0, 0x07,
  0xCF, 0xFF, 0xE0, 0x03, 0xC1, 0xFF, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x03, 0xFF, 0xF8, 0xF0, 0x0F, 0xFF,
  0xF9, 0xE0, 0x3F, 0x80, 0x7B, 0xC0, 0xFC, 0x00, 0x77, 0x81, 0xF0, 0x00,
  0x7F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0xC0, 0x7F, 0x03, 0xEF, 0x00, 0x7F, 0xFF,
  0x9E, 0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x7F, 0xF0, 0x78, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0x87, 0xFF, 0x80, 0x0F, 0x3F, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0x80, 0xF7, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x1F, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x05, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFC,
  0x00, 0xF8, 0x01, 0xEF, 0x00, 0x7E, 0x00, 0x7B, 0xC0, 0x1F, 0x80, 0x3C,
  0xF0, 0x07, 0xE0, 0x0F, 0x3C, 0x03, 0xB8, 0x03, 0xCF, 0x00, 0xEE, 0x01,
  0xE3, 0xC0, 0x3B, 0x80, 0x78, 0xF0, 0x1C, 0xE0, 0x1E, 0x3C, 0x07, 0x38,
  0x07, 0x0F, 0x01, 0xCE, 0x03, 0xC3, 0xC0, 0xE3, 0x80, 0xF0, 0xF0, 0x38,
  0xE0, 0x38, 0x3C, 0x0E, 0x38, 0x1E, 0x0F, 0x07, 0x0E, 0x07, 0x83, 0xC1,
  0xC3, 0x81, 0xC0, 0xF0, 0x70, 0xE0, 0xF0, 0x3C, 0x38, 0x38, 0x3C, 0x0F,
  0x0E, 0x0E, 0x0E, 0x03, 0xC3, 0x83, 0x87, 0x80, 0xF1, 0xC0, 0xE1, 0xE0,
  0x3C, 0x70, 0x38, 0x70, 0x0F, 0x1C, 0x0E, 0x3C, 0x03, 0xCE, 0x03, 0x8F,
  0x00, 0xF3, 0x80, 0xE3, 0x80, 0x3C, 0xE0, 0x39, 0xE0, 0x0F, 0x70, 0x0E,
  0x78, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0xEF, 0x00, 0x3B, 0x80,
  0x3B, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x03, 0xB8, 0x03, 0xB8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x06, 0xF0, 0x3F, 0x00, 0x7B, 0xC0, 0xFF, 0x8F, 0xDF, 0x01, 0xFF,
  0xFE, 0x7C, 0x03, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x3C, 0x3F,
  0xF8, 0x00, 0x78, 0xFF, 0xF8, 0x00, 0xF3, 0xE1, 0xF8, 0x01, 0xEF, 0x81,
  0xF0, 0x07, 0x9E, 0x01, 0xF0, 0x0F, 0x3C, 0x01, 0xF0, 0x1E, 0x78, 0x03,
  0xF0, 0x7D, 0xF0, 0x03, 0xFF, 0xF3, 0xC0, 0x03, 0xFF, 0xC7, 0x80, 0x03,
  0xFF, 0x0F, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 14, 48, 40, 13, -48 },
  { 85, 21, 20, 40, 13, -48 },
  { 138, 38, 48, 40, 2, -48 },
  { 366, 34, 66, 40, 3, -57 },
  { 647, 45, 49, 40, -2, -49 },
  { 923, 35, 50, 40, 2, -49 },
  { 1142, 8, 20, 40, 19, -48 },
  { 1162, 27, 64, 40, 11, -56 },
  { 1378, 27, 64, 40, 3, -56 },
  { 1594, 34, 33, 40, 4, -40 },
  { 1735, 31, 31, 40, 5, -37 },
  { 1856, 16, 21, 40, 7, -10 },
  { 1898, 22, 4, 40, 9, -24 },
  { 1909, 11, 11, 40, 12, -10 },
  { 1925, 38, 62, 40, 2, -55 },
  { 2220, 33, 50, 40, 4, -49 },
  { 2427, 30, 48, 40, 3, -48 },
  { 2607, 34, 49, 40, 3, -49 },
  { 2816, 33, 49, 40, 4, -48 },
  { 3019, 30, 48, 40, 5, -48 },
  { 3199, 32, 49, 40, 5, -48 },
  { 3395, 31, 49, 40, 4, -48 },
  { 3585, 32, 48, 40, 8, -48 },
  { 3777, 33, 50, 40, 4, -49 },
  { 3984, 31, 49, 40, 7, -49 },
  { 4174, 15, 38, 40, 12, -37 },
  { 4246, 21, 48, 40, 7, -37 },
  { 4372, 31, 34, 40, 6, -39 },
  { 4504, 31, 19, 40, 5, -31 },
  { 4578, 31, 34, 40, 4, -39 },
  { 4710, 26, 48, 40, 10, -48 },
  { 4866, 38, 61, 40, 1, -49 },
  { 5156, 32, 48, 40, 1, -48 },
  { 5348, 33, 48, 40, 4, -48 },
  { 5546, 32, 50, 40, 5, -49 },
  { 5746, 32, 48, 40, 4, -48 },
  { 5938, 35, 48, 40, 4, -48 },
  { 6148, 35, 48, 40, 4, -48 },
  { 6358, 32, 50, 40, 5, -49 },
  { 6558, 34, 48, 40, 4, -48 },
  { 6762, 32, 48, 40, 5, -48 },
  { 6954, 35, 49, 40, 2, -48 },
  { 7169, 36, 48, 40, 4, -48 },
  { 7385, 28, 48, 40, 5, -48 },
  { 7553, 36, 48, 40, 3, -48 },
  { 7769, 34, 48, 40, 4, -48 },
  { 7973, 32, 50, 40, 5, -49 },
  { 8173, 35, 48, 40, 4, -48 },
  { 8383, 32, 61, 40, 5, -49 },
  { 8627, 34, 48, 40, 4, -48 },
  { 8831, 34, 50, 40, 3, -49 },
  { 9044, 33, 48, 40, 8, -48 },
  { 9242, 33, 49, 40, 5, -48 },
  { 9445, 31, 48, 40, 9, -48 },
  { 9631, 37, 48, 40, 5, -48 },
  { 9853, 40, 48, 40, 0, -48 },
  { 10093, 33, 48, 40, 8, -48 },
  { 10291, 35, 48, 40, 3, -48 },
  { 10501, 25, 62, 40, 10, -55 },
  { 10695, 19, 62, 40, 11, -55 },
  { 10843, 25, 62, 40, 6, -55 },
  { 11037, 27, 26, 40, 7, -48 },
  { 11125, 32, 3, 40, 0, 2 },
  { 11137, 11, 9, 40, 18, -52 },
  { 11150, 31, 38, 40, 5, -37 },
  { 11298, 31, 49, 40, 4, -48 },
  { 11488, 30, 38, 40, 5, -37 },
  { 11631, 33, 49, 40, 5, -48 },
  { 11834, 30, 38, 40, 5, -37 },
  { 11977, 42, 60, 40, -2, -48 },
  { 12292, 31, 49, 40, 5, -37 },
  { 12482, 31, 48, 40, 4, -48 },
  { 12668, 30, 51, 40, 3, -51 },
  { 12860, 34, 63, 40, 1, -51 },
  { 13128, 34, 48, 40, 4, -48 },
  { 13332, 27, 48, 40, 7, -48 },
  { 13494, 35, 37, 40, 2, -37 },
  { 13656, 31, 37, 40, 4, -37 },
  { 13800, 30, 38, 40, 5, -37 },
  { 13943, 33, 49, 40, 2, -37 },
  { 14146, 31, 49, 40, 5, -37 },
  { 14336, 31, 37, 40, 5, -37 },
  { 14480, 31, 38, 40, 4, -37 },
  { 14628, 31, 46, 40, 6, -46 },
  { 14807, 31, 37, 40, 5, -36 },
  { 14951, 31, 36, 40, 7, -36 },
  { 15091, 34, 36, 40, 6, -36 },
  { 15244, 35, 36, 40, 2, -36 },
  { 15402, 30, 48, 40, 5, -36 },
  { 15582, 31, 36, 40, 4, -36 },
  { 15722, 32, 62, 40, 7, -55 },
  { 15970, 14, 62, 40, 14, -55 },
  { 16079, 33, 62, 40, 2, -55 },
  { 16335, 31, 13, 40, 5, -30 },
};

const GFXfont JetBrainsMono_ExtraLightItalic66pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic66pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC66PT7B_H_
