#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC13PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x60, 0x80, 0xBA, 0xA0, 0x1B, 0x12, 0x7F, 0x24, 0x24, 0xB6,
  0x48, 0x48, 0x48, 0x08, 0x67, 0x55, 0x51, 0xC1, 0x89, 0x26, 0xAF, 0x08,
  0x20, 0x30, 0xA4, 0x92, 0x8A, 0x86, 0x80, 0x80, 0x78, 0x54, 0x4A, 0x47,
  0x00, 0x08, 0x68, 0x89, 0x03, 0x0A, 0x52, 0xA6, 0x8C, 0xEC, 0xE0, 0x08,
  0x88, 0x84, 0x21, 0x10, 0x84, 0x10, 0xC1, 0x00, 0x20, 0x84, 0x10, 0x84,
  0x42, 0x10, 0x88, 0x88, 0x00, 0x10, 0x23, 0x59, 0xC3, 0x09, 0x22, 0x00,
  0x10, 0x4F, 0xC8, 0x20, 0x80, 0x36, 0x4C, 0xF0, 0x58, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x19, 0x94, 0x51,
  0x86, 0xD8, 0x61, 0x89, 0xC0, 0x3A, 0x84, 0x21, 0x08, 0x44, 0xF8, 0x19,
  0x94, 0x41, 0x04, 0x21, 0x08, 0xC3, 0xE0, 0x7C, 0x21, 0x0E, 0x08, 0x18,
  0xA2, 0xF0, 0x0C, 0x42, 0x08, 0x46, 0x2F, 0x82, 0x08, 0x7D, 0x04, 0x1E,
  0x44, 0x10, 0xA2, 0x70, 0x18, 0x42, 0x1E, 0xCE, 0x18, 0x62, 0x70, 0xFE,
  0x20, 0x84, 0x20, 0x84, 0x10, 0x80, 0x19, 0x94, 0x51, 0x29, 0xE8, 0xA1,
  0x8B, 0xC0, 0x19, 0x94, 0x61, 0x85, 0xE0, 0x84, 0x21, 0x00, 0x64, 0x00,
  0xB0, 0x31, 0x00, 0x03, 0x24, 0xC0, 0x04, 0x33, 0x30, 0x40, 0xC0, 0x80,
  0xFC, 0x00, 0x7E, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x78, 0x42, 0x26,
  0x20, 0x00, 0xC0, 0x0C, 0x32, 0x21, 0x41, 0x4E, 0x52, 0x52, 0x92, 0x9E,
  0x80, 0x80, 0x70, 0x08, 0x51, 0x49, 0x24, 0xF4, 0x51, 0x84, 0x7D, 0x14,
  0x52, 0xBA, 0x18, 0x62, 0xF0, 0x19, 0x94, 0x50, 0x42, 0x08, 0x21, 0x89,
  0xC0, 0x7D, 0x14, 0x51, 0x86, 0x18, 0xA2, 0xF0, 0x7E, 0x81, 0x02, 0x27,
  0x90, 0x20, 0x40, 0xF8, 0x7E, 0x81, 0x02, 0x07, 0xD0, 0x20, 0x40, 0x80,
  0x19, 0x94, 0x50, 0x42, 0x78, 0x61, 0x89, 0xC0, 0x45, 0x14, 0x51, 0xBE,
  0x18, 0xA2, 0x88, 0x7C, 0x41, 0x04, 0x10, 0x42, 0x08, 0x23, 0xE0, 0x0E,
  0x04, 0x08, 0x10, 0x20, 0x91, 0x22, 0x78, 0x42, 0x89, 0x12, 0x45, 0x16,
  0x24, 0x44, 0x89, 0x18, 0x42, 0x10, 0x84, 0x42, 0x10, 0xF8, 0x46, 0xDA,
  0xB5, 0xAB, 0x50, 0xA1, 0x44, 0x88, 0x65, 0x96, 0x59, 0x96, 0x59, 0xA6,
  0x88, 0x19, 0x94, 0x51, 0x46, 0x18, 0x62, 0x89, 0xC0, 0x7C, 0x85, 0x0A,
  0x2F, 0x90, 0x20, 0x40, 0x80, 0x19, 0x94, 0x51, 0x86, 0x18, 0x62, 0x89,
  0xC1, 0x06, 0x7C, 0x89, 0x12, 0x2F, 0x92, 0x22, 0x44, 0x88, 0x19, 0x94,
  0x50, 0x60, 0x60, 0x41, 0x8B, 0xC0, 0xFC, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x40, 0x45, 0x14, 0x51, 0x86, 0x18, 0xA2, 0x70, 0x86, 0x28, 0xA4, 0x92,
  0x8A, 0x28, 0x40, 0x93, 0x26, 0xCD, 0xAB, 0x5A, 0xB6, 0x64, 0x98, 0x23,
  0x22, 0x14, 0x18, 0x18, 0x18, 0x24, 0x44, 0x86, 0x86, 0x29, 0x14, 0x61,
  0x04, 0x10, 0x40, 0x7C, 0x10, 0x84, 0x20, 0x84, 0x20, 0xF8, 0x39, 0x10,
  0x84, 0x21, 0x08, 0x44, 0x21, 0xC0, 0x88, 0x44, 0x44, 0x22, 0x22, 0x21,
  0x38, 0x42, 0x10, 0x88, 0x42, 0x10, 0x85, 0xC0, 0x18, 0xA2, 0x91, 0x84,
  0xFC, 0x90, 0x7D, 0x18, 0x61, 0x8A, 0x27, 0x80, 0x41, 0x07, 0x91, 0x86,
  0x18, 0xA2, 0xF0, 0x79, 0x18, 0x20, 0x82, 0x27, 0x00, 0x04, 0x17, 0xD1,
  0x86, 0x18, 0xA2, 0x78, 0x79, 0x18, 0x7F, 0x82, 0x27, 0x00, 0x0F, 0x08,
  0x7E, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xE0, 0x7D, 0x18, 0x61,
  0x8B, 0x62, 0x82, 0xF0, 0x41, 0x07, 0x91, 0x86, 0x18, 0xA2, 0x88, 0x18,
  0x40, 0x1C, 0x10, 0x41, 0x08, 0x23, 0xF0, 0x06, 0x08, 0x01, 0xE0, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x27, 0x80, 0x40, 0x85, 0x12, 0x49, 0x1E, 0x24,
  0x44, 0x88, 0xF0, 0x82, 0x08, 0x20, 0x82, 0x10, 0x3C, 0x7E, 0x95, 0x2A,
  0x95, 0x2A, 0x65, 0x00, 0x79, 0x18, 0x61, 0x8A, 0x28, 0x80, 0x79, 0x18,
  0x61, 0x8A, 0x27, 0x00, 0x3C, 0x45, 0x0A, 0x14, 0x48, 0x9E, 0x20, 0x80,
  0x7D, 0x18, 0x61, 0x8A, 0x27, 0x82, 0x08, 0x7D, 0x14, 0x60, 0x82, 0x08,
  0x00, 0x7D, 0x14, 0x0E, 0x0A, 0x2F, 0x80, 0x10, 0x8F, 0xC8, 0x20, 0x82,
  0x10, 0x38, 0x45, 0x18, 0x61, 0x8A, 0x27, 0x00, 0x85, 0x14, 0x92, 0x51,
  0x42, 0x00, 0x93, 0x6A, 0xD5, 0xAD, 0x9B, 0x26, 0x00, 0x22, 0x48, 0x60,
  0xC2, 0x84, 0xB1, 0x00, 0x46, 0x18, 0x62, 0x8B, 0x62, 0x82, 0xF0, 0x7C,
  0x21, 0x08, 0x42, 0x0F, 0x80, 0x06, 0x10, 0x40, 0x81, 0x02, 0x38, 0x08,
  0x10, 0x40, 0x81, 0xC0, 0x55, 0x56, 0xAA, 0x30, 0x10, 0x20, 0x41, 0x02,
  0x03, 0x88, 0x10, 0x20, 0x47, 0x00, 0x66, 0x58, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 3, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 13, 8, 1, -11 },
  { 25, 9, 10, 8, 0, -10 },
  { 37, 7, 10, 8, 0, -10 },
  { 46, 1, 3, 8, 4, -9 },
  { 47, 5, 13, 8, 2, -11 },
  { 56, 5, 13, 8, 1, -11 },
  { 65, 7, 7, 8, 1, -8 },
  { 72, 6, 6, 8, 1, -7 },
  { 77, 4, 4, 8, 1, -2 },
  { 79, 4, 1, 8, 2, -5 },
  { 80, 3, 2, 8, 2, -2 },
  { 81, 8, 12, 8, 0, -11 },
  { 93, 6, 10, 8, 1, -10 },
  { 101, 5, 9, 8, 1, -9 },
  { 107, 6, 10, 8, 1, -10 },
  { 115, 6, 9, 8, 1, -9 },
  { 122, 6, 9, 8, 1, -9 },
  { 129, 6, 9, 8, 1, -9 },
  { 136, 6, 9, 8, 1, -9 },
  { 143, 6, 9, 8, 2, -9 },
  { 150, 6, 10, 8, 1, -10 },
  { 158, 6, 10, 8, 1, -10 },
  { 166, 3, 7, 8, 2, -7 },
  { 169, 4, 9, 8, 1, -7 },
  { 174, 6, 7, 8, 1, -8 },
  { 180, 6, 4, 8, 1, -6 },
  { 183, 6, 7, 8, 1, -8 },
  { 189, 5, 9, 8, 2, -9 },
  { 195, 8, 12, 8, 0, -10 },
  { 207, 6, 9, 8, 0, -9 },
  { 214, 6, 9, 8, 1, -9 },
  { 221, 6, 10, 8, 1, -10 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 7, 9, 8, 1, -9 },
  { 244, 7, 9, 8, 1, -9 },
  { 252, 6, 10, 8, 1, -10 },
  { 260, 6, 9, 8, 1, -9 },
  { 267, 6, 10, 8, 1, -10 },
  { 275, 7, 9, 8, 0, -9 },
  { 283, 7, 10, 8, 1, -10 },
  { 292, 5, 9, 8, 1, -9 },
  { 298, 7, 9, 8, 1, -9 },
  { 306, 6, 9, 8, 1, -9 },
  { 313, 6, 10, 8, 1, -10 },
  { 321, 7, 9, 8, 1, -9 },
  { 329, 6, 12, 8, 1, -10 },
  { 338, 7, 9, 8, 1, -9 },
  { 346, 6, 10, 8, 1, -10 },
  { 354, 6, 9, 8, 2, -9 },
  { 361, 6, 9, 8, 1, -9 },
  { 368, 6, 9, 8, 2, -9 },
  { 375, 7, 9, 8, 1, -9 },
  { 383, 8, 9, 8, 0, -9 },
  { 392, 6, 9, 8, 2, -9 },
  { 399, 6, 9, 8, 1, -9 },
  { 406, 5, 12, 8, 2, -11 },
  { 414, 4, 12, 8, 2, -11 },
  { 420, 5, 12, 8, 1, -11 },
  { 428, 6, 5, 8, 1, -9 },
  { 432, 6, 1, 8, 0, 0 },
  { 433, 2, 2, 8, 4, -10 },
  { 434, 6, 7, 8, 1, -7 },
  { 440, 6, 9, 8, 1, -9 },
  { 447, 6, 7, 8, 1, -7 },
  { 453, 6, 9, 8, 1, -9 },
  { 460, 6, 7, 8, 1, -7 },
  { 466, 8, 11, 8, 0, -9 },
  { 477, 6, 9, 8, 1, -7 },
  { 484, 6, 9, 8, 1, -9 },
  { 491, 6, 10, 8, 1, -10 },
  { 499, 7, 12, 8, 0, -10 },
  { 510, 7, 9, 8, 1, -9 },
  { 518, 6, 9, 8, 1, -9 },
  { 525, 7, 7, 8, 0, -7 },
  { 532, 6, 7, 8, 1, -7 },
  { 538, 6, 7, 8, 1, -7 },
  { 544, 7, 9, 8, 0, -7 },
  { 552, 6, 9, 8, 1, -7 },
  { 559, 6, 7, 8, 1, -7 },
  { 565, 6, 7, 8, 1, -7 },
  { 571, 6, 9, 8, 1, -9 },
  { 578, 6, 7, 8, 1, -7 },
  { 584, 6, 7, 8, 1, -7 },
  { 590, 7, 7, 8, 1, -7 },
  { 597, 7, 7, 8, 0, -7 },
  { 604, 6, 9, 8, 1, -7 },
  { 611, 6, 7, 8, 1, -7 },
  { 617, 7, 12, 8, 1, -11 },
  { 628, 2, 12, 8, 3, -11 },
  { 631, 7, 12, 8, 0, -11 },
  { 642, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC13PT7B_H_
