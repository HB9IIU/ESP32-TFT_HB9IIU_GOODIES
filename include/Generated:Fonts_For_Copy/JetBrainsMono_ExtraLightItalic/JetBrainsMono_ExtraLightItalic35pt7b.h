#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC35PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x70, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0x60, 0xC0, 0x00, 0x00, 0x1C, 0x7C, 0xF9, 0xE0,
  0x70, 0xEE, 0x1D, 0xC3, 0xB0, 0x6E, 0x0D, 0xC3, 0xB8, 0x77, 0x0E, 0xC1,
  0x98, 0x33, 0x06, 0x00, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x1F, 0xFF, 0xF0, 0x30, 0x30, 0x03, 0x03, 0x00, 0x70, 0x30, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x81, 0x81, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x06, 0x07, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7B,
  0x78, 0x38, 0xCE, 0x0C, 0x21, 0x87, 0x08, 0x61, 0x86, 0x18, 0x61, 0x80,
  0x18, 0x60, 0x07, 0x18, 0x01, 0xE4, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0x38, 0x00, 0x87, 0x00, 0x21, 0xC0, 0x18,
  0x73, 0x86, 0x1C, 0xE1, 0x86, 0x38, 0x61, 0x8E, 0x18, 0xE1, 0xC4, 0x70,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x03, 0x03, 0xF0, 0x06, 0x06, 0x38,
  0x0C, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x30, 0x0C, 0x18, 0x30, 0x18, 0x18,
  0x60, 0x18, 0x18, 0xC0, 0x18, 0x31, 0x80, 0x1C, 0x33, 0x00, 0x0F, 0xE6,
  0x00, 0x07, 0xCE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x67, 0xF0, 0x00, 0xCE, 0x30, 0x01, 0x8C, 0x18, 0x03, 0x8C,
  0x18, 0x03, 0x18, 0x18, 0x06, 0x18, 0x30, 0x0C, 0x18, 0x30, 0x18, 0x18,
  0x30, 0x30, 0x18, 0x70, 0x60, 0x1F, 0xE0, 0xE0, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x0F, 0x1C, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0x73, 0x81, 0xCC, 0x30, 0x33, 0x87, 0x0C,
  0x60, 0x73, 0x8C, 0x06, 0x61, 0x80, 0xF8, 0x30, 0x0F, 0x0E, 0x01, 0xC1,
  0xC0, 0x3C, 0x38, 0x0D, 0x83, 0x87, 0x38, 0x7F, 0xC3, 0x07, 0xF0, 0x70,
  0x37, 0x77, 0x77, 0x66, 0xEE, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x30, 0x3F, 0xCC, 0x7D, 0xFB, 0x7E,
  0x0F, 0xFC, 0x00, 0x30, 0x00, 0x16, 0x00, 0x1D, 0x80, 0x0E, 0x70, 0x03,
  0x0E, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x70, 0x1C, 0x04, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0F, 0x0E, 0x1E,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFE, 0x39,
  0xF7, 0xDF, 0x78, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0xF0, 0x38, 0x0E, 0x1C,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x01, 0x8E, 0x00,
  0x63, 0x00, 0x38, 0xC3, 0x0E, 0x31, 0xE3, 0x9C, 0x78, 0xC7, 0x0C, 0x31,
  0xC0, 0x0C, 0x60, 0x07, 0x18, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x03, 0x87, 0x01, 0xC1, 0xE0, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0xF3, 0x83, 0x87,
  0x06, 0x0C, 0x10, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x70, 0x38, 0x0E, 0x1C,
  0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x61,
  0x80, 0x70, 0xE0, 0x70, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x31, 0xC0, 0xE7, 0x01, 0xCC,
  0x03, 0x30, 0x06, 0xE0, 0x0D, 0x80, 0x1B, 0xFF, 0xF7, 0xFF, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x78, 0x06, 0xFF, 0x03, 0xE3, 0xC3,
  0xC0, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x70, 0xE0,
  0x70, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x30, 0x1D, 0xFC, 0x1F, 0x3E, 0x38, 0x0F, 0x30, 0x07,
  0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x06,
  0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x3C, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x33, 0x80,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78,
  0x70, 0x38, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x1C, 0x03, 0x03, 0x01, 0xC0, 0xE0, 0xE0, 0x1E, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0xE3, 0xC0, 0x60, 0x38, 0x30, 0x0E, 0x1C, 0x01, 0x86, 0x00,
  0x73, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x01, 0x86, 0x00, 0xC1, 0xC0, 0x70,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1E, 0x3C, 0x38,
  0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x3C, 0x7F, 0xF8, 0x1F,
  0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x06, 0x07, 0x87,
  0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x7C, 0x3E, 0x1F, 0x0F, 0x00, 0x01, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x20, 0x00, 0x18,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x7F,
  0x81, 0xFF, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x7F, 0x01, 0xF0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8,
  0x03, 0x81, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00,
  0x71, 0x80, 0x07, 0x38, 0x00, 0x63, 0x01, 0xF6, 0x30, 0x3F, 0xE3, 0x06,
  0x0E, 0x30, 0xE0, 0xE7, 0x0C, 0x0E, 0x60, 0xC0, 0xE6, 0x0C, 0x0C, 0x61,
  0xC0, 0xC6, 0x18, 0x0C, 0x61, 0x80, 0xCE, 0x18, 0x0C, 0xE1, 0x81, 0xCC,
  0x1C, 0x38, 0xC0, 0xFF, 0x8C, 0x07, 0x98, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0xEC, 0x00, 0xCC, 0x01, 0xCC, 0x01, 0x8C, 0x01, 0x8E, 0x03,
  0x0E, 0x03, 0x06, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x06, 0x0C, 0x06, 0x0C,
  0x06, 0x1F, 0xFE, 0x1F, 0xFF, 0x38, 0x07, 0x30, 0x07, 0x30, 0x03, 0x60,
  0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x0F, 0xE0, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x30, 0x0E, 0x1C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x70, 0xE0, 0x78, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x07, 0x1C, 0x00, 0xC7,
  0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC3, 0x80,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3,
  0xC3, 0x80, 0xE1, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x01,
  0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x61, 0xE0, 0xF0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0x80, 0xE1, 0xC0,
  0x38, 0xE0, 0x1C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01, 0xC6,
  0x00, 0xE7, 0x00, 0x63, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E,
  0x30, 0x07, 0x38, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x00,
  0x61, 0x80, 0x71, 0xC0, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x86, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0x80,
  0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x0F, 0xF1, 0x87, 0xF8, 0xC0, 0x0C,
  0xE0, 0x06, 0x70, 0x07, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0xE3, 0x80, 0x61, 0xE0, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0C, 0x00,
  0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x06, 0x1C, 0x01, 0x87, 0x00, 0x61,
  0xC0, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x30, 0xE0,
  0x0C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x06,
  0x1C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x86,
  0x00, 0xC3, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C,
  0x18, 0x03, 0x03, 0x81, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x0C, 0x00,
  0x61, 0x80, 0x1C, 0x30, 0x07, 0x06, 0x00, 0xC1, 0xC0, 0x38, 0x38, 0x0E,
  0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xE0,
  0x1C, 0x38, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0C, 0x1C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0xC0,
  0xC0, 0x18, 0x18, 0x03, 0x07, 0x00, 0x70, 0xE0, 0x06, 0x18, 0x00, 0xE0,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0D, 0x03, 0x60, 0xD8,
  0x36, 0x0D, 0x86, 0xE1, 0x98, 0x6C, 0x19, 0x8C, 0xC1, 0x88, 0xCC, 0x18,
  0xD8, 0xC1, 0x8D, 0x9C, 0x18, 0xF1, 0xC3, 0x8F, 0x18, 0x38, 0x61, 0x83,
  0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x07,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0xF0, 0x1C, 0x3C, 0x06,
  0x1F, 0x01, 0x86, 0xC0, 0x61, 0xB8, 0x18, 0x66, 0x06, 0x19, 0x83, 0x86,
  0x60, 0xE3, 0x98, 0x30, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x70, 0xC3, 0x9C, 0x30, 0x66, 0x1C, 0x19, 0x86, 0x06, 0x61, 0x81, 0x98,
  0x60, 0x36, 0x18, 0x0F, 0x86, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x30,
  0x07, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x0E, 0x1C, 0x07, 0x18, 0x03,
  0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x07, 0x70, 0x07, 0x70, 0x06,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xE0, 0x38,
  0xE0, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x06, 0x00, 0xE1, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x1C, 0x01, 0xC3, 0x80,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0x0E, 0x1C, 0x07, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x70, 0x07, 0x70, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x38, 0xF0, 0x70, 0x7F, 0xE0, 0x3F, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x30, 0x0E, 0x1C, 0x01, 0xC7,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x61, 0x80,
  0x38, 0xE0, 0x1C, 0x38, 0x1E, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xC1, 0xC0,
  0x30, 0x70, 0x1C, 0x0C, 0x07, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x18, 0x18,
  0x07, 0x06, 0x01, 0xC3, 0x80, 0x30, 0xE0, 0x0E, 0x30, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38, 0x0E, 0x0C, 0x01, 0x87, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0x8E, 0x00, 0xE1, 0xC0, 0x70, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x18, 0x01, 0x8C, 0x01, 0xC6, 0x00,
  0xE3, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x07, 0x18, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x38, 0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x01,
  0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x80, 0xE0, 0xE0, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30,
  0x60, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x70, 0xC0, 0x71, 0xC0,
  0x31, 0x80, 0x33, 0x80, 0x33, 0x00, 0x33, 0x00, 0x36, 0x00, 0x36, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x60, 0x60, 0x6C, 0x1C, 0x0D, 0x83,
  0x81, 0xB0, 0x50, 0x66, 0x0A, 0x0D, 0xC3, 0x41, 0xB8, 0x68, 0x37, 0x09,
  0x0C, 0xC3, 0x21, 0x98, 0x64, 0x33, 0x08, 0x8E, 0x63, 0x31, 0x8C, 0x66,
  0x31, 0x8C, 0xC6, 0x31, 0x19, 0x86, 0x63, 0x30, 0xCC, 0x66, 0x19, 0x0C,
  0xC3, 0x61, 0xB0, 0x6C, 0x36, 0x0D, 0x06, 0xC1, 0xA0, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x38,
  0x01, 0xC1, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x38, 0x0C, 0x00, 0xC0, 0xE0,
  0x06, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x70, 0x00, 0x1B,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0C, 0x0C,
  0x00, 0xE0, 0x70, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x70, 0x70,
  0x01, 0x87, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x39,
  0x80, 0x0C, 0x70, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xE0, 0x60, 0x18,
  0x38, 0x06, 0x0C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFE,
  0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xD8,
  0x07, 0x60, 0x18, 0xC0, 0xE3, 0x03, 0x0C, 0x18, 0x38, 0xE0, 0x63, 0x01,
  0x9C, 0x06, 0x60, 0x1F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3,
  0x0C, 0x70, 0x00, 0x40, 0x03, 0xFD, 0xC3, 0xEF, 0xE3, 0x80, 0xF1, 0x80,
  0x71, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x18, 0x03, 0x9C,
  0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x1C,
  0x70, 0x1C, 0x38, 0x1E, 0x0F, 0xFB, 0x03, 0xF9, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x80,
  0x33, 0xF8, 0x1B, 0xBE, 0x0F, 0x03, 0x87, 0x01, 0xC7, 0x00, 0x63, 0x80,
  0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x1C,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x71, 0xC0, 0x71, 0xF0, 0x70,
  0xFF, 0xF0, 0x67, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x18,
  0x0E, 0x30, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0xC0,
  0x1C, 0xE0, 0x18, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x04,
  0x18, 0x1F, 0xEE, 0x0F, 0xBF, 0x87, 0x01, 0xE1, 0x80, 0x70, 0xE0, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x06, 0x1C,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x87, 0x01,
  0xC1, 0xC0, 0xF0, 0x3F, 0xEC, 0x07, 0xF3, 0x00, 0x00, 0xC0, 0x0F, 0xF0,
  0x7C, 0xF0, 0xC0, 0x73, 0x00, 0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x0E, 0xE0, 0x19, 0xC0, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x80, 0x07, 0xF7, 0x1F, 0x7F, 0x38, 0x0F, 0x30, 0x0E,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0xE0, 0x0C,
  0xE0, 0x0C, 0xC0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x79, 0xF8,
  0x3F, 0x98, 0x06, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x7F, 0xE0, 0xFF, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x20, 0x19, 0xFC, 0x1B, 0x9E,
  0x1E, 0x07, 0x1C, 0x07, 0x38, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x07,
  0x30, 0x07, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x0E,
  0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0x00, 0x38,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x81, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x18, 0x03, 0x86,
  0x01, 0xC1, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x0C, 0x0C, 0x03, 0x07,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0C, 0x38, 0x07, 0x06, 0x01, 0xC1, 0xC0,
  0x60, 0x30, 0x18, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x70, 0xE0, 0x0C, 0x38,
  0x03, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1F, 0xFC, 0x1F, 0xF0,
  0x00, 0x81, 0x03, 0x7C, 0xF8, 0x73, 0xA7, 0x0C, 0x38, 0x63, 0x86, 0x0C,
  0x70, 0xC1, 0x8C, 0x18, 0x31, 0x83, 0x06, 0x30, 0x61, 0xC6, 0x0C, 0x38,
  0xC3, 0x06, 0x38, 0x60, 0xC6, 0x0C, 0x18, 0xC1, 0x83, 0x18, 0x30, 0x63,
  0x06, 0x1C, 0x61, 0xC3, 0x1C, 0x30, 0x63, 0x06, 0x0C, 0x60, 0xC1, 0x80,
  0x00, 0x20, 0x19, 0xFC, 0x1B, 0x9E, 0x1E, 0x07, 0x3C, 0x07, 0x38, 0x03,
  0x38, 0x03, 0x30, 0x03, 0x30, 0x07, 0x30, 0x07, 0x30, 0x06, 0x70, 0x06,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C,
  0xE0, 0x0C, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xF0, 0x7D, 0xF1, 0xC0, 0x73,
  0x00, 0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x07, 0x60, 0x0C, 0xE0, 0x39,
  0xC0, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x10, 0x03, 0x3F, 0x80, 0xDD,
  0xF0, 0x38, 0x0E, 0x1E, 0x03, 0x87, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0C, 0x38, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x38, 0x0E, 0x1F, 0x07, 0x07, 0xFF,
  0x81, 0x9F, 0xC0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFD, 0xC3, 0xEF, 0xE3,
  0x80, 0xE1, 0x80, 0x71, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x07,
  0x18, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x38, 0xC0, 0x1C, 0x70, 0x1C, 0x38, 0x1E, 0x0F, 0xFB, 0x03, 0xF9, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x1B, 0xFC, 0x3F, 0xBE, 0x3C, 0x06, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x07, 0xFE, 0x0F, 0x9F, 0x1C,
  0x07, 0x18, 0x03, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0xE0,
  0x06, 0xE0, 0x0E, 0x70, 0x1C, 0x7F, 0xF8, 0x3F, 0xF0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x30,
  0x03, 0x30, 0x07, 0x30, 0x07, 0x70, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x0E, 0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x3F,
  0xC0, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0x60,
  0x18, 0x60, 0x38, 0x70, 0x30, 0x30, 0x70, 0x30, 0x60, 0x30, 0xE0, 0x30,
  0xC0, 0x31, 0xC0, 0x39, 0x80, 0x1B, 0x80, 0x1B, 0x00, 0x1B, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0xC0, 0xC0, 0xF0, 0x70, 0x6C, 0x14, 0x1B, 0x05, 0x06,
  0xC3, 0x43, 0x30, 0x90, 0xCC, 0x24, 0x33, 0x19, 0x18, 0xC4, 0x46, 0x31,
  0x11, 0x8C, 0xC4, 0xC3, 0x21, 0x30, 0xD8, 0x4C, 0x36, 0x12, 0x0D, 0x05,
  0x83, 0xC1, 0x60, 0xF0, 0x58, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1C, 0x01,
  0xE1, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x83, 0x80, 0x30, 0xE0, 0x07, 0x38,
  0x00, 0x66, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x01, 0xD8, 0x00, 0x73, 0x80, 0x1C, 0x30, 0x03, 0x07, 0x00, 0xC0, 0x60,
  0x38, 0x0E, 0x0E, 0x00, 0xC3, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x30, 0x07,
  0x70, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E,
  0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x38, 0x7D, 0xD8, 0x3F, 0x98, 0x04, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF,
  0x8F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x7C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x03,
  0x7F, 0x03, 0x67, 0x03, 0xC1, 0x83, 0xC1, 0xC6, 0xC0, 0xFE, 0xC0, 0x7C,
};

const GFXglyph JetBrainsMono_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 26, 21, 7, -26 },
  { 24, 11, 11, 21, 7, -26 },
  { 40, 20, 26, 21, 1, -26 },
  { 105, 18, 35, 21, 2, -30 },
  { 184, 24, 26, 21, -1, -26 },
  { 262, 19, 26, 21, 1, -26 },
  { 324, 4, 11, 21, 10, -26 },
  { 330, 14, 34, 21, 6, -30 },
  { 390, 14, 34, 21, 2, -30 },
  { 450, 18, 18, 21, 2, -21 },
  { 491, 16, 17, 21, 3, -20 },
  { 525, 8, 11, 21, 4, -5 },
  { 536, 12, 2, 21, 5, -13 },
  { 539, 6, 5, 21, 6, -5 },
  { 543, 20, 33, 21, 1, -29 },
  { 626, 18, 26, 21, 2, -26 },
  { 685, 15, 26, 21, 2, -26 },
  { 734, 18, 26, 21, 2, -26 },
  { 793, 17, 26, 21, 2, -26 },
  { 849, 15, 26, 21, 3, -26 },
  { 898, 17, 26, 21, 2, -26 },
  { 954, 16, 26, 21, 2, -26 },
  { 1006, 17, 26, 21, 4, -26 },
  { 1062, 18, 26, 21, 2, -26 },
  { 1121, 16, 26, 21, 4, -26 },
  { 1173, 9, 20, 21, 6, -20 },
  { 1196, 11, 26, 21, 4, -20 },
  { 1232, 17, 18, 21, 3, -21 },
  { 1271, 16, 11, 21, 3, -17 },
  { 1293, 16, 18, 21, 2, -21 },
  { 1329, 14, 26, 21, 5, -26 },
  { 1375, 20, 32, 21, 1, -26 },
  { 1455, 16, 26, 21, 1, -26 },
  { 1507, 18, 26, 21, 2, -26 },
  { 1566, 17, 26, 21, 3, -26 },
  { 1622, 17, 26, 21, 2, -26 },
  { 1678, 19, 26, 21, 2, -26 },
  { 1740, 19, 26, 21, 2, -26 },
  { 1802, 17, 26, 21, 3, -26 },
  { 1858, 18, 26, 21, 2, -26 },
  { 1917, 18, 26, 21, 2, -26 },
  { 1976, 19, 26, 21, 1, -26 },
  { 2038, 19, 26, 21, 2, -26 },
  { 2100, 14, 26, 21, 3, -26 },
  { 2146, 20, 26, 21, 1, -26 },
  { 2211, 18, 26, 21, 2, -26 },
  { 2270, 16, 26, 21, 3, -26 },
  { 2322, 19, 26, 21, 2, -26 },
  { 2384, 16, 32, 21, 3, -26 },
  { 2448, 18, 26, 21, 2, -26 },
  { 2507, 18, 26, 21, 2, -26 },
  { 2566, 17, 26, 21, 4, -26 },
  { 2622, 17, 26, 21, 3, -26 },
  { 2678, 16, 26, 21, 5, -26 },
  { 2730, 19, 26, 21, 3, -26 },
  { 2792, 21, 26, 21, 0, -26 },
  { 2861, 18, 26, 21, 4, -26 },
  { 2920, 18, 26, 21, 2, -26 },
  { 2979, 14, 33, 21, 5, -29 },
  { 3037, 10, 33, 21, 6, -29 },
  { 3079, 14, 33, 21, 3, -29 },
  { 3137, 14, 14, 21, 4, -26 },
  { 3162, 17, 2, 21, 0, 1 },
  { 3167, 5, 4, 21, 10, -27 },
  { 3170, 17, 20, 21, 2, -20 },
  { 3213, 17, 26, 21, 2, -26 },
  { 3269, 16, 20, 21, 3, -20 },
  { 3309, 18, 26, 21, 2, -26 },
  { 3368, 15, 20, 21, 3, -20 },
  { 3406, 22, 32, 21, -1, -26 },
  { 3494, 16, 26, 21, 3, -20 },
  { 3546, 16, 26, 21, 2, -26 },
  { 3598, 16, 27, 21, 2, -27 },
  { 3652, 17, 33, 21, 1, -27 },
  { 3723, 18, 26, 21, 2, -26 },
  { 3782, 14, 26, 21, 4, -26 },
  { 3828, 19, 20, 21, 1, -20 },
  { 3876, 16, 20, 21, 2, -20 },
  { 3916, 15, 20, 21, 3, -20 },
  { 3954, 18, 26, 21, 1, -20 },
  { 4013, 17, 26, 21, 2, -20 },
  { 4069, 16, 20, 21, 3, -20 },
  { 4109, 16, 20, 21, 2, -20 },
  { 4149, 16, 25, 21, 3, -25 },
  { 4199, 16, 19, 21, 3, -19 },
  { 4237, 16, 19, 21, 4, -19 },
  { 4275, 18, 19, 21, 3, -19 },
  { 4318, 19, 19, 21, 1, -19 },
  { 4364, 16, 25, 21, 3, -19 },
  { 4414, 17, 19, 21, 2, -19 },
  { 4455, 17, 33, 21, 4, -29 },
  { 4526, 8, 33, 21, 7, -29 },
  { 4559, 17, 33, 21, 1, -29 },
  { 4630, 16, 7, 21, 3, -16 },
};

const GFXfont JetBrainsMono_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC35PT7B_H_
