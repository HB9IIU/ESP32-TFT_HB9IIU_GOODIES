#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/JetBrainsMono_ExtraLightItalic
// Headers: 67

#include "JetBrainsMono_ExtraLightItalic6pt7b.h"
#include "JetBrainsMono_ExtraLightItalic7pt7b.h"
#include "JetBrainsMono_ExtraLightItalic8pt7b.h"
#include "JetBrainsMono_ExtraLightItalic9pt7b.h"
#include "JetBrainsMono_ExtraLightItalic10pt7b.h"
#include "JetBrainsMono_ExtraLightItalic11pt7b.h"
#include "JetBrainsMono_ExtraLightItalic12pt7b.h"
#include "JetBrainsMono_ExtraLightItalic13pt7b.h"
#include "JetBrainsMono_ExtraLightItalic14pt7b.h"
#include "JetBrainsMono_ExtraLightItalic15pt7b.h"
#include "JetBrainsMono_ExtraLightItalic16pt7b.h"
#include "JetBrainsMono_ExtraLightItalic17pt7b.h"
#include "JetBrainsMono_ExtraLightItalic18pt7b.h"
#include "JetBrainsMono_ExtraLightItalic19pt7b.h"
#include "JetBrainsMono_ExtraLightItalic20pt7b.h"
#include "JetBrainsMono_ExtraLightItalic21pt7b.h"
#include "JetBrainsMono_ExtraLightItalic22pt7b.h"
#include "JetBrainsMono_ExtraLightItalic23pt7b.h"
#include "JetBrainsMono_ExtraLightItalic24pt7b.h"
#include "JetBrainsMono_ExtraLightItalic25pt7b.h"
#include "JetBrainsMono_ExtraLightItalic26pt7b.h"
#include "JetBrainsMono_ExtraLightItalic27pt7b.h"
#include "JetBrainsMono_ExtraLightItalic28pt7b.h"
#include "JetBrainsMono_ExtraLightItalic29pt7b.h"
#include "JetBrainsMono_ExtraLightItalic30pt7b.h"
#include "JetBrainsMono_ExtraLightItalic31pt7b.h"
#include "JetBrainsMono_ExtraLightItalic32pt7b.h"
#include "JetBrainsMono_ExtraLightItalic33pt7b.h"
#include "JetBrainsMono_ExtraLightItalic34pt7b.h"
#include "JetBrainsMono_ExtraLightItalic35pt7b.h"
#include "JetBrainsMono_ExtraLightItalic36pt7b.h"
#include "JetBrainsMono_ExtraLightItalic37pt7b.h"
#include "JetBrainsMono_ExtraLightItalic38pt7b.h"
#include "JetBrainsMono_ExtraLightItalic39pt7b.h"
#include "JetBrainsMono_ExtraLightItalic40pt7b.h"
#include "JetBrainsMono_ExtraLightItalic41pt7b.h"
#include "JetBrainsMono_ExtraLightItalic42pt7b.h"
#include "JetBrainsMono_ExtraLightItalic43pt7b.h"
#include "JetBrainsMono_ExtraLightItalic44pt7b.h"
#include "JetBrainsMono_ExtraLightItalic45pt7b.h"
#include "JetBrainsMono_ExtraLightItalic46pt7b.h"
#include "JetBrainsMono_ExtraLightItalic47pt7b.h"
#include "JetBrainsMono_ExtraLightItalic48pt7b.h"
#include "JetBrainsMono_ExtraLightItalic49pt7b.h"
#include "JetBrainsMono_ExtraLightItalic50pt7b.h"
#include "JetBrainsMono_ExtraLightItalic51pt7b.h"
#include "JetBrainsMono_ExtraLightItalic52pt7b.h"
#include "JetBrainsMono_ExtraLightItalic53pt7b.h"
#include "JetBrainsMono_ExtraLightItalic54pt7b.h"
#include "JetBrainsMono_ExtraLightItalic55pt7b.h"
#include "JetBrainsMono_ExtraLightItalic56pt7b.h"
#include "JetBrainsMono_ExtraLightItalic57pt7b.h"
#include "JetBrainsMono_ExtraLightItalic58pt7b.h"
#include "JetBrainsMono_ExtraLightItalic59pt7b.h"
#include "JetBrainsMono_ExtraLightItalic60pt7b.h"
#include "JetBrainsMono_ExtraLightItalic61pt7b.h"
#include "JetBrainsMono_ExtraLightItalic62pt7b.h"
#include "JetBrainsMono_ExtraLightItalic63pt7b.h"
#include "JetBrainsMono_ExtraLightItalic64pt7b.h"
#include "JetBrainsMono_ExtraLightItalic65pt7b.h"
#include "JetBrainsMono_ExtraLightItalic66pt7b.h"
#include "JetBrainsMono_ExtraLightItalic67pt7b.h"
#include "JetBrainsMono_ExtraLightItalic68pt7b.h"
#include "JetBrainsMono_ExtraLightItalic69pt7b.h"
#include "JetBrainsMono_ExtraLightItalic70pt7b.h"
#include "JetBrainsMono_ExtraLightItalic71pt7b.h"
#include "JetBrainsMono_ExtraLightItalic72pt7b.h"
