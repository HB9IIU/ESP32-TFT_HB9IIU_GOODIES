#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0x00, 0x00, 0x8E, 0xFF, 0x9C, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0x71,
  0xD8, 0x76, 0x1D, 0x87, 0x61, 0xD8, 0x70, 0x07, 0x1C, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0E, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18,
  0x60, 0x18, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x30,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0x03, 0xFF, 0x3F, 0xFB, 0xD8,
  0xDC, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0xCC, 0x0F, 0x60, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x37, 0x81, 0x9C, 0x0C, 0x70, 0x63, 0x83,
  0x1C, 0x18, 0xF0, 0xCE, 0xFF, 0xF7, 0xFE, 0x0F, 0xE0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x10, 0x00, 0x81, 0xF0, 0x0C, 0x07, 0xE0, 0x70,
  0x39, 0xC1, 0xC0, 0xC7, 0x06, 0x03, 0x0C, 0x38, 0x0C, 0x30, 0xE0, 0x30,
  0xC3, 0x00, 0xC3, 0x1C, 0x03, 0x0C, 0x70, 0x0C, 0x31, 0x80, 0x30, 0xCE,
  0x30, 0xC3, 0x39, 0xF3, 0x1C, 0xCF, 0xEE, 0x77, 0x33, 0x9F, 0x99, 0xC6,
  0x3C, 0x67, 0x1C, 0x43, 0x9C, 0x70, 0x0C, 0x61, 0xC0, 0x31, 0x87, 0x01,
  0xC6, 0x1C, 0x06, 0x18, 0x70, 0x38, 0x71, 0xC0, 0xE1, 0xC6, 0x03, 0x07,
  0x18, 0x1C, 0x0C, 0xE0, 0x70, 0x3F, 0x01, 0x80, 0x7C, 0x02, 0x00, 0x07,
  0xE0, 0x07, 0xF8, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC3, 0x00, 0xE1, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0x0E, 0x7B, 0xC7, 0x38, 0xE3, 0xBC,
  0x39, 0xDC, 0x1F, 0xCE, 0x07, 0xE7, 0x03, 0xF3, 0x80, 0xF1, 0xE0, 0x78,
  0x70, 0x7E, 0x3F, 0xFF, 0x8F, 0xF9, 0xC3, 0xF0, 0xF0, 0xFF, 0xFF, 0x76,
  0x66, 0x66, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x07, 0x77, 0x3F, 0xFF, 0xFF, 0xE1, 0xF0, 0x0D, 0x80, 0xEE,
  0x0E, 0x38, 0x71, 0xC0, 0x88, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x3C, 0xE3, 0x8E, 0x71, 0xC7, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0x2F, 0xFF,
  0x70, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x02, 0x00, 0xFC,
  0x0F, 0xF0, 0xFB, 0xC7, 0x0E, 0x38, 0x7B, 0x81, 0xDC, 0x0E, 0xE0, 0x77,
  0x03, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xCE, 0x1E,
  0x70, 0xE3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x03, 0x83, 0xC3, 0xE3, 0xF3,
  0xBF, 0x9D, 0x8E, 0x47, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x02, 0x00, 0xFF, 0x07, 0xFE, 0x3E, 0x7C, 0x20, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x02, 0x01, 0xFE, 0x1F, 0xFD, 0xF1, 0xE6, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x80, 0x7F, 0xDF, 0xBF, 0xF8, 0xFF,
  0x80, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x6E,
  0x01, 0xDC, 0x03, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0x83,
  0x87, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x60, 0x71, 0xC0, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3B, 0x81, 0xFF, 0x8F,
  0xFE, 0x20, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xD0, 0x1E, 0xF7, 0xE7, 0xFE, 0x3F, 0xE0,
  0x00, 0x80, 0x3F, 0x07, 0xF8, 0x7C, 0x43, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xCF, 0x8E, 0xFE, 0x7F, 0xF3, 0xC3,
  0xDE, 0x0E, 0xE0, 0x77, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x81, 0xCE, 0x0E, 0x70, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0x00,
  0x3F, 0x83, 0xFF, 0x0F, 0x1E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x39, 0xE0, 0xE3, 0x87, 0x8F, 0x3C, 0x1F, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xF8, 0x38, 0xF1, 0xC1, 0xE7, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x01, 0xDC, 0x0F, 0x70, 0x39, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0x02,
  0x00, 0x7E, 0x0F, 0xF8, 0x79, 0xE7, 0x87, 0x38, 0x3D, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xE1, 0xE7,
  0xFF, 0x3F, 0xB8, 0x79, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x01, 0xE1, 0xBE, 0x0F, 0xF0, 0x7E, 0x00, 0x27, 0xFF, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x27, 0xFF, 0x70, 0x10, 0xE7, 0x9E, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0x8E, 0x39,
  0xC7, 0x1C, 0x63, 0x80, 0x00, 0x04, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1C, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00,
  0x04, 0x07, 0xF3, 0xFF, 0x39, 0xF4, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xF0, 0x3C,
  0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0xCE, 0x0F, 0x86,
  0x60, 0xFE, 0x33, 0x0E, 0x71, 0xF8, 0xE3, 0x8F, 0xC7, 0x1C, 0x7E, 0x30,
  0xE3, 0xE1, 0x87, 0x1F, 0x0C, 0x38, 0xF8, 0x61, 0xC7, 0xC3, 0x0E, 0x3E,
  0x18, 0x71, 0xF0, 0xC7, 0x8D, 0xC7, 0x3C, 0x6E, 0x3F, 0x7F, 0x70, 0xF9,
  0xF1, 0x81, 0x86, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x0C, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0x01, 0xC3, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x78, 0x03, 0xFC, 0x00, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFF, 0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0x81, 0xEE, 0x07, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x8E, 0x0F, 0x38, 0x1E,
  0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x03,
  0xB8, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x80, 0x1F, 0xE0,
  0xFF, 0xC7, 0xCE, 0x3C, 0x08, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x04, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC7, 0x07, 0xCE, 0x07, 0x9C, 0x07, 0xB8, 0x0F, 0x70, 0x0E,
  0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x03,
  0xDC, 0x07, 0x38, 0x1E, 0x70, 0x78, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0xB8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xBF, 0xF7, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xF3,
  0xE3, 0xE0, 0x21, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x1D, 0xE0, 0x0E, 0x78, 0x07, 0x3E, 0x03, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xC0, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x78, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0E, 0xFE, 0xFE, 0xFC, 0xE0, 0x3F, 0x81, 0xEE,
  0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x1C, 0x38, 0xF0, 0xE3, 0x83,
  0x9C, 0x0E, 0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0,
  0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x07,
  0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xDF, 0xF0, 0x07, 0x7F, 0xC0,
  0x1D, 0xFB, 0x00, 0x7F, 0xEE, 0x01, 0xBF, 0xB8, 0x0E, 0xFE, 0x60, 0x3B,
  0xF9, 0xC0, 0xCF, 0xE7, 0x07, 0x3F, 0x9C, 0x1C, 0xFE, 0x30, 0x73, 0xF8,
  0xE1, 0x8F, 0xE3, 0x8E, 0x3F, 0x8E, 0x38, 0xFE, 0x1C, 0xC3, 0xF8, 0x77,
  0x0F, 0xE1, 0xDC, 0x3F, 0x83, 0x70, 0xFE, 0x0F, 0x83, 0xF8, 0x3E, 0x0F,
  0xE0, 0xF8, 0x3F, 0x81, 0xC0, 0xFE, 0x07, 0x03, 0xC0, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xEE,
  0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE1, 0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0xF7, 0xE0,
  0x77, 0xE0, 0x77, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0x00, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0xEF, 0x83,
  0xC1, 0xE3, 0xC0, 0x79, 0xC0, 0x3C, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x3C, 0xF0, 0x1C, 0x3C, 0x1E, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F,
  0x71, 0xF3, 0xFF, 0x1F, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x80, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0xEF, 0xC3, 0xC1, 0xE3, 0xC0, 0x79,
  0xC0, 0x3C, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C,
  0xF0, 0x1C, 0x3C, 0x1E, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x07,
  0xB8, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x07, 0x38, 0x3C, 0xE1, 0xE3, 0xFF,
  0x8F, 0xF8, 0x3F, 0xE0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0,
  0xE3, 0x83, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xC0,
  0x01, 0x00, 0x7F, 0x87, 0xFE, 0x7F, 0xE7, 0x81, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0xC0, 0x77, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xFC, 0x0E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0xE0, 0x07,
  0xF8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0xE1, 0xC0, 0x78, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x3C,
  0x03, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0xFE,
  0x01, 0xE0, 0x1D, 0xC0, 0x3C, 0x07, 0xB8, 0x0F, 0x80, 0xE7, 0x01, 0xF0,
  0x1C, 0xE0, 0x3E, 0x03, 0x8E, 0x06, 0xE0, 0x71, 0xC0, 0xDC, 0x1E, 0x38,
  0x3B, 0x83, 0x87, 0x07, 0x70, 0x70, 0xE0, 0xE6, 0x0E, 0x0E, 0x1C, 0xE1,
  0xC1, 0xC3, 0x1C, 0x78, 0x38, 0xE3, 0x8E, 0x07, 0x1C, 0x71, 0xC0, 0xE3,
  0x86, 0x38, 0x0E, 0x70, 0xC7, 0x01, 0xCC, 0x1D, 0xE0, 0x3B, 0x83, 0xB8,
  0x07, 0x70, 0x77, 0x00, 0xEE, 0x06, 0xE0, 0x0D, 0xC0, 0xDC, 0x01, 0xF0,
  0x1B, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x70, 0x38, 0xE0, 0xF1, 0xE1, 0xC1,
  0xC3, 0x83, 0x8F, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xE0,
  0x1D, 0xC0, 0x39, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x87, 0x0E, 0x0E, 0x1C,
  0x1E, 0x78, 0x1C, 0xE0, 0x3B, 0xC0, 0x78, 0xF0, 0x1E, 0xE0, 0x39, 0xC0,
  0x73, 0xC1, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x0E, 0x38, 0x1C, 0x70,
  0x39, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0xEE, 0x01, 0xDC, 0x07, 0x18, 0x0E, 0x38, 0x38, 0x30, 0x70, 0x71,
  0xC0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE1, 0xE1, 0xE1, 0xC1, 0xC1, 0xC0, 0x07, 0x83, 0xFE,
  0x3F, 0xE1, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF,
  0x3F, 0xF7, 0x87, 0x70, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x77, 0x0F,
  0x79, 0xB7, 0xFB, 0x3F, 0x30, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF1, 0xC3, 0xDF, 0x8E, 0xFF,
  0x3E, 0x1E, 0xF8, 0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3B, 0xE0, 0xEE, 0xEF, 0xBB, 0xFC, 0xE7, 0xE0, 0x07, 0x87, 0xF3, 0xFD,
  0xE1, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0xCC, 0xFF, 0x1F, 0xC0, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x0E, 0x39, 0xFD, 0xDF, 0xFE, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7B, 0x83, 0xDE, 0x7E, 0x7F, 0x71, 0xF1, 0x80, 0x07,
  0x01, 0xFC, 0x3F, 0xE7, 0x0E, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x01, 0x7C, 0x73, 0xFF, 0x1F, 0xE0, 0x07, 0xC3, 0xF1, 0xFC, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xEF, 0xF8, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xFD, 0xDF,
  0xFE, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7B,
  0x83, 0xDF, 0x7E, 0x7F, 0x71, 0xF3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xD0, 0x3C, 0xFF, 0xE7, 0xFE, 0x1F, 0xC0, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF3, 0xC7,
  0xBF, 0x3B, 0xFD, 0xF8, 0xEF, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x80, 0x6F, 0xF7, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C,
  0x3C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1C, 0x3B, 0xF7, 0xEF, 0x80, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x83,
  0xBC, 0x39, 0xE1, 0xCF, 0x1C, 0x79, 0xE3, 0xCE, 0x1E, 0xE0, 0xE7, 0x07,
  0x78, 0x3B, 0xE1, 0xF7, 0x0F, 0x38, 0x78, 0xE3, 0xC7, 0x1E, 0x3C, 0xF0,
  0xE7, 0x87, 0xBC, 0x1D, 0xE0, 0xEF, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC1, 0xE3, 0x9F, 0x9F, 0xCE, 0xFF, 0x7F, 0xBE, 0x3F, 0x1E, 0xF0, 0x78,
  0x3B, 0xC1, 0xE0, 0xEF, 0x07, 0x83, 0xBC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3C, 0x01, 0x87, 0x3F,
  0x3B, 0xFD, 0xF0, 0xEF, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x80, 0x0F, 0x00, 0xFE, 0x0F,
  0xF8, 0xF1, 0xE7, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x7B,
  0x83, 0x9F, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0x01, 0xC3, 0x9F, 0x8E, 0xFF,
  0x3E, 0x1E, 0xF8, 0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3B, 0xE0, 0xEE, 0xCF, 0xBB, 0xFC, 0xF7, 0xE3, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0E, 0x01, 0xFD, 0xDF, 0xFE, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7B, 0x83, 0xDF, 0x7E, 0x7F, 0x71, 0xF3, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x03, 0xF3, 0xFB, 0xFD, 0xDF, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0xFD, 0xFF, 0x38, 0x2E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x3B, 0xDF, 0x7F, 0xC7, 0xF0, 0x38, 0x38, 0x38, 0x38, 0x38, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3D, 0x3F, 0x1F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xEE, 0x0F, 0x70, 0xFB, 0xEF,
  0xCF, 0xEE, 0x3E, 0x70, 0xF0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x1C, 0xE0, 0x33, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xF0, 0x38, 0x1E, 0xE0, 0xF8, 0x39, 0xC1, 0xF0, 0x73,
  0x83, 0x60, 0xE7, 0x06, 0xC1, 0xC7, 0x0D, 0x87, 0x0E, 0x3B, 0x8E, 0x1C,
  0x77, 0x1C, 0x38, 0xEE, 0x38, 0x71, 0x8C, 0x60, 0x73, 0x19, 0xC0, 0xEE,
  0x3B, 0x81, 0xDC, 0x77, 0x03, 0xB8, 0xEE, 0x03, 0x60, 0xD8, 0x06, 0xC1,
  0xB0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x38, 0x1E,
  0x00, 0xF0, 0x73, 0x87, 0x9C, 0x38, 0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0,
  0xE7, 0x07, 0x3C, 0x70, 0xE3, 0x87, 0xB8, 0x1D, 0xC0, 0xF0, 0xF0, 0x1D,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x78, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x18, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x0C, 0xE0, 0x3B, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0xE0, 0x1F, 0x00, 0x78,
  0x00, 0xFF, 0xBF, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xC1, 0xF0, 0xF8, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC3, 0xE0, 0xE0, 0x3E,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xFC, 0x1F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x3E, 0x07, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1F, 0x01, 0xC1, 0xF0, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x0F, 0xC3, 0xE0, 0xE0, 0x00, 0x3C, 0x05, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0x80, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 27, 9, 2, -27 },
  { 18, 10, 10, 14, 2, -27 },
  { 31, 16, 27, 17, 1, -27 },
  { 85, 13, 31, 16, 2, -29 },
  { 136, 22, 28, 25, 2, -28 },
  { 213, 17, 28, 18, 1, -28 },
  { 273, 4, 10, 8, 2, -27 },
  { 278, 8, 33, 11, 2, -27 },
  { 311, 8, 33, 11, 1, -27 },
  { 344, 13, 13, 15, 1, -29 },
  { 366, 14, 17, 16, 1, -22 },
  { 396, 6, 9, 9, 1, -4 },
  { 403, 8, 3, 10, 1, -12 },
  { 406, 4, 5, 9, 2, -5 },
  { 409, 13, 27, 14, 1, -27 },
  { 453, 13, 28, 16, 2, -28 },
  { 499, 9, 27, 16, 2, -27 },
  { 530, 14, 28, 16, 1, -28 },
  { 579, 13, 28, 16, 1, -28 },
  { 625, 15, 27, 16, 1, -27 },
  { 676, 13, 27, 16, 2, -27 },
  { 720, 13, 28, 16, 2, -28 },
  { 766, 14, 27, 16, 1, -27 },
  { 814, 14, 28, 16, 1, -28 },
  { 863, 13, 28, 16, 1, -28 },
  { 909, 4, 21, 9, 2, -21 },
  { 920, 6, 26, 9, 1, -21 },
  { 940, 14, 17, 16, 1, -22 },
  { 970, 14, 11, 16, 1, -19 },
  { 990, 14, 17, 16, 1, -22 },
  { 1020, 11, 28, 12, 0, -28 },
  { 1059, 21, 30, 25, 2, -27 },
  { 1138, 17, 27, 17, 0, -27 },
  { 1196, 14, 27, 18, 3, -27 },
  { 1244, 14, 28, 17, 2, -28 },
  { 1293, 15, 27, 20, 3, -27 },
  { 1344, 11, 27, 15, 3, -27 },
  { 1382, 11, 27, 14, 3, -27 },
  { 1420, 17, 28, 21, 2, -28 },
  { 1480, 15, 27, 20, 3, -27 },
  { 1531, 8, 27, 11, 1, -27 },
  { 1558, 8, 34, 9, -2, -27 },
  { 1592, 14, 27, 17, 3, -27 },
  { 1640, 10, 27, 14, 3, -27 },
  { 1674, 22, 27, 27, 3, -27 },
  { 1749, 16, 27, 22, 3, -27 },
  { 1803, 17, 28, 21, 2, -28 },
  { 1863, 13, 27, 17, 3, -27 },
  { 1907, 17, 34, 21, 2, -28 },
  { 1980, 14, 27, 18, 3, -27 },
  { 2028, 13, 28, 16, 1, -28 },
  { 2074, 14, 27, 14, 0, -27 },
  { 2122, 14, 27, 20, 3, -27 },
  { 2170, 17, 27, 17, 0, -27 },
  { 2228, 27, 27, 27, 0, -27 },
  { 2320, 15, 27, 15, 0, -27 },
  { 2371, 15, 27, 15, 0, -27 },
  { 2422, 12, 27, 14, 1, -27 },
  { 2463, 8, 33, 12, 3, -27 },
  { 2496, 13, 27, 14, 1, -27 },
  { 2540, 8, 33, 12, 1, -27 },
  { 2573, 15, 14, 17, 1, -27 },
  { 2600, 17, 3, 17, 0, 3 },
  { 2607, 7, 6, 10, 2, -29 },
  { 2613, 12, 21, 16, 1, -21 },
  { 2645, 14, 29, 18, 2, -29 },
  { 2696, 10, 21, 13, 2, -21 },
  { 2723, 13, 29, 18, 2, -29 },
  { 2771, 12, 21, 16, 2, -21 },
  { 2803, 10, 29, 10, 0, -29 },
  { 2840, 13, 30, 18, 2, -21 },
  { 2889, 13, 29, 17, 2, -29 },
  { 2937, 4, 28, 8, 2, -28 },
  { 2951, 7, 37, 8, -1, -28 },
  { 2984, 13, 29, 15, 2, -29 },
  { 3032, 4, 29, 8, 2, -29 },
  { 3047, 22, 21, 26, 2, -21 },
  { 3105, 13, 21, 17, 2, -21 },
  { 3140, 13, 21, 17, 2, -21 },
  { 3175, 14, 30, 18, 2, -21 },
  { 3228, 13, 30, 18, 2, -21 },
  { 3277, 9, 21, 12, 2, -21 },
  { 3301, 11, 21, 13, 1, -21 },
  { 3330, 8, 25, 10, 1, -25 },
  { 3355, 13, 20, 17, 2, -20 },
  { 3388, 14, 20, 14, 0, -20 },
  { 3423, 23, 20, 23, 0, -20 },
  { 3481, 13, 20, 14, 1, -20 },
  { 3514, 14, 29, 14, 0, -20 },
  { 3565, 10, 20, 12, 1, -20 },
  { 3590, 10, 33, 14, 2, -27 },
  { 3632, 3, 38, 15, 6, -29 },
  { 3647, 10, 33, 14, 2, -27 },
  { 3689, 14, 5, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Regular38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR38PT7B_H_
