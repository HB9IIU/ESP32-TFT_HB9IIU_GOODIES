#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x60,
  0x00, 0xEF, 0xFF, 0xF0, 0xF1, 0xFE, 0x3D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1,
  0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1C, 0x03, 0x0E, 0x03, 0x87, 0x01, 0xC3,
  0x00, 0xE1, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x18, 0x70, 0x0C, 0x38, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xC3, 0x00, 0xE1, 0x80, 0x70, 0xC0,
  0x30, 0xE0, 0x18, 0x70, 0x0C, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE1, 0xC3, 0x00, 0xE1, 0x80, 0x61, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0x0C,
  0x38, 0x0E, 0x1C, 0x07, 0x0C, 0x03, 0x86, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xF0, 0x3F, 0xF9, 0xFF, 0xE7, 0xB3, 0xB8, 0xC0, 0xE3, 0x03,
  0x8C, 0x0E, 0x30, 0x38, 0xC0, 0xE3, 0x03, 0xEC, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x37, 0x80, 0xCF, 0x03, 0x1C, 0x0C, 0x70, 0x31,
  0xC0, 0xC7, 0x83, 0x3F, 0x0D, 0xEF, 0xFF, 0x3F, 0xF8, 0x3F, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x01, 0xC0,
  0x7F, 0x01, 0x80, 0xE7, 0x03, 0x80, 0xE3, 0x83, 0x80, 0xE3, 0x83, 0x00,
  0xE3, 0x87, 0x00, 0xC3, 0x87, 0x00, 0xC3, 0x86, 0x00, 0xC3, 0x8E, 0x00,
  0xC3, 0x8E, 0x00, 0xC3, 0x8C, 0x00, 0xE3, 0x9C, 0x78, 0xE3, 0x9C, 0xFC,
  0xE3, 0x99, 0xFC, 0x67, 0x39, 0x8E, 0x7F, 0x39, 0x8E, 0x3E, 0x73, 0x86,
  0x1C, 0x73, 0x86, 0x00, 0x63, 0x87, 0x00, 0xE3, 0x87, 0x00, 0xE3, 0x87,
  0x00, 0xC3, 0x87, 0x01, 0xC3, 0x87, 0x01, 0xC3, 0x86, 0x01, 0x83, 0x8E,
  0x03, 0x81, 0x8E, 0x03, 0x81, 0xCE, 0x03, 0x00, 0xFC, 0x07, 0x00, 0xF8,
  0x03, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x73, 0xC0, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xC3, 0x87, 0x3C, 0x71, 0xE3, 0x8E, 0x38, 0x79, 0xCF,
  0x07, 0x79, 0xE0, 0xFE, 0x3C, 0x0F, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E,
  0x07, 0xE1, 0xE1, 0xFC, 0x3F, 0xFB, 0xC3, 0xFE, 0x3C, 0x3F, 0x87, 0xC0,
  0xFF, 0x77, 0x77, 0x77, 0x77, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xF0, 0xE0, 0x38,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C,
  0x1E, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x73, 0x39,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x3B, 0x81, 0xCE, 0x0F, 0x1C,
  0x18, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x9C, 0x73, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x73, 0xFF, 0xF7, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x7F, 0x03, 0xFE, 0x0F, 0xFC, 0x78, 0x71, 0xC1, 0xE7, 0x03, 0xBC, 0x0E,
  0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xEF, 0x03, 0xBC, 0x0E, 0x70, 0x79, 0xC1, 0xE7, 0x8F, 0x0F, 0xFC, 0x3F,
  0xE0, 0x3F, 0x00, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xBF, 0x9F, 0x8E, 0x87,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x07, 0x80, 0x3F, 0xC1, 0xFF, 0xC3, 0xEF, 0xC2, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x7F,
  0xC1, 0xFF, 0xE7, 0xC7, 0xC6, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x79, 0x01, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8, 0x03, 0xB8, 0x03, 0x38,
  0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC4, 0x0F, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x7A, 0x03, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0x00, 0xF0, 0x1F,
  0xC0, 0xFF, 0x07, 0xC4, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x40, 0xE7, 0xE3, 0xBF, 0xCF, 0xFF, 0xBE,
  0x1E, 0xF0, 0x3B, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0x70, 0x39, 0xE0, 0xE7, 0x87, 0x8F, 0xFC, 0x1F, 0xF0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F,
  0xE0, 0x7F, 0xE1, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0x9C, 0x07, 0xB8, 0x0F,
  0x70, 0x1C, 0xF0, 0x38, 0xE0, 0xF1, 0xE1, 0xC1, 0xE7, 0x81, 0xFE, 0x01,
  0xF0, 0x07, 0xF0, 0x1E, 0xF0, 0x78, 0xF1, 0xE0, 0xF3, 0x80, 0xF7, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xE0, 0x71,
  0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0x00, 0x7F, 0x03, 0xFE, 0x1F,
  0x7C, 0xF0, 0x73, 0xC1, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x07, 0xFE, 0x3F, 0x7F, 0xFC,
  0xFE, 0xE1, 0xF3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x73,
  0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xFF,
  0xB8, 0x38, 0xF7, 0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF3, 0xCF, 0x38, 0xE3, 0x9E, 0x71, 0xCE, 0x00, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x06, 0x03, 0xFC, 0xFF, 0xE7,
  0x9F, 0x40, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3C, 0x0F, 0x00, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E,
  0x1C, 0x00, 0x0C, 0x30, 0x08, 0x1C, 0xE0, 0xFE, 0x39, 0xC3, 0xFC, 0x33,
  0x0F, 0x38, 0x7E, 0x1C, 0x70, 0xFC, 0x30, 0xE1, 0xF8, 0xE1, 0xC3, 0xF1,
  0xC3, 0x87, 0xE3, 0x87, 0x0F, 0xC7, 0x0E, 0x1F, 0x8E, 0x1C, 0x3F, 0x1C,
  0x38, 0x7E, 0x38, 0x70, 0xDC, 0x31, 0xE3, 0xB8, 0x73, 0xE7, 0x70, 0xFC,
  0xFC, 0x70, 0xF9, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0xCF, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x80, 0xE0,
  0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3C, 0x07, 0x0E, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x0E, 0x78, 0x03, 0x9E,
  0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xC0, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7, 0x03, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F,
  0xFC, 0x70, 0x7C, 0xE0, 0x3D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3D, 0xC0, 0xFB, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFC, 0xF1,
  0xE0, 0x47, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x08, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x3C, 0xE0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x3E,
  0x1E, 0x01, 0x8F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xDC, 0x00, 0x77, 0x80, 0x1D, 0xE0, 0x07, 0x3C, 0x01, 0xCF,
  0x00, 0x71, 0xF0, 0x1C, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC7,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x9F, 0xFF, 0xF8, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0F, 0x9F, 0xFE, 0xFE, 0xF8, 0xE0, 0x1F, 0xC0, 0x7B, 0x80,
  0xF7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE1, 0xC1,
  0xC7, 0x83, 0x9E, 0x07, 0x3C, 0x0E, 0xF0, 0x1D, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFB, 0xC1, 0xE7, 0x83, 0x87, 0x87, 0x0F, 0x0E, 0x0F, 0x1C, 0x1E,
  0x38, 0x1C, 0x70, 0x3C, 0xE0, 0x39, 0xC0, 0x7B, 0x80, 0x77, 0x00, 0xFE,
  0x01, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xEE, 0x00, 0x7F, 0xEE, 0x00, 0xEF, 0xEE, 0x00,
  0xEF, 0xE7, 0x00, 0xEF, 0xE7, 0x00, 0xEF, 0xE7, 0x01, 0xCF, 0xE7, 0x81,
  0xCF, 0xE3, 0x81, 0xCF, 0xE3, 0x83, 0x8F, 0xE3, 0x83, 0x8F, 0xE1, 0xC3,
  0x8F, 0xE1, 0xC3, 0x8F, 0xE1, 0xC7, 0x0F, 0xE1, 0xE7, 0x0F, 0xE0, 0xE7,
  0x0F, 0xE0, 0xEE, 0x0F, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x38,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xB8, 0x0F, 0xDC, 0x07, 0xE7, 0x03, 0xF3, 0x81, 0xF9, 0xE0,
  0xFC, 0x70, 0x7E, 0x3C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC1, 0xC7, 0xE0,
  0xE3, 0xF0, 0x79, 0xF8, 0x1C, 0xFC, 0x0F, 0x7E, 0x03, 0xBF, 0x01, 0xDF,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xDF,
  0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x1E, 0x70, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03,
  0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x07,
  0x78, 0x00, 0xEF, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xF3, 0xC0, 0x1C,
  0x78, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0xE0, 0x7B,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3B, 0x81, 0xEE, 0x3F, 0x3F, 0xFC, 0xFF, 0xC3, 0xF8, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xDF, 0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x1E, 0x00, 0xE3, 0xC0,
  0x1E, 0x70, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00,
  0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3B, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00,
  0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x3C, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0xC7, 0x07, 0xCE, 0x07, 0x9C, 0x07, 0xB8, 0x0F, 0x70,
  0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xCE, 0x07, 0x9C, 0x1E,
  0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC1, 0xC3, 0x83, 0x87, 0x87, 0x07, 0x0E,
  0x0F, 0x1C, 0x1E, 0x38, 0x1C, 0x70, 0x3C, 0xE0, 0x39, 0xC0, 0x7B, 0x80,
  0xF7, 0x00, 0xFE, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF,
  0x81, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xF0,
  0x3D, 0xFF, 0xEF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF0,
  0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x78, 0x07, 0x9E, 0x01,
  0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x3B, 0x80, 0x3C, 0x03,
  0xDC, 0x01, 0xE0, 0x1E, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0xF8, 0x07, 0x3C,
  0x07, 0xE0, 0x38, 0xE0, 0x3F, 0x03, 0xC7, 0x01, 0xB8, 0x1E, 0x38, 0x1D,
  0xC0, 0xF1, 0xE0, 0xEE, 0x07, 0x0F, 0x07, 0x38, 0x38, 0x38, 0x39, 0xC3,
  0xC1, 0xC1, 0xCE, 0x1E, 0x0E, 0x1C, 0x70, 0xF0, 0x78, 0xE3, 0x87, 0x03,
  0xC7, 0x0E, 0x38, 0x0E, 0x38, 0x73, 0xC0, 0x71, 0xC3, 0x9E, 0x03, 0x9C,
  0x1C, 0xF0, 0x1C, 0xE0, 0xE7, 0x00, 0xF7, 0x03, 0x38, 0x03, 0xB8, 0x1D,
  0xC0, 0x1D, 0xC0, 0xFE, 0x00, 0xEC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x38, 0x0E, 0x3C, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0F, 0x70, 0x07, 0x70, 0x07,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1E, 0x38, 0x1C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x3F, 0xFF, 0xFF, 0xF8, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x0E, 0x0E,
  0x07, 0x0F, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x7B, 0x80, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE1, 0xE1, 0xC1, 0xC0, 0x1F,
  0xE1, 0xFF, 0x87, 0x3E, 0x20, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x7F, 0xC7, 0xFE, 0x7C, 0x77, 0x83, 0xB8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3B, 0x83, 0xDC, 0x1E, 0xFB, 0xB3, 0xF9, 0x8F, 0x8C, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x9F, 0x8E, 0xFF, 0x3F, 0xFE, 0xF8, 0x7B, 0xC0, 0xEF,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xBE, 0x1E,
  0xFF, 0xFB, 0xBF, 0xCC, 0x7E, 0x00, 0x0F, 0xE7, 0xFC, 0xFF, 0xBC, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x9F, 0xF3, 0xFE, 0x3F,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x7E, 0x73, 0xFD, 0xDF, 0xFF, 0x78, 0x7D,
  0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03,
  0xDE, 0x1F, 0x7D, 0xFC, 0xFF, 0x71, 0xF8, 0xC0, 0x0F, 0xC0, 0xFF, 0x83,
  0xCF, 0x1C, 0x1C, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x8F, 0xBE, 0x1F, 0xF8, 0x3F, 0xC0, 0x07,
  0xE1, 0xFC, 0x3F, 0x8F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0xFB, 0xFF, 0x7F, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x9C, 0xFF, 0x77, 0xFF, 0xDE,
  0x1F, 0x70, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0xF7, 0x87, 0xDF, 0xFF, 0x3F, 0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xE0, 0x0E, 0x60, 0xF9, 0xFF, 0xC7, 0xFE,
  0x07, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x3F, 0x3B, 0xFD, 0xFF, 0xEF, 0x87, 0xF8,
  0x3F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x7F, 0xF7, 0x00, 0x00, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x0E, 0x3C, 0x78, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0xF1, 0xFF, 0xBF, 0x38, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0xF8,
  0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x8E, 0x1C, 0xF0, 0xE7, 0x07, 0x78,
  0x3B, 0xC1, 0xFE, 0x0F, 0xF8, 0x79, 0xC3, 0x8F, 0x1C, 0x38, 0xE1, 0xC7,
  0x0F, 0x38, 0x39, 0xC1, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC7, 0xE3,
  0xF3, 0xBF, 0x9F, 0xEF, 0xFF, 0x7F, 0xFC, 0x1F, 0x0F, 0xF0, 0x78, 0x1F,
  0x81, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81,
  0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0,
  0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E,
  0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x70, 0xC7,
  0xE7, 0x7F, 0xBF, 0xFD, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C, 0x0F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x78, 0x0E, 0xF0, 0x3C, 0xE0, 0x79, 0xE1, 0xE1, 0xFF,
  0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xC7, 0xE3, 0xBF, 0xCF, 0xFF, 0xBE, 0x1E,
  0xF0, 0x3B, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xEF, 0x87, 0xBF, 0xFE, 0xEF, 0xF3, 0x9F, 0x8E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x1F, 0x9C, 0xFF, 0x77, 0xFF, 0xDE, 0x1F, 0x70, 0x3F, 0xC0, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0xDF, 0xFF,
  0x3F, 0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC7, 0xE7, 0xFF,
  0xFF, 0x8F, 0x87, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1F, 0xE3,
  0xFF, 0x7D, 0xE7, 0x02, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0E, 0xC0, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0x9F,
  0xC7, 0xE0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xFF, 0xF7, 0xFB,
  0x9F, 0x9C, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x81, 0xC7,
  0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x0D, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x3C, 0x07, 0x70,
  0x3E, 0x07, 0x70, 0x3E, 0x07, 0x70, 0x3E, 0x0F, 0x78, 0x36, 0x0E, 0x38,
  0x76, 0x0E, 0x38, 0x77, 0x0E, 0x38, 0x77, 0x0E, 0x38, 0x77, 0x1E, 0x3C,
  0x67, 0x1C, 0x1C, 0xE3, 0x1C, 0x1C, 0xE3, 0x9C, 0x1C, 0xE3, 0x9C, 0x1C,
  0xE3, 0xB8, 0x1E, 0xC3, 0xB8, 0x0E, 0xC1, 0xB8, 0x0F, 0xC1, 0xB8, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07,
  0x80, 0xF0, 0xF0, 0x3D, 0xC1, 0xE7, 0x07, 0x0E, 0x1C, 0x38, 0xF0, 0xF3,
  0x81, 0xDE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x7F, 0x01, 0xDC, 0x07, 0x78, 0x38, 0xE0, 0xE3, 0xC7, 0x87, 0x1C,
  0x1E, 0xF0, 0x3B, 0x80, 0xF0, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0x73, 0x80,
  0xE7, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0xF0,
  0x71, 0xC0, 0xE3, 0x81, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x06,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0xFC, 0x1F, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0xFC, 0x1C,
  0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xFC, 0x0F,
  0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0xE0, 0x3C, 0x1F, 0x87, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x3C, 0x1F, 0x83, 0xE0, 0x40, 0x00, 0x3E, 0x02, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 11, 10, 16, 2, -29 },
  { 30, 17, 29, 19, 1, -29 },
  { 92, 14, 33, 18, 2, -31 },
  { 150, 24, 30, 27, 2, -30 },
  { 240, 19, 30, 20, 1, -30 },
  { 312, 4, 10, 9, 2, -29 },
  { 317, 9, 36, 12, 2, -30 },
  { 358, 9, 36, 12, 1, -30 },
  { 399, 14, 13, 16, 1, -31 },
  { 422, 15, 19, 18, 1, -24 },
  { 458, 6, 10, 9, 1, -5 },
  { 466, 9, 4, 11, 1, -13 },
  { 471, 5, 5, 9, 2, -5 },
  { 475, 14, 29, 15, 1, -29 },
  { 526, 14, 30, 18, 2, -30 },
  { 579, 9, 29, 18, 3, -29 },
  { 612, 15, 30, 18, 1, -30 },
  { 669, 15, 30, 18, 1, -30 },
  { 726, 16, 30, 18, 1, -30 },
  { 786, 14, 29, 18, 2, -29 },
  { 837, 14, 30, 18, 2, -30 },
  { 890, 15, 29, 18, 1, -29 },
  { 945, 15, 30, 18, 1, -30 },
  { 1002, 14, 30, 18, 2, -30 },
  { 1055, 5, 22, 9, 2, -22 },
  { 1069, 6, 27, 9, 1, -22 },
  { 1090, 15, 19, 18, 1, -24 },
  { 1126, 15, 11, 18, 1, -20 },
  { 1147, 15, 19, 18, 1, -24 },
  { 1183, 12, 30, 13, 0, -30 },
  { 1228, 23, 33, 27, 2, -30 },
  { 1323, 18, 29, 18, 0, -29 },
  { 1389, 15, 29, 20, 3, -29 },
  { 1444, 15, 30, 18, 2, -30 },
  { 1501, 16, 29, 21, 3, -29 },
  { 1559, 12, 29, 16, 3, -29 },
  { 1603, 12, 29, 16, 3, -29 },
  { 1647, 18, 30, 22, 2, -30 },
  { 1715, 16, 29, 22, 3, -29 },
  { 1773, 9, 29, 12, 1, -29 },
  { 1806, 8, 37, 9, -2, -29 },
  { 1843, 15, 29, 18, 3, -29 },
  { 1898, 12, 29, 15, 3, -29 },
  { 1942, 24, 29, 29, 3, -29 },
  { 2029, 17, 29, 23, 3, -29 },
  { 2091, 19, 30, 23, 2, -30 },
  { 2163, 14, 29, 18, 3, -29 },
  { 2214, 19, 37, 23, 2, -30 },
  { 2302, 15, 29, 19, 3, -29 },
  { 2357, 13, 30, 17, 2, -30 },
  { 2406, 15, 29, 16, 0, -29 },
  { 2461, 16, 29, 21, 3, -29 },
  { 2519, 18, 29, 18, 0, -29 },
  { 2585, 29, 29, 29, 0, -29 },
  { 2691, 16, 29, 16, 0, -29 },
  { 2749, 16, 29, 16, 0, -29 },
  { 2807, 13, 29, 15, 1, -29 },
  { 2855, 9, 37, 13, 3, -30 },
  { 2897, 14, 29, 15, 1, -29 },
  { 2948, 9, 37, 13, 1, -30 },
  { 2990, 17, 15, 18, 1, -29 },
  { 3022, 18, 3, 18, 0, 3 },
  { 3029, 7, 6, 11, 2, -31 },
  { 3035, 13, 22, 17, 1, -22 },
  { 3071, 14, 31, 19, 3, -31 },
  { 3126, 11, 22, 14, 2, -22 },
  { 3157, 14, 31, 19, 2, -31 },
  { 3212, 14, 22, 17, 2, -22 },
  { 3251, 11, 31, 10, 0, -31 },
  { 3294, 14, 32, 19, 2, -22 },
  { 3350, 13, 31, 19, 3, -31 },
  { 3401, 4, 30, 9, 2, -30 },
  { 3416, 7, 40, 9, -1, -30 },
  { 3451, 13, 31, 16, 3, -31 },
  { 3502, 3, 31, 9, 3, -31 },
  { 3514, 22, 22, 28, 3, -22 },
  { 3575, 13, 22, 19, 3, -22 },
  { 3611, 15, 22, 18, 2, -22 },
  { 3653, 14, 32, 19, 3, -22 },
  { 3709, 14, 32, 19, 2, -22 },
  { 3765, 9, 22, 12, 3, -22 },
  { 3790, 12, 22, 14, 1, -22 },
  { 3823, 9, 27, 11, 1, -27 },
  { 3854, 13, 22, 19, 3, -22 },
  { 3890, 15, 22, 15, 0, -22 },
  { 3932, 24, 22, 25, 0, -22 },
  { 3998, 14, 22, 15, 1, -22 },
  { 4037, 15, 32, 15, 0, -22 },
  { 4097, 11, 22, 12, 1, -22 },
  { 4128, 11, 36, 15, 2, -29 },
  { 4178, 3, 41, 17, 7, -31 },
  { 4194, 11, 36, 15, 2, -29 },
  { 4244, 15, 5, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Regular41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR41PT7B_H_
