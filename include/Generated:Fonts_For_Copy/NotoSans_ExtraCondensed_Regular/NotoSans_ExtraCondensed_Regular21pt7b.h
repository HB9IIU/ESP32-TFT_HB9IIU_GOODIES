#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0xD9, 0x24, 0x92, 0x49, 0x05, 0xF8, 0xCF, 0x3C, 0xF3, 0x48, 0x19,
  0x0C, 0x84, 0xC2, 0x67, 0xFB, 0xFC, 0x48, 0x24, 0x32, 0x7F, 0xC9, 0x84,
  0xC2, 0x61, 0x20, 0x90, 0x10, 0x21, 0xFE, 0x99, 0x12, 0x34, 0x38, 0x3C,
  0x3C, 0x58, 0x91, 0x7F, 0x9E, 0x08, 0x10, 0x70, 0x8D, 0x18, 0x99, 0x09,
  0x90, 0x9B, 0x09, 0xA0, 0x9A, 0xED, 0x6B, 0x75, 0x90, 0x59, 0x0D, 0x90,
  0x99, 0x09, 0x91, 0x8B, 0x10, 0xE0, 0x38, 0x36, 0x13, 0x09, 0x86, 0xC3,
  0x40, 0xE0, 0xE0, 0xD9, 0x64, 0xA3, 0xD0, 0xEC, 0x66, 0x79, 0xE6, 0xFF,
  0x40, 0x19, 0x98, 0xC4, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x21, 0x8C, 0x21,
  0x80, 0xC4, 0x66, 0x23, 0x33, 0x33, 0x33, 0x33, 0x66, 0x4C, 0x30, 0x63,
  0x57, 0xF3, 0x8D, 0x33, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08,
  0x10, 0x20, 0x7B, 0x68, 0xFF, 0x5F, 0x00, 0x03, 0x06, 0x06, 0x04, 0x0C,
  0x08, 0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0xC0, 0x38, 0xDB,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x6D, 0x8E, 0x00,
  0x19, 0xDF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x60, 0x79, 0x98,
  0x18, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x20, 0xC3, 0x04, 0x1F, 0xFF, 0x80,
  0x7D, 0x98, 0x18, 0x30, 0x61, 0x9E, 0x3C, 0x0C, 0x0C, 0x18, 0x30, 0x71,
  0xBE, 0x00, 0x06, 0x03, 0x03, 0x81, 0xC1, 0x60, 0xB0, 0xD8, 0x4C, 0x66,
  0x23, 0x3F, 0xFF, 0xF0, 0x60, 0x30, 0x18, 0x7D, 0xFB, 0x06, 0x0C, 0x18,
  0x3F, 0x46, 0x06, 0x0C, 0x18, 0x30, 0x71, 0xBE, 0x00, 0x3C, 0xE5, 0x82,
  0x0C, 0x18, 0x3F, 0x63, 0xC7, 0x8F, 0x1E, 0x3C, 0x6D, 0x8F, 0x00, 0xFF,
  0xFC, 0x18, 0x30, 0x41, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18,
  0x00, 0x7D, 0xDF, 0x1E, 0x3C, 0x6D, 0x9F, 0x1C, 0x6D, 0x8F, 0x1C, 0x1C,
  0x78, 0xDF, 0x00, 0x79, 0xDB, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x7E, 0x4C,
  0x18, 0x20, 0xD3, 0x3C, 0x00, 0xDC, 0x00, 0x00, 0x5F, 0x00, 0xDC, 0x00,
  0x00, 0x0F, 0x6D, 0x00, 0x02, 0x1C, 0xE3, 0x8C, 0x1C, 0x0E, 0x07, 0x02,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC0, 0xE0, 0xE0, 0x61, 0xCE,
  0x70, 0x80, 0xF9, 0x30, 0xC1, 0x0C, 0x31, 0x86, 0x30, 0x82, 0x00, 0x20,
  0xC3, 0x00, 0x0F, 0x83, 0x0C, 0x20, 0x66, 0x02, 0x47, 0x2C, 0x93, 0xD9,
  0x39, 0x93, 0x99, 0x39, 0x93, 0x9B, 0x2C, 0xFE, 0xC4, 0xC4, 0x00, 0x60,
  0x03, 0xB8, 0x0F, 0x00, 0x0C, 0x0E, 0x07, 0x02, 0xC1, 0x61, 0xB0, 0xC8,
  0x66, 0x23, 0x3F, 0x98, 0x4C, 0x34, 0x1E, 0x0F, 0x06, 0xF9, 0xFA, 0x1C,
  0x38, 0x70, 0xFF, 0x7E, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xBE, 0x00, 0x1F,
  0x32, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x32, 0x1E, 0xF8, 0xFC, 0x86, 0x86, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x86, 0x86, 0xFC, 0xF8, 0xFF, 0xF8, 0x20, 0x82, 0x0F, 0xBE, 0x82,
  0x08, 0x20, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x3E, 0xFA,
  0x08, 0x20, 0x82, 0x08, 0x00, 0x1F, 0x9C, 0xD8, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0xC7, 0xE0, 0x70, 0x2C, 0x16, 0x09, 0xCC, 0x7E, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0xFF, 0xFF, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0x87, 0x0A, 0x34, 0xC9, 0x96,
  0x2C, 0x78, 0xD1, 0x32, 0x64, 0x68, 0xD0, 0xE1, 0x80, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x7F, 0xE0, 0xC0, 0x7C, 0x07, 0xE0, 0xFE,
  0x0F, 0xA0, 0xBB, 0x1B, 0xB1, 0xB9, 0x13, 0x91, 0x39, 0xB3, 0x9B, 0x38,
  0xA3, 0x8E, 0x38, 0xE3, 0x84, 0x30, 0xC1, 0xC1, 0xE1, 0xE1, 0xB1, 0xB1,
  0x91, 0x99, 0x89, 0x8D, 0x8D, 0x87, 0x87, 0x83, 0x83, 0x3E, 0x1C, 0xC6,
  0x1B, 0x06, 0xC1, 0xB0, 0x2C, 0x0B, 0x03, 0xC0, 0xB0, 0x2C, 0x19, 0x06,
  0x61, 0x9D, 0xC3, 0xE0, 0xF9, 0xFA, 0x34, 0x38, 0x70, 0xE3, 0x4E, 0xF9,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x3E, 0x1C, 0xC6, 0x1B, 0x06, 0xC1,
  0xB0, 0x2C, 0x0B, 0x03, 0xC0, 0xB0, 0x2C, 0x19, 0x06, 0x61, 0x9D, 0xC3,
  0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0xF9, 0xFA, 0x34, 0x38, 0x70, 0xE3,
  0x7E, 0xF1, 0x32, 0x24, 0x68, 0xD0, 0xE1, 0x80, 0x7F, 0xDB, 0x06, 0x0C,
  0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x18, 0x30, 0x7B, 0xBE, 0x00, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x26, 0x33, 0xB8, 0xF8, 0xC1, 0xE0, 0xD0, 0x6C, 0x26, 0x33,
  0x18, 0x8C, 0x64, 0x36, 0x1B, 0x05, 0x82, 0x81, 0xC0, 0xE0, 0x70, 0xC1,
  0x87, 0x87, 0x0D, 0x0E, 0x1B, 0x14, 0x26, 0x28, 0xCC, 0x51, 0x99, 0xB3,
  0x13, 0x66, 0x36, 0x48, 0x68, 0xB0, 0xD1, 0x61, 0xE3, 0xC1, 0xC7, 0x03,
  0x86, 0x06, 0x0C, 0x00, 0x63, 0x63, 0x26, 0x36, 0x34, 0x1C, 0x1C, 0x18,
  0x1C, 0x3C, 0x36, 0x26, 0x62, 0x63, 0xC3, 0xC3, 0x43, 0x62, 0x66, 0x26,
  0x34, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF0,
  0xC6, 0x18, 0x43, 0x0C, 0x21, 0x86, 0x30, 0xC3, 0xFF, 0xC0, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x60, 0x60, 0x20, 0x30,
  0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x03, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x08, 0x0E, 0x07, 0x06, 0xC3,
  0x21, 0x19, 0x85, 0x83, 0xFF, 0x80, 0xC6, 0x30, 0x7D, 0x30, 0x41, 0x3F,
  0xDC, 0x61, 0xCF, 0x37, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE6,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0xE6, 0xDC, 0x7D, 0x8C, 0x30,
  0xC3, 0x0C, 0x30, 0xC1, 0x97, 0xC0, 0x02, 0x04, 0x08, 0x10, 0x2F, 0x71,
  0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xD9, 0xBD, 0x7C, 0x8B, 0x1E, 0x3F,
  0xFF, 0xF0, 0x60, 0xC0, 0xC4, 0xF8, 0x3C, 0xD2, 0x08, 0x23, 0xE2, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x7B, 0x8F, 0x1E, 0x1C, 0x38, 0x70,
  0xE1, 0xC6, 0xDD, 0xE8, 0x10, 0x20, 0xFF, 0xBC, 0xC1, 0x83, 0x06, 0x0C,
  0x1F, 0xF9, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x7C, 0x3F,
  0xFF, 0xFF, 0x2D, 0x80, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xFC, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0xF3, 0x64, 0xD9, 0xF3, 0xE6, 0x4C, 0xD9, 0xB1, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEE, 0x73, 0xC6, 0x3C, 0x63, 0xC6, 0x3C,
  0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30, 0xFF, 0xCF, 0x1E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x08, 0x7C, 0x8F, 0x1E, 0x1C, 0x38,
  0x70, 0xE1, 0xC6, 0xCC, 0xF0, 0xDE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE2, 0xE6, 0xDC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7A, 0x8F, 0x1E,
  0x1C, 0x38, 0x70, 0xE1, 0xC6, 0xDD, 0xE8, 0x10, 0x20, 0x40, 0x81, 0xDF,
  0x39, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0xFE, 0x61, 0x8E, 0x38, 0x61, 0x0C,
  0xFC, 0x21, 0x09, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC2, 0x9C, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x71, 0xE3, 0xC6, 0xDD, 0xE8, 0xC3, 0x42, 0x46, 0x66,
  0x64, 0x24, 0x2C, 0x3C, 0x38, 0x18, 0x18, 0xC6, 0x1A, 0x39, 0x91, 0x4C,
  0xCA, 0x66, 0xD2, 0x36, 0x90, 0xA7, 0x85, 0x3C, 0x38, 0xE1, 0xC6, 0x06,
  0x30, 0xE6, 0x66, 0x2C, 0x3C, 0x18, 0x18, 0x3C, 0x3C, 0x64, 0x66, 0xC3,
  0xC3, 0x42, 0x66, 0x66, 0x64, 0x24, 0x2C, 0x3C, 0x38, 0x18, 0x18, 0x18,
  0x10, 0x30, 0xF0, 0xE0, 0xF8, 0xCC, 0x62, 0x31, 0x98, 0xC4, 0x3E, 0x1C,
  0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0xE3, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0x83, 0x0C, 0x30, 0xC3,
  0x0C, 0x1C, 0x73, 0x0C, 0x30, 0xC3, 0x0C, 0x63, 0x80, 0x63, 0xFE, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 6, 5, 8, 1, -15 },
  { 11, 9, 15, 10, 0, -15 },
  { 28, 7, 17, 9, 1, -16 },
  { 43, 12, 15, 14, 1, -15 },
  { 66, 9, 15, 10, 1, -15 },
  { 83, 2, 5, 4, 1, -15 },
  { 85, 5, 18, 6, 1, -15 },
  { 97, 4, 18, 6, 1, -15 },
  { 106, 7, 7, 8, 1, -16 },
  { 113, 7, 10, 9, 1, -12 },
  { 122, 3, 5, 5, 1, -2 },
  { 124, 4, 2, 6, 1, -7 },
  { 125, 3, 3, 5, 1, -3 },
  { 127, 8, 15, 8, 0, -15 },
  { 142, 7, 15, 9, 1, -15 },
  { 156, 5, 15, 9, 1, -15 },
  { 166, 7, 15, 9, 1, -15 },
  { 180, 7, 15, 9, 1, -15 },
  { 194, 9, 15, 9, 0, -15 },
  { 211, 7, 15, 9, 1, -15 },
  { 225, 7, 15, 9, 1, -15 },
  { 239, 7, 15, 9, 1, -15 },
  { 253, 7, 15, 9, 1, -15 },
  { 267, 7, 15, 9, 1, -15 },
  { 281, 3, 11, 5, 1, -11 },
  { 286, 3, 14, 5, 1, -11 },
  { 292, 7, 9, 9, 1, -12 },
  { 300, 7, 6, 9, 1, -10 },
  { 306, 7, 9, 9, 1, -12 },
  { 314, 6, 15, 7, 0, -15 },
  { 326, 12, 17, 14, 1, -15 },
  { 352, 9, 15, 9, 0, -15 },
  { 369, 7, 15, 10, 2, -15 },
  { 383, 8, 15, 9, 1, -15 },
  { 398, 8, 15, 11, 2, -15 },
  { 413, 6, 15, 8, 2, -15 },
  { 425, 6, 15, 8, 2, -15 },
  { 437, 9, 15, 11, 1, -15 },
  { 454, 8, 15, 11, 2, -15 },
  { 469, 4, 15, 6, 1, -15 },
  { 477, 4, 19, 5, -1, -15 },
  { 487, 7, 15, 9, 2, -15 },
  { 501, 5, 15, 8, 2, -15 },
  { 511, 12, 15, 15, 2, -15 },
  { 534, 8, 15, 12, 2, -15 },
  { 549, 10, 15, 12, 1, -15 },
  { 568, 7, 15, 9, 2, -15 },
  { 582, 10, 19, 12, 1, -15 },
  { 606, 7, 15, 10, 2, -15 },
  { 620, 7, 15, 9, 1, -15 },
  { 634, 8, 15, 8, 0, -15 },
  { 649, 9, 15, 11, 1, -15 },
  { 666, 9, 15, 9, 0, -15 },
  { 683, 15, 15, 15, 0, -15 },
  { 712, 8, 15, 8, 0, -15 },
  { 727, 8, 15, 8, 0, -15 },
  { 742, 6, 15, 8, 1, -15 },
  { 754, 4, 18, 7, 2, -15 },
  { 763, 8, 15, 8, 0, -15 },
  { 778, 4, 18, 7, 1, -15 },
  { 787, 9, 8, 9, 0, -15 },
  { 796, 9, 1, 9, 0, 2 },
  { 798, 4, 3, 6, 1, -16 },
  { 800, 6, 11, 9, 1, -11 },
  { 809, 8, 16, 10, 1, -16 },
  { 825, 6, 11, 7, 1, -11 },
  { 834, 7, 16, 10, 1, -16 },
  { 848, 7, 11, 9, 1, -11 },
  { 858, 6, 16, 5, 0, -16 },
  { 870, 7, 16, 10, 1, -11 },
  { 884, 7, 16, 10, 1, -16 },
  { 898, 2, 16, 4, 1, -16 },
  { 902, 3, 21, 4, 0, -16 },
  { 910, 7, 16, 8, 1, -16 },
  { 924, 2, 16, 4, 1, -16 },
  { 928, 12, 11, 14, 1, -11 },
  { 945, 7, 11, 10, 1, -11 },
  { 955, 7, 11, 9, 1, -11 },
  { 965, 8, 16, 10, 1, -11 },
  { 981, 7, 16, 10, 1, -11 },
  { 995, 5, 11, 6, 1, -11 },
  { 1002, 5, 11, 7, 1, -11 },
  { 1009, 5, 14, 5, 0, -14 },
  { 1018, 7, 11, 10, 1, -11 },
  { 1028, 8, 11, 8, 0, -11 },
  { 1039, 13, 11, 13, 0, -11 },
  { 1057, 8, 11, 8, 0, -11 },
  { 1068, 8, 16, 8, 0, -11 },
  { 1084, 5, 11, 6, 1, -11 },
  { 1091, 6, 18, 8, 1, -15 },
  { 1105, 2, 21, 9, 3, -16 },
  { 1111, 6, 18, 8, 1, -15 },
  { 1125, 7, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Regular21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR21PT7B_H_
