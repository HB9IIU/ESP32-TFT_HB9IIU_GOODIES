#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x84, 0xFC, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x78, 0x00,
  0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0xF0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x1C, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38,
  0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0x9C, 0x1C, 0xF8, 0xE0, 0x07, 0x87, 0x00,
  0x3C, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x70, 0x03, 0xC3,
  0x80, 0x1F, 0x1C, 0x00, 0xF8, 0xE0, 0x03, 0xF7, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xEF, 0xE0, 0x07, 0x1F, 0x80, 0x38, 0x7C, 0x01, 0xC1, 0xE0,
  0x0E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE0,
  0xF8, 0x07, 0x0F, 0xF0, 0x38, 0xFB, 0xF9, 0xDF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x01, 0xE0,
  0x03, 0xCF, 0x80, 0x3C, 0x00, 0x38, 0x78, 0x03, 0xC0, 0x07, 0x83, 0x80,
  0x78, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x78,
  0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC7, 0x83, 0xE0, 0x78, 0x3C, 0x78, 0xFF,
  0x87, 0x83, 0xC7, 0x8F, 0xF8, 0x78, 0x38, 0xF1, 0xF7, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x3C, 0xF8, 0xF3, 0xC1, 0xE1, 0xFF, 0x1E, 0x3C, 0x1E, 0x1F,
  0xF1, 0xE3, 0xC1, 0xE0, 0xFC, 0x3C, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC1,
  0xE0, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x78,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x1E, 0x00,
  0x0F, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC1, 0xE0, 0x03, 0xC0,
  0x3C, 0x1E, 0x00, 0x3C, 0x01, 0xE3, 0xC0, 0x03, 0xC0, 0x1E, 0x7C, 0x00,
  0x78, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB,
  0xE0, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0x3E,
  0x7C, 0x0F, 0xCF, 0x8F, 0x80, 0xF9, 0xF1, 0xF0, 0x0F, 0xBE, 0x3E, 0x01,
  0xFF, 0x87, 0xC0, 0x1F, 0xF0, 0xF8, 0x03, 0xFE, 0x1F, 0x00, 0x3F, 0x83,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC1, 0xF8, 0x0F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC3, 0xFF, 0xFC, 0xF8, 0x3F, 0xFF, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xF0, 0x1F, 0x80, 0x60, 0x00, 0x00, 0xFD, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x60, 0xF0, 0x67, 0xCF, 0x3E, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0x9E, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x1E, 0x07, 0x80,
  0x60, 0x60, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF,
  0x88, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81,
  0xFC, 0xFC, 0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x7E, 0x1F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0x7E,
  0x7F, 0xF1, 0xF7, 0x87, 0xDC, 0x1F, 0x20, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xE0, 0xFE, 0x1C, 0x03, 0xF0, 0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xC0, 0xFE, 0x38, 0x01, 0xF0, 0x80, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x40, 0x03, 0xFB, 0xC0, 0x3F,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x05,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x01,
  0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE8, 0x00, 0xFC, 0xE0, 0x1F,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x58,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x41, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF,
  0x8F, 0x7F, 0xFC, 0xF7, 0x9F, 0xCF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE3, 0xE0, 0x7E,
  0x3F, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0x07, 0xE0, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xF0,
  0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0x03, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01,
  0xFC, 0xFE, 0x3F, 0xE7, 0xFF, 0xDF, 0x1F, 0xFE, 0xF8, 0x7F, 0xE7, 0x80,
  0xFC, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x80, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x30,
  0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C,
  0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0x83, 0xF3, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0xC7, 0x80, 0x08, 0x01, 0xE3, 0xC0, 0x3F, 0xF0,
  0xF1, 0xE0, 0x3F, 0xF8, 0x79, 0xE0, 0x3F, 0xFC, 0x1E, 0xF0, 0x3E, 0x3E,
  0x0F, 0x78, 0x3E, 0x1F, 0x07, 0xBC, 0x1E, 0x0F, 0x83, 0xFC, 0x0F, 0x07,
  0xC1, 0xFE, 0x07, 0x83, 0xE0, 0xFF, 0x07, 0x81, 0xE0, 0x7F, 0x83, 0xC0,
  0xF0, 0x3F, 0xC1, 0xE0, 0x78, 0x1F, 0xE0, 0xF0, 0x3C, 0x0F, 0xF0, 0x78,
  0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0x03, 0xFC, 0x1E, 0x07, 0x81, 0xFE, 0x0F,
  0x03, 0xC0, 0xFF, 0x07, 0x81, 0xE0, 0x7F, 0x83, 0xC1, 0xF0, 0x3B, 0xC0,
  0xF0, 0xF8, 0x3D, 0xE0, 0x78, 0x6E, 0x1E, 0xF8, 0x3F, 0xF7, 0xBE, 0x3C,
  0x0F, 0xFB, 0xFF, 0x1E, 0x07, 0xF8, 0xFF, 0x0F, 0x00, 0xF8, 0x3F, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xF8, 0x3F, 0xF3, 0xE0, 0x0F, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x83, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF,
  0x80, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xC1, 0xE0, 0xFC, 0x00, 0x87, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x43, 0xFC, 0x06, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0,
  0xF8, 0x03, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x07, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0x83,
  0xF8, 0x00, 0xE1, 0xFC, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D,
  0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xF0, 0x00,
  0x3C, 0x7E, 0x00, 0x0F, 0x1F, 0x80, 0x03, 0xC3, 0xF8, 0x00, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xF8, 0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x18, 0x00,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF,
  0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83,
  0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xBE, 0x00, 0xFE, 0x7C, 0x01,
  0xFC, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00,
  0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFD, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x78, 0x00, 0x0F, 0x7F, 0xEF, 0x00, 0x01, 0xEF,
  0xFD, 0xF0, 0x00, 0x7D, 0xFF, 0x9E, 0x00, 0x0F, 0x3F, 0xF3, 0xC0, 0x01,
  0xE7, 0xFE, 0x7C, 0x00, 0x3C, 0xFF, 0xCF, 0x80, 0x0F, 0x9F, 0xF8, 0xF0,
  0x01, 0xE3, 0xFF, 0x1E, 0x00, 0x3C, 0x7F, 0xE3, 0xE0, 0x0F, 0x8F, 0xFC,
  0x3C, 0x01, 0xE1, 0xFF, 0x87, 0x80, 0x3C, 0x3F, 0xF0, 0xF8, 0x07, 0x87,
  0xFE, 0x1F, 0x01, 0xF0, 0xFF, 0xC1, 0xE0, 0x3C, 0x1F, 0xF8, 0x3C, 0x07,
  0x83, 0xFF, 0x07, 0xC1, 0xF0, 0x7F, 0xE0, 0x78, 0x3C, 0x0F, 0xFC, 0x0F,
  0x07, 0x81, 0xFF, 0x81, 0xF0, 0xF0, 0x3F, 0xF0, 0x3E, 0x3E, 0x07, 0xFE,
  0x03, 0xC7, 0x80, 0xFF, 0xC0, 0x78, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03,
  0xFF, 0x00, 0xF7, 0x80, 0x7F, 0xE0, 0x1E, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFE, 0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x7F, 0xE7, 0x80, 0x1F,
  0xF9, 0xF0, 0x07, 0xFE, 0x7C, 0x01, 0xFF, 0x8F, 0x80, 0x7F, 0xE3, 0xE0,
  0x1F, 0xF8, 0x78, 0x07, 0xFE, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE0,
  0xF8, 0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F,
  0xE0, 0x3C, 0x1F, 0xF8, 0x0F, 0x87, 0xFE, 0x03, 0xE1, 0xFF, 0x80, 0x7C,
  0x7F, 0xE0, 0x1F, 0x1F, 0xF8, 0x03, 0xE7, 0xFE, 0x00, 0xF9, 0xFF, 0x80,
  0x3E, 0x7F, 0xE0, 0x07, 0xDF, 0xF8, 0x01, 0xF7, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x7E, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7C,
  0x07, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x07, 0xEF, 0x80, 0x7E, 0x7C, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x01, 0xFC, 0x3E, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFC,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F,
  0x81, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFD,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE3, 0xF0, 0xFC, 0x01,
  0x8F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFB, 0x00, 0x1F,
  0x9F, 0x83, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F,
  0xE0, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x8F, 0x80, 0x0F,
  0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3B, 0xC0,
  0x0F, 0x87, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xEF, 0x00, 0x3E,
  0x0F, 0x80, 0x3D, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xBC, 0x01, 0xF0, 0x3E,
  0x00, 0xF7, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x78, 0x07, 0xC0, 0xF8, 0x07,
  0x8F, 0x00, 0xF8, 0x0F, 0x80, 0xF1, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x3C,
  0x07, 0xC0, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x78, 0x1F,
  0x00, 0xF8, 0x1E, 0x0F, 0x03, 0xE0, 0x0F, 0x83, 0xC1, 0xE0, 0x7C, 0x01,
  0xF0, 0x78, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x78, 0x7C, 0x00, 0xF8, 0x78, 0x0F, 0x0F, 0x80, 0x0F, 0x8F, 0x01,
  0xE1, 0xF0, 0x01, 0xF1, 0xE0, 0x3C, 0x7C, 0x00, 0x3E, 0x3C, 0x07, 0xCF,
  0x80, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x00,
  0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x00, 0x3E,
  0xF0, 0x07, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xF7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x78, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0x80,
  0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xF1, 0xFC, 0x10, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF8, 0x7D, 0xF8, 0x0F,
  0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0xFE,
  0xFE, 0x7B, 0xCF, 0xFE, 0x79, 0xFF, 0xCF, 0x1F, 0xE1, 0xE0, 0x20, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x1E,
  0x03, 0xE3, 0xFC, 0x1F, 0x3F, 0xF0, 0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xC1, 0xF9, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFE, 0x03, 0xF7,
  0xF8, 0x3F, 0x3D, 0xFF, 0xF9, 0xE7, 0xFF, 0x8F, 0x1F, 0xF8, 0x78, 0x7F,
  0x80, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF1, 0xF8, 0x11, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x11, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x7C, 0x3F, 0xE3, 0xE3, 0xFF, 0x9F, 0x1F,
  0xFE, 0xF9, 0xFF, 0xFF, 0xDF, 0x81, 0xFE, 0xF8, 0x07, 0xF7, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7E, 0x03, 0xFB, 0xF0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFC,
  0xF0, 0xFF, 0xC7, 0x83, 0xFC, 0x3C, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xE0, 0x7C,
  0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x02, 0x3F, 0x00, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x00, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xE4, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC3, 0xC7,
  0xFF, 0x1E, 0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0xBF, 0x03, 0xFD, 0xF0, 0x0F,
  0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0x9F, 0xFF,
  0x7C, 0x7F, 0xFB, 0xE1, 0xFF, 0x9F, 0x07, 0xF8, 0xF8, 0x04, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF2, 0x00, 0x1F, 0x1E, 0x03, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0xF9, 0xFF, 0x0F,
  0xBF, 0xF8, 0xFB, 0xFF, 0xCF, 0x7F, 0xFC, 0xFF, 0x07, 0xEF, 0xE0, 0x3E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xEF, 0xFB, 0xFC, 0xFF, 0x3F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0,
  0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xE7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x01, 0xF0, 0x78, 0xFF, 0x83, 0xFE, 0x3C, 0xFF, 0xE3, 0xFF, 0x9E, 0xFF,
  0xF3, 0xFF, 0xEF, 0x7F, 0xFD, 0xFF, 0xF7, 0xF0, 0x3F, 0xC0, 0xFB, 0xF0,
  0x1F, 0xC0, 0x7F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFC,
  0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F,
  0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00,
  0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0,
  0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x1F, 0xF0, 0xF3, 0xFF, 0x8F, 0x3F,
  0xFC, 0xF7, 0xFF, 0xCF, 0xF0, 0x7E, 0xFE, 0x03, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFD, 0xFC, 0x1F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0xFC,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xFC, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x87,
  0xF8, 0x3C, 0x7F, 0xE1, 0xE7, 0xFF, 0x8F, 0x7C, 0xFE, 0x7F, 0x81, 0xF3,
  0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xFC, 0x07, 0xEF, 0xF0, 0x7E,
  0x7F, 0xFF, 0xF3, 0xEF, 0xFF, 0x1F, 0x3F, 0xF0, 0xF8, 0xFF, 0x07, 0xC0,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xC3, 0xC7, 0xFF, 0x1E, 0x3F, 0xFD, 0xF3, 0xFF,
  0xFF, 0xBF, 0x03, 0xFD, 0xF0, 0x0F, 0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC,
  0x07, 0xF7, 0xE0, 0x7F, 0x9F, 0xFF, 0x7C, 0x7F, 0xFB, 0xE1, 0xFF, 0x9F,
  0x07, 0xF8, 0xF8, 0x04, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7B, 0xC3, 0xFF, 0x1F, 0xBC, 0xFE, 0xF7,
  0xFB, 0xDE, 0x2F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0x1E,
  0xFC, 0x06, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x30, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xBF, 0x0F, 0xF7, 0xFF, 0xDE, 0x7F, 0xFB, 0xCF, 0xFE, 0x78, 0x7F, 0x8F,
  0x01, 0x80, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0x7B, 0xE0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xFC, 0x03,
  0xE7, 0x80, 0x7F, 0x80, 0x7C, 0xF8, 0x0F, 0xF0, 0x0F, 0x9F, 0x01, 0xFE,
  0x01, 0xE3, 0xE0, 0x3D, 0xC0, 0x7C, 0x7C, 0x07, 0xBC, 0x0F, 0x87, 0x81,
  0xF7, 0x81, 0xF0, 0xF8, 0x3C, 0xF0, 0x3C, 0x1F, 0x07, 0x9E, 0x07, 0x83,
  0xE0, 0xF3, 0xC1, 0xF0, 0x7C, 0x1E, 0x3C, 0x3E, 0x07, 0x87, 0xC7, 0x87,
  0xC0, 0xF8, 0xF0, 0xF0, 0xF0, 0x1F, 0x1E, 0x1E, 0x1E, 0x03, 0xE3, 0xC3,
  0xC7, 0xC0, 0x3C, 0x78, 0x7C, 0xF8, 0x07, 0x9F, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0xF3, 0xC0, 0x1F, 0x78, 0x1E, 0x78, 0x03, 0xEF, 0x03, 0xDF, 0x00,
  0x3D, 0xE0, 0x7B, 0xE0, 0x07, 0xBC, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x1E, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x07,
  0x87, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x03, 0xCF,
  0x80, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0x80, 0x1F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00,
  0xFF, 0x20, 0x00, 0x20,
};

const GFXglyph NotoSans_ExtraCondensed_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 44, 14, 4, -43 },
  { 34, 16, 16, 23, 3, -43 },
  { 66, 26, 43, 28, 1, -43 },
  { 206, 21, 49, 26, 2, -46 },
  { 335, 36, 44, 40, 2, -43 },
  { 533, 27, 44, 29, 2, -43 },
  { 682, 6, 16, 12, 3, -43 },
  { 694, 13, 52, 17, 3, -43 },
  { 779, 13, 52, 17, 2, -43 },
  { 864, 20, 20, 24, 2, -46 },
  { 914, 22, 28, 26, 2, -35 },
  { 991, 8, 15, 14, 2, -7 },
  { 1006, 13, 5, 16, 2, -19 },
  { 1015, 6, 8, 14, 4, -7 },
  { 1021, 20, 43, 22, 1, -43 },
  { 1129, 21, 44, 26, 2, -43 },
  { 1245, 14, 43, 26, 4, -43 },
  { 1321, 21, 43, 26, 2, -43 },
  { 1434, 21, 44, 26, 2, -43 },
  { 1550, 24, 43, 26, 1, -43 },
  { 1679, 20, 44, 26, 3, -43 },
  { 1789, 20, 44, 26, 3, -43 },
  { 1899, 22, 43, 26, 2, -43 },
  { 2018, 22, 44, 26, 2, -43 },
  { 2139, 21, 44, 26, 2, -43 },
  { 2255, 6, 33, 14, 4, -32 },
  { 2280, 8, 40, 14, 2, -32 },
  { 2320, 22, 27, 26, 2, -35 },
  { 2395, 22, 17, 26, 2, -30 },
  { 2442, 22, 27, 26, 2, -35 },
  { 2517, 17, 44, 19, 1, -43 },
  { 2611, 33, 48, 39, 3, -43 },
  { 2809, 27, 43, 27, 0, -43 },
  { 2955, 22, 43, 29, 4, -43 },
  { 3074, 22, 45, 27, 3, -44 },
  { 3198, 24, 43, 31, 4, -43 },
  { 3327, 17, 43, 24, 4, -43 },
  { 3419, 17, 43, 23, 4, -43 },
  { 3511, 26, 44, 33, 3, -43 },
  { 3654, 24, 43, 32, 4, -43 },
  { 3783, 13, 43, 17, 2, -43 },
  { 3853, 12, 55, 13, -3, -43 },
  { 3936, 23, 43, 27, 4, -43 },
  { 4060, 17, 43, 22, 4, -43 },
  { 4152, 35, 43, 43, 4, -43 },
  { 4341, 26, 43, 34, 4, -43 },
  { 4481, 27, 44, 33, 3, -43 },
  { 4630, 21, 43, 27, 4, -43 },
  { 4743, 27, 53, 33, 3, -43 },
  { 4922, 23, 43, 28, 4, -43 },
  { 5046, 21, 45, 25, 2, -44 },
  { 5165, 21, 43, 23, 1, -43 },
  { 5278, 23, 44, 31, 4, -43 },
  { 5405, 26, 43, 26, 0, -43 },
  { 5545, 43, 43, 43, 0, -43 },
  { 5777, 24, 43, 24, 0, -43 },
  { 5906, 24, 43, 24, 0, -43 },
  { 6035, 18, 43, 22, 2, -43 },
  { 6132, 13, 53, 19, 4, -43 },
  { 6219, 20, 43, 22, 1, -43 },
  { 6327, 12, 53, 19, 2, -43 },
  { 6407, 25, 23, 27, 1, -43 },
  { 6479, 26, 4, 26, 0, 5 },
  { 6492, 12, 10, 16, 2, -46 },
  { 6507, 19, 34, 25, 2, -33 },
  { 6588, 21, 47, 28, 4, -46 },
  { 6712, 17, 34, 21, 3, -33 },
  { 6785, 21, 47, 28, 3, -46 },
  { 6909, 20, 34, 25, 3, -33 },
  { 6994, 16, 46, 15, 1, -46 },
  { 7086, 21, 47, 28, 3, -33 },
  { 7210, 20, 46, 27, 4, -46 },
  { 7325, 5, 44, 13, 4, -44 },
  { 7353, 10, 58, 13, -1, -44 },
  { 7426, 20, 46, 24, 4, -46 },
  { 7541, 5, 46, 13, 4, -46 },
  { 7570, 33, 33, 41, 4, -33 },
  { 7707, 20, 33, 27, 4, -33 },
  { 7790, 21, 34, 27, 3, -33 },
  { 7880, 21, 47, 28, 4, -33 },
  { 8004, 21, 47, 28, 3, -33 },
  { 8128, 14, 33, 18, 4, -33 },
  { 8186, 16, 34, 20, 2, -33 },
  { 8254, 14, 40, 16, 1, -39 },
  { 8324, 19, 33, 27, 4, -32 },
  { 8403, 22, 32, 22, 0, -32 },
  { 8491, 35, 32, 36, 1, -32 },
  { 8631, 21, 32, 22, 1, -32 },
  { 8715, 22, 46, 22, 0, -32 },
  { 8842, 16, 32, 18, 1, -32 },
  { 8906, 17, 53, 22, 2, -43 },
  { 9019, 4, 60, 24, 10, -46 },
  { 9049, 17, 53, 22, 2, -43 },
  { 9162, 22, 8, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Regular60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR60PT7B_H_
