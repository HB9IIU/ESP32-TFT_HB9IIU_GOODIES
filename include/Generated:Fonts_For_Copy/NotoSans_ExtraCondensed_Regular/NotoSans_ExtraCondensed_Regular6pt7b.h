#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x5F, 0xE0, 0x79, 0xC0, 0xED, 0x37, 0xCB, 0xF0, 0x80,
  0xEA, 0x40, 0xF8, 0x70, 0x74, 0xC0, 0x80, 0x80, 0x5A, 0xFF, 0xD5, 0xD7,
  0xD7, 0x7D, 0xF7, 0xFF, 0xD6, 0xDF, 0xF7, 0xA0, 0xB0, 0xD0, 0xF0, 0xF0,
  0xDA, 0xFF, 0xF8, 0x60, 0x5B, 0x50, 0xFA, 0xF0, 0xF2, 0x20, 0xF6, 0xE0,
  0xFB, 0xFA, 0xF2, 0xB0, 0xBE, 0xD0, 0xF0, 0xF8, 0xFB, 0x50, 0xAB, 0x9D,
  0xFB, 0xBF, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6, 0xF2, 0xF7, 0x50, 0xE7, 0xD5,
  0xB6, 0xF0, 0xB9, 0x20, 0xBB, 0x55, 0xD7, 0xD5, 0xDB, 0xEA, 0xC0, 0xA5,
  0xF8, 0x54, 0xE0, 0x80, 0xFC, 0x9A, 0xDE, 0xEC, 0x5F, 0xC0, 0xEC, 0x6A,
  0x80, 0xFF, 0xAF, 0xC0, 0xF0, 0xF8, 0xAF, 0xC0, 0xF8, 0xFB, 0xB0, 0xFC,
  0xFC, 0xF7, 0xC0, 0xFD, 0xE8, 0xDC, 0xF0, 0xFC, 0xF4, 0xDE, 0x60, 0xDC,
  0xF6, 0xEC, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 2, 2, 0, -5 },
  { 16, 2, 3, 3, 0, -4 },
  { 17, 1, 2, 1, 0, -1 },
  { 18, 1, 1, 2, 0, -2 },
  { 19, 1, 1, 1, 0, -1 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 2, 4, 3, 0, -4 },
  { 22, 2, 4, 3, 0, -4 },
  { 23, 2, 4, 3, 0, -4 },
  { 24, 2, 4, 3, 0, -4 },
  { 25, 2, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 2, 4, 3, 0, -4 },
  { 30, 2, 4, 3, 0, -4 },
  { 31, 1, 3, 1, 0, -3 },
  { 32, 1, 4, 1, 0, -3 },
  { 33, 2, 2, 3, 0, -3 },
  { 34, 2, 2, 3, 0, -3 },
  { 35, 2, 2, 3, 0, -3 },
  { 36, 2, 4, 2, 0, -4 },
  { 37, 4, 5, 4, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 3, 4, 3, 0, -4 },
  { 48, 2, 4, 2, 0, -4 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 3, 4, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 1, 4, 2, 0, -4 },
  { 55, 1, 5, 1, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 2, 4, 2, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 2, 4, 3, 0, -4 },
  { 66, 3, 5, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 2, 4, 2, 0, -4 },
  { 79, 2, 4, 2, 0, -4 },
  { 80, 2, 4, 2, 0, -4 },
  { 81, 2, 5, 2, 0, -4 },
  { 83, 2, 4, 2, 0, -4 },
  { 84, 1, 5, 2, 0, -4 },
  { 85, 3, 2, 3, 0, -4 },
  { 86, 3, 1, 3, 0, 0 },
  { 87, 1, 1, 2, 0, -5 },
  { 88, 2, 3, 3, 0, -3 },
  { 89, 3, 5, 3, 0, -5 },
  { 91, 2, 3, 2, 0, -3 },
  { 92, 2, 5, 3, 0, -5 },
  { 94, 2, 3, 3, 0, -3 },
  { 95, 2, 5, 2, 0, -5 },
  { 97, 2, 4, 3, 0, -3 },
  { 98, 2, 5, 3, 0, -5 },
  { 100, 1, 4, 1, 0, -4 },
  { 101, 1, 5, 1, 0, -4 },
  { 102, 2, 5, 2, 0, -5 },
  { 104, 1, 5, 1, 0, -5 },
  { 105, 4, 3, 4, 0, -3 },
  { 107, 2, 3, 3, 0, -3 },
  { 108, 2, 3, 3, 0, -3 },
  { 109, 3, 4, 3, 0, -3 },
  { 111, 2, 4, 3, 0, -3 },
  { 112, 2, 3, 2, 0, -3 },
  { 113, 2, 3, 2, 0, -3 },
  { 114, 1, 4, 2, 0, -4 },
  { 115, 2, 3, 3, 0, -3 },
  { 116, 2, 3, 2, 0, -3 },
  { 117, 4, 3, 4, 0, -3 },
  { 119, 2, 3, 2, 0, -3 },
  { 120, 2, 4, 2, 0, -3 },
  { 121, 2, 3, 2, 0, -3 },
  { 122, 2, 5, 2, 0, -4 },
  { 124, 1, 6, 2, 1, -5 },
  { 125, 2, 5, 2, 0, -4 },
  { 127, 2, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Regular6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR6PT7B_H_
