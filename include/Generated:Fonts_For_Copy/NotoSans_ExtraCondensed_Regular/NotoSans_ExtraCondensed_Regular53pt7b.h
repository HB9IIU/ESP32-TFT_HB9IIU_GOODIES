#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x79, 0xFF, 0xFF, 0x7D, 0xE0, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0xF7,
  0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80,
  0x1C, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x3C,
  0x1C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x38, 0x3C,
  0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xC1, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C,
  0xE3, 0x8F, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1,
  0xC0, 0x3C, 0x38, 0x07, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0xDC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0xE7, 0xC0, 0x1C, 0x78, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x0E,
  0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x74, 0x07, 0x1E, 0xE0, 0xE7, 0xDF, 0xDF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x80, 0x0F, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0xFF, 0x80, 0x38, 0x03, 0xCF,
  0x00, 0xF0, 0x07, 0x0F, 0x01, 0xC0, 0x0E, 0x1E, 0x03, 0x80, 0x3C, 0x1C,
  0x0F, 0x00, 0x78, 0x38, 0x1C, 0x00, 0xF0, 0x70, 0x78, 0x01, 0xE0, 0xE0,
  0xF0, 0x03, 0xC1, 0xC1, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x0F, 0x07, 0x0F,
  0x00, 0x1E, 0x0E, 0x1C, 0x00, 0x3C, 0x1C, 0x78, 0x00, 0x78, 0x38, 0xF1,
  0xF8, 0x70, 0x71, 0xC7, 0xF8, 0xE1, 0xE7, 0x9F, 0xF1, 0xC3, 0xCF, 0x3C,
  0xF3, 0xC7, 0x1C, 0x70, 0xE3, 0xFE, 0x79, 0xE1, 0xC7, 0xF8, 0xE3, 0xC3,
  0xC7, 0xE1, 0xC7, 0x87, 0x80, 0x07, 0x8E, 0x0F, 0x00, 0x0E, 0x1C, 0x1E,
  0x00, 0x1C, 0x38, 0x3C, 0x00, 0x78, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0xF0,
  0x03, 0xC1, 0xC1, 0xE0, 0x07, 0x83, 0x83, 0xC0, 0x0E, 0x07, 0x07, 0x80,
  0x3C, 0x0F, 0x0F, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0xE0, 0x1C, 0x38, 0x03,
  0xC0, 0x3C, 0xF0, 0x07, 0x80, 0x7F, 0xC0, 0x0E, 0x00, 0x7F, 0x80, 0x3C,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xF9, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E,
  0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xEF, 0x07, 0xCF, 0x9F, 0x0F, 0x9F, 0x1E, 0x1F, 0x7C, 0x3E, 0x3C,
  0xF0, 0x3E, 0x79, 0xE0, 0x3C, 0xF3, 0xC0, 0x7F, 0xE7, 0x80, 0x7F, 0x8F,
  0x00, 0xFF, 0x1E, 0x00, 0xFC, 0x3C, 0x00, 0xF8, 0x78, 0x03, 0xF0, 0xF8,
  0x0F, 0xF1, 0xF8, 0x3F, 0xE1, 0xFD, 0xFF, 0xE3, 0xFF, 0xF3, 0xE3, 0xFF,
  0xC7, 0xC3, 0xFE, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0x7B, 0x9C, 0xE7, 0x38, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03,
  0x8E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xFC,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF8, 0xF8, 0x78, 0x3C, 0x0C,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF3, 0xC7,
  0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07,
  0xCF, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07,
  0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C,
  0xF0, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF,
  0xDF, 0xFC, 0xFB, 0xC7, 0xCC, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x78,
  0x1F, 0x88, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF,
  0xFC, 0x70, 0x1F, 0x98, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xB0, 0x07, 0xEF, 0x87, 0xF3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78,
  0x07, 0x87, 0x80, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x1F,
  0xBC, 0x7F, 0x9F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3E, 0x03, 0xCF,
  0xF0, 0x7B, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0x3E, 0x7E, 0x03, 0xEF, 0xC0,
  0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00,
  0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x07, 0x9F, 0x00,
  0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0x7E, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF,
  0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x1F,
  0x0F, 0x87, 0xC0, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xCF, 0x80, 0xF9,
  0xFC, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x18, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x1F,
  0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x3F, 0xFB, 0xCF,
  0xFE, 0xF1, 0xFF, 0x3C, 0x1F, 0x8F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x83, 0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x00, 0xC0, 0x00, 0x31, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0x18, 0x79, 0xFB, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E,
  0x7C, 0xF1, 0xE3, 0xCF, 0x9E, 0x3C, 0x79, 0xE3, 0xC7, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE6,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x8E, 0x01, 0xF0, 0x3C, 0xF0, 0x3F, 0xF0, 0xE7,
  0x83, 0xFF, 0x87, 0x38, 0x3E, 0x3C, 0x3F, 0xC1, 0xE1, 0xE1, 0xFE, 0x0E,
  0x0E, 0x0F, 0xF0, 0xF0, 0x70, 0x7F, 0x07, 0x83, 0x81, 0xF8, 0x38, 0x1C,
  0x0F, 0xC1, 0xC0, 0xE0, 0x7E, 0x0E, 0x0F, 0x03, 0xF0, 0x70, 0x78, 0x3F,
  0x83, 0x83, 0xC1, 0xFC, 0x1C, 0x1E, 0x0F, 0xE0, 0xE0, 0xF0, 0x7F, 0x07,
  0x07, 0x83, 0xB8, 0x3C, 0x3C, 0x1D, 0xC1, 0xE3, 0xE1, 0xEF, 0x07, 0x9B,
  0x9E, 0x78, 0x3F, 0xCF, 0xF3, 0xC0, 0xFC, 0x7F, 0x0E, 0x03, 0xC1, 0xF0,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x3F, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7,
  0x80, 0x03, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3,
  0xC0, 0x07, 0x83, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x81,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0xF8, 0x1E, 0x00,
  0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x1F, 0xBC, 0x01, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x7C, 0xFF, 0xFF, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0x01, 0xF9, 0xE0, 0x0F, 0xBC,
  0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xDE, 0x01, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xF8, 0x0C, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x08, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x02, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0x03, 0xF8,
  0x78, 0x07, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80,
  0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0xF8, 0xF0,
  0x0F, 0xC7, 0x81, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFC, 0x03, 0xC3, 0xF0, 0x01, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0xC0, 0x01, 0xEF, 0x80, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x1F,
  0x00, 0x1E, 0x3F, 0x80, 0x3C, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x83,
  0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xF0, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0,
  0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80,
  0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0,
  0x0F, 0x7C, 0x00, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF,
  0x00, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E,
  0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF7,
  0x80, 0x03, 0xBF, 0xDE, 0x00, 0x1E, 0xFF, 0x78, 0x00, 0x7B, 0xFD, 0xE0,
  0x01, 0xEF, 0xF3, 0xC0, 0x0F, 0x3F, 0xCF, 0x00, 0x3C, 0xFF, 0x3C, 0x00,
  0xF3, 0xFC, 0x78, 0x03, 0x8F, 0xF1, 0xE0, 0x1E, 0x3F, 0xC7, 0x80, 0x78,
  0xFF, 0x1E, 0x01, 0xE3, 0xFC, 0x3C, 0x0F, 0x0F, 0xF0, 0xF0, 0x3C, 0x3F,
  0xC3, 0xC0, 0xF0, 0xFF, 0x07, 0x83, 0x83, 0xFC, 0x1E, 0x1E, 0x0F, 0xF0,
  0x78, 0x78, 0x3F, 0xC1, 0xE1, 0xE0, 0xFF, 0x03, 0xCF, 0x03, 0xFC, 0x0F,
  0x3C, 0x0F, 0xF0, 0x3C, 0xF0, 0x3F, 0xC0, 0x7B, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00,
  0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xF0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xF7, 0x80, 0x3F, 0xDE, 0x00, 0xFF, 0x7C, 0x03, 0xFC, 0xF0,
  0x0F, 0xF3, 0xE0, 0x3F, 0xC7, 0x80, 0xFF, 0x1E, 0x03, 0xFC, 0x7C, 0x0F,
  0xF0, 0xF0, 0x3F, 0xC3, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1F, 0x0F, 0xF0,
  0x3C, 0x3F, 0xC0, 0xF0, 0xFF, 0x03, 0xE3, 0xFC, 0x07, 0x8F, 0xF0, 0x1F,
  0x3F, 0xC0, 0x3C, 0xFF, 0x00, 0xF3, 0xFC, 0x01, 0xEF, 0xF0, 0x07, 0xBF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x3F, 0x3C, 0x07, 0xEF,
  0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x0F,
  0xBC, 0x03, 0xEF, 0x03, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x7F, 0x0F, 0x01, 0xF8,
  0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00,
  0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x0F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07,
  0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x03, 0xFE, 0x03, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0x03, 0x9F, 0x00, 0x27, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x80, 0x0F, 0xB8, 0x07,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1E, 0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xCF,
  0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C,
  0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1F, 0x03,
  0xC0, 0x3E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xC0,
  0x07, 0x9E, 0x00, 0x3F, 0x00, 0x1E, 0x7C, 0x00, 0xFC, 0x00, 0x79, 0xF0,
  0x03, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0xC0, 0x0F, 0x8F, 0x00, 0x3F, 0x80,
  0x3C, 0x3C, 0x01, 0xFE, 0x00, 0xF0, 0xF8, 0x07, 0xF8, 0x03, 0xC3, 0xE0,
  0x1E, 0xE0, 0x1F, 0x07, 0x80, 0x73, 0x80, 0x7C, 0x1E, 0x01, 0xCF, 0x01,
  0xE0, 0x78, 0x0F, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0xF0, 0x1E, 0x07, 0xC0,
  0xF3, 0xC0, 0xF8, 0x0F, 0x03, 0xC7, 0x03, 0xE0, 0x3C, 0x1E, 0x1E, 0x0F,
  0x00, 0xF0, 0x78, 0x78, 0x3C, 0x03, 0xE1, 0xE1, 0xE0, 0xF0, 0x0F, 0x87,
  0x87, 0x87, 0xC0, 0x1E, 0x1E, 0x0E, 0x1F, 0x00, 0x78, 0xF0, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x1F, 0x3C,
  0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x1C, 0xF8, 0x00, 0xF3, 0x80, 0x7B, 0xC0,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x07, 0xBC, 0x00, 0x1D, 0xE0,
  0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0,
  0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00, 0x7C,
  0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xC0,
  0x78, 0x1E, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x00,
  0xF8, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xFB, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0,
  0x00, 0xF3, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x0F, 0x00,
  0x78, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0xBC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0x81, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x1F, 0x7C, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xBE, 0x1B, 0xDF, 0xFD, 0xE7, 0xFC, 0xF1,
  0xFC, 0x78, 0x10, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3E, 0x0F, 0x9F, 0xE1, 0xF7,
  0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0x7E, 0xFE, 0x07, 0xDF, 0x80, 0x7B, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x7B, 0xF0, 0x0F, 0x7F, 0x03, 0xEF, 0xF0, 0xF9, 0xE7, 0xFF, 0x3C, 0xFF,
  0xC7, 0x87, 0xF0, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8,
  0xFF, 0xE3, 0xF0, 0x47, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x02, 0x7F, 0x1C, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F,
  0xC0, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0xF0, 0xFF, 0x9E, 0x3F, 0xFB,
  0xC7, 0xFF, 0x79, 0xF0, 0x7F, 0x3C, 0x07, 0xEF, 0x80, 0x7D, 0xE0, 0x0F,
  0xBC, 0x01, 0xF7, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x1F, 0x9F, 0x03, 0xF3, 0xF1, 0xFE, 0x3F, 0xFB, 0xC3, 0xFE, 0x78,
  0x3F, 0x87, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3E, 0x0F, 0x0F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x87, 0xE1, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7C, 0x41, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x3C, 0x7F,
  0xF7, 0x8F, 0xFE, 0xF3, 0xE0, 0xFE, 0x78, 0x0F, 0xDF, 0x00, 0xFB, 0xC0,
  0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x3F, 0x3E, 0x07, 0xE7, 0xE3, 0xFC, 0x7F, 0xF7, 0x87, 0xFC,
  0xF0, 0x7F, 0x1E, 0x03, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE2, 0x00, 0x7C, 0x70, 0x3F,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE3,
  0xF0, 0xF9, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF, 0xFB, 0xFC, 0x3E, 0xFE, 0x07,
  0xBF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3D, 0x3E, 0xFF,
  0x7F, 0x3F, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xBE, 0x03, 0xCF,
  0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3,
  0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xEF, 0x03, 0xF3, 0xE0, 0xFC, 0x78, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE0, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0x8F, 0x81, 0xF3, 0xE0,
  0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x0F, 0xC3, 0xC7, 0xF8, 0x7F, 0x8F, 0x3F, 0xF3, 0xFF, 0x3D, 0xFF,
  0xDF, 0xFE, 0xFE, 0x1F, 0x70, 0xFB, 0xF0, 0x3F, 0x81, 0xEF, 0xC0, 0x7C,
  0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1E, 0x01,
  0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x3F,
  0xE0, 0x1E, 0x00, 0xFF, 0x80, 0x78, 0x03, 0xFE, 0x01, 0xE0, 0x0F, 0xF8,
  0x07, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0xFF, 0x80, 0x78, 0x03, 0xFE, 0x01,
  0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0xFF, 0x80, 0x78,
  0x03, 0xFE, 0x01, 0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x3F, 0xE0, 0x1E, 0x00,
  0xFF, 0x80, 0x78, 0x03, 0xFE, 0x01, 0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x3C,
  0x00, 0xFC, 0x3C, 0x7F, 0x8F, 0x3F, 0xF3, 0xDF, 0xFE, 0xFE, 0x0F, 0xBF,
  0x01, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x9F, 0x00, 0xF3, 0xC0,
  0x1F, 0x78, 0x03, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDF, 0x00,
  0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x1E, 0x3F, 0xC3, 0xCF,
  0xFC, 0x7B, 0xFF, 0xCF, 0xE0, 0xFD, 0xF8, 0x0F, 0xBF, 0x00, 0xF7, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xF7, 0xE0, 0x3E, 0xFE, 0x07, 0xDF, 0xF3, 0xF3, 0xEF, 0xFE, 0x7D, 0xFF,
  0x8F, 0x8F, 0xE1, 0xF0, 0x60, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFF, 0x3C, 0x7F, 0xF7, 0x8F, 0xFE, 0xF3, 0xE0, 0xFE, 0x78, 0x0F,
  0xDF, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E,
  0xF0, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x3E, 0x07, 0xE7, 0xE3, 0xFC,
  0x7F, 0xF7, 0x87, 0xFC, 0xF0, 0x7F, 0x1E, 0x03, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xFF, 0x8F, 0xBC, 0xFD, 0xEF, 0xEF, 0x7F, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE, 0xF8, 0x1B, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xC7, 0xEF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x08, 0x00, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF1, 0x1F, 0xF0, 0xFF, 0x07, 0xF0,
  0x08, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xDE, 0x01, 0xF7, 0x80, 0xFD, 0xF0, 0x7F, 0x7F, 0x7B, 0xCF, 0xFE, 0xF1,
  0xFF, 0x3C, 0x3F, 0x8F, 0x01, 0x00, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1,
  0xE0, 0x3C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x81,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07,
  0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x3C, 0x07, 0xE0, 0x3E, 0x3C, 0x0F,
  0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0x70, 0x3C, 0x3E, 0x0E,
  0x70, 0x3C, 0x1E, 0x0E, 0x70, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E,
  0x78, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1F, 0x1C, 0x38, 0x78, 0x0F, 0x1C,
  0x38, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C,
  0x3C, 0xF0, 0x07, 0x38, 0x1C, 0xE0, 0x07, 0xB8, 0x1D, 0xE0, 0x07, 0xB8,
  0x1D, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xDF, 0x03, 0xE3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF7,
  0xC0, 0x3C, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xF0, 0xF0, 0x3C,
  0x7C, 0x0F, 0x1E, 0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF8, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x01, 0xF1, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x0F,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x08, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x20, 0x00,
  0x00, 0x3F, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x7F, 0xA0, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 38, 12, 3, -38 },
  { 30, 14, 14, 20, 3, -38 },
  { 55, 22, 38, 24, 1, -38 },
  { 160, 19, 43, 23, 2, -40 },
  { 263, 31, 38, 35, 2, -38 },
  { 411, 23, 39, 25, 2, -38 },
  { 524, 5, 14, 11, 3, -38 },
  { 533, 11, 46, 15, 3, -38 },
  { 597, 11, 46, 15, 2, -38 },
  { 661, 17, 17, 21, 2, -40 },
  { 698, 19, 25, 23, 2, -31 },
  { 758, 7, 13, 12, 2, -6 },
  { 770, 12, 4, 15, 1, -16 },
  { 776, 6, 6, 12, 3, -6 },
  { 781, 18, 38, 20, 1, -38 },
  { 867, 19, 39, 23, 2, -38 },
  { 960, 13, 38, 23, 3, -38 },
  { 1022, 18, 38, 23, 2, -38 },
  { 1108, 18, 39, 23, 2, -38 },
  { 1196, 21, 38, 23, 1, -38 },
  { 1296, 17, 39, 23, 3, -38 },
  { 1379, 19, 39, 23, 2, -38 },
  { 1472, 19, 38, 23, 2, -38 },
  { 1563, 19, 39, 23, 2, -38 },
  { 1656, 18, 39, 23, 2, -38 },
  { 1744, 6, 29, 12, 3, -29 },
  { 1766, 7, 36, 12, 2, -29 },
  { 1798, 19, 24, 23, 2, -31 },
  { 1855, 19, 15, 23, 2, -26 },
  { 1891, 19, 24, 23, 2, -31 },
  { 1948, 15, 38, 17, 1, -38 },
  { 2020, 29, 42, 35, 3, -38 },
  { 2173, 24, 38, 24, 0, -38 },
  { 2287, 19, 38, 25, 4, -38 },
  { 2378, 19, 39, 24, 3, -38 },
  { 2471, 21, 38, 27, 4, -38 },
  { 2571, 15, 38, 21, 4, -38 },
  { 2643, 15, 38, 20, 4, -38 },
  { 2715, 23, 39, 29, 3, -38 },
  { 2828, 20, 38, 28, 4, -38 },
  { 2923, 11, 38, 15, 2, -38 },
  { 2976, 11, 48, 12, -3, -38 },
  { 3042, 20, 38, 24, 4, -38 },
  { 3137, 15, 38, 20, 4, -38 },
  { 3209, 30, 38, 38, 4, -38 },
  { 3352, 22, 38, 30, 4, -38 },
  { 3457, 24, 39, 29, 3, -38 },
  { 3574, 18, 38, 23, 4, -38 },
  { 3660, 24, 47, 29, 3, -38 },
  { 3801, 20, 38, 24, 4, -38 },
  { 3896, 18, 39, 22, 2, -38 },
  { 3984, 19, 38, 20, 1, -38 },
  { 4075, 20, 39, 28, 4, -38 },
  { 4173, 23, 38, 23, 0, -38 },
  { 4283, 38, 38, 38, 0, -38 },
  { 4464, 21, 38, 21, 0, -38 },
  { 4564, 21, 38, 21, 0, -38 },
  { 4664, 17, 38, 19, 1, -38 },
  { 4745, 11, 47, 17, 4, -38 },
  { 4810, 18, 38, 20, 1, -38 },
  { 4896, 11, 47, 17, 2, -38 },
  { 4961, 22, 20, 23, 1, -38 },
  { 5016, 23, 4, 23, 0, 4 },
  { 5028, 10, 9, 14, 2, -41 },
  { 5040, 17, 30, 22, 2, -29 },
  { 5104, 19, 41, 24, 3, -40 },
  { 5202, 15, 30, 18, 2, -29 },
  { 5259, 19, 41, 24, 2, -40 },
  { 5357, 18, 30, 22, 2, -29 },
  { 5425, 15, 41, 13, 0, -41 },
  { 5502, 19, 42, 24, 2, -29 },
  { 5602, 18, 40, 24, 3, -40 },
  { 5692, 5, 39, 11, 3, -39 },
  { 5717, 9, 52, 11, -1, -39 },
  { 5776, 18, 40, 21, 3, -40 },
  { 5866, 5, 40, 11, 3, -40 },
  { 5891, 30, 29, 36, 3, -29 },
  { 6000, 18, 29, 24, 3, -29 },
  { 6066, 19, 30, 24, 2, -29 },
  { 6138, 19, 42, 24, 3, -29 },
  { 6238, 19, 42, 24, 2, -29 },
  { 6338, 13, 29, 16, 3, -29 },
  { 6386, 14, 30, 18, 2, -29 },
  { 6439, 12, 36, 14, 1, -35 },
  { 6493, 18, 29, 24, 3, -28 },
  { 6559, 19, 28, 20, 0, -28 },
  { 6626, 32, 28, 32, 0, -28 },
  { 6738, 18, 28, 20, 1, -28 },
  { 6801, 19, 41, 20, 0, -28 },
  { 6899, 14, 28, 16, 1, -28 },
  { 6948, 15, 47, 19, 2, -38 },
  { 7037, 4, 53, 21, 9, -40 },
  { 7064, 15, 47, 19, 2, -38 },
  { 7153, 19, 7, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Regular53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR53PT7B_H_
