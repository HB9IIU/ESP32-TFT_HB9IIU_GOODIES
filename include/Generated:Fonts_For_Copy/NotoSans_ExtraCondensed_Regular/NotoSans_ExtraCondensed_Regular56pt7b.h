#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0xCF, 0xBE, 0xFF, 0xFF, 0xBE, 0x20, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x1F, 0x78,
  0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x81, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07,
  0x03, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE6, 0x1C,
  0x7C, 0x60, 0x47, 0x86, 0x00, 0xF8, 0x60, 0x0F, 0x06, 0x00, 0xF0, 0x60,
  0x0F, 0x06, 0x00, 0xF8, 0x60, 0x07, 0x86, 0x00, 0x7C, 0x60, 0x03, 0xF6,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x06, 0xFC, 0x00, 0x67, 0xE0, 0x06, 0x1E, 0x00, 0x61, 0xF0,
  0x06, 0x0F, 0x00, 0x60, 0xF0, 0x06, 0x0F, 0x00, 0x60, 0xF0, 0x06, 0x1E,
  0x80, 0x63, 0xEF, 0x06, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0x03, 0xC3, 0x80, 0x78, 0x01, 0xC1, 0xE0, 0x38, 0x00, 0xE0,
  0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x0E, 0x00, 0x3C,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x83, 0x80, 0x07,
  0x83, 0xC3, 0xC0, 0x03, 0xC1, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0xE0, 0x00,
  0xF0, 0x78, 0xF0, 0x20, 0x38, 0x3C, 0x78, 0xFE, 0x1C, 0x1E, 0x38, 0xFF,
  0x8F, 0x0F, 0x3C, 0x7F, 0xC7, 0x87, 0x1E, 0x78, 0xF1, 0xC7, 0x9E, 0x38,
  0x78, 0xFF, 0x8F, 0x1C, 0x1C, 0x3F, 0xC7, 0x9E, 0x0F, 0x0F, 0xC7, 0x8F,
  0x07, 0x81, 0x83, 0xC7, 0x83, 0xC0, 0x01, 0xC3, 0xC1, 0xE0, 0x01, 0xE1,
  0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x78, 0x00, 0x70, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x07, 0x80, 0x1E,
  0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0xE0, 0xE0, 0x07,
  0x80, 0x78, 0xF0, 0x03, 0xC0, 0x3C, 0x78, 0x01, 0xC0, 0x0F, 0xF8, 0x01,
  0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x78,
  0x7C, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1F, 0x3E, 0x0F, 0x8F,
  0x9F, 0x03, 0xE7, 0x8F, 0x00, 0xFF, 0xC7, 0x80, 0x7F, 0xE3, 0xC0, 0x1F,
  0xE1, 0xE0, 0x0F, 0xF0, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00,
  0xFE, 0x1F, 0x00, 0xFF, 0x07, 0xC0, 0xFF, 0xC3, 0xFF, 0xFB, 0xF0, 0xFF,
  0xF8, 0xF8, 0x3F, 0xF8, 0x7E, 0x0F, 0xF8, 0x1F, 0x80, 0x40, 0x00, 0x00,
  0xFF, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x01,
  0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x1E, 0x3D, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xEF, 0x00, 0xF3,
  0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0x80, 0x40, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xFF,
  0xFF, 0xFD, 0xF7, 0xC4, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C,
  0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x87, 0xFC, 0x7D, 0xE7,
  0xCF, 0xFC, 0x7B, 0xC3, 0xCC, 0x1E, 0x20, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x40, 0x01, 0xFF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF8, 0xF0, 0x1F, 0x8C, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x40, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0xF0, 0x1F, 0x88, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xEE, 0x00, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x39, 0xF0, 0x01, 0xE7, 0xC0, 0x07,
  0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F,
  0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x00,
  0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x8C, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x7F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF2, 0x00, 0x7E,
  0x60, 0x1F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0xFE, 0x07, 0x9F, 0xF0,
  0x7B, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x07, 0xCF, 0xE0, 0x3E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x07, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0x9F, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x80, 0xFB,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xBF, 0x01, 0xF1, 0xF8, 0x3E, 0x0F, 0xC7, 0xC0, 0x7E, 0x78, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07,
  0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x7E, 0x7C, 0x1F, 0xCF, 0xFF, 0x78, 0xFF, 0xEF, 0x0F, 0xF9,
  0xE0, 0xFE, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x79, 0xFF, 0xFF, 0xFD, 0xF3, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x7F,
  0xFF, 0xFF, 0x7D, 0xF1, 0x00, 0x3C, 0x3E, 0x7E, 0x7E, 0x7E, 0x3E, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0x60, 0x7E, 0x40, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x02, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF1, 0xE0,
  0x3F, 0xE1, 0xE7, 0x81, 0xFF, 0xC3, 0xCF, 0x03, 0xFF, 0x83, 0x9E, 0x0F,
  0x0F, 0x07, 0xF8, 0x3E, 0x1E, 0x0F, 0xF0, 0x78, 0x3C, 0x1F, 0xE0, 0xF0,
  0x78, 0x3F, 0xC1, 0xC0, 0xF0, 0x7F, 0x87, 0x81, 0xE0, 0xFF, 0x0F, 0x03,
  0xC1, 0xFC, 0x1E, 0x07, 0x83, 0xF8, 0x3C, 0x1F, 0x07, 0xF0, 0x78, 0x3E,
  0x0F, 0xE0, 0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0xF0, 0x3B, 0x83, 0xC1, 0xE0,
  0x77, 0x83, 0x83, 0xC1, 0xEF, 0x07, 0x87, 0xC3, 0xDE, 0x0F, 0x1F, 0x8F,
  0x3C, 0x1F, 0xF3, 0xFE, 0x78, 0x1F, 0xE7, 0xF8, 0x78, 0x1F, 0x87, 0xE0,
  0xF0, 0x0C, 0x03, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0x80, 0xFE, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7C,
  0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9,
  0xF0, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xE0, 0x30, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xF8, 0x3F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x0F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0x00, 0xF0, 0x7E, 0x00, 0x18, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xF0, 0x01, 0xF0, 0xFE, 0x00, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0xEF, 0xEF, 0xFC,
  0xFF, 0xCF, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFB, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF7, 0x80, 0x01, 0xEF, 0xF7, 0x80, 0x01, 0xEF, 0xF7, 0x80,
  0x01, 0xEF, 0xF3, 0xC0, 0x01, 0xEF, 0xF3, 0xC0, 0x03, 0xCF, 0xFB, 0xC0,
  0x03, 0xCF, 0xFB, 0xE0, 0x03, 0xCF, 0xF9, 0xE0, 0x07, 0x8F, 0xF9, 0xE0,
  0x07, 0x8F, 0xF9, 0xE0, 0x07, 0x8F, 0xF8, 0xF0, 0x07, 0x8F, 0xF8, 0xF0,
  0x0F, 0x0F, 0xF8, 0xF0, 0x0F, 0x0F, 0xF8, 0xF8, 0x0F, 0x0F, 0xF8, 0x78,
  0x1E, 0x0F, 0xF8, 0x78, 0x1E, 0x0F, 0xF8, 0x78, 0x1E, 0x0F, 0xF8, 0x3C,
  0x1E, 0x0F, 0xF8, 0x3C, 0x3C, 0x0F, 0xF8, 0x3C, 0x3C, 0x0F, 0xF8, 0x3E,
  0x3C, 0x0F, 0xF8, 0x1E, 0x78, 0x0F, 0xF8, 0x1E, 0x78, 0x0F, 0xF8, 0x1E,
  0x78, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x07,
  0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03,
  0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xF7, 0x80, 0x1F, 0xF7, 0xC0, 0x1F, 0xF3, 0xC0, 0x1F, 0xF3,
  0xE0, 0x1F, 0xF9, 0xE0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF8,
  0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1E, 0x1F, 0xF8,
  0x1F, 0x1F, 0xF8, 0x0F, 0x1F, 0xF8, 0x0F, 0x9F, 0xF8, 0x0F, 0x9F, 0xF8,
  0x07, 0xDF, 0xF8, 0x07, 0xDF, 0xF8, 0x03, 0xCF, 0xF8, 0x03, 0xEF, 0xF8,
  0x01, 0xEF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x01, 0xF0,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x83, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C,
  0x0F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0x83, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x1F, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7E, 0x07, 0x9F, 0x80, 0x23, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x40, 0x07, 0xEF, 0x01, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xFE, 0x07, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x07, 0x87,
  0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x78, 0x00, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x1E, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x3C, 0x00, 0x7F,
  0x00, 0x3E, 0x3C, 0x00, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x3C,
  0x3E, 0x00, 0xF7, 0x00, 0x7C, 0x3E, 0x00, 0xF7, 0x00, 0x7C, 0x1E, 0x00,
  0xF7, 0x80, 0x7C, 0x1E, 0x01, 0xE7, 0x80, 0x7C, 0x1F, 0x01, 0xE7, 0x80,
  0x78, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x0F,
  0x01, 0xE3, 0xC0, 0xF8, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0x0F, 0x83, 0xC3,
  0xC0, 0xF0, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x0F, 0x83, 0xC3, 0xC1, 0xF0,
  0x07, 0x83, 0xC1, 0xE1, 0xF0, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0x07, 0xC7,
  0x81, 0xE1, 0xE0, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x03, 0xC7, 0x81, 0xE3,
  0xE0, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x03,
  0xEF, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00,
  0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x77, 0xC0, 0x01, 0xEF, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x1F, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xEF, 0x80, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C,
  0xF8, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x3C,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xBE, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x1E, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E,
  0x1F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x7C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF1, 0xF0, 0x01,
  0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1E, 0x1F, 0x84, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x87, 0xDF, 0x81, 0xF7, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFD, 0xF8, 0xEF, 0x7F, 0xFB, 0xCF,
  0xFC, 0xF1, 0xFC, 0x3C, 0x08, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x20, 0x0F, 0x1F, 0xE0, 0xF3, 0xFF, 0x0F, 0x7F, 0xF8, 0xFF, 0xBF,
  0x8F, 0xE0, 0xFC, 0xFC, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0xC0, 0x7C, 0xFE, 0x07, 0xCF, 0xF9, 0xF8, 0xF7, 0xFF,
  0x8F, 0x3F, 0xF0, 0xE1, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x30, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xDE, 0x3F, 0x02, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x01, 0x1F, 0xDF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x30,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xC0, 0xF0, 0x7F, 0x8F, 0x0F,
  0xFC, 0xF1, 0xFF, 0xEF, 0x1F, 0x9F, 0xF3, 0xE0, 0x7F, 0x3E, 0x03, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x3F, 0x3E,
  0x07, 0xF1, 0xF8, 0xFF, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xF8, 0x70,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x81,
  0xF0, 0xF8, 0x7C, 0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0x0F, 0xE3, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7C, 0x40, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x8F, 0x0F, 0xFC, 0xF1, 0xFF,
  0xEF, 0x1F, 0xDE, 0xF3, 0xE0, 0x7F, 0x3E, 0x03, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x07, 0xF1, 0xFD,
  0xEF, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x08, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x40, 0x03, 0xE3, 0x00, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x70, 0x3C, 0x7F,
  0x8F, 0x3F, 0xF3, 0xDF, 0xFE, 0xFF, 0xBF, 0xBF, 0x83, 0xEF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x7B, 0xEF, 0xFF, 0x79, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x78, 0x07, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0xFB, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C,
  0x0F, 0x8F, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1F,
  0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xF8, 0x0F, 0x7E, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0x3C, 0x0F, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3C,
  0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0xCF, 0x01,
  0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x01, 0x81,
  0xC3, 0xF8, 0x1F, 0xE3, 0x8F, 0xF8, 0x7F, 0xE7, 0xBF, 0xF9, 0xFF, 0xCF,
  0xFB, 0xF7, 0xDF, 0xDF, 0x81, 0xFE, 0x0F, 0xBF, 0x03, 0xF8, 0x1F, 0x7C,
  0x03, 0xE0, 0x1E, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0x00, 0x78, 0x03, 0xFE, 0x00,
  0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x07,
  0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0xFF, 0x80, 0x3C,
  0x01, 0xFF, 0x00, 0x78, 0x03, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE0,
  0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00,
  0x7F, 0xC0, 0x1E, 0x00, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x00, 0x78, 0x03,
  0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x70, 0x38,
  0x7F, 0x8E, 0x3F, 0xF3, 0xDF, 0xFE, 0xFF, 0xBF, 0xBF, 0x83, 0xEF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF9, 0xFC, 0x1F, 0x03, 0xF0, 0xF8,
  0x0F, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x3C,
  0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3C, 0xF0, 0x01, 0xE7,
  0x80, 0x0F, 0x3C, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x3C, 0x01,
  0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0xBF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x70, 0x0E, 0x1F, 0xE0,
  0xF3, 0xFF, 0x0F, 0x7F, 0xF8, 0xFF, 0x1F, 0x8F, 0xE0, 0x7C, 0xFC, 0x07,
  0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x7C,
  0xFE, 0x0F, 0xCF, 0xFB, 0xF8, 0xF7, 0xFF, 0x8F, 0x3F, 0xF0, 0xF1, 0xFE,
  0x0F, 0x02, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x7F, 0x8F, 0x0F, 0xFC, 0xF1, 0xFF, 0xEF, 0x1F, 0x9E, 0xF3, 0xE0, 0x7F,
  0x3E, 0x03, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF3,
  0xE0, 0x3F, 0x3E, 0x07, 0xF1, 0xFD, 0xEF, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF,
  0x07, 0xF8, 0xF0, 0x08, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x7F, 0x0F, 0xB8, 0xFD, 0xCF, 0xEF, 0x7F, 0x7F, 0x83, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x1F, 0xF8, 0xFF, 0xFB, 0xFF, 0xF7, 0xE3, 0xDF,
  0x00, 0xBE, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xF8,
  0x01, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xC3, 0xFE, 0x1F,
  0xF0, 0x7F, 0x80, 0x40, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x07, 0xF7, 0xFF, 0xBD, 0xFF, 0xEF, 0x3F, 0xF3, 0xC7, 0xF8, 0xF0,
  0x30, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x78,
  0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xBC, 0x01, 0xF8, 0x03, 0xDF, 0x00, 0xFC, 0x03, 0xEF, 0x80, 0x7E,
  0x01, 0xF7, 0xC0, 0x7F, 0x00, 0xF1, 0xE0, 0x3F, 0xC0, 0x78, 0xF0, 0x1F,
  0xE0, 0x3C, 0x7C, 0x0F, 0xF0, 0x3E, 0x3E, 0x07, 0x38, 0x1F, 0x0F, 0x07,
  0x9C, 0x0F, 0x07, 0x83, 0xCF, 0x07, 0x83, 0xC1, 0xE7, 0x83, 0xC1, 0xF0,
  0xF3, 0xC3, 0xE0, 0xF8, 0x79, 0xE1, 0xE0, 0x3C, 0x78, 0x70, 0xF0, 0x1E,
  0x3C, 0x3C, 0x78, 0x0F, 0x1E, 0x1E, 0x3C, 0x07, 0xCF, 0x0F, 0x3E, 0x03,
  0xE7, 0x87, 0x9E, 0x00, 0xF7, 0x81, 0xCF, 0x00, 0x7B, 0xC0, 0xF7, 0x80,
  0x3D, 0xE0, 0x7B, 0xC0, 0x1E, 0xF0, 0x3F, 0xC0, 0x07, 0x70, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x03, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0xBE, 0x00, 0xF7,
  0xC0, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xDE,
  0x00, 0xFB, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0xC0, 0xF0, 0x78, 0x3E, 0x0F,
  0x87, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3D, 0xF0, 0x07,
  0xC0, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78,
  0x01, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x0B, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x40, 0x1F, 0xF2, 0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 41, 13, 4, -40 },
  { 32, 15, 14, 21, 3, -40 },
  { 59, 24, 40, 26, 1, -40 },
  { 179, 20, 46, 24, 2, -43 },
  { 294, 33, 42, 37, 2, -41 },
  { 468, 25, 42, 27, 2, -41 },
  { 600, 6, 14, 12, 3, -40 },
  { 611, 12, 49, 16, 3, -40 },
  { 685, 12, 49, 16, 2, -40 },
  { 759, 18, 19, 22, 2, -43 },
  { 802, 20, 26, 24, 2, -33 },
  { 867, 8, 13, 13, 2, -6 },
  { 880, 12, 4, 15, 2, -17 },
  { 886, 6, 8, 13, 3, -7 },
  { 892, 19, 40, 21, 1, -40 },
  { 987, 20, 42, 24, 2, -41 },
  { 1092, 13, 40, 24, 3, -40 },
  { 1157, 19, 41, 24, 2, -41 },
  { 1255, 19, 42, 24, 2, -41 },
  { 1355, 22, 40, 24, 1, -40 },
  { 1465, 19, 41, 24, 3, -40 },
  { 1563, 20, 42, 24, 2, -41 },
  { 1668, 20, 40, 24, 2, -40 },
  { 1768, 20, 42, 24, 2, -41 },
  { 1873, 19, 42, 24, 2, -41 },
  { 1973, 6, 31, 13, 3, -30 },
  { 1997, 8, 37, 13, 2, -30 },
  { 2034, 20, 25, 24, 2, -32 },
  { 2097, 20, 16, 24, 2, -28 },
  { 2137, 20, 25, 24, 2, -32 },
  { 2200, 16, 42, 18, 1, -41 },
  { 2284, 31, 45, 36, 3, -40 },
  { 2459, 25, 40, 25, 0, -40 },
  { 2584, 21, 40, 27, 4, -40 },
  { 2689, 21, 42, 25, 3, -41 },
  { 2800, 22, 40, 29, 4, -40 },
  { 2910, 16, 40, 23, 4, -40 },
  { 2990, 16, 40, 21, 4, -40 },
  { 3070, 25, 42, 31, 3, -41 },
  { 3202, 22, 40, 30, 4, -40 },
  { 3312, 12, 40, 16, 2, -40 },
  { 3372, 12, 51, 13, -3, -40 },
  { 3449, 21, 40, 25, 4, -40 },
  { 3554, 16, 40, 21, 4, -40 },
  { 3634, 32, 40, 40, 4, -40 },
  { 3794, 24, 40, 32, 4, -40 },
  { 3914, 25, 42, 31, 3, -41 },
  { 4046, 19, 40, 25, 4, -40 },
  { 4141, 25, 51, 31, 3, -41 },
  { 4301, 21, 40, 26, 4, -40 },
  { 4406, 19, 42, 23, 2, -41 },
  { 4506, 20, 40, 21, 1, -40 },
  { 4606, 21, 41, 29, 4, -40 },
  { 4714, 25, 40, 25, 0, -40 },
  { 4839, 40, 40, 40, 0, -40 },
  { 5039, 22, 40, 22, 0, -40 },
  { 5149, 22, 40, 22, 0, -40 },
  { 5259, 18, 40, 20, 1, -40 },
  { 5349, 12, 49, 17, 4, -40 },
  { 5423, 19, 40, 21, 1, -40 },
  { 5518, 11, 49, 17, 2, -40 },
  { 5586, 23, 21, 25, 1, -40 },
  { 5647, 25, 3, 24, 0, 5 },
  { 5657, 11, 9, 15, 2, -43 },
  { 5670, 18, 32, 23, 2, -31 },
  { 5742, 20, 44, 26, 4, -43 },
  { 5852, 16, 32, 19, 2, -31 },
  { 5916, 20, 44, 26, 2, -43 },
  { 6026, 19, 32, 23, 2, -31 },
  { 6102, 15, 43, 14, 0, -43 },
  { 6183, 20, 44, 26, 2, -31 },
  { 6293, 18, 43, 26, 4, -43 },
  { 6390, 6, 41, 12, 3, -41 },
  { 6421, 10, 54, 12, -1, -41 },
  { 6489, 18, 43, 22, 4, -43 },
  { 6586, 4, 43, 12, 4, -43 },
  { 6608, 31, 31, 38, 4, -31 },
  { 6729, 18, 31, 26, 4, -31 },
  { 6799, 21, 32, 25, 2, -31 },
  { 6883, 20, 44, 26, 4, -31 },
  { 6993, 20, 44, 26, 2, -31 },
  { 7103, 13, 31, 17, 4, -31 },
  { 7154, 15, 32, 19, 2, -31 },
  { 7214, 13, 38, 15, 1, -37 },
  { 7276, 18, 31, 26, 4, -30 },
  { 7346, 21, 30, 21, 0, -30 },
  { 7425, 33, 30, 34, 0, -30 },
  { 7549, 19, 30, 21, 1, -30 },
  { 7621, 21, 43, 21, 0, -30 },
  { 7734, 15, 30, 17, 1, -30 },
  { 7791, 16, 49, 20, 2, -40 },
  { 7889, 4, 56, 23, 9, -43 },
  { 7917, 16, 49, 20, 2, -40 },
  { 8015, 21, 7, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Regular56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR56PT7B_H_
