#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC0,
  0x00, 0x00, 0x07, 0x3E, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x1F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03,
  0xC0, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03,
  0x81, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07,
  0x81, 0xC0, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0F,
  0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E,
  0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E,
  0x07, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xF7, 0xE7, 0xC7, 0x04, 0x78, 0x70, 0x07, 0x87, 0x00, 0xF8,
  0x70, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x87, 0x00, 0x78, 0x70, 0x07,
  0xC7, 0x00, 0x7E, 0x70, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0x7E, 0x00, 0x73,
  0xE0, 0x07, 0x1F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07,
  0x0F, 0x00, 0x70, 0xF0, 0x07, 0x1F, 0xC0, 0x71, 0xEF, 0x87, 0x7E, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0xFE, 0x00, 0x78,
  0x00, 0xF3, 0xC0, 0x1E, 0x00, 0x78, 0x70, 0x07, 0x00, 0x1E, 0x1E, 0x03,
  0xC0, 0x07, 0x07, 0x80, 0xF0, 0x01, 0xC1, 0xE0, 0x38, 0x00, 0xF0, 0x38,
  0x1E, 0x00, 0x3C, 0x0E, 0x07, 0x80, 0x0F, 0x03, 0x81, 0xC0, 0x03, 0xC0,
  0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x3C, 0x0F, 0x1E, 0x00, 0x0F,
  0x03, 0xC7, 0x80, 0x03, 0xC0, 0xE1, 0xE0, 0x00, 0xF0, 0x38, 0xF0, 0x78,
  0x1C, 0x1E, 0x3C, 0x7F, 0x87, 0x87, 0x8F, 0x3F, 0xE1, 0xE1, 0xE7, 0x8F,
  0x7C, 0x78, 0x71, 0xE7, 0x8F, 0x0F, 0x3C, 0x71, 0xE1, 0xE3, 0xFE, 0x3C,
  0x78, 0x78, 0x7F, 0x8F, 0x1C, 0x1E, 0x0F, 0xC3, 0x87, 0x07, 0x80, 0x01,
  0xE3, 0xC0, 0xE0, 0x00, 0x78, 0xF0, 0x3C, 0x00, 0x1C, 0x3C, 0x0F, 0x00,
  0x0F, 0x0F, 0x03, 0xC0, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x3C,
  0x00, 0x78, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x03, 0x80, 0x0F, 0x01, 0xC1,
  0xE0, 0x03, 0xC0, 0x78, 0x78, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x78, 0x07,
  0x87, 0x80, 0x1E, 0x00, 0xF3, 0xC0, 0x07, 0x80, 0x3F, 0xF0, 0x03, 0xC0,
  0x07, 0xF8, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7C, 0x7C,
  0xF8, 0x3E, 0x7C, 0x3E, 0x1E, 0x3C, 0x1F, 0x0F, 0x3E, 0x07, 0xCF, 0x9F,
  0x03, 0xE7, 0xCF, 0x80, 0xFB, 0xC7, 0xC0, 0x3F, 0xE3, 0xC0, 0x1F, 0xF1,
  0xE0, 0x07, 0xF0, 0xF8, 0x03, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFE,
  0x1F, 0x80, 0xFF, 0x87, 0xE0, 0xFF, 0xC3, 0xFF, 0xFD, 0xF0, 0xFF, 0xFC,
  0xFC, 0x3F, 0xFC, 0x3E, 0x0F, 0xF8, 0x1F, 0x80, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xC1, 0xC1, 0x9F, 0x39, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0xC0,
  0x1E, 0x7C, 0x07, 0xC7, 0x80, 0xF0, 0xF8, 0x3E, 0x0F, 0x81, 0x81, 0xC0,
  0x10, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C,
  0x78, 0x78, 0x70, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0xFB, 0xF7, 0xFF, 0xCF, 0x9F, 0x08, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0x8F, 0x81, 0xF0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3E,
  0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xDF, 0xFC, 0xFF, 0xC7, 0xDC,
  0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7C, 0x1F, 0xC3, 0x00, 0x7C, 0x20, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x7C, 0x0F, 0xC7, 0x00, 0x7C,
  0x20, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE8, 0x00, 0x7E, 0xE0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x40, 0x07, 0xCC, 0x03, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFC, 0x08, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x83, 0x80, 0xF1, 0xFE,
  0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0xDF, 0xCF, 0xE0, 0xFD, 0xF8, 0x0F,
  0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0x7E, 0x3F, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x83, 0xE0,
  0xF8, 0x1F, 0x9F, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7E, 0x7E, 0x07, 0xE1, 0xF8, 0x3E, 0x07,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x3E, 0x1F, 0xEF, 0xF0, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0x87, 0xE0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF3, 0xF1, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0xDE, 0x0F, 0xF9,
  0xE0, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x38, 0xF9, 0xF7, 0xFF, 0xEF,
  0x9F, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xF9, 0xF7, 0xFF, 0xEF, 0x9F, 0x08, 0x1C,
  0x3E, 0x3E, 0x7F, 0x7F, 0x3E, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x70,
  0xF0, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0x70, 0x7E, 0x40, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x03, 0xF0, 0x3C, 0x78, 0x0F, 0xFC, 0x1E,
  0x78, 0x1F, 0xFC, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x78, 0x3C, 0x3C, 0x1E,
  0xF0, 0x3C, 0x3C, 0x1E, 0xF0, 0x78, 0x3C, 0x0E, 0xF0, 0x78, 0x3C, 0x0E,
  0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0xF0, 0x3C, 0x0F,
  0xF0, 0xF0, 0x3C, 0x0E, 0xF0, 0xF0, 0x3C, 0x0E, 0xF0, 0xF0, 0x3C, 0x0E,
  0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0x70, 0x7C, 0x1E,
  0xF0, 0x78, 0x7C, 0x1E, 0xF0, 0x78, 0x6C, 0x3C, 0xF0, 0x7C, 0xEE, 0x3C,
  0xF0, 0x3F, 0xEF, 0xF8, 0xF0, 0x3F, 0xCF, 0xF8, 0x78, 0x1F, 0x87, 0xF0,
  0x78, 0x06, 0x00, 0x80, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x02, 0x00, 0x07, 0xE0, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3C, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0x83, 0xFE, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0x80, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFE, 0x07, 0x0F, 0xC0, 0x08, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x03, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0x01, 0xFC, 0x3E, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x0F, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0x01, 0xF0, 0x7E, 0x00, 0x30, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x03,
  0xE3, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xEC, 0x7E, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xEF, 0x00, 0x01, 0xFF,
  0xF7, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0xF0, 0x00, 0x7B,
  0xFF, 0x78, 0x00, 0x3D, 0xFF, 0xBC, 0x00, 0x1E, 0xFF, 0xDF, 0x00, 0x1E,
  0x7F, 0xE7, 0x80, 0x0F, 0x3F, 0xF3, 0xC0, 0x07, 0x9F, 0xF9, 0xF0, 0x07,
  0xCF, 0xFC, 0x78, 0x03, 0xC7, 0xFE, 0x3C, 0x01, 0xE3, 0xFF, 0x1E, 0x00,
  0xF1, 0xFF, 0x8F, 0x80, 0xF0, 0xFF, 0xC3, 0xC0, 0x78, 0x7F, 0xE1, 0xE0,
  0x3C, 0x3F, 0xF0, 0xF8, 0x3E, 0x1F, 0xF8, 0x3C, 0x1E, 0x0F, 0xFC, 0x1E,
  0x0F, 0x07, 0xFE, 0x0F, 0x07, 0x83, 0xFF, 0x07, 0xC7, 0x81, 0xFF, 0x81,
  0xE3, 0xC0, 0xFF, 0xC0, 0xF1, 0xE0, 0x7F, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF8, 0x0F, 0x78, 0x0F, 0xFC, 0x07, 0xBC, 0x07, 0xFE,
  0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xFB,
  0xC0, 0x0F, 0xFB, 0xE0, 0x0F, 0xF9, 0xE0, 0x0F, 0xF9, 0xF0, 0x0F, 0xF9,
  0xF0, 0x0F, 0xF8, 0xF0, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0x78, 0x0F, 0xF8,
  0x7C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8,
  0x1E, 0x0F, 0xF8, 0x1F, 0x0F, 0xF8, 0x0F, 0x0F, 0xF8, 0x0F, 0x8F, 0xF8,
  0x0F, 0x8F, 0xF8, 0x07, 0xCF, 0xF8, 0x07, 0xCF, 0xF8, 0x03, 0xCF, 0xF8,
  0x03, 0xEF, 0xF8, 0x01, 0xEF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC,
  0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xF0,
  0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07,
  0xEF, 0x83, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x7C, 0xFC, 0x01, 0x9F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xEF, 0x01, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x50, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0x80,
  0x03, 0xCF, 0x80, 0x07, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xF8, 0x00, 0xF8, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x78, 0x00,
  0xEE, 0x00, 0x3C, 0x3E, 0x00, 0x77, 0x00, 0x3E, 0x1F, 0x00, 0x7B, 0xC0,
  0x1F, 0x0F, 0x80, 0x3D, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0x7C, 0x07,
  0x8F, 0x01, 0xF0, 0x3E, 0x03, 0xC7, 0x80, 0xF8, 0x0F, 0x01, 0xE3, 0xC0,
  0x7C, 0x07, 0x80, 0xF1, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0xF0, 0x3E, 0x01,
  0xF0, 0x7C, 0x3C, 0x1F, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x80, 0x3C, 0x1E,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x07, 0x87, 0xC0, 0x0F, 0x87, 0x83, 0xC3,
  0xE0, 0x07, 0xC7, 0xC0, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x78, 0xF8, 0x00,
  0xF1, 0xE0, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x00, 0x3E, 0x78,
  0x0F, 0x3E, 0x00, 0x1F, 0x7C, 0x03, 0x9F, 0x00, 0x0F, 0xBC, 0x01, 0xEF,
  0x80, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x00,
  0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF8, 0x00, 0xF1, 0xE0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x7C,
  0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1F,
  0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0xBC, 0x00,
  0x3E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xE7, 0x80, 0x07, 0x8F,
  0x00, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x03,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1C, 0x0F, 0x84, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFD,
  0xF8, 0xEF, 0x7F, 0xFB, 0xCF, 0xFC, 0xF1, 0xFE, 0x1C, 0x08, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFC, 0x0F, 0x1F, 0xF0, 0xF3, 0xFF,
  0x8F, 0x7F, 0xF8, 0xFF, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFE, 0x07,
  0xCF, 0x7D, 0xFC, 0xF7, 0xFF, 0x8F, 0x3F, 0xF0, 0xF1, 0xFE, 0x00, 0x01,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF8, 0x21,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x43, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x0F, 0x83, 0xFE, 0x7C, 0x3F, 0xFB,
  0xE3, 0xFF, 0xFF, 0x3F, 0x07, 0xF9, 0xF0, 0x1F, 0xCF, 0x80, 0x7E, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x9F, 0x01,
  0xFC, 0xFC, 0x1F, 0xE3, 0xF9, 0xFF, 0x1F, 0xFE, 0x78, 0x7F, 0xE3, 0xC1,
  0xFE, 0x1E, 0x00, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x41, 0xFE, 0x7C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x03,
  0x00, 0x00, 0x60, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x78, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFD, 0xF3, 0xF0,
  0x7F, 0x9F, 0x01, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF9, 0xF0, 0x1F, 0xCF, 0xC1, 0xFE, 0x3F,
  0xBF, 0xF1, 0xFF, 0xEF, 0x87, 0xFE, 0x7C, 0x1F, 0xE3, 0xE0, 0x08, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC6, 0x00, 0xFC, 0x3F, 0x3F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0xFC, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xDF, 0xFE, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C,
  0x79, 0xEF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x07, 0x81, 0xE0, 0xFC,
  0x3F, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xFB,
  0xFE, 0xFF, 0x3F, 0xCF, 0xE1, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x7D, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x7C,
  0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0xFC, 0x03, 0xDF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xEF, 0x01, 0xF9, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x7C,
  0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E,
  0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0xFC, 0x07, 0xE1, 0xE7, 0xFC, 0x3F, 0xF3, 0xDF, 0xFC, 0x7F, 0xF7, 0xBF,
  0xFD, 0xFF, 0xEF, 0xE1, 0xFF, 0x87, 0xDF, 0x81, 0xFC, 0x07, 0xFE, 0x01,
  0xF8, 0x0F, 0xFC, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x0F,
  0x80, 0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C,
  0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xE0,
  0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00,
  0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x03,
  0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F,
  0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF,
  0x00, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0xE0, 0xFC, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xDF, 0xFE, 0xFF, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF0, 0x7E, 0x1F,
  0x01, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xE0, 0x07,
  0x9E, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E,
  0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x80,
  0x3E, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0xE0, 0xFC,
  0x0F, 0x1F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xF8, 0xFE, 0x0F, 0xCF, 0xC0,
  0x7C, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x03,
  0xEF, 0xC0, 0x7E, 0xFE, 0x07, 0xCF, 0x7F, 0xFC, 0xF7, 0xFF, 0x8F, 0x3F,
  0xF0, 0xF1, 0xFE, 0x0F, 0x01, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x78, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F,
  0xFD, 0xF3, 0xF0, 0x7F, 0x9F, 0x01, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3F,
  0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF9, 0xF0, 0x1F, 0xCF,
  0xC1, 0xFE, 0x3F, 0xBF, 0xF1, 0xFF, 0xEF, 0x87, 0xFE, 0x7C, 0x1F, 0xE3,
  0xE0, 0x08, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xE0, 0xFF, 0x0F, 0xFC, 0xFD, 0xEF, 0xEF, 0x7F, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F,
  0xFE, 0xFC, 0x0C, 0xF8, 0x04, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x80, 0x3E, 0xC0, 0x3E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x02, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x02,
  0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0xC1, 0xFD, 0xFF, 0xEF, 0x7F, 0xFB, 0xCF, 0xFC, 0xF1, 0xFE, 0x1C, 0x04,
  0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x7C, 0x07,
  0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x7C,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF,
  0x00, 0xFC, 0x01, 0xEF, 0x80, 0x7F, 0x00, 0xF3, 0xC0, 0x3F, 0x80, 0xF9,
  0xE0, 0x3F, 0xC0, 0x7C, 0xF8, 0x1E, 0xE0, 0x3C, 0x7C, 0x0F, 0x70, 0x1E,
  0x3E, 0x07, 0xBC, 0x0F, 0x0F, 0x03, 0xDE, 0x0F, 0x87, 0x83, 0xCF, 0x07,
  0xC3, 0xE1, 0xE7, 0x83, 0xC1, 0xF0, 0xF1, 0xC1, 0xE0, 0x78, 0x78, 0xF0,
  0xF0, 0x3C, 0x3C, 0x78, 0xF8, 0x1E, 0x3C, 0x3C, 0x78, 0x0F, 0x9E, 0x1E,
  0x3C, 0x07, 0xCF, 0x07, 0x1E, 0x01, 0xE7, 0x83, 0xCF, 0x00, 0xF3, 0xC1,
  0xEF, 0x80, 0x7B, 0xC0, 0xF7, 0x80, 0x3D, 0xE0, 0x7B, 0xC0, 0x1F, 0xF0,
  0x3D, 0xE0, 0x07, 0xF8, 0x0E, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1F, 0x0F,
  0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x07, 0xBE, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x07, 0xBE, 0x00,
  0xF9, 0xE0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x07, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xCF, 0x80, 0x3E, 0xF8, 0x03,
  0xF0, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x07,
  0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0B, 0xFE, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xFA, 0x00,
  0x7F, 0x90, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 42, 13, 4, -41 },
  { 33, 15, 15, 22, 3, -41 },
  { 62, 24, 41, 26, 1, -41 },
  { 185, 20, 46, 24, 2, -43 },
  { 300, 34, 42, 38, 2, -41 },
  { 479, 25, 42, 27, 2, -41 },
  { 611, 6, 15, 12, 3, -41 },
  { 623, 12, 50, 17, 3, -41 },
  { 698, 12, 50, 17, 2, -41 },
  { 773, 19, 19, 23, 2, -43 },
  { 819, 21, 27, 25, 2, -34 },
  { 890, 8, 15, 13, 2, -7 },
  { 905, 12, 5, 16, 2, -18 },
  { 913, 7, 8, 13, 3, -7 },
  { 920, 19, 41, 21, 1, -41 },
  { 1018, 20, 42, 24, 2, -41 },
  { 1123, 13, 41, 24, 4, -41 },
  { 1190, 20, 41, 24, 2, -41 },
  { 1293, 20, 42, 24, 2, -41 },
  { 1398, 23, 41, 24, 1, -41 },
  { 1516, 19, 42, 24, 3, -41 },
  { 1616, 19, 42, 24, 3, -41 },
  { 1716, 20, 41, 24, 2, -41 },
  { 1819, 21, 42, 24, 2, -41 },
  { 1930, 20, 42, 24, 2, -41 },
  { 2035, 7, 32, 13, 3, -31 },
  { 2063, 8, 39, 13, 2, -31 },
  { 2102, 21, 25, 25, 2, -33 },
  { 2168, 21, 16, 25, 2, -28 },
  { 2210, 21, 25, 25, 2, -33 },
  { 2276, 16, 42, 18, 1, -41 },
  { 2360, 32, 46, 37, 3, -41 },
  { 2544, 26, 41, 26, 0, -41 },
  { 2678, 21, 41, 27, 4, -41 },
  { 2786, 21, 42, 25, 3, -41 },
  { 2897, 23, 41, 29, 4, -41 },
  { 3015, 16, 41, 23, 4, -41 },
  { 3097, 16, 41, 22, 4, -41 },
  { 3179, 25, 42, 31, 3, -41 },
  { 3311, 22, 41, 30, 4, -41 },
  { 3424, 12, 41, 16, 2, -41 },
  { 3486, 12, 52, 13, -3, -41 },
  { 3564, 22, 41, 25, 4, -41 },
  { 3677, 16, 41, 21, 4, -41 },
  { 3759, 33, 41, 41, 4, -41 },
  { 3929, 24, 41, 32, 4, -41 },
  { 4052, 26, 42, 31, 3, -41 },
  { 4189, 19, 41, 25, 4, -41 },
  { 4287, 26, 51, 31, 3, -41 },
  { 4453, 22, 41, 26, 4, -41 },
  { 4566, 19, 42, 24, 2, -41 },
  { 4666, 20, 41, 22, 1, -41 },
  { 4769, 22, 42, 30, 4, -41 },
  { 4885, 25, 41, 25, 0, -41 },
  { 5014, 41, 41, 41, 0, -41 },
  { 5225, 22, 41, 23, 0, -41 },
  { 5338, 22, 41, 22, 0, -41 },
  { 5451, 18, 41, 21, 1, -41 },
  { 5544, 12, 50, 18, 4, -41 },
  { 5619, 19, 41, 21, 1, -41 },
  { 5717, 12, 50, 18, 2, -41 },
  { 5792, 23, 22, 25, 1, -41 },
  { 5856, 25, 3, 25, 0, 5 },
  { 5866, 11, 9, 15, 2, -44 },
  { 5879, 18, 32, 24, 2, -31 },
  { 5951, 20, 44, 26, 4, -43 },
  { 6061, 17, 32, 20, 2, -31 },
  { 6129, 21, 44, 26, 2, -43 },
  { 6245, 20, 32, 24, 2, -31 },
  { 6325, 15, 44, 14, 1, -44 },
  { 6408, 21, 45, 26, 2, -31 },
  { 6527, 18, 43, 26, 4, -43 },
  { 6624, 6, 42, 12, 3, -42 },
  { 6656, 10, 56, 12, -1, -42 },
  { 6726, 19, 43, 23, 4, -43 },
  { 6829, 4, 43, 12, 4, -43 },
  { 6851, 31, 31, 39, 4, -31 },
  { 6972, 18, 31, 26, 4, -31 },
  { 7042, 21, 32, 25, 2, -31 },
  { 7126, 20, 45, 26, 4, -31 },
  { 7239, 21, 45, 26, 2, -31 },
  { 7358, 13, 31, 17, 4, -31 },
  { 7409, 16, 32, 19, 2, -31 },
  { 7473, 13, 39, 15, 1, -38 },
  { 7537, 18, 32, 26, 4, -31 },
  { 7609, 21, 31, 21, 0, -31 },
  { 7691, 33, 31, 34, 1, -31 },
  { 7819, 20, 31, 21, 1, -31 },
  { 7897, 21, 45, 21, 0, -31 },
  { 8016, 15, 31, 17, 1, -31 },
  { 8075, 16, 50, 21, 2, -41 },
  { 8175, 5, 57, 23, 9, -43 },
  { 8211, 16, 50, 21, 2, -41 },
  { 8311, 21, 8, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Regular57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR57PT7B_H_
