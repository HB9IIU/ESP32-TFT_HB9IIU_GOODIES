#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0xD0, 0x0B, 0xFE, 0xE7, 0xC7, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0x0C, 0x60, 0xCC, 0x18, 0xC1, 0x8C, 0x18, 0xC1,
  0x8C, 0xFF, 0xFF, 0xFF, 0x18, 0x81, 0x98, 0x11, 0x83, 0x18, 0x31, 0x8F,
  0xFF, 0x31, 0x83, 0x18, 0x31, 0x83, 0x30, 0x23, 0x06, 0x30, 0x63, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x1F, 0xE7, 0xFC, 0xC8, 0xB9, 0x06, 0x20, 0xC4,
  0x1C, 0x81, 0xD0, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0x30, 0x27, 0x04, 0x60,
  0x9E, 0x13, 0x7F, 0xEF, 0xF8, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x10,
  0x04, 0x1F, 0x06, 0x06, 0xC1, 0x81, 0x18, 0x60, 0xC6, 0x30, 0x31, 0x8C,
  0x0C, 0x63, 0x03, 0x19, 0x80, 0xC6, 0x60, 0x31, 0x9B, 0xC4, 0x6C, 0xF9,
  0xB3, 0x66, 0x7D, 0xD9, 0x84, 0x66, 0x30, 0x19, 0x8C, 0x0C, 0x63, 0x03,
  0x18, 0xC0, 0xC6, 0x30, 0x61, 0x9C, 0x18, 0x66, 0x06, 0x0F, 0x83, 0x03,
  0xC0, 0x0E, 0x01, 0xF8, 0x0E, 0xC0, 0x67, 0x07, 0x18, 0x38, 0xC0, 0xCE,
  0x06, 0x60, 0x3F, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x17, 0x63, 0x73, 0x9B,
  0x8C, 0xD8, 0x7E, 0xC1, 0xE6, 0x07, 0x38, 0x79, 0xC7, 0xE7, 0xFB, 0x1F,
  0x1C, 0xFB, 0x6D, 0xB0, 0x06, 0x18, 0x70, 0xC3, 0x86, 0x0C, 0x38, 0x60,
  0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x06, 0x0E,
  0x0C, 0x1C, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x30, 0xE1, 0x86, 0x1C, 0x70,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0x8C,
  0x00, 0x0C, 0x03, 0x00, 0xC3, 0x32, 0xFF, 0xCF, 0xC1, 0xE0, 0xDC, 0x73,
  0x88, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xFF,
  0xFF, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x77, 0x76,
  0x6E, 0xC0, 0xFF, 0xF0, 0x5F, 0xF0, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x0E, 0x03,
  0xE0, 0xFE, 0x38, 0xE6, 0x1C, 0xC1, 0x98, 0x37, 0x06, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x37, 0x06, 0x60, 0xCC, 0x19, 0xC7,
  0x38, 0xC3, 0xF8, 0x3E, 0x00, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0x1E, 0x1F, 0xCF, 0xF9, 0x07, 0x01, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03,
  0x80, 0xFF, 0xFF, 0xF0, 0x0C, 0x1F, 0xEF, 0xF9, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x81, 0xE3, 0xE0, 0xFC, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1E, 0x0F, 0xFF, 0xBF, 0xC0, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x58, 0x1B, 0x03, 0x60, 0xCC, 0x19, 0x86, 0x30, 0xC6, 0x30,
  0xC6, 0x19, 0xC3, 0x30, 0x67, 0xFF, 0xFF, 0xE0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x7F, 0x8F, 0xF1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x3B, 0x0F, 0x7F, 0xC7, 0xF0, 0x03, 0x81, 0xF8, 0x7F,
  0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x62, 0x1D, 0xF3, 0xFF, 0x78,
  0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xEC, 0x19, 0xC3, 0x38, 0xE3,
  0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0xF1, 0xEF,
  0x30, 0xE6, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x71, 0xC7, 0x70, 0x7C, 0x0F,
  0x83, 0xB8, 0xC3, 0xB8, 0x37, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xB8, 0xE7,
  0xFC, 0x7F, 0x00, 0x0E, 0x0F, 0xC7, 0xF9, 0x86, 0xE1, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x1D, 0xCF, 0x7E, 0xCF, 0xB0, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x1C, 0x7F, 0x1F, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0x05,
  0xFF, 0x77, 0x72, 0x00, 0x00, 0x00, 0x00, 0x07, 0x77, 0x66, 0xEC, 0x00,
  0x60, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x38, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0x70, 0x08, 0x00,
  0x1C, 0x7F, 0x9F, 0xC8, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x83,
  0x81, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x04, 0x07, 0x03, 0xC0,
  0xC0, 0x00, 0xE0, 0x03, 0xFC, 0x03, 0x87, 0x03, 0x80, 0xC3, 0x80, 0x71,
  0x80, 0x18, 0xC3, 0x8E, 0xC3, 0xE3, 0x63, 0x31, 0xB3, 0x98, 0xD9, 0x8C,
  0x7C, 0xC6, 0x3C, 0x63, 0x1E, 0x31, 0x8F, 0x18, 0xC6, 0xCC, 0x63, 0x63,
  0x7B, 0x31, 0xEF, 0x98, 0x21, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0xE0, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xF8,
  0x03, 0x60, 0x0D, 0x80, 0x37, 0x01, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0x63,
  0x81, 0x8E, 0x0E, 0x18, 0x3F, 0xE0, 0xFF, 0xC3, 0x07, 0x1C, 0x0C, 0x70,
  0x31, 0xC0, 0xE6, 0x03, 0xB8, 0x0E, 0xE0, 0x1C, 0xFF, 0x9F, 0xFB, 0x87,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE3, 0xDF, 0xE3, 0xFE, 0x70,
  0xEE, 0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x7F, 0xEF,
  0xF0, 0x03, 0xC0, 0xFF, 0x1F, 0xE3, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC2, 0x1F, 0xE0, 0x7E, 0xFF, 0x0F,
  0xFC, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE,
  0x0E, 0xE3, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xBF, 0xDC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xDF, 0xEE, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x02, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x3F, 0x60, 0xFD, 0x80, 0x76, 0x01, 0xDC, 0x07, 0x70, 0x1C,
  0xC0, 0x73, 0x81, 0xC7, 0x07, 0x1F, 0xFC, 0x1F, 0xE0, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFC, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F, 0xFC, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC6, 0xFB, 0xEE, 0x00, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0xE3, 0x8E, 0x70, 0xE6, 0x0E, 0xE0, 0xEC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0,
  0xE7, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE1, 0x8E, 0x1C, 0xE0, 0xCE, 0x0E,
  0xE0, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0xFF, 0xF8, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFB, 0x00, 0xFD, 0x80,
  0xFF, 0xC0, 0x6F, 0xB0, 0x37, 0xD8, 0x1B, 0xEC, 0x19, 0xF7, 0x0C, 0xF9,
  0x86, 0x7C, 0xC7, 0x3E, 0x63, 0x1F, 0x19, 0x8F, 0x8C, 0xC7, 0xC6, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x38, 0x3E, 0x1C, 0x18, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3D, 0x81, 0xFE, 0x0F, 0xB0, 0x7D, 0xC3,
  0xE6, 0x1F, 0x30, 0xF9, 0xC7, 0xC6, 0x3E, 0x39, 0xF0, 0xCF, 0x87, 0x7C,
  0x1B, 0xE0, 0xDF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0x80, 0x03, 0x80,
  0x3F, 0x81, 0xFF, 0x0E, 0x1C, 0x70, 0x39, 0xC0, 0x67, 0x01, 0xD8, 0x07,
  0x60, 0x1D, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0x80, 0x76, 0x01,
  0xD8, 0x07, 0x70, 0x19, 0xC0, 0xE3, 0x83, 0x8F, 0x1C, 0x1F, 0xE0, 0x3F,
  0x00, 0xFF, 0x3F, 0xEE, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7F, 0xFB, 0xFC, 0xF8, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0x81, 0xFF, 0x0E, 0x1E, 0x70,
  0x39, 0xC0, 0x67, 0x01, 0xD8, 0x07, 0x60, 0x1D, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0x60, 0x1D, 0x80, 0x76, 0x01, 0xD8, 0x07, 0x70, 0x19, 0xC0, 0xE3,
  0x83, 0x8F, 0x1C, 0x1F, 0xF0, 0x3F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0xEE, 0x0D, 0xC1,
  0xB8, 0x37, 0x06, 0xE1, 0xDC, 0x73, 0xFE, 0x7F, 0x0E, 0x71, 0xCE, 0x38,
  0xE7, 0x1C, 0xE1, 0x9C, 0x3B, 0x83, 0x70, 0x7E, 0x0E, 0x0E, 0x0F, 0xF7,
  0xFD, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x1F, 0x0E, 0xFF, 0xBF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0x70, 0xE7, 0xFC,
  0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0x67, 0x07, 0x38, 0x38,
  0xC1, 0xC6, 0x0C, 0x38, 0x61, 0xC7, 0x06, 0x38, 0x31, 0x81, 0xCC, 0x0E,
  0xE0, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x00, 0xE0, 0x70, 0x1B, 0x03, 0x80, 0xD8, 0x1E, 0x0E, 0xC0, 0xF0, 0x77,
  0x07, 0x83, 0x38, 0x6C, 0x18, 0xC3, 0x60, 0xC6, 0x1B, 0x8E, 0x30, 0xCC,
  0x71, 0xC6, 0x63, 0x0E, 0x73, 0x18, 0x33, 0x18, 0xC1, 0x98, 0xEE, 0x0C,
  0xC3, 0x70, 0x76, 0x1B, 0x03, 0xF0, 0xD8, 0x0F, 0x06, 0xC0, 0x78, 0x3E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x77, 0x0E,
  0x30, 0xC3, 0x8C, 0x19, 0xC1, 0x98, 0x1D, 0x80, 0xF8, 0x0F, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xD8, 0x19, 0x83, 0x9C, 0x38, 0xC3, 0x0C,
  0x70, 0xE6, 0x06, 0xE0, 0x70, 0xE0, 0x76, 0x0E, 0x70, 0xE7, 0x0C, 0x30,
  0xC3, 0x9C, 0x39, 0x81, 0x98, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x1B, 0x00, 0xDC, 0x0C, 0x60, 0x63, 0x86, 0x0C,
  0x30, 0x73, 0x81, 0xB8, 0x0E, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x06,
  0x0C, 0x3F, 0x1F, 0xE2, 0x18, 0x06, 0x01, 0xC0, 0x70, 0xFC, 0xFF, 0x71,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xF7, 0xFD, 0xF3, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x78, 0xDF, 0x9E, 0x3B, 0x83,
  0x70, 0x6C, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1B, 0x83, 0x70,
  0x6F, 0x1D, 0xBF, 0x33, 0xC0, 0x1F, 0x9F, 0x9C, 0x0C, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x84, 0xFE, 0x3F, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x19, 0xF3, 0x3F, 0x6E,
  0x3D, 0x83, 0xB0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1D,
  0x83, 0xB0, 0x77, 0x1E, 0x7E, 0xC7, 0x98, 0x1F, 0x0F, 0xE7, 0x1D, 0x83,
  0x60, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x13, 0xFC, 0x7E, 0x0F, 0x1F, 0x18, 0x38, 0x38, 0x38, 0x38, 0x7E, 0xFE,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x3E, 0x67, 0xED, 0xC7, 0xB0, 0x76, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0x7C, 0x1F, 0x83, 0xB0, 0x76, 0x0E, 0xE3, 0xCF, 0xD8, 0xF3,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x64, 0x1C, 0xFF, 0x0F, 0xC0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x7C, 0xDF, 0xBC, 0x6E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1C, 0xDF, 0x00, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80,
  0x31, 0xCC, 0x00, 0x00, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8D, 0xEE, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x06, 0xC3, 0xB1, 0xCC, 0x63, 0x38, 0xCC, 0x37,
  0x0F, 0xC3, 0xF8, 0xE6, 0x31, 0xCC, 0x73, 0x0C, 0xC3, 0xB0, 0x6C, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xDF, 0x3E, 0x6F, 0xDF, 0xB8, 0xF0,
  0xDC, 0x38, 0x6E, 0x1C, 0x3E, 0x0E, 0x1F, 0x06, 0x0F, 0x83, 0x07, 0xC1,
  0x83, 0xE0, 0xC1, 0xF0, 0x60, 0xF8, 0x30, 0x7C, 0x18, 0x3E, 0x0C, 0x1F,
  0x06, 0x0F, 0x83, 0x07, 0xDF, 0x37, 0xEE, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x1F, 0x87, 0xF9, 0xC7, 0x30, 0x76, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xB0, 0x76, 0x0C, 0xE3, 0x8F, 0xE0, 0xF8, 0xCF, 0x1B,
  0xF3, 0xC7, 0x70, 0x6E, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x83, 0x70, 0x6E, 0x1D, 0xE3, 0xB7, 0xE6, 0x78, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x3E, 0x67, 0xED, 0xC7, 0xB0, 0x76,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x1F, 0x83, 0xB0, 0x76, 0x0E,
  0xE3, 0xCF, 0xD8, 0xF3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0xCF, 0xBF, 0xC7, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x3F, 0x7F, 0xE1, 0xC0, 0xC0, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x07, 0x03, 0x03, 0x87, 0xFE, 0xFE, 0x20, 0x86, 0x18, 0xFF,
  0xF6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC7, 0xCF, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xE1, 0xF8, 0xF7, 0xED, 0xF3, 0xE0, 0xEC, 0x1D, 0x83, 0x30,
  0x67, 0x1C, 0x63, 0x8C, 0x61, 0x8C, 0x39, 0x83, 0x70, 0x6C, 0x0D, 0x81,
  0xB0, 0x1E, 0x03, 0x80, 0x70, 0xE0, 0xE1, 0xD8, 0x78, 0x76, 0x1E, 0x19,
  0x87, 0x86, 0x71, 0xE1, 0x9C, 0x6C, 0xE3, 0x33, 0x30, 0xCC, 0xCC, 0x33,
  0x33, 0x0E, 0xCC, 0xC1, 0xB3, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x38, 0x70, 0x70, 0xEE, 0x38, 0xC6, 0x1C, 0xC1, 0xB8,
  0x3E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xE0, 0x6C, 0x1D, 0xC3, 0x18, 0x63,
  0x9C, 0x37, 0x07, 0xE0, 0xEC, 0x1D, 0x83, 0x38, 0x67, 0x1C, 0x63, 0x8C,
  0x61, 0x8C, 0x3B, 0x83, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC1, 0xF0, 0x3C, 0x00, 0xFF,
  0xFC, 0x38, 0x70, 0xC3, 0x86, 0x1C, 0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x3F,
  0xFF, 0x00, 0x83, 0xC3, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x03, 0x87, 0x03, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x78, 0x3E, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x3C, 0x3E, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x78, 0x38, 0x00, 0x00,
  0x3F, 0x87, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 8, 7, 11, 2, -21 },
  { 16, 12, 21, 14, 1, -21 },
  { 48, 11, 25, 13, 1, -23 },
  { 83, 18, 22, 20, 1, -22 },
  { 133, 13, 22, 14, 1, -22 },
  { 169, 3, 7, 6, 2, -21 },
  { 172, 7, 27, 9, 1, -22 },
  { 196, 6, 27, 9, 1, -22 },
  { 217, 10, 10, 12, 1, -23 },
  { 230, 11, 14, 13, 1, -18 },
  { 250, 4, 7, 7, 1, -3 },
  { 254, 6, 2, 8, 1, -9 },
  { 256, 3, 4, 7, 2, -4 },
  { 258, 10, 22, 11, 1, -22 },
  { 286, 11, 22, 13, 1, -22 },
  { 317, 7, 21, 13, 2, -21 },
  { 336, 10, 22, 13, 1, -22 },
  { 364, 10, 22, 13, 1, -22 },
  { 392, 11, 22, 13, 1, -22 },
  { 423, 11, 21, 13, 1, -21 },
  { 452, 11, 22, 13, 1, -22 },
  { 483, 11, 21, 13, 1, -21 },
  { 512, 11, 22, 13, 1, -22 },
  { 543, 10, 22, 13, 1, -22 },
  { 571, 3, 16, 7, 2, -16 },
  { 577, 4, 20, 7, 1, -16 },
  { 587, 11, 13, 13, 1, -17 },
  { 605, 11, 9, 13, 1, -15 },
  { 618, 11, 13, 13, 1, -17 },
  { 636, 9, 22, 10, 0, -22 },
  { 661, 17, 25, 20, 1, -22 },
  { 715, 14, 21, 14, 0, -21 },
  { 752, 11, 21, 14, 2, -21 },
  { 781, 12, 22, 13, 1, -22 },
  { 814, 12, 21, 15, 2, -21 },
  { 846, 9, 21, 12, 2, -21 },
  { 870, 9, 21, 11, 2, -21 },
  { 894, 14, 22, 16, 1, -22 },
  { 933, 12, 21, 16, 2, -21 },
  { 965, 6, 21, 8, 1, -21 },
  { 981, 6, 27, 7, -1, -21 },
  { 1002, 12, 21, 13, 2, -21 },
  { 1034, 9, 21, 11, 2, -21 },
  { 1058, 17, 21, 22, 2, -21 },
  { 1103, 13, 21, 17, 2, -21 },
  { 1138, 14, 22, 17, 1, -22 },
  { 1177, 10, 21, 13, 2, -21 },
  { 1204, 14, 27, 17, 1, -22 },
  { 1252, 11, 21, 14, 2, -21 },
  { 1281, 10, 22, 12, 1, -22 },
  { 1309, 11, 21, 11, 0, -21 },
  { 1338, 12, 21, 16, 2, -21 },
  { 1370, 13, 21, 13, 0, -21 },
  { 1405, 21, 21, 22, 0, -21 },
  { 1461, 12, 21, 12, 0, -21 },
  { 1493, 12, 21, 12, 0, -21 },
  { 1525, 9, 21, 11, 1, -21 },
  { 1549, 6, 27, 9, 2, -22 },
  { 1570, 10, 22, 11, 1, -22 },
  { 1598, 6, 27, 9, 1, -22 },
  { 1619, 13, 11, 13, 0, -21 },
  { 1637, 13, 2, 13, 0, 2 },
  { 1641, 6, 5, 8, 1, -23 },
  { 1645, 10, 16, 12, 1, -16 },
  { 1665, 11, 23, 14, 2, -23 },
  { 1697, 9, 16, 10, 1, -16 },
  { 1715, 11, 23, 14, 1, -23 },
  { 1747, 10, 16, 13, 1, -16 },
  { 1767, 8, 23, 8, 0, -23 },
  { 1790, 11, 23, 14, 1, -16 },
  { 1822, 10, 23, 14, 2, -23 },
  { 1851, 3, 22, 6, 2, -22 },
  { 1860, 5, 29, 6, 0, -22 },
  { 1879, 10, 23, 12, 2, -23 },
  { 1908, 2, 23, 6, 2, -23 },
  { 1914, 17, 16, 20, 2, -16 },
  { 1948, 10, 16, 14, 2, -16 },
  { 1968, 11, 16, 13, 1, -16 },
  { 1990, 11, 23, 14, 2, -16 },
  { 2022, 11, 23, 14, 1, -16 },
  { 2054, 7, 16, 9, 2, -16 },
  { 2068, 8, 16, 10, 1, -16 },
  { 2084, 6, 20, 8, 1, -20 },
  { 2099, 10, 16, 14, 2, -16 },
  { 2119, 11, 16, 11, 0, -16 },
  { 2141, 18, 16, 18, 0, -16 },
  { 2177, 11, 16, 11, 0, -16 },
  { 2199, 11, 23, 11, 0, -16 },
  { 2231, 7, 16, 9, 1, -16 },
  { 2245, 9, 27, 11, 1, -22 },
  { 2276, 2, 30, 12, 5, -23 },
  { 2284, 9, 27, 11, 1, -22 },
  { 2315, 11, 4, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Regular30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR30PT7B_H_
