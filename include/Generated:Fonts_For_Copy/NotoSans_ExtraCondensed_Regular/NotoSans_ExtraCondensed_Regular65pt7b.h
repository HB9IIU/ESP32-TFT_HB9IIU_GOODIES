#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xC7, 0x8F, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xE7, 0x83, 0x3F, 0x1E, 0x02, 0xF8, 0x78, 0x03, 0xE1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x87, 0x80, 0x3E, 0x1E, 0x00, 0xFC, 0x78, 0x01, 0xFD, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xEF, 0xE0, 0x07, 0x8F, 0xC0,
  0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xF8, 0x07, 0x87, 0xF0, 0x1E, 0x3E,
  0xF8, 0x7B, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x08, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xE0, 0x01,
  0xE1, 0xF0, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x3C, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1F, 0x00, 0x0F,
  0x03, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3E, 0x0F,
  0x80, 0x03, 0xC0, 0xF8, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0xF0, 0x00, 0x3C,
  0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x3E, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x78,
  0x00, 0x0F, 0x03, 0xE3, 0xE0, 0x60, 0x3C, 0x0F, 0x0F, 0x07, 0xE0, 0xF0,
  0x3C, 0x3C, 0x3F, 0xC3, 0xC0, 0xF1, 0xE1, 0xFF, 0x8F, 0x83, 0xC7, 0x8F,
  0x9F, 0x1E, 0x1F, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0xF1, 0xF0, 0xF8, 0xFF,
  0xE3, 0xC7, 0x83, 0xE3, 0xFF, 0x1F, 0x1E, 0x07, 0x87, 0xF8, 0x78, 0x78,
  0x1E, 0x07, 0xC1, 0xE1, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0x81, 0xE0, 0x00,
  0x3C, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x7C, 0x00, 0x1E, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x78, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x81,
  0xE0, 0x01, 0xF0, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x1E,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0xC3, 0xE0, 0x03, 0xC0, 0x0F, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x1F, 0x0F, 0xCF,
  0xC0, 0xF8, 0x7E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0x3E, 0x3E, 0x07, 0xE3,
  0xF3, 0xF0, 0x1F, 0x1F, 0x1F, 0x80, 0xFC, 0xF8, 0xF8, 0x03, 0xE7, 0xC7,
  0xC0, 0x1F, 0xFE, 0x3E, 0x00, 0x7F, 0xE1, 0xF0, 0x01, 0xFF, 0x0F, 0x80,
  0x0F, 0xF0, 0x7C, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0xE0, 0x7E, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xFC, 0x1F, 0xE3, 0xFF, 0xF0,
  0x7F, 0xFF, 0xCF, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xC1, 0xF8, 0x1F,
  0xF8, 0x0F, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC1, 0xE0, 0xEF, 0xEF, 0x7F, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0x3C, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0xFC,
  0x3E, 0x07, 0xC1, 0xF8, 0x1E, 0x07, 0x80, 0x20, 0x30, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBE, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E,
  0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00,
  0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xBF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xFC, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x9F, 0xDF, 0x7F, 0x3F, 0xFC, 0x7D, 0xF0, 0xF9, 0xC1, 0xF1,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0x0E, 0x00, 0x7E,
  0x08, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0x80,
  0x7F, 0x0E, 0x00, 0x7E, 0x10, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x80, 0x01, 0xFD, 0xC0, 0x07, 0xF3, 0xF0, 0x3F, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0x74, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF1, 0x80,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0x81, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xA0, 0x00,
  0xFC, 0xC0, 0x07, 0xF3, 0xE0, 0x7F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x87,
  0xF0, 0x3E, 0x3F, 0xF0, 0xF9, 0xFF, 0xE3, 0xEF, 0xFF, 0xCF, 0xFE, 0xFF,
  0x3F, 0xC0, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F,
  0x01, 0xF8, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC7, 0xF0,
  0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F,
  0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x9F, 0x80, 0xFF,
  0x3F, 0x83, 0xFE, 0x3F, 0xFF, 0x7C, 0x7F, 0xFD, 0xF8, 0x7F, 0xFB, 0xE0,
  0x7F, 0xC7, 0xC0, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0xC0, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7D, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xF1, 0x80, 0x1F, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9E, 0x07, 0xE2, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0xF0, 0x1E, 0x3E, 0x03,
  0xFF, 0xC1, 0xE3, 0xC0, 0x7F, 0xFC, 0x1F, 0x3C, 0x07, 0xEF, 0xC1, 0xF7,
  0xC0, 0xF8, 0x7C, 0x0F, 0x78, 0x0F, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x7C,
  0x0F, 0x78, 0x1E, 0x07, 0xC0, 0xF7, 0x81, 0xE0, 0x7C, 0x0F, 0xF8, 0x3E,
  0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xC0, 0xFF,
  0x03, 0xC0, 0x7C, 0x0F, 0xF0, 0x3C, 0x07, 0xC0, 0xFF, 0x03, 0xC0, 0x78,
  0x0F, 0xF0, 0x3C, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x78, 0x0F, 0xF0, 0x3E,
  0x0F, 0x80, 0xFF, 0x83, 0xE0, 0xF8, 0x1F, 0xF8, 0x3E, 0x0F, 0x81, 0xEF,
  0x81, 0xE0, 0xFC, 0x1E, 0xF8, 0x1F, 0x1D, 0xC3, 0xE7, 0x81, 0xFB, 0xDE,
  0x7C, 0x78, 0x0F, 0xF9, 0xFF, 0xC7, 0xC0, 0xFF, 0x8F, 0xF8, 0x7C, 0x07,
  0xF0, 0x7F, 0x07, 0xC0, 0x1C, 0x01, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x20, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0x80, 0xFF, 0x9F, 0x00, 0x7F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00,
  0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xF8, 0x07, 0xF9,
  0xF0, 0x03, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x03, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x0E, 0x0F, 0xE0, 0x02, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x02, 0x07, 0xFE, 0x3E, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0x83, 0xFF, 0x87, 0xC0, 0x1F, 0xC3, 0xE0, 0x07, 0xF1, 0xF0,
  0x01, 0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xF3,
  0xE0, 0x03, 0xF1, 0xF0, 0x07, 0xF8, 0xF8, 0x07, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFE, 0x01, 0xF0, 0x1F, 0xC0, 0x01, 0x81, 0xFC, 0x00, 0x04, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7E,
  0x00, 0x03, 0xE3, 0xF8, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0xF8, 0x3F, 0x80,
  0x07, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x67, 0xFB,
  0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xFC, 0x04, 0x00, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8,
  0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xFB,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1E, 0xFF, 0xFE, 0x00, 0x01, 0xF7, 0xFE, 0xF8, 0x00, 0x0F,
  0xBF, 0xF7, 0xC0, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x03, 0xCF, 0xFC, 0xF0,
  0x00, 0x3E, 0x7F, 0xE7, 0xC0, 0x01, 0xF3, 0xFF, 0x3E, 0x00, 0x0F, 0x1F,
  0xF9, 0xF0, 0x00, 0xF8, 0xFF, 0xC7, 0xC0, 0x07, 0xC7, 0xFE, 0x3E, 0x00,
  0x3E, 0x3F, 0xF1, 0xF0, 0x01, 0xE1, 0xFF, 0x87, 0x80, 0x1F, 0x0F, 0xFC,
  0x3E, 0x00, 0xF8, 0x7F, 0xE1, 0xF0, 0x07, 0x83, 0xFF, 0x0F, 0x80, 0x7C,
  0x1F, 0xF8, 0x3E, 0x03, 0xE0, 0xFF, 0xC1, 0xF0, 0x1F, 0x07, 0xFE, 0x0F,
  0x80, 0xF0, 0x3F, 0xF0, 0x3C, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x7C, 0x0F,
  0xFC, 0x0F, 0x83, 0xC0, 0x7F, 0xE0, 0x7C, 0x3E, 0x03, 0xFF, 0x01, 0xF1,
  0xF0, 0x1F, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0xC0, 0x7C, 0x78, 0x07, 0xFE,
  0x01, 0xE7, 0xC0, 0x3F, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7D, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0x80, 0x0F, 0xFD, 0xF0, 0x01, 0xFF,
  0x9F, 0x00, 0x3F, 0xF3, 0xE0, 0x07, 0xFE, 0x7E, 0x00, 0xFF, 0xC7, 0xC0,
  0x1F, 0xF8, 0xFC, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE1, 0xF0, 0x0F, 0xFC,
  0x1F, 0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x7E, 0x07, 0xFE, 0x07, 0xC0,
  0xFF, 0xC0, 0xFC, 0x1F, 0xF8, 0x0F, 0x83, 0xFF, 0x01, 0xF0, 0x7F, 0xE0,
  0x1F, 0x0F, 0xFC, 0x03, 0xE1, 0xFF, 0x80, 0x7E, 0x3F, 0xF0, 0x07, 0xC7,
  0xFE, 0x00, 0xFC, 0xFF, 0xC0, 0x0F, 0x9F, 0xF8, 0x01, 0xF3, 0xFF, 0x00,
  0x3F, 0x7F, 0xE0, 0x03, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x7F, 0xF3, 0xE0, 0x1F, 0xCF,
  0x80, 0x3F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE,
  0x00, 0x7E, 0xF8, 0x03, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x03,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x03, 0xF8, 0xF8, 0x07, 0xF0, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0x03, 0xE3, 0xF8, 0x01, 0x9F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFB, 0xC0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7F,
  0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1E, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3D, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7B, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xF7, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xDF, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x3E, 0x00, 0xFC, 0x07,
  0xC0, 0x1E, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xC3, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x87, 0xC0, 0x7C, 0x00, 0xF8,
  0x1F, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0x7C, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xE0, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3E,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0,
  0x07, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x0F, 0x3F, 0x00, 0x03, 0xE7, 0xC0,
  0x1F, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x00, 0x07, 0xDE, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xF8,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7C,
  0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0x03, 0xF8, 0x20,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x81, 0xF7,
  0xF0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE,
  0x01, 0xFD, 0xF0, 0x0F, 0xEF, 0xC0, 0xFF, 0x7F, 0xFE, 0xF9, 0xFF, 0xF3,
  0xC7, 0xFF, 0x1E, 0x1F, 0xE0, 0xF0, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0xE0, 0x7C, 0x7F, 0xF0, 0xF9, 0xFF, 0xF1, 0xF7, 0xFF,
  0xE3, 0xEF, 0x0F, 0xE7, 0xF8, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F,
  0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7D, 0xFC, 0x00, 0xFB, 0xF8, 0x03,
  0xF7, 0xF8, 0x0F, 0xCF, 0xFC, 0x3F, 0x9F, 0x7F, 0xFE, 0x3E, 0x7F, 0xFC,
  0x7C, 0x7F, 0xF0, 0xF8, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0xE3, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x04, 0xFF, 0x07, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x08,
  0x07, 0xC0, 0xFF, 0x0F, 0x87, 0xFF, 0x1F, 0x1F, 0xFF, 0x3E, 0x3F, 0xFF,
  0x7C, 0xFE, 0x1F, 0xF9, 0xF8, 0x0F, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F,
  0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x01, 0xFD, 0xF8, 0x03,
  0xF9, 0xF8, 0x0F, 0xF3, 0xF8, 0x3F, 0xE3, 0xFF, 0xF7, 0xC7, 0xFF, 0xCF,
  0x87, 0xFF, 0x1F, 0x07, 0xFC, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x41, 0xFC, 0x07, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0x08, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xF8, 0x7C, 0x3F, 0xF8, 0xF8, 0x7F, 0xF9, 0xF1, 0xFF,
  0xFB, 0xE7, 0xF0, 0xF7, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00,
  0xFE, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0xC1, 0xDF, 0x1F, 0xFF, 0xBE, 0x3F, 0xFE,
  0x7C, 0x3F, 0xF8, 0xF8, 0x3F, 0xE1, 0xF0, 0x0F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCC, 0x00, 0x3F, 0x1F,
  0x01, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x0B, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x20, 0x0F, 0x87, 0xF8, 0x3E, 0x3F,
  0xF8, 0xF9, 0xFF, 0xE3, 0xEF, 0xFF, 0xCF, 0xBC, 0x7F, 0xBF, 0xC0, 0x7E,
  0xFE, 0x01, 0xFB, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x7B, 0xFF, 0xFF, 0xFF,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x03, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFA, 0x3F, 0x7F, 0xEF, 0xF9, 0xFE, 0x3F, 0x81, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0,
  0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xE0, 0x0F, 0xBF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x7E, 0x03, 0xFC, 0xF8, 0x0F, 0xE3, 0xF0,
  0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E,
  0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x08,
  0x00, 0x08, 0x0F, 0x87, 0xF8, 0x0F, 0xF0, 0xF9, 0xFF, 0xC1, 0xFF, 0x8F,
  0x9F, 0xFE, 0x3F, 0xFC, 0xFB, 0xFF, 0xE7, 0xFF, 0xEF, 0xF8, 0x7F, 0x78,
  0xFE, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x80,
  0x1F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80,
  0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80,
  0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0C, 0x03, 0xE1, 0xFE, 0x0F, 0x8F, 0xFE,
  0x3E, 0x7F, 0xF8, 0xFB, 0xFF, 0xF3, 0xFF, 0x1F, 0xEF, 0xF0, 0x1F, 0xBF,
  0x80, 0x7E, 0xFE, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0xFF, 0x03,
  0xE3, 0xFF, 0x87, 0xCF, 0xFF, 0x8F, 0xBF, 0xFF, 0x1F, 0x78, 0x7F, 0x3F,
  0xC0, 0x7E, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xEF, 0xE0, 0x07, 0xDF, 0xC0, 0x1F, 0xBF, 0xC0, 0x7E, 0x7D,
  0xE1, 0xFC, 0xFB, 0xFF, 0xF1, 0xF3, 0xFF, 0xE3, 0xE3, 0xFF, 0x87, 0xC3,
  0xFE, 0x0F, 0x80, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xF8, 0x7C, 0x3F, 0xF8, 0xF8, 0x7F, 0xF9, 0xF1,
  0xFF, 0xFB, 0xE7, 0xF0, 0xF7, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0x7F, 0x7E,
  0x00, 0xFE, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0xC1, 0xDF, 0x1F, 0xFF, 0xBE, 0x3F,
  0xFE, 0x7C, 0x3F, 0xF8, 0xF8, 0x3F, 0xE1, 0xF0, 0x0F, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x19, 0xE0, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0x9F, 0x81, 0xE7, 0xC0, 0x13, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFB,
  0xE0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x03,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0xBF, 0x01, 0xFD, 0xFC, 0x3D, 0xE7, 0xFF,
  0xEF, 0x3F, 0xFE, 0x78, 0xFF, 0xE3, 0xC3, 0xFE, 0x1E, 0x01, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xC0, 0x0F, 0xBF,
  0x00, 0x7F, 0x00, 0x3E, 0x7C, 0x01, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xF8,
  0x07, 0xE7, 0xC0, 0x3F, 0xE0, 0x1F, 0x1F, 0x00, 0xF7, 0x80, 0x7C, 0x7E,
  0x03, 0xDE, 0x01, 0xF0, 0xF8, 0x0F, 0x7C, 0x07, 0xC3, 0xE0, 0x3D, 0xF0,
  0x3E, 0x0F, 0x81, 0xF3, 0xC0, 0xF8, 0x3E, 0x07, 0xCF, 0x03, 0xE0, 0xFC,
  0x1E, 0x3C, 0x0F, 0x81, 0xF0, 0x78, 0xF8, 0x3E, 0x07, 0xC1, 0xE3, 0xE1,
  0xF0, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x7C, 0x3E, 0x1E, 0x1F, 0x00, 0xF8,
  0xF0, 0x78, 0x7C, 0x03, 0xE3, 0xC1, 0xF1, 0xE0, 0x0F, 0x8F, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x3C, 0xF8, 0x01, 0xE7,
  0x80, 0xF3, 0xE0, 0x07, 0xDE, 0x03, 0xCF, 0x00, 0x1F, 0x78, 0x0F, 0x3C,
  0x00, 0x7D, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFD, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0,
  0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x47, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFC, 0x07,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 47, 15, 4, -46 },
  { 43, 17, 16, 25, 4, -46 },
  { 77, 28, 46, 30, 1, -46 },
  { 238, 22, 53, 28, 3, -49 },
  { 384, 38, 48, 43, 3, -47 },
  { 612, 29, 48, 31, 2, -47 },
  { 786, 6, 16, 14, 4, -46 },
  { 798, 14, 57, 19, 3, -47 },
  { 898, 14, 57, 19, 2, -47 },
  { 998, 21, 21, 26, 2, -49 },
  { 1054, 24, 30, 28, 2, -38 },
  { 1144, 9, 16, 15, 2, -7 },
  { 1162, 14, 5, 18, 2, -20 },
  { 1171, 7, 9, 15, 4, -8 },
  { 1179, 22, 47, 24, 1, -47 },
  { 1309, 22, 48, 28, 3, -47 },
  { 1441, 15, 46, 28, 4, -46 },
  { 1528, 23, 47, 28, 2, -47 },
  { 1664, 23, 48, 28, 2, -47 },
  { 1802, 26, 47, 28, 1, -47 },
  { 1955, 22, 47, 28, 3, -46 },
  { 2085, 22, 48, 28, 3, -47 },
  { 2217, 24, 46, 28, 2, -46 },
  { 2355, 24, 48, 28, 2, -47 },
  { 2499, 23, 48, 28, 2, -47 },
  { 2637, 7, 36, 15, 4, -35 },
  { 2669, 9, 44, 15, 2, -35 },
  { 2719, 24, 29, 28, 2, -38 },
  { 2806, 24, 18, 28, 2, -32 },
  { 2860, 24, 29, 28, 2, -38 },
  { 2947, 18, 48, 21, 1, -47 },
  { 3055, 36, 52, 42, 3, -47 },
  { 3289, 29, 46, 29, 0, -46 },
  { 3456, 23, 46, 31, 5, -46 },
  { 3589, 24, 48, 29, 3, -47 },
  { 3733, 25, 46, 34, 5, -46 },
  { 3877, 18, 46, 26, 5, -46 },
  { 3981, 18, 46, 25, 5, -46 },
  { 4085, 29, 48, 35, 3, -47 },
  { 4259, 25, 46, 35, 5, -46 },
  { 4403, 14, 46, 18, 2, -46 },
  { 4484, 13, 59, 15, -3, -46 },
  { 4580, 24, 46, 29, 5, -46 },
  { 4718, 18, 46, 24, 5, -46 },
  { 4822, 37, 46, 47, 5, -46 },
  { 5035, 27, 46, 37, 5, -46 },
  { 5191, 30, 48, 36, 3, -47 },
  { 5371, 22, 46, 29, 5, -46 },
  { 5498, 30, 58, 36, 3, -47 },
  { 5716, 24, 46, 30, 5, -46 },
  { 5854, 22, 48, 27, 2, -47 },
  { 5986, 23, 46, 25, 1, -46 },
  { 6119, 26, 47, 34, 4, -46 },
  { 6272, 29, 46, 29, 0, -46 },
  { 6439, 47, 46, 47, 0, -46 },
  { 6710, 26, 46, 26, 0, -46 },
  { 6860, 25, 46, 25, 0, -46 },
  { 7004, 20, 46, 23, 2, -46 },
  { 7119, 13, 57, 20, 5, -47 },
  { 7212, 22, 47, 24, 1, -47 },
  { 7342, 14, 57, 20, 2, -47 },
  { 7442, 27, 24, 29, 1, -46 },
  { 7523, 29, 4, 28, 0, 5 },
  { 7538, 12, 11, 17, 3, -50 },
  { 7555, 21, 37, 27, 2, -36 },
  { 7653, 23, 50, 30, 4, -49 },
  { 7797, 18, 37, 23, 3, -36 },
  { 7881, 23, 50, 30, 3, -49 },
  { 8025, 22, 36, 27, 3, -35 },
  { 8124, 17, 50, 16, 1, -50 },
  { 8231, 23, 52, 30, 3, -36 },
  { 8381, 22, 49, 30, 4, -49 },
  { 8516, 6, 48, 14, 4, -48 },
  { 8552, 11, 64, 14, -1, -48 },
  { 8640, 22, 49, 26, 4, -49 },
  { 8775, 5, 49, 14, 4, -49 },
  { 8806, 36, 36, 44, 4, -36 },
  { 8968, 22, 36, 30, 4, -36 },
  { 9067, 23, 37, 29, 3, -36 },
  { 9174, 23, 52, 30, 4, -36 },
  { 9324, 23, 52, 30, 3, -36 },
  { 9474, 15, 36, 20, 4, -36 },
  { 9542, 18, 37, 22, 2, -36 },
  { 9626, 15, 44, 17, 1, -43 },
  { 9709, 21, 36, 30, 4, -35 },
  { 9804, 24, 35, 24, 0, -35 },
  { 9909, 38, 35, 39, 1, -35 },
  { 10076, 22, 35, 24, 1, -35 },
  { 10173, 24, 51, 24, 0, -35 },
  { 10326, 16, 35, 20, 2, -35 },
  { 10396, 18, 57, 24, 3, -47 },
  { 10525, 5, 65, 26, 11, -50 },
  { 10566, 18, 57, 24, 3, -47 },
  { 10695, 24, 8, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Regular65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR65PT7B_H_
