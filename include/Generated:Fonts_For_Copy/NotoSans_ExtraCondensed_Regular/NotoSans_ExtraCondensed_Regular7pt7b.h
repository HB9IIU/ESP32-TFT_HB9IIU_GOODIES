#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x7D, 0x5C, 0x79, 0x3C, 0xDE, 0xF7, 0x50, 0xD9, 0x5E,
  0xC0, 0x6A, 0x90, 0x95, 0x60, 0xF8, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x29,
  0x48, 0xD6, 0xDC, 0x75, 0x40, 0xC5, 0x2E, 0xE5, 0x1E, 0x4A, 0xF2, 0x53,
  0x9C, 0x53, 0xDE, 0xE5, 0x24, 0xF5, 0x5E, 0xD7, 0x9C, 0x90, 0x98, 0x71,
  0x80, 0xFC, 0xC7, 0x00, 0xD6, 0x80, 0x7B, 0xFF, 0x86, 0x4A, 0xFA, 0xFF,
  0xC0, 0x72, 0x46, 0xFF, 0xC0, 0xEA, 0xC0, 0xEA, 0x80, 0x72, 0xD6, 0xFF,
  0xC0, 0xEA, 0xC0, 0xFC, 0xEA, 0xC0, 0xF8, 0x9B, 0xBD, 0xD0, 0xFF, 0xC0,
  0x69, 0x99, 0x60, 0xFE, 0x80, 0x69, 0x99, 0x62, 0xFE, 0xC0, 0xF1, 0x1C,
  0xE9, 0x24, 0xB6, 0xD6, 0xB6, 0xA4, 0xAD, 0x76, 0xA5, 0x00, 0xA9, 0x6A,
  0xB9, 0x24, 0xD6, 0xC0, 0xEA, 0xB0, 0x91, 0x22, 0xD5, 0x70, 0x56, 0x80,
  0xE0, 0xC0, 0x5F, 0x9E, 0xDE, 0x6B, 0x2E, 0xDE, 0x57, 0x70, 0xFA, 0x80,
  0x76, 0xF3, 0x80, 0x9E, 0xDA, 0xF8, 0xFE, 0x97, 0x6A, 0xF8, 0xDB, 0xBB,
  0xF6, 0xD0, 0x56, 0xF0, 0xF6, 0xF9, 0x00, 0x76, 0xF2, 0x40, 0xEA, 0xE7,
  0xBA, 0xC0, 0xB6, 0xF0, 0xB9, 0x20, 0xBB, 0x75, 0xA9, 0x70, 0xB9, 0x25,
  0x00, 0xDB, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 3, 0, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 5, 5, 0, -5 },
  { 10, 3, 5, 3, 0, -5 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 3, 2, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 2, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 3, 5, 3, 0, -5 },
  { 25, 3, 5, 3, 0, -5 },
  { 27, 2, 5, 3, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 1, 4, 2, 0, -4 },
  { 46, 1, 5, 2, 0, -4 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 2, 5, 2, 0, -5 },
  { 54, 4, 6, 5, 0, -5 },
  { 57, 3, 5, 3, 0, -5 },
  { 59, 2, 5, 3, 1, -5 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 2, 5, 4, 1, -5 },
  { 65, 2, 5, 3, 1, -5 },
  { 67, 2, 5, 3, 1, -5 },
  { 69, 3, 5, 4, 0, -5 },
  { 71, 2, 5, 4, 1, -5 },
  { 73, 2, 5, 2, 0, -5 },
  { 75, 1, 6, 2, 0, -5 },
  { 76, 2, 5, 3, 1, -5 },
  { 78, 1, 5, 3, 1, -5 },
  { 79, 4, 5, 5, 1, -5 },
  { 82, 2, 5, 4, 1, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 2, 5, 3, 1, -5 },
  { 89, 4, 6, 4, 0, -5 },
  { 92, 2, 5, 3, 1, -5 },
  { 94, 3, 5, 3, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 3, 5, 4, 0, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 5, 5, 5, 0, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 2, 5, 3, 0, -5 },
  { 112, 2, 6, 2, 0, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 2, 6, 2, 0, -5 },
  { 118, 3, 3, 3, 0, -5 },
  { 120, 3, 1, 3, 0, 0 },
  { 121, 2, 1, 2, 0, -5 },
  { 122, 2, 4, 3, 0, -4 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 2, 4, 2, 0, -4 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 3, 4, 3, 0, -4 },
  { 130, 2, 5, 2, 0, -5 },
  { 132, 3, 6, 3, 0, -4 },
  { 135, 3, 5, 3, 0, -5 },
  { 137, 1, 5, 1, 0, -5 },
  { 138, 1, 7, 1, 0, -5 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 1, 5, 1, 0, -5 },
  { 142, 4, 4, 5, 0, -4 },
  { 144, 3, 4, 3, 0, -4 },
  { 146, 3, 4, 3, 0, -4 },
  { 148, 3, 6, 3, 0, -4 },
  { 151, 3, 6, 3, 0, -4 },
  { 154, 2, 4, 2, 0, -4 },
  { 155, 2, 4, 2, 0, -4 },
  { 156, 2, 5, 2, 0, -5 },
  { 158, 3, 4, 3, 0, -4 },
  { 160, 3, 4, 3, 0, -4 },
  { 162, 4, 4, 4, 0, -4 },
  { 164, 3, 4, 3, 0, -4 },
  { 166, 3, 6, 3, 0, -4 },
  { 169, 2, 4, 2, 0, -4 },
  { 170, 2, 6, 3, 0, -5 },
  { 172, 1, 7, 3, 1, -5 },
  { 173, 2, 6, 3, 0, -5 },
  { 175, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Regular7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR7PT7B_H_
