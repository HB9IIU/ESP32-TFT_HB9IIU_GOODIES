#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x01, 0xEF, 0xFF, 0xFE, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x30, 0x07, 0x0E, 0x0F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x70, 0xE0, 0x0C, 0x1C, 0x01, 0x83,
  0x80, 0x70, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x07, 0x00, 0xE0, 0xC0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70,
  0x06, 0x0E, 0x01, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0x79, 0x84, 0xF1, 0x80, 0xE1,
  0x80, 0xE1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0xF1, 0x80, 0x79, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xBE, 0x01,
  0x9E, 0x01, 0x8E, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8E, 0x01, 0x8E, 0xC1,
  0x9E, 0xFD, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0xC0,
  0x1C, 0x07, 0xF8, 0x0E, 0x01, 0xCE, 0x03, 0x80, 0x63, 0xC0, 0xE0, 0x38,
  0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x03, 0x87, 0x07, 0x00, 0xE1, 0xC3, 0x80,
  0x38, 0x70, 0xE0, 0x0E, 0x1C, 0x38, 0x03, 0x87, 0x1C, 0x00, 0xE1, 0xC7,
  0x00, 0x38, 0x71, 0xC7, 0x0E, 0x1C, 0xE3, 0xF3, 0x87, 0x39, 0xFE, 0x61,
  0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xE7, 0xF9, 0xCE, 0x1C, 0xFC, 0xE3, 0x87,
  0x0C, 0x38, 0xE1, 0xC0, 0x0E, 0x38, 0x70, 0x07, 0x0E, 0x1C, 0x01, 0xC3,
  0x87, 0x00, 0x70, 0xE1, 0xC0, 0x38, 0x38, 0x70, 0x0E, 0x0E, 0x1C, 0x03,
  0x83, 0x87, 0x01, 0xC0, 0xE1, 0xC0, 0x70, 0x38, 0xE0, 0x1C, 0x07, 0xF8,
  0x0E, 0x01, 0xFC, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xE3, 0x80, 0x0E, 0x1E, 0x00, 0x70,
  0xF0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x8E, 0x00,
  0x3C, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x38, 0x79, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x3C, 0xF1, 0xC0, 0xF7, 0x1E, 0x07, 0xF8, 0xF0, 0x1F,
  0xC7, 0x80, 0xFC, 0x3C, 0x03, 0xE0, 0xE0, 0x1F, 0x07, 0x81, 0xFC, 0x3E,
  0x1F, 0xE0, 0xFF, 0xE7, 0x87, 0xFE, 0x3E, 0x1F, 0xE0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xEE, 0xEE, 0xE0, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0xC3, 0x0F, 0xED, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0x01,
  0xCE, 0x0F, 0x3C, 0x78, 0x78, 0xE1, 0xC0, 0x84, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3D, 0xF7, 0x9E, 0x79, 0xC7, 0x3C,
  0xE3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBF, 0xEF, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC3, 0xC7, 0x8F, 0x07, 0x9E,
  0x0F, 0x38, 0x0F, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3D, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xC7, 0x8F, 0x0F, 0xFE, 0x0F, 0xF8,
  0x0F, 0xE0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0x7F, 0x9F, 0xC7,
  0x63, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xFC, 0x78, 0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x7F, 0xC1, 0xFF, 0xE7, 0xFF, 0xCE, 0x07, 0xC8, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xD8, 0x0F, 0xBF, 0xFE, 0x7F, 0xF8,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x37, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0xF0,
  0x1C, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x78, 0x0F, 0xFE, 0x3F, 0xFE, 0x3E, 0xFE, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xEC, 0x0F, 0xDF, 0xFF, 0x3F, 0xFC,
  0x3F, 0xF0, 0x00, 0x30, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x7E, 0x3D, 0xFE, 0x7F, 0xFE, 0xFC, 0x3D, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0xC0, 0xF7, 0x81, 0xE7, 0x87, 0x8F, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3C, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1C,
  0x78, 0x3C, 0x3C, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x3E, 0xF8, 0x78, 0x7C, 0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0x78, 0x3E,
  0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x01, 0x00, 0x1F, 0xC0, 0xFF, 0xC1,
  0xFF, 0xC7, 0x87, 0x8E, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x3E, 0xF8, 0xFD, 0xFF, 0xF9, 0xFE, 0xF1, 0xF9, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xF7, 0xBF, 0xEF, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x7F, 0xDE, 0x79,
  0xE7, 0xDE, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x7D, 0xE7, 0x9E, 0x71, 0xCF, 0x38, 0xE3, 0x80, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x07, 0xFC, 0xFF, 0xEF, 0xFE, 0x41, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0xF0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x38, 0x06, 0x07, 0x1C, 0x1F,
  0xE3, 0x9C, 0x1F, 0xF0, 0xEE, 0x1E, 0x38, 0x77, 0x0E, 0x1C, 0x3B, 0x87,
  0x0E, 0x1F, 0x87, 0x07, 0x0F, 0xC3, 0x83, 0x87, 0xE1, 0xC1, 0xC3, 0xF0,
  0xE0, 0xE1, 0xF8, 0x70, 0xF0, 0xFC, 0x38, 0x78, 0x7E, 0x1C, 0x3C, 0x3F,
  0x0E, 0x1E, 0x1F, 0x87, 0x0F, 0x1D, 0xC1, 0xCD, 0x8E, 0x70, 0xFE, 0xFF,
  0x38, 0x3E, 0x3F, 0x1C, 0x0E, 0x0E, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x0F, 0x80,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xDC, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x78, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x01, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9E, 0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xCF, 0x01, 0xE7, 0x87,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x78, 0x1F, 0x3C, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x07, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF1, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1,
  0xF8, 0x30, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x18, 0x3F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC3, 0xF8, 0xF0,
  0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03,
  0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x80, 0xE1, 0xF0,
  0x02, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF8,
  0x0F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xDF,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xFB, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0xF7, 0xFB, 0xF9, 0xFC, 0x78, 0x00, 0xF0, 0x0F, 0xF8, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7E, 0xF0, 0x3E, 0x78,
  0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7B,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0x7F, 0xF0, 0x01, 0xDF, 0xFC, 0x00, 0x77, 0xF7, 0x00,
  0x3F, 0xFD, 0xC0, 0x0E, 0xFF, 0x78, 0x03, 0xBF, 0xCE, 0x01, 0xEF, 0xF3,
  0x80, 0x73, 0xFC, 0xF0, 0x1C, 0xFF, 0x3C, 0x07, 0x3F, 0xC7, 0x03, 0xCF,
  0xF1, 0xC0, 0xE3, 0xFC, 0x78, 0x38, 0xFF, 0x0E, 0x1E, 0x3F, 0xC3, 0x87,
  0x0F, 0xF0, 0xF1, 0xC3, 0xFC, 0x3C, 0x70, 0xFF, 0x07, 0x3C, 0x3F, 0xC1,
  0xCE, 0x0F, 0xF0, 0x7B, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x3F,
  0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x07, 0xC0, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xF7,
  0x80, 0xFE, 0xF0, 0x1F, 0xCE, 0x03, 0xF9, 0xE0, 0x7F, 0x1C, 0x0F, 0xE3,
  0xC1, 0xFC, 0x78, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x0E, 0x1F, 0xC1,
  0xE3, 0xF8, 0x1C, 0x7F, 0x03, 0xCF, 0xE0, 0x79, 0xFC, 0x07, 0xBF, 0x80,
  0xF7, 0xF0, 0x0E, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF0, 0x7C, 0x1F, 0x01, 0xE0,
  0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x38, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x3C,
  0x0F, 0x87, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xF0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x07, 0x8F, 0x80, 0x3C,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x38, 0x00,
  0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x87, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1E, 0x1F, 0x8F,
  0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x1E, 0x1E, 0x0F, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0x01,
  0xC0, 0x1F, 0xF8, 0xFF, 0xF9, 0xFF, 0xE7, 0xC1, 0xDF, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE8, 0x03, 0xDC, 0x1F, 0xBF, 0xFE, 0x7F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0xE1, 0xF1, 0xFF,
  0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x07, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x70, 0x03, 0xC0, 0x0F, 0x78, 0x03, 0xE0,
  0x0F, 0x78, 0x03, 0xE0, 0x0E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0,
  0x1E, 0x38, 0x07, 0xE0, 0x1E, 0x3C, 0x07, 0xF0, 0x1E, 0x3C, 0x07, 0x70,
  0x1C, 0x3C, 0x0F, 0x70, 0x3C, 0x3C, 0x0E, 0x70, 0x3C, 0x1C, 0x0E, 0x70,
  0x3C, 0x1C, 0x0E, 0x78, 0x3C, 0x1E, 0x0E, 0x78, 0x38, 0x1E, 0x1E, 0x38,
  0x78, 0x1E, 0x1E, 0x38, 0x78, 0x0E, 0x1C, 0x38, 0x78, 0x0E, 0x1C, 0x3C,
  0x78, 0x0F, 0x1C, 0x3C, 0x70, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0x3C, 0x1C,
  0xF0, 0x07, 0x38, 0x1C, 0xF0, 0x07, 0x38, 0x1C, 0xF0, 0x07, 0xB8, 0x1E,
  0xE0, 0x07, 0xB8, 0x0E, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x70, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x80, 0xE1,
  0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xB8, 0x01, 0xCF, 0x00, 0xF3,
  0xC0, 0x38, 0x70, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0F, 0xF0, 0x07, 0xDC,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xE0, 0x70, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x00, 0xE3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x38, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x73, 0x80, 0x3C,
  0xF0, 0x0E, 0x1C, 0x07, 0x87, 0x81, 0xC0, 0xE0, 0xF0, 0x3C, 0x38, 0x07,
  0x1E, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x03, 0x01, 0x80, 0xFF, 0x87, 0xFF, 0x0F, 0x7E, 0x20, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xC7, 0xFF, 0x3F, 0xFD,
  0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFD, 0xDF, 0xE7, 0x3F, 0x1C, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x80, 0xF3, 0xF0, 0xF7, 0xF8, 0xEF, 0xFC, 0xFC,
  0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF8, 0x1E, 0xFC, 0x3E, 0xEF,
  0xFC, 0xE7, 0xF8, 0xE3, 0xF0, 0x01, 0x80, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7,
  0xC1, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x08, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x02, 0x0F, 0x1F, 0xCF, 0x3F, 0xEF, 0x3F, 0xFF,
  0x7C, 0x3F, 0x78, 0x1F, 0x70, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F, 0x78, 0x1F, 0x7C, 0x3F,
  0x3F, 0xF7, 0x1F, 0xE7, 0x0F, 0xC7, 0x01, 0x00, 0x1F, 0xC0, 0x7F, 0xC1,
  0xF7, 0xC7, 0x83, 0xCF, 0x03, 0x9C, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x8F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xEF, 0xFE, 0xFF,
  0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0x00, 0x0F, 0xC7,
  0x1F, 0xE7, 0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0x70, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F,
  0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x40, 0x3E,
  0x7D, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xC0, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE1, 0x83, 0xDF, 0xC7, 0xFF, 0xCE, 0xFF, 0xDF, 0x87, 0xBE, 0x07,
  0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C,
  0xEF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0xFE, 0xFE, 0xFC,
  0x70, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xF7, 0x83, 0xCF,
  0x07, 0x9E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xDE,
  0x07, 0x3C, 0x0E, 0xF8, 0x1D, 0xF8, 0x3F, 0xF0, 0x7C, 0xE0, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0x8F, 0x07, 0x1E, 0x0F, 0x3C, 0x1E, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x30, 0x73, 0xF8, 0x7F, 0x3B, 0xFE, 0x7F, 0xDD, 0xFF, 0x7F, 0xEF, 0x83,
  0xF0, 0xF7, 0xC1, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0,
  0x1C, 0x07, 0xF8, 0x0E, 0x03, 0xFC, 0x07, 0x01, 0xFE, 0x03, 0x80, 0xFF,
  0x01, 0xC0, 0x7F, 0x80, 0xE0, 0x3F, 0xC0, 0x70, 0x1F, 0xE0, 0x38, 0x0F,
  0xF0, 0x1C, 0x07, 0xF8, 0x0E, 0x03, 0xFC, 0x07, 0x01, 0xFE, 0x03, 0x80,
  0xFF, 0x01, 0xC0, 0x7F, 0x80, 0xE0, 0x3F, 0xC0, 0x70, 0x1F, 0xE0, 0x38,
  0x0F, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0xC1, 0xCF, 0xE3, 0xBF, 0xE7, 0x7F,
  0xEF, 0x83, 0xDF, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1E, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xC0, 0xE3, 0xF0, 0xE7, 0xF8,
  0xEF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF8, 0x1E,
  0xFC, 0x3C, 0xEF, 0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x0F, 0xC7, 0x1F, 0xE7,
  0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0x70, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F, 0x78, 0x1F,
  0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0xF8, 0xFE, 0x7F, 0xBF, 0xEE,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0x00, 0xFF, 0x8F, 0xFE, 0xFF, 0xE7, 0x81, 0x38, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0xF0, 0x7B, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0x1F, 0xC3, 0xF0, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x87,
  0xEF, 0xFF, 0xDF, 0xF7, 0x8F, 0xC7, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C,
  0x1C, 0x3C, 0x1C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x1F, 0x01, 0xEE, 0x03, 0xE0,
  0x39, 0xE0, 0x7C, 0x07, 0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xF8, 0x3C, 0x70,
  0x77, 0x07, 0x8E, 0x0E, 0xE0, 0xE1, 0xE1, 0xDC, 0x1C, 0x3C, 0x3B, 0x87,
  0x87, 0x87, 0x38, 0xF0, 0x71, 0xE7, 0x1C, 0x0E, 0x38, 0xE3, 0x81, 0xE7,
  0x1C, 0x70, 0x3C, 0xE3, 0x9E, 0x03, 0x9C, 0x7B, 0xC0, 0x77, 0x87, 0x70,
  0x0E, 0xE0, 0xEE, 0x01, 0xDC, 0x1D, 0xC0, 0x3F, 0x83, 0xB8, 0x03, 0xF0,
  0x7F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7,
  0x83, 0x8E, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0x70, 0x1E, 0xF0, 0x38,
  0xE0, 0xF1, 0xE1, 0xC3, 0xC7, 0x83, 0xCF, 0x07, 0xBC, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x38, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x3F, 0x07, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0xFC, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xF0, 0x0F, 0x03, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x1C, 0x00, 0xBF, 0xC0, 0x7F,
  0xF8, 0xFE, 0xFF, 0xFC, 0x0F, 0xF4, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 32, 11, 3, -32 },
  { 21, 11, 11, 17, 3, -32 },
  { 37, 19, 32, 21, 1, -32 },
  { 113, 16, 37, 19, 2, -34 },
  { 187, 26, 33, 30, 2, -33 },
  { 295, 21, 33, 21, 1, -33 },
  { 382, 4, 11, 9, 3, -32 },
  { 388, 10, 39, 13, 2, -32 },
  { 437, 10, 39, 13, 1, -32 },
  { 486, 14, 15, 18, 2, -34 },
  { 513, 17, 21, 19, 1, -26 },
  { 558, 6, 11, 10, 2, -5 },
  { 567, 10, 4, 12, 1, -14 },
  { 572, 5, 5, 10, 3, -5 },
  { 576, 15, 32, 17, 1, -32 },
  { 636, 15, 33, 19, 2, -33 },
  { 698, 10, 32, 19, 3, -32 },
  { 738, 16, 33, 19, 1, -33 },
  { 804, 15, 33, 19, 2, -33 },
  { 866, 18, 32, 19, 1, -32 },
  { 938, 15, 32, 19, 2, -32 },
  { 998, 15, 33, 19, 2, -33 },
  { 1060, 17, 32, 19, 1, -32 },
  { 1128, 16, 33, 19, 2, -33 },
  { 1194, 15, 33, 19, 2, -33 },
  { 1256, 5, 24, 10, 3, -24 },
  { 1271, 6, 30, 10, 2, -24 },
  { 1294, 17, 20, 19, 1, -26 },
  { 1337, 17, 13, 19, 1, -22 },
  { 1365, 17, 20, 19, 1, -26 },
  { 1408, 12, 33, 14, 1, -33 },
  { 1458, 25, 36, 29, 2, -32 },
  { 1571, 20, 32, 20, 0, -32 },
  { 1651, 17, 32, 21, 3, -32 },
  { 1719, 17, 33, 20, 2, -33 },
  { 1790, 18, 32, 23, 3, -32 },
  { 1862, 13, 32, 18, 3, -32 },
  { 1914, 13, 32, 17, 3, -32 },
  { 1966, 20, 33, 25, 2, -33 },
  { 2049, 18, 32, 24, 3, -32 },
  { 2121, 9, 32, 13, 2, -32 },
  { 2157, 9, 41, 10, -2, -32 },
  { 2204, 17, 32, 20, 3, -32 },
  { 2272, 13, 32, 17, 3, -32 },
  { 2324, 26, 32, 32, 3, -32 },
  { 2428, 19, 32, 26, 3, -32 },
  { 2504, 21, 33, 25, 2, -33 },
  { 2591, 16, 32, 20, 3, -32 },
  { 2655, 21, 41, 25, 2, -33 },
  { 2763, 17, 32, 21, 3, -32 },
  { 2831, 15, 33, 19, 2, -33 },
  { 2893, 17, 32, 17, 0, -32 },
  { 2961, 17, 32, 23, 3, -32 },
  { 3029, 20, 32, 20, 0, -32 },
  { 3109, 32, 32, 32, 0, -32 },
  { 3237, 18, 32, 18, 0, -32 },
  { 3309, 18, 32, 18, 0, -32 },
  { 3381, 14, 32, 16, 1, -32 },
  { 3437, 10, 39, 14, 3, -32 },
  { 3486, 15, 32, 17, 1, -32 },
  { 3546, 10, 39, 14, 1, -32 },
  { 3595, 18, 17, 20, 1, -32 },
  { 3634, 20, 3, 20, 0, 4 },
  { 3642, 8, 7, 12, 2, -34 },
  { 3649, 14, 25, 19, 2, -25 },
  { 3693, 16, 34, 21, 3, -34 },
  { 3761, 13, 25, 16, 2, -25 },
  { 3802, 16, 34, 21, 2, -34 },
  { 3870, 15, 25, 19, 2, -25 },
  { 3917, 12, 34, 11, 0, -34 },
  { 3968, 16, 36, 21, 2, -25 },
  { 4040, 15, 34, 21, 3, -34 },
  { 4104, 4, 33, 10, 3, -33 },
  { 4121, 8, 44, 10, -1, -33 },
  { 4165, 15, 34, 18, 3, -34 },
  { 4229, 4, 34, 9, 3, -34 },
  { 4246, 25, 25, 31, 3, -25 },
  { 4325, 15, 25, 21, 3, -25 },
  { 4372, 16, 25, 20, 2, -25 },
  { 4422, 16, 36, 21, 3, -25 },
  { 4494, 16, 36, 21, 2, -25 },
  { 4566, 10, 25, 14, 3, -25 },
  { 4598, 13, 25, 15, 1, -25 },
  { 4639, 10, 30, 12, 1, -30 },
  { 4677, 15, 24, 21, 3, -24 },
  { 4722, 16, 24, 17, 0, -24 },
  { 4770, 27, 24, 27, 0, -24 },
  { 4851, 15, 24, 17, 1, -24 },
  { 4896, 16, 35, 17, 0, -24 },
  { 4966, 12, 24, 14, 1, -24 },
  { 5002, 12, 39, 16, 2, -32 },
  { 5061, 4, 45, 18, 7, -34 },
  { 5084, 12, 39, 16, 2, -32 },
  { 5143, 17, 6, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Regular45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR45PT7B_H_
