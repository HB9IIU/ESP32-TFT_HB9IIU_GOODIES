#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x4B, 0xE5, 0x14, 0x50,
  0x47, 0xDC, 0xC6, 0x55, 0xF4, 0x40, 0xC9, 0x52, 0xC5, 0xAD, 0xA5, 0x4A,
  0x95, 0x46, 0x71, 0x45, 0x0C, 0x61, 0x59, 0xB2, 0x74, 0xE0, 0x6A, 0xAA,
  0x94, 0xC8, 0x92, 0x49, 0x2B, 0x00, 0x25, 0x5C, 0xA0, 0x21, 0x09, 0xF2,
  0x10, 0x58, 0xE0, 0xC0, 0x18, 0x84, 0x42, 0x11, 0x08, 0x80, 0xE9, 0x99,
  0x99, 0x99, 0xE0, 0x74, 0x92, 0x49, 0x20, 0xF0, 0x42, 0x31, 0x10, 0x88,
  0xF8, 0xF0, 0x42, 0x27, 0x04, 0x21, 0xF0, 0x11, 0x8C, 0xA5, 0x4B, 0xE2,
  0x10, 0xF8, 0x8E, 0x31, 0x11, 0xE0, 0x78, 0x8E, 0x99, 0x99, 0xE0, 0xF8,
  0x44, 0x21, 0x10, 0x84, 0x60, 0x7A, 0x52, 0xE7, 0x27, 0x29, 0x70, 0x72,
  0x72, 0x95, 0x94, 0x22, 0x70, 0xC6, 0x50, 0x05, 0x80, 0x08, 0xD9, 0x83,
  0x04, 0xF8, 0x3E, 0x86, 0x0C, 0x13, 0x60, 0xF1, 0x12, 0x24, 0x04, 0x40,
  0x7D, 0x0A, 0xED, 0x5A, 0xB5, 0x6E, 0xD2, 0x80, 0xF0, 0x30, 0xC3, 0x14,
  0x49, 0xE4, 0xB2, 0x84, 0xF4, 0xE5, 0x2F, 0x4E, 0x33, 0xF0, 0x78, 0x88,
  0x88, 0x8C, 0x70, 0xF4, 0xE3, 0x18, 0xC6, 0x32, 0xF0, 0xF8, 0x88, 0xE8,
  0x88, 0xF0, 0xF8, 0x88, 0xE8, 0x88, 0x80, 0x7C, 0x21, 0x09, 0xC6, 0x39,
  0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xE9, 0x24, 0x92, 0xE0, 0x24,
  0x92, 0x49, 0x27, 0xA0, 0x9C, 0xA9, 0xCE, 0x52, 0x52, 0x98, 0x88, 0x88,
  0x88, 0x88, 0xF0, 0xC3, 0x8F, 0x1D, 0x3A, 0xB5, 0x6A, 0xCD, 0x92, 0xCE,
  0x73, 0x5A, 0xCE, 0x71, 0x88, 0x7A, 0x28, 0xA2, 0x8E, 0x28, 0xA2, 0x70,
  0xF9, 0x99, 0xF8, 0x88, 0x80, 0x7A, 0x28, 0xA2, 0x8E, 0x28, 0xA2, 0x70,
  0x40, 0x80, 0xF4, 0xA5, 0x2F, 0x52, 0x52, 0x98, 0x7A, 0x10, 0xC3, 0x0C,
  0x21, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x70, 0x8F, 0x24, 0x92, 0x49, 0x43, 0x0C, 0x30, 0x88, 0xE6, 0x53,
  0x2A, 0xB5, 0x52, 0xA9, 0x4C, 0x66, 0x23, 0x00, 0xCA, 0x94, 0x62, 0x19,
  0x4B, 0x88, 0x8A, 0x94, 0xA2, 0x10, 0x84, 0x20, 0xF1, 0x32, 0x24, 0x44,
  0xF0, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x10, 0x42, 0x10, 0x42, 0x18,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x30, 0xC4, 0x92, 0x8C, 0xFC, 0x90, 0x70,
  0xC2, 0xFC, 0xED, 0xA0, 0x88, 0x8F, 0x99, 0x99, 0x9F, 0xF2, 0x49, 0x38,
  0x11, 0x1F, 0x99, 0x99, 0x9F, 0xE9, 0x9F, 0x88, 0xF0, 0x74, 0x4E, 0x44,
  0x44, 0x44, 0xF9, 0x99, 0x99, 0xF1, 0x1E, 0x88, 0x8F, 0x99, 0x99, 0x99,
  0xDF, 0xC0, 0x51, 0x55, 0x55, 0xC0, 0x88, 0x89, 0xAC, 0xEA, 0xB9, 0xFF,
  0xC0, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xF9, 0x99, 0x99, 0x90,
  0xE9, 0x99, 0x99, 0xE0, 0xF9, 0x99, 0x99, 0xF8, 0x88, 0xF9, 0x99, 0x99,
  0xF1, 0x11, 0xF2, 0x49, 0x20, 0x78, 0x46, 0x11, 0xF0, 0x4B, 0xA4, 0x92,
  0x60, 0x99, 0x99, 0x99, 0xF0, 0x8C, 0x94, 0xA5, 0x30, 0x80, 0x99, 0x9A,
  0x5A, 0x5A, 0x6A, 0x66, 0x24, 0xDA, 0x98, 0x45, 0x2A, 0x60, 0x8C, 0x94,
  0xA5, 0x10, 0x84, 0x66, 0x00, 0xF2, 0x26, 0x44, 0xF0, 0x69, 0x25, 0x12,
  0x49, 0x80, 0xFF, 0xF8, 0xC9, 0x24, 0x52, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 5, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 4, 11, 6, 1, -10 },
  { 18, 7, 9, 9, 1, -9 },
  { 26, 6, 9, 6, 0, -9 },
  { 33, 1, 3, 3, 1, -9 },
  { 34, 2, 11, 4, 1, -9 },
  { 37, 3, 11, 4, 0, -9 },
  { 42, 5, 4, 5, 0, -10 },
  { 45, 5, 6, 6, 0, -8 },
  { 49, 2, 3, 3, 0, -1 },
  { 50, 3, 1, 4, 0, -4 },
  { 51, 1, 2, 3, 1, -2 },
  { 52, 5, 9, 5, 0, -9 },
  { 58, 4, 9, 6, 1, -9 },
  { 63, 3, 9, 6, 1, -9 },
  { 67, 5, 9, 6, 0, -9 },
  { 73, 5, 9, 6, 0, -9 },
  { 79, 5, 9, 6, 0, -9 },
  { 85, 4, 9, 6, 1, -9 },
  { 90, 4, 9, 6, 1, -9 },
  { 95, 5, 9, 6, 0, -9 },
  { 101, 5, 9, 6, 0, -9 },
  { 107, 5, 9, 6, 0, -9 },
  { 113, 1, 7, 3, 1, -7 },
  { 114, 2, 9, 3, 0, -7 },
  { 117, 5, 6, 6, 0, -8 },
  { 121, 5, 3, 6, 0, -6 },
  { 123, 5, 6, 6, 0, -8 },
  { 127, 4, 9, 4, 0, -9 },
  { 132, 7, 10, 8, 1, -9 },
  { 141, 6, 9, 6, 0, -9 },
  { 148, 5, 9, 6, 1, -9 },
  { 154, 4, 9, 6, 1, -9 },
  { 159, 5, 9, 7, 1, -9 },
  { 165, 4, 9, 5, 1, -9 },
  { 170, 4, 9, 5, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 5, 9, 7, 1, -9 },
  { 187, 3, 9, 4, 0, -9 },
  { 191, 3, 12, 3, -1, -9 },
  { 196, 5, 9, 6, 1, -9 },
  { 202, 4, 9, 5, 1, -9 },
  { 207, 7, 9, 9, 1, -9 },
  { 215, 5, 9, 7, 1, -9 },
  { 221, 6, 9, 7, 1, -9 },
  { 228, 4, 9, 6, 1, -9 },
  { 233, 6, 11, 7, 1, -9 },
  { 242, 5, 9, 6, 1, -9 },
  { 248, 5, 9, 5, 0, -9 },
  { 254, 5, 9, 5, 0, -9 },
  { 260, 5, 9, 7, 1, -9 },
  { 266, 6, 9, 6, 0, -9 },
  { 273, 9, 9, 9, 0, -9 },
  { 284, 5, 9, 5, 0, -9 },
  { 290, 5, 9, 5, 0, -9 },
  { 296, 4, 9, 5, 0, -9 },
  { 301, 3, 11, 4, 1, -9 },
  { 306, 5, 9, 5, 0, -9 },
  { 312, 3, 11, 4, 0, -9 },
  { 317, 6, 5, 6, 0, -9 },
  { 321, 6, 1, 6, 0, 1 },
  { 322, 2, 2, 3, 1, -10 },
  { 323, 5, 7, 5, 0, -7 },
  { 328, 4, 10, 6, 1, -10 },
  { 333, 3, 7, 5, 1, -7 },
  { 336, 4, 10, 6, 1, -10 },
  { 341, 4, 7, 5, 1, -7 },
  { 345, 4, 10, 3, 0, -10 },
  { 350, 4, 10, 6, 1, -7 },
  { 355, 4, 10, 6, 1, -10 },
  { 360, 1, 10, 3, 1, -10 },
  { 362, 2, 13, 3, 0, -10 },
  { 366, 4, 10, 5, 1, -10 },
  { 371, 1, 10, 3, 1, -10 },
  { 373, 7, 7, 9, 1, -7 },
  { 380, 4, 7, 6, 1, -7 },
  { 384, 4, 7, 6, 1, -7 },
  { 388, 4, 10, 6, 1, -7 },
  { 393, 4, 10, 6, 1, -7 },
  { 398, 3, 7, 4, 1, -7 },
  { 401, 4, 7, 4, 0, -7 },
  { 405, 3, 9, 3, 0, -9 },
  { 409, 4, 7, 6, 1, -7 },
  { 413, 5, 7, 5, 0, -7 },
  { 418, 8, 7, 8, 0, -7 },
  { 425, 5, 7, 5, 0, -7 },
  { 430, 5, 10, 5, 0, -7 },
  { 437, 4, 7, 4, 0, -7 },
  { 441, 3, 11, 5, 1, -9 },
  { 446, 1, 13, 5, 2, -10 },
  { 448, 3, 11, 5, 1, -9 },
  { 453, 5, 1, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Regular13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR13PT7B_H_
