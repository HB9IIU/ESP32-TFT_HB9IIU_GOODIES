#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x60, 0x00,
  0x7F, 0xF7, 0xE3, 0xF8, 0xFE, 0x3B, 0x8E, 0xE3, 0xB8, 0x66, 0x19, 0x86,
  0x61, 0x98, 0x60, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xE0, 0x71, 0x80, 0xE3,
  0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x7F, 0xFE, 0xFF, 0xFC, 0x31, 0xC0,
  0xE3, 0x81, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0xFF, 0xFD, 0xFF,
  0xF8, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60,
  0x30, 0xC0, 0x63, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0xF3, 0xFF,
  0x3D, 0x99, 0xCC, 0x1C, 0x60, 0xE3, 0x07, 0x18, 0x1C, 0xC0, 0xF6, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0x78, 0x19, 0xC0, 0xCE, 0x06,
  0x70, 0x33, 0xC1, 0x9F, 0xCF, 0xDF, 0xFC, 0x3F, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x1C, 0x03, 0x80, 0xF8, 0x0C, 0x07, 0x70, 0x70,
  0x18, 0xC1, 0x80, 0x63, 0x86, 0x01, 0x8E, 0x38, 0x0E, 0x38, 0xC0, 0x38,
  0xE3, 0x00, 0xE3, 0x9C, 0x03, 0x8E, 0x60, 0x06, 0x39, 0x8E, 0x18, 0xEE,
  0x7C, 0x63, 0x33, 0xB1, 0xDC, 0xCC, 0xE3, 0xE7, 0x71, 0x87, 0x19, 0xC6,
  0x00, 0x67, 0x18, 0x03, 0x9C, 0x60, 0x0C, 0x71, 0xC0, 0x71, 0xC6, 0x01,
  0xC7, 0x18, 0x06, 0x1C, 0x60, 0x38, 0x31, 0x80, 0xC0, 0xCE, 0x03, 0x03,
  0xF0, 0x1C, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x3D, 0xC0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x1D, 0xC0,
  0x1F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3B, 0x8E, 0x73, 0x8E,
  0x71, 0xCE, 0xE0, 0xEE, 0xE0, 0xFC, 0xE0, 0x7C, 0xE0, 0x78, 0xE0, 0x78,
  0xF0, 0xFC, 0x79, 0xFE, 0x7F, 0xCE, 0x3F, 0x8F, 0xFF, 0xFF, 0xDB, 0x6C,
  0x06, 0x1C, 0x70, 0xC3, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xE1,
  0xC1, 0xC3, 0x83, 0x83, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0C,
  0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x60, 0xE0,
  0x07, 0x00, 0x60, 0x06, 0x06, 0x63, 0x7F, 0xFF, 0xFF, 0x0F, 0x01, 0xF8,
  0x1D, 0xC3, 0x9C, 0x38, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x39, 0xCE,
  0xE7, 0x39, 0x8C, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0x71, 0xE7, 0x87, 0x38, 0x39, 0xC1, 0xCE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x38,
  0xE3, 0xC7, 0xBC, 0x1F, 0xE0, 0x7E, 0x00, 0x03, 0x83, 0xC3, 0xE3, 0xF3,
  0xBF, 0x9D, 0x8E, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x1F, 0x83, 0xFE, 0x3F, 0xF8, 0xC1, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xFF, 0x3F,
  0xF8, 0xC1, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x3F, 0x81, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3A, 0x03, 0xDE, 0x3C, 0xFF,
  0xE3, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x06, 0x38,
  0x38, 0xE0, 0xC3, 0x87, 0x0E, 0x18, 0x38, 0xE0, 0xE3, 0x03, 0x8F, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x7F, 0xC7, 0xFC, 0x7F, 0xC6, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x0F, 0xF8, 0xFF, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x81, 0xEE,
  0x3C, 0xFF, 0x8F, 0xF0, 0x07, 0xE1, 0xFE, 0x3F, 0xE3, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x8F, 0xFC, 0xDB, 0xEF,
  0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0x70, 0xE7, 0xBE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0x7C, 0xF0, 0xE7, 0x07, 0xB8, 0x1D,
  0xC0, 0xEE, 0x07, 0x70, 0x71, 0xC3, 0x8F, 0x38, 0x3F, 0x80, 0xF8, 0x0F,
  0xE0, 0xF7, 0x8F, 0x1E, 0x70, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1D, 0xC1, 0xEF, 0x1E, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0x80, 0xFE,
  0x0F, 0xF8, 0xF1, 0xC7, 0x07, 0x38, 0x3B, 0x81, 0xDC, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x0E, 0xE0, 0xF7, 0x07, 0xBC, 0x7C, 0xFE, 0xE3, 0xE6, 0x04,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x88, 0x78,
  0x7F, 0x83, 0xF8, 0x00, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x7B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x39, 0xDC, 0xE7, 0x31, 0x9C, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xE0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x38, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0x80,
  0x10, 0x00, 0x3F, 0x1F, 0xF1, 0xFF, 0x20, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x1E,
  0x03, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0, 0x38,
  0x38, 0x01, 0xC3, 0x80, 0x0C, 0x70, 0x00, 0xE7, 0x07, 0x86, 0x61, 0xFC,
  0x6E, 0x39, 0xC7, 0xE3, 0x1C, 0x7C, 0x31, 0xC7, 0xC7, 0x1C, 0x7C, 0x71,
  0xC7, 0xC7, 0x1C, 0x7C, 0x71, 0xC7, 0xC7, 0x1C, 0x7C, 0x71, 0xC6, 0xC3,
  0x1C, 0x6C, 0x3B, 0xEE, 0xE3, 0xE7, 0xCE, 0x1C, 0x38, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x3F, 0xF9,
  0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8,
  0x39, 0xFF, 0x8F, 0xF8, 0x7F, 0xF3, 0x83, 0xDC, 0x0E, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3B, 0x83, 0xDF, 0xFC, 0xFF, 0xE7,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0x78, 0x23, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE7, 0x1F, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFF,
  0x0F, 0xFE, 0x38, 0x7C, 0xE0, 0xF3, 0x81, 0xEE, 0x03, 0xB8, 0x0E, 0xE0,
  0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x81, 0xCE,
  0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF,
  0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEF, 0xFB, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3C, 0x06, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x07, 0x3C, 0x07, 0x1F,
  0x1F, 0x0F, 0xFF, 0x07, 0xFC, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x70, 0xFF, 0xFF, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0xFE,
  0xFC, 0xF8, 0xE0, 0x3F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xE3,
  0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xDC, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0xF1, 0xC3, 0x8E, 0x1E,
  0x70, 0x73, 0x83, 0xDC, 0x0E, 0xE0, 0x7F, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFD, 0x80, 0x3F, 0xDC, 0x03, 0xFD,
  0xC0, 0x3F, 0xCC, 0x03, 0x7E, 0xE0, 0x77, 0xEE, 0x07, 0x7E, 0xE0, 0x67,
  0xE6, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x30, 0xC7, 0xE3, 0x9C,
  0x7E, 0x39, 0xC7, 0xE3, 0x98, 0x7E, 0x1B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0E, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFB, 0x81, 0xF7, 0x03,
  0xEE, 0x07, 0xCE, 0x0F, 0xDC, 0x1F, 0x9C, 0x3F, 0x38, 0x7E, 0x30, 0xFC,
  0x71, 0xF8, 0xE3, 0xF0, 0xE7, 0xE1, 0xCF, 0xC1, 0xDF, 0x83, 0xBF, 0x03,
  0x7E, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3C,
  0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E,
  0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x3E, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF,
  0xFC, 0xFF, 0x8F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x3E, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0xFE,
  0x07, 0xFC, 0x3F, 0xF1, 0xC3, 0xCE, 0x0E, 0x70, 0x7B, 0x81, 0xDC, 0x0E,
  0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x3E, 0x7F, 0xE3, 0xFC, 0x1C,
  0xE0, 0xE3, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x8E, 0x1E, 0x70, 0x73, 0x83,
  0xDC, 0x0E, 0xE0, 0x77, 0x01, 0xC0, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0xF0,
  0x47, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x3A, 0x03, 0xDF, 0xFC, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x83,
  0xCF, 0xBE, 0x3F, 0xF0, 0x3F, 0x80, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x0C,
  0x01, 0xF8, 0x07, 0x80, 0xF7, 0x01, 0xE0, 0x39, 0xC0, 0x78, 0x0E, 0x70,
  0x1E, 0x03, 0x9C, 0x0F, 0x80, 0xE7, 0x03, 0xF0, 0x78, 0xE0, 0xFC, 0x1C,
  0x38, 0x37, 0x07, 0x0E, 0x0C, 0xC1, 0xC3, 0x87, 0x30, 0x70, 0xE1, 0xCE,
  0x38, 0x1C, 0x73, 0x8E, 0x07, 0x18, 0xE3, 0x81, 0xC6, 0x18, 0xE0, 0x73,
  0x86, 0x38, 0x1C, 0xE1, 0xDC, 0x03, 0xB8, 0x77, 0x00, 0xEC, 0x1D, 0xC0,
  0x3B, 0x03, 0x70, 0x0E, 0xC0, 0xDC, 0x01, 0xF0, 0x36, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x70,
  0x1D, 0xC0, 0xE3, 0x83, 0x8E, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x03,
  0xB8, 0x0E, 0xE0, 0x3B, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x7C, 0x03, 0xF0, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x83, 0x9C, 0x0E, 0x70, 0x3F, 0xC0, 0x70, 0xE0, 0x1F, 0xC0,
  0x77, 0x03, 0x9C, 0x0E, 0x78, 0x38, 0xE1, 0xC3, 0x87, 0x07, 0x1C, 0x1C,
  0xE0, 0x73, 0x80, 0xCE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0x00,
  0x0C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x33, 0x01, 0xCE, 0x06, 0x18,
  0x38, 0x70, 0xC1, 0xC7, 0x03, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xC1, 0xC0, 0x07, 0x03, 0xFC,
  0x3F, 0xE2, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x03, 0xF1, 0xFF,
  0x3F, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xF7, 0x1F,
  0x7F, 0x73, 0xE7, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x70, 0xE7, 0xE7, 0x7F, 0x3E, 0x3D, 0xE0, 0xEF, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0E, 0xFC, 0xF7, 0x7F, 0x39, 0xF0, 0x0F,
  0x0F, 0xF7, 0xF9, 0xE2, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1E, 0x33, 0xFC, 0x7E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xC7,
  0x3F, 0x77, 0xFF, 0x70, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F,
  0x79, 0xF7, 0xFB, 0x3F, 0x30, 0x06, 0x03, 0xF8, 0x7F, 0xC7, 0x1E, 0xE0,
  0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x86, 0x3F, 0xE1, 0xFC, 0x03,
  0x03, 0xF1, 0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xEF,
  0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0xF3, 0x7F, 0xB7, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7,
  0x9B, 0x7F, 0xF3, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7C,
  0x1E, 0xFF, 0xEF, 0xF8, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x38, 0xEF, 0xEE, 0xFE, 0xF8, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x6E,
  0xFE, 0x40, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE0, 0x18, 0xE3, 0xCE, 0x10, 0x00, 0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x3B, 0xEF, 0x30, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E,
  0x70, 0xE7, 0x0E, 0xE0, 0xEF, 0x0F, 0xF0, 0xF3, 0x8F, 0x38, 0xE3, 0x8E,
  0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x83, 0x8E, 0xFC,
  0x7E, 0xEF, 0xEF, 0xEF, 0x8F, 0x8F, 0xF0, 0xF8, 0x7F, 0x07, 0x07, 0xE0,
  0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E,
  0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07,
  0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0x03, 0x0E,
  0xFE, 0xEF, 0xEF, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x06, 0x01, 0xFE, 0x1F, 0xF8, 0xE1, 0xCE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x01, 0xF8, 0x0F, 0xC0, 0x6E,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0x70, 0xE3, 0xCF, 0x0F, 0xF0, 0x3F,
  0x00, 0x03, 0x87, 0x3F, 0x3B, 0xF9, 0xF0, 0xEF, 0x07, 0x78, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x77, 0xE7, 0xBB, 0xF9, 0xCF, 0x8E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x0E, 0x03, 0xF3, 0x7F, 0xB7, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xF7, 0x9B, 0x7F, 0xF3, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xF3, 0xBB,
  0xDF, 0x9F, 0x87, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0xF7, 0xFF,
  0xC2, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x81, 0xF8, 0xFF, 0xF9, 0xFC, 0x30, 0x30, 0x30,
  0x30, 0x30, 0xFF, 0xFF, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x39, 0x3F, 0x1F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x79, 0xF7, 0xFB,
  0x3F, 0x30, 0xE0, 0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x18, 0x38,
  0xE1, 0x87, 0x1C, 0x38, 0xE0, 0xC7, 0x07, 0x30, 0x3B, 0x81, 0xDC, 0x06,
  0xE0, 0x36, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0xE0, 0x78, 0x3B,
  0x83, 0xC1, 0xDC, 0x1E, 0x0E, 0xE1, 0xF0, 0x77, 0x0F, 0xC3, 0x18, 0x7E,
  0x38, 0xE3, 0x71, 0xC7, 0x19, 0x8E, 0x39, 0xCC, 0x71, 0xCE, 0x73, 0x06,
  0x73, 0xB8, 0x3B, 0x1D, 0xC1, 0xD8, 0x6E, 0x0E, 0xC3, 0x60, 0x3E, 0x1B,
  0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x70,
  0x79, 0xC3, 0x8E, 0x3C, 0x31, 0xC1, 0xCE, 0x0E, 0xE0, 0x3F, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x81, 0xDC, 0x0E, 0x60, 0x63, 0x87,
  0x1C, 0x38, 0x73, 0x83, 0xBC, 0x0E, 0xE0, 0x3B, 0x81, 0xDC, 0x0C, 0xE0,
  0xE7, 0x07, 0x1C, 0x38, 0xE1, 0x87, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0x30,
  0x3B, 0x80, 0xDC, 0x06, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0xE0,
  0x3E, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xE0, 0xE0, 0x7F,
  0xFF, 0xE0, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x07, 0xC0,
  0xF8, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1F, 0x03, 0xE0,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE1, 0xF8, 0x3E, 0x07, 0x00, 0x3C, 0x0F, 0xF8, 0x7F,
  0xFF, 0x07, 0xF8, 0x04, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 26, 8, 2, -26 },
  { 14, 10, 10, 14, 2, -26 },
  { 27, 15, 26, 17, 1, -26 },
  { 76, 13, 29, 15, 1, -27 },
  { 124, 22, 26, 24, 1, -26 },
  { 196, 16, 26, 17, 1, -26 },
  { 248, 3, 10, 7, 2, -26 },
  { 252, 7, 32, 10, 2, -26 },
  { 280, 8, 32, 10, 1, -26 },
  { 312, 12, 12, 14, 1, -27 },
  { 330, 13, 17, 15, 1, -21 },
  { 358, 5, 9, 8, 1, -4 },
  { 364, 8, 3, 10, 1, -11 },
  { 367, 4, 4, 8, 2, -4 },
  { 369, 12, 26, 13, 1, -26 },
  { 408, 13, 26, 15, 1, -26 },
  { 451, 9, 26, 15, 2, -26 },
  { 481, 13, 26, 15, 1, -26 },
  { 524, 13, 26, 15, 1, -26 },
  { 567, 14, 26, 15, 1, -26 },
  { 613, 12, 26, 15, 2, -26 },
  { 652, 12, 26, 15, 2, -26 },
  { 691, 13, 26, 15, 1, -26 },
  { 734, 13, 26, 15, 1, -26 },
  { 777, 13, 26, 15, 1, -26 },
  { 820, 4, 19, 8, 2, -19 },
  { 830, 5, 24, 8, 1, -19 },
  { 845, 13, 16, 15, 1, -21 },
  { 871, 13, 10, 15, 1, -18 },
  { 888, 13, 16, 15, 1, -21 },
  { 914, 11, 26, 11, 0, -26 },
  { 950, 20, 29, 23, 2, -26 },
  { 1023, 16, 26, 16, 0, -26 },
  { 1075, 13, 26, 17, 3, -26 },
  { 1118, 13, 26, 16, 2, -26 },
  { 1161, 14, 26, 19, 3, -26 },
  { 1207, 10, 26, 14, 3, -26 },
  { 1240, 10, 26, 14, 3, -26 },
  { 1273, 16, 26, 20, 2, -26 },
  { 1325, 14, 26, 19, 3, -26 },
  { 1371, 8, 26, 10, 1, -26 },
  { 1397, 8, 33, 8, -2, -26 },
  { 1430, 13, 26, 16, 3, -26 },
  { 1473, 10, 26, 13, 3, -26 },
  { 1506, 20, 26, 26, 3, -26 },
  { 1571, 15, 26, 20, 3, -26 },
  { 1620, 16, 26, 20, 2, -26 },
  { 1672, 12, 26, 16, 3, -26 },
  { 1711, 16, 32, 20, 2, -26 },
  { 1775, 13, 26, 17, 3, -26 },
  { 1818, 13, 26, 15, 1, -26 },
  { 1861, 13, 26, 14, 0, -26 },
  { 1904, 14, 26, 19, 2, -26 },
  { 1950, 16, 26, 16, 0, -26 },
  { 2002, 26, 26, 26, 0, -26 },
  { 2087, 14, 26, 14, 0, -26 },
  { 2133, 14, 26, 14, 0, -26 },
  { 2179, 11, 26, 13, 1, -26 },
  { 2215, 7, 32, 11, 3, -26 },
  { 2243, 12, 26, 13, 1, -26 },
  { 2282, 8, 32, 11, 1, -26 },
  { 2314, 14, 14, 16, 1, -26 },
  { 2339, 16, 2, 16, 0, 3 },
  { 2343, 7, 6, 10, 1, -28 },
  { 2349, 12, 20, 15, 1, -20 },
  { 2379, 13, 27, 17, 2, -27 },
  { 2423, 10, 20, 12, 2, -20 },
  { 2448, 12, 27, 17, 2, -27 },
  { 2489, 12, 20, 15, 2, -20 },
  { 2519, 10, 28, 9, 0, -28 },
  { 2554, 12, 29, 17, 2, -20 },
  { 2598, 12, 27, 16, 2, -27 },
  { 2639, 4, 27, 8, 2, -27 },
  { 2653, 6, 36, 8, 0, -27 },
  { 2680, 12, 27, 14, 2, -27 },
  { 2721, 3, 27, 8, 2, -27 },
  { 2732, 20, 20, 25, 2, -20 },
  { 2782, 12, 20, 16, 2, -20 },
  { 2812, 13, 20, 16, 2, -20 },
  { 2845, 13, 29, 17, 2, -20 },
  { 2893, 12, 29, 17, 2, -20 },
  { 2937, 9, 20, 11, 2, -20 },
  { 2960, 10, 20, 12, 1, -20 },
  { 2985, 8, 24, 9, 1, -24 },
  { 3009, 12, 19, 16, 2, -19 },
  { 3038, 13, 19, 13, 0, -19 },
  { 3069, 21, 19, 22, 0, -19 },
  { 3119, 13, 19, 13, 0, -19 },
  { 3150, 13, 28, 13, 0, -19 },
  { 3196, 9, 19, 11, 1, -19 },
  { 3218, 11, 32, 13, 1, -26 },
  { 3262, 3, 36, 15, 6, -27 },
  { 3276, 11, 32, 13, 1, -26 },
  { 3320, 13, 5, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Regular36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR36PT7B_H_
