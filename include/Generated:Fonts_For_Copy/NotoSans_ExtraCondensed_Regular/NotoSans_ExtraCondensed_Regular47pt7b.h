#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x02, 0x7F, 0xFF, 0xFB, 0x80, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0E, 0x60, 0x60, 0x01, 0xC3, 0x80, 0x38, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x30, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x70, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0E, 0x1C, 0x00, 0xC1, 0xC0,
  0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE,
  0x79, 0x82, 0xF1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0xE1, 0x80,
  0xF1, 0x80, 0x79, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x01, 0xBE, 0x01, 0x9F, 0x01, 0x8F, 0x01, 0x87, 0x01, 0x87,
  0x01, 0x87, 0x01, 0x87, 0x81, 0x8F, 0xC1, 0x9E, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x1E, 0x00, 0x38, 0x07, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0xC0,
  0x39, 0xE0, 0x38, 0x07, 0x1C, 0x0F, 0x01, 0xC3, 0x81, 0xC0, 0x38, 0x78,
  0x38, 0x07, 0x07, 0x0F, 0x00, 0xE0, 0xE1, 0xC0, 0x1C, 0x1C, 0x38, 0x03,
  0x83, 0x8E, 0x00, 0x70, 0x71, 0xC0, 0x0E, 0x0E, 0x38, 0x01, 0xC1, 0xCE,
  0x0C, 0x38, 0x79, 0xC7, 0xE7, 0x0E, 0x39, 0xFE, 0x71, 0xCE, 0x39, 0xCE,
  0x39, 0xCE, 0x3D, 0xFE, 0x39, 0xC3, 0x9F, 0xCE, 0x38, 0x71, 0xE1, 0xC7,
  0x0E, 0x00, 0x79, 0xE1, 0xC0, 0x0E, 0x3C, 0x38, 0x01, 0xC7, 0x87, 0x00,
  0x78, 0xF0, 0xE0, 0x0E, 0x1E, 0x1C, 0x01, 0xC1, 0xC3, 0x80, 0x78, 0x38,
  0x70, 0x0E, 0x07, 0x0E, 0x01, 0xC0, 0xE1, 0xC0, 0x70, 0x1C, 0x70, 0x0E,
  0x01, 0xFE, 0x01, 0xC0, 0x3F, 0x80, 0x70, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0x70, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x70,
  0x01, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x0F, 0x0F, 0x3C, 0x3C, 0x7C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x83, 0xCE,
  0x3C, 0x0F, 0xF8, 0xF0, 0x1F, 0xE3, 0xC0, 0x3F, 0x0F, 0x00, 0xFC, 0x3C,
  0x01, 0xE0, 0x78, 0x0F, 0xC1, 0xE0, 0x7F, 0x87, 0xC3, 0xFE, 0x0F, 0xFF,
  0x7C, 0x1F, 0xF8, 0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x60, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1C, 0x73, 0xBF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xF0, 0x0F, 0x80, 0x3B, 0x80, 0xF7, 0x83, 0xCF, 0x0F, 0x8F,
  0x0E, 0x1C, 0x04, 0x10, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x1C,
  0xF3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xBF, 0xFF,
  0xF8, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE,
  0x7F, 0xDF, 0x7F, 0xCF, 0x71, 0xEC, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0x60, 0x3E, 0x40, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFC, 0xFD, 0xFC, 0x60, 0x3E, 0x40, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x80, 0x3E,
  0xE0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x03, 0xCF,
  0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x1C, 0x1E,
  0x03, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C,
  0x3C, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x73, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x80, 0x3E, 0xE0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xEE, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xF7, 0xFC, 0xFE, 0x7E, 0xFC,
  0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3C,
  0x1E, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xCF, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x38, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC3,
  0xC3, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF8,
  0x07, 0xBE, 0x07, 0x8F, 0x87, 0x83, 0xE7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xEF, 0x00, 0xF7,
  0xC0, 0x79, 0xF0, 0x78, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3C, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x41,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xF7, 0xFF, 0xFF, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF, 0xFF, 0xF0, 0x79,
  0xF7, 0xDF, 0x78, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x1C, 0xF3, 0x8E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0x3F, 0xFD, 0xF7, 0xE4,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0x81, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x8E, 0x01, 0xE0, 0xE3, 0x81, 0xFE,
  0x3D, 0xE0, 0xFF, 0x87, 0x70, 0x78, 0xE1, 0xDC, 0x3C, 0x38, 0x77, 0x0E,
  0x1E, 0x1D, 0xC3, 0x87, 0x87, 0xF0, 0xE1, 0xE1, 0xFC, 0x38, 0x78, 0x7E,
  0x1E, 0x1E, 0x1F, 0x87, 0x87, 0x87, 0xE1, 0xE1, 0xE1, 0xF8, 0x78, 0x78,
  0x7E, 0x0E, 0x1C, 0x1F, 0xC3, 0x87, 0x87, 0xF0, 0xE3, 0x63, 0x9C, 0x3C,
  0xD9, 0xE7, 0x07, 0xF7, 0xF1, 0xC0, 0xF8, 0xFC, 0x78, 0x18, 0x0C, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x04, 0x00, 0xF8, 0x07, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xE3, 0x80, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x1F, 0x3C, 0x03,
  0xEF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x03, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0x03, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x07, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0x80, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x18, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x03, 0xF1, 0xE0, 0x1F, 0x3C,
  0x03, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x1F, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x3E, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x07, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x80,
  0x3C, 0x3F, 0x03, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE1,
  0xFE, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3F,
  0xFE, 0xFF, 0x7F, 0x3F, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xF7, 0x80, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x78, 0xF0, 0x1F, 0x3C, 0x03,
  0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x00, 0xF0, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xBF, 0xB8, 0x00,
  0x77, 0xF7, 0x00, 0x1E, 0xFE, 0xF0, 0x03, 0xDF, 0xDE, 0x00, 0x73, 0xF9,
  0xC0, 0x0E, 0x7F, 0x38, 0x03, 0xCF, 0xE7, 0x80, 0x71, 0xFC, 0x70, 0x0E,
  0x3F, 0x8E, 0x03, 0xC7, 0xF1, 0xE0, 0x78, 0xFE, 0x3C, 0x0E, 0x1F, 0xC3,
  0x81, 0xC3, 0xF8, 0x70, 0x78, 0x7F, 0x0F, 0x0E, 0x0F, 0xE0, 0xE1, 0xC1,
  0xFC, 0x1C, 0x78, 0x3F, 0x83, 0xCF, 0x07, 0xF0, 0x79, 0xC0, 0xFE, 0x07,
  0x38, 0x1F, 0xC0, 0xEF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xF0, 0x0F,
  0x00, 0xFE, 0x01, 0xE0, 0x1C, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xF7, 0x80, 0x7F, 0x78, 0x07, 0xF3, 0xC0, 0x7F, 0x3C, 0x07, 0xF1,
  0xC0, 0x7F, 0x1E, 0x07, 0xF1, 0xE0, 0x7F, 0x0F, 0x07, 0xF0, 0xF0, 0x7F,
  0x07, 0x07, 0xF0, 0x78, 0x7F, 0x07, 0x87, 0xF0, 0x3C, 0x7F, 0x03, 0xC7,
  0xF0, 0x1E, 0x7F, 0x01, 0xE7, 0xF0, 0x0E, 0x7F, 0x00, 0xF7, 0xF0, 0x0F,
  0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1E, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x79, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E,
  0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0x03, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00,
  0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B,
  0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF8,
  0x7C, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x7E, 0x3C, 0x07, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x78, 0xF0,
  0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xF0, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x04, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x80,
  0x3E, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0x78, 0x03, 0xDF, 0x01, 0xE3, 0xF1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBE, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xFC, 0x00, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x00, 0x79, 0xE0, 0x0F,
  0x80, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x9E, 0x00, 0xFC, 0x01, 0xE7, 0x80,
  0x3F, 0x00, 0xF0, 0xF0, 0x0F, 0xC0, 0x3C, 0x3C, 0x07, 0xF0, 0x0F, 0x0F,
  0x01, 0xDE, 0x03, 0xC3, 0xC0, 0x77, 0x80, 0xF0, 0xF0, 0x1C, 0xE0, 0x78,
  0x1E, 0x07, 0x38, 0x1E, 0x07, 0x83, 0xCE, 0x07, 0x81, 0xE0, 0xF3, 0xC1,
  0xE0, 0x78, 0x38, 0xF0, 0x78, 0x0E, 0x0E, 0x1C, 0x3C, 0x03, 0xC3, 0x87,
  0x0F, 0x00, 0xF1, 0xE1, 0xC3, 0xC0, 0x3C, 0x78, 0x78, 0xF0, 0x0F, 0x1C,
  0x1E, 0x3C, 0x01, 0xC7, 0x03, 0x9E, 0x00, 0x71, 0xC0, 0xE7, 0x80, 0x1E,
  0xF0, 0x39, 0xE0, 0x07, 0xBC, 0x0E, 0x78, 0x01, 0xEE, 0x03, 0xDE, 0x00,
  0x3B, 0x80, 0x77, 0x00, 0x0E, 0xE0, 0x1F, 0xC0, 0x03, 0xB8, 0x07, 0xF0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E,
  0x03, 0x83, 0xC0, 0x78, 0x70, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE3,
  0xC0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7C, 0xF0, 0x03, 0xFC, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C,
  0x01, 0xCF, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x38,
  0x0F, 0x07, 0x81, 0xC0, 0x70, 0x78, 0x0F, 0x0E, 0x00, 0xE3, 0xC0, 0x1E,
  0x70, 0x01, 0xDE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0x3F, 0xE1, 0xFF, 0xE1, 0xF7, 0xE3, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x7F, 0xF1, 0xFF, 0xEF, 0xFF,
  0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xBF, 0xEF, 0x7F, 0xDE, 0x7F, 0x1C, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x38, 0x1E, 0x7F,
  0x0F, 0x7F, 0xC7, 0xFF, 0xF3, 0xF0, 0x79, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x07, 0xBC, 0x01, 0xDE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xF7, 0x80, 0x7B, 0xE0, 0x3D, 0xF0, 0x3E, 0xFC, 0x1E, 0x7F, 0xFF, 0x39,
  0xFF, 0x1C, 0x7F, 0x00, 0x01, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF3, 0xC0,
  0xBE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x27, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xC1, 0xE1, 0xFC,
  0xF1, 0xFF, 0x79, 0xFF, 0xFD, 0xF0, 0x7E, 0xF0, 0x3F, 0x78, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7B, 0x80, 0x7D, 0xE0, 0x3E, 0xF0, 0x3F, 0x3C, 0x1F, 0x9F, 0xFB, 0xC7,
  0xFD, 0xE1, 0xFC, 0x70, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x02,
  0x3E, 0x06, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x01, 0xF0, 0x3F, 0xC1,
  0xFC, 0x1F, 0x20, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x07, 0xF3, 0xC7,
  0xFD, 0xE7, 0xFF, 0xF7, 0xC1, 0xFB, 0xC0, 0xFD, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xF7, 0x80, 0xFB, 0xC0, 0xFD, 0xF0, 0xFE, 0x7F, 0xEF, 0x1F, 0xF7,
  0x87, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x40, 0x1F, 0x38, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0x87, 0x9F,
  0xCF, 0x7F, 0xDF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x70, 0x6F, 0xFF,
  0xF6, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x0F, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x9E, 0xFE,
  0xFE, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF1, 0xE0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFD, 0xE0, 0xF9, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x3C, 0x38,
  0xFE, 0x1F, 0xCE, 0x7F, 0xCF, 0xFB, 0xBF, 0xF7, 0xFE, 0xFC, 0x3F, 0x87,
  0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0,
  0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xF0, 0x00, 0xE1, 0xC7,
  0xF3, 0x9F, 0xF7, 0x7F, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1C, 0x01, 0xC0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE3, 0xC0, 0x79, 0xE0,
  0x3C, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF8, 0xF0, 0x78, 0x7F,
  0xF8, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x71, 0xFC, 0x39, 0xFF,
  0x1F, 0xFF, 0xCF, 0xC1, 0xE7, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x07, 0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDF, 0x01,
  0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xF0, 0x79, 0xFF, 0xFC, 0xF7, 0xFC, 0x79,
  0xFC, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x07, 0xF3, 0xC7, 0xFD, 0xE7, 0xFF, 0xF7, 0xC1, 0xFB,
  0xC0, 0xFD, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0xFD,
  0xF0, 0xFE, 0x7F, 0xEF, 0x1F, 0xF7, 0x87, 0xE3, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xDC, 0x7F, 0x9F,
  0xF7, 0xEE, 0xE3, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x07, 0x03, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF0, 0x2E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x0F, 0xC1, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x1F, 0xF7, 0xFE, 0xFF, 0xC7,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xFE, 0x3F, 0xC3, 0xF8, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xEF, 0x0F, 0xDF,
  0xFB, 0x9F, 0xE7, 0x1F, 0x8E, 0xF0, 0x07, 0xB8, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E,
  0x0E, 0x0F, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xE3, 0xC0, 0x71, 0xE0, 0x38,
  0xE0, 0x1E, 0x70, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xE7, 0x81, 0xF8,
  0x0E, 0x78, 0x1F, 0x81, 0xE3, 0x81, 0xFC, 0x1E, 0x3C, 0x1D, 0xC1, 0xE3,
  0xC1, 0xDC, 0x1C, 0x3C, 0x3D, 0xC3, 0xC1, 0xC3, 0x9C, 0x3C, 0x1C, 0x39,
  0xE3, 0xC1, 0xE3, 0x9E, 0x38, 0x1E, 0x38, 0xE3, 0x81, 0xE7, 0x8E, 0x78,
  0x0E, 0x70, 0xE7, 0x80, 0xE7, 0x0E, 0x78, 0x0E, 0x70, 0xF7, 0x00, 0xF7,
  0x07, 0x70, 0x0F, 0xF0, 0x77, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x1F, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x78, 0x3C, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x1C, 0x1E,
  0x0E, 0x0F, 0x07, 0x87, 0x03, 0xC3, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x3C,
  0xE0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0xC1, 0xFC, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xF0,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x83, 0xF8, 0x1F, 0x80, 0xF8, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x4F, 0xE0, 0x17, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xA0,
  0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 34, 11, 3, -34 },
  { 23, 12, 13, 18, 3, -34 },
  { 43, 20, 34, 22, 1, -34 },
  { 128, 16, 39, 20, 2, -36 },
  { 206, 27, 34, 31, 2, -34 },
  { 321, 22, 34, 22, 1, -34 },
  { 415, 4, 13, 10, 3, -34 },
  { 422, 10, 41, 14, 2, -34 },
  { 474, 10, 41, 14, 1, -34 },
  { 526, 15, 16, 19, 2, -36 },
  { 556, 18, 22, 20, 1, -28 },
  { 606, 6, 11, 11, 2, -5 },
  { 615, 11, 4, 13, 1, -15 },
  { 621, 5, 6, 11, 3, -6 },
  { 625, 16, 34, 17, 1, -34 },
  { 693, 16, 34, 20, 2, -34 },
  { 761, 11, 34, 20, 3, -34 },
  { 808, 16, 34, 20, 2, -34 },
  { 876, 16, 34, 20, 2, -34 },
  { 944, 19, 34, 20, 1, -34 },
  { 1025, 16, 34, 20, 2, -34 },
  { 1093, 16, 34, 20, 2, -34 },
  { 1161, 17, 34, 20, 1, -34 },
  { 1234, 17, 34, 20, 2, -34 },
  { 1307, 16, 34, 20, 2, -34 },
  { 1375, 5, 25, 11, 3, -25 },
  { 1391, 6, 31, 11, 2, -25 },
  { 1415, 18, 21, 20, 1, -27 },
  { 1463, 18, 13, 20, 1, -23 },
  { 1493, 18, 21, 20, 1, -27 },
  { 1541, 13, 34, 15, 1, -34 },
  { 1597, 26, 38, 31, 2, -34 },
  { 1721, 21, 34, 21, 0, -34 },
  { 1811, 18, 34, 22, 3, -34 },
  { 1888, 18, 34, 21, 2, -34 },
  { 1965, 19, 34, 24, 3, -34 },
  { 2046, 14, 34, 19, 3, -34 },
  { 2106, 14, 34, 18, 3, -34 },
  { 2166, 21, 34, 26, 2, -34 },
  { 2256, 19, 34, 25, 3, -34 },
  { 2337, 10, 34, 13, 2, -34 },
  { 2380, 9, 43, 11, -2, -34 },
  { 2429, 18, 34, 21, 3, -34 },
  { 2506, 14, 34, 17, 3, -34 },
  { 2566, 27, 34, 34, 3, -34 },
  { 2681, 20, 34, 27, 3, -34 },
  { 2766, 22, 34, 26, 2, -34 },
  { 2860, 16, 34, 21, 3, -34 },
  { 2928, 22, 42, 26, 2, -34 },
  { 3044, 18, 34, 22, 3, -34 },
  { 3121, 16, 34, 19, 2, -34 },
  { 3189, 17, 34, 18, 0, -34 },
  { 3262, 18, 34, 25, 3, -34 },
  { 3339, 21, 34, 21, 0, -34 },
  { 3429, 34, 34, 34, 0, -34 },
  { 3574, 19, 34, 19, 0, -34 },
  { 3655, 18, 34, 18, 0, -34 },
  { 3732, 15, 34, 17, 1, -34 },
  { 3796, 10, 42, 15, 3, -34 },
  { 3849, 16, 34, 17, 1, -34 },
  { 3917, 10, 42, 15, 1, -34 },
  { 3970, 19, 18, 21, 1, -34 },
  { 4013, 21, 3, 21, 0, 4 },
  { 4021, 9, 8, 13, 2, -36 },
  { 4030, 15, 26, 20, 2, -26 },
  { 4079, 17, 36, 22, 3, -36 },
  { 4156, 13, 26, 16, 2, -26 },
  { 4199, 17, 36, 22, 2, -36 },
  { 4276, 16, 26, 20, 2, -26 },
  { 4328, 13, 36, 12, 0, -36 },
  { 4387, 17, 37, 22, 2, -26 },
  { 4466, 15, 36, 21, 3, -36 },
  { 4534, 4, 35, 10, 3, -35 },
  { 4552, 8, 46, 10, -1, -35 },
  { 4598, 16, 36, 19, 3, -36 },
  { 4670, 4, 36, 10, 3, -36 },
  { 4688, 26, 26, 32, 3, -26 },
  { 4773, 15, 26, 21, 3, -26 },
  { 4822, 17, 26, 21, 2, -26 },
  { 4878, 17, 37, 22, 3, -26 },
  { 4957, 17, 37, 22, 2, -26 },
  { 5036, 11, 26, 14, 3, -26 },
  { 5072, 12, 26, 16, 2, -26 },
  { 5111, 11, 31, 12, 1, -31 },
  { 5154, 15, 25, 21, 3, -25 },
  { 5201, 17, 25, 17, 0, -25 },
  { 5255, 28, 25, 28, 0, -25 },
  { 5343, 16, 25, 18, 1, -25 },
  { 5393, 17, 36, 17, 0, -25 },
  { 5470, 12, 25, 14, 1, -25 },
  { 5508, 13, 42, 17, 2, -34 },
  { 5577, 3, 47, 19, 8, -36 },
  { 5595, 13, 42, 17, 2, -34 },
  { 5664, 18, 6, 20, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Regular47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR47PT7B_H_
