#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x79, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x3D, 0xEF, 0xFB, 0xC0, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x18, 0x03, 0x06,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x18, 0x38, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF,
  0x87, 0x06, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x60, 0xE0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x87, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x01, 0xFF, 0xE7, 0xFF, 0x9F, 0xEF,
  0x79, 0xC2, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1E,
  0x70, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x39, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1E,
  0x0E, 0x77, 0x9F, 0xEF, 0xFF, 0x9F, 0xFE, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x10, 0x0F, 0xC0,
  0x38, 0x07, 0xF8, 0x0E, 0x01, 0xCE, 0x03, 0x80, 0xE3, 0x81, 0xC0, 0x38,
  0x70, 0x70, 0x0E, 0x1C, 0x18, 0x03, 0x87, 0x0E, 0x00, 0xE1, 0xC3, 0x80,
  0x38, 0x71, 0xC0, 0x0E, 0x1C, 0x70, 0x03, 0x87, 0x1C, 0x00, 0xE1, 0xCE,
  0x00, 0x38, 0x73, 0x8F, 0x8E, 0x1C, 0xE7, 0xF3, 0x8E, 0x73, 0xDC, 0x73,
  0x9C, 0xE3, 0x9F, 0xE7, 0x38, 0xE3, 0xF3, 0x8C, 0x38, 0x70, 0xE7, 0x0E,
  0x00, 0x39, 0xC3, 0x80, 0x1C, 0x70, 0xE0, 0x07, 0x1C, 0x3C, 0x01, 0xC7,
  0x0E, 0x00, 0xE1, 0xC3, 0x80, 0x38, 0x70, 0xE0, 0x0C, 0x0C, 0x38, 0x07,
  0x03, 0x8E, 0x01, 0xC0, 0xE3, 0x80, 0xE0, 0x3D, 0xC0, 0x38, 0x07, 0xF0,
  0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xE7,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x1E,
  0x3C, 0xE1, 0xE7, 0x8F, 0x1E, 0x70, 0x79, 0xC7, 0x07, 0xBC, 0xF0, 0x3F,
  0xCF, 0x01, 0xF8, 0xF0, 0x1F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x81,
  0xF8, 0x7C, 0x3F, 0xC3, 0xFF, 0xBC, 0x3F, 0xF1, 0xE1, 0xFE, 0x1F, 0xFF,
  0xFE, 0xEE, 0xEE, 0xEE, 0xE0, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0xE7, 0x3B, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0x80, 0x77,
  0x03, 0xCE, 0x0E, 0x3C, 0x78, 0x70, 0x41, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x7D, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0xE3,
  0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC3, 0x87, 0x8F, 0x07, 0x9E, 0x0F, 0x38,
  0x0E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1C, 0xE0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE3, 0xC7, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xC1,
  0xF0, 0xFC, 0x7F, 0x3F, 0xDE, 0xFF, 0x3D, 0x8F, 0x43, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0xC0, 0x1F, 0xF0, 0x7F, 0xF8, 0x7E, 0xFC, 0x30, 0x3E, 0x20,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0xC3, 0xFF, 0xE7, 0xCF,
  0xC6, 0x07, 0xC8, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x07, 0xF8, 0x0F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xEC, 0x07, 0xDF,
  0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x06, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xBC,
  0x01, 0xDE, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x70,
  0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x87,
  0x03, 0xC7, 0x01, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x20, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7A, 0x01, 0xF6, 0x07, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFE, 0x41, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x1E,
  0x1E, 0xFE, 0x3B, 0xFE, 0x77, 0x7E, 0xF8, 0x3D, 0xE0, 0x3B, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0,
  0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xC3, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x3C, 0x1E,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x38, 0x0E,
  0x3C, 0x1E, 0x1E, 0x3C, 0x1F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3E, 0x3C, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07,
  0x70, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x7C, 0x1E,
  0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xC3,
  0xFF, 0xC7, 0x87, 0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xE0, 0x1D, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0x78, 0x7E, 0xFF, 0xFC, 0xFF, 0x78, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x6F, 0xFF, 0xF6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x31, 0xE7, 0x9E, 0x78, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x79, 0xE7, 0x9E,
  0x71, 0xCF, 0x38, 0xE3, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x07, 0xFC, 0xFF, 0xEF,
  0xBE, 0x40, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x0F, 0xC3, 0x9C, 0x1F, 0xF1, 0xCE, 0x1E, 0x78, 0xE7, 0x0E, 0x3C, 0x73,
  0x87, 0x1C, 0x1F, 0x87, 0x0E, 0x0F, 0xC3, 0x87, 0x07, 0xE1, 0xC3, 0x83,
  0xF0, 0xE1, 0xC1, 0xF8, 0x70, 0xE0, 0xFC, 0x38, 0x70, 0x6E, 0x1C, 0x38,
  0x77, 0x0E, 0x1C, 0x3B, 0x87, 0x0E, 0x1D, 0xC3, 0xCF, 0x8E, 0xF0, 0xFE,
  0xFE, 0x38, 0x7E, 0x7E, 0x1C, 0x1E, 0x1E, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x0F,
  0x80, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3B, 0xC0, 0x03, 0xBC, 0x00, 0x39, 0xC0, 0x07, 0x9C, 0x00, 0x79,
  0xE0, 0x07, 0x1E, 0x00, 0x71, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F,
  0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xE0, 0x70, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x38, 0x03, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0xF8, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFB, 0xE1, 0xF0, 0x11, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x30, 0x7F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC1,
  0xF8, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x07, 0xCF, 0x03, 0xE3, 0xC3, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBC, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x7E, 0x1F, 0x00, 0xC1, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF3, 0xC0,
  0x0F, 0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x1F, 0x80, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFC, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xFF, 0xFF,
  0xF1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x3F, 0xFF,
  0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xEF, 0xF7, 0xF3, 0xF0, 0xF0, 0x0F, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1,
  0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7C, 0xF0, 0x3C,
  0x78, 0x1E, 0x1C, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x3E, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xEF, 0xFE, 0x00, 0x77, 0xF7, 0x00, 0x3B, 0xFB, 0x80,
  0x3D, 0xFD, 0xE0, 0x1C, 0xFE, 0x70, 0x0E, 0x7F, 0x38, 0x0F, 0x3F, 0x9C,
  0x07, 0x1F, 0xCF, 0x03, 0x8F, 0xE3, 0x81, 0xC7, 0xF1, 0xC1, 0xE3, 0xF8,
  0xF0, 0xE1, 0xFC, 0x38, 0x70, 0xFE, 0x1C, 0x38, 0x7F, 0x0E, 0x38, 0x3F,
  0x87, 0x9C, 0x1F, 0xC1, 0xCE, 0x0F, 0xE0, 0xEF, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x7F, 0x03, 0xE0,
  0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0E, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xDC, 0x03, 0xFF, 0xC0, 0x7F,
  0xB8, 0x0F, 0xF7, 0x81, 0xFE, 0xF0, 0x3F, 0xCE, 0x07, 0xF9, 0xE0, 0xFF,
  0x1C, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x87, 0x0F, 0xF0, 0xF1, 0xFE,
  0x0E, 0x3F, 0xC1, 0xE7, 0xF8, 0x1C, 0xFF, 0x03, 0xDF, 0xE0, 0x7B, 0xFC,
  0x07, 0x7F, 0x80, 0xF7, 0xF0, 0x0E, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x1F, 0x0F, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0x83,
  0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xBC, 0x1F, 0x79, 0xFC, 0xFF,
  0xF9, 0xFF, 0xC3, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3,
  0xE0, 0x3C, 0x1F, 0x0F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1E, 0x0F, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3,
  0xC3, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x78, 0x1E, 0x1E,
  0x0F, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3E,
  0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0x80, 0x9E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF4, 0x03, 0xEE, 0x0F, 0x9F, 0xFF, 0x3F, 0xFC, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x03, 0xCF,
  0x83, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xF0, 0x01, 0xFE, 0x00,
  0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x8E, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0x70, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x0F, 0x0E,
  0x01, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x0F, 0x38,
  0x01, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x70, 0x03, 0xC0, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0x07,
  0xC0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1C, 0x38, 0x07,
  0xE0, 0x3C, 0x38, 0x06, 0xE0, 0x3C, 0x3C, 0x0E, 0xE0, 0x3C, 0x3C, 0x0E,
  0xF0, 0x38, 0x3C, 0x0E, 0x70, 0x38, 0x1C, 0x0E, 0x70, 0x78, 0x1C, 0x1E,
  0x70, 0x78, 0x1E, 0x1C, 0x70, 0x78, 0x1E, 0x1C, 0x78, 0x70, 0x1E, 0x1C,
  0x38, 0x70, 0x0E, 0x1C, 0x38, 0xF0, 0x0E, 0x3C, 0x38, 0xF0, 0x0F, 0x38,
  0x38, 0xF0, 0x0F, 0x38, 0x3C, 0xE0, 0x07, 0x38, 0x1C, 0xE0, 0x07, 0x38,
  0x1D, 0xE0, 0x07, 0x38, 0x1D, 0xE0, 0x07, 0x70, 0x1D, 0xE0, 0x07, 0xF0,
  0x1D, 0xC0, 0x03, 0xF0, 0x0D, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC3, 0x81, 0xE1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x38, 0x70, 0x1E, 0x78, 0x07, 0x3C, 0x03, 0x9C, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xEF, 0x00, 0x73, 0x80, 0x79,
  0xE0, 0x38, 0xF0, 0x3C, 0x38, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x03, 0xC7,
  0x01, 0xE7, 0x80, 0x73, 0xC0, 0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03,
  0xDE, 0x03, 0xCF, 0x01, 0xE3, 0x80, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x38,
  0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xE7, 0x00, 0x77, 0x80,
  0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0xF3, 0x80, 0x38, 0xF0,
  0x1E, 0x1C, 0x07, 0x07, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x78, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF8, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0,
  0xC1, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x1F, 0xF8, 0xFF, 0xF3, 0xF9, 0xEF, 0x83, 0xDE, 0x07, 0xB8, 0x0F,
  0x70, 0x1F, 0xE0, 0x3D, 0xC0, 0xFB, 0x81, 0xF7, 0x87, 0xEF, 0xFF, 0xCF,
  0xF3, 0x8F, 0xC7, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xE7,
  0xF8, 0xEF, 0xF8, 0xFC, 0x7C, 0xF8, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8,
  0x1E, 0xF8, 0x3C, 0xEF, 0xFC, 0xE7, 0xF8, 0xE3, 0xF0, 0x07, 0xE1, 0xFF,
  0x3F, 0xF3, 0xC2, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x7C, 0x13, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x1F, 0xCF, 0x3F, 0xEF, 0x7C, 0x7F, 0x78,
  0x3F, 0x70, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x1F, 0x78, 0x3F, 0x3F, 0xFF, 0x3F,
  0xEF, 0x0F, 0xC7, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC7, 0x83,
  0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC,
  0x01, 0xC0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0xEF, 0xFE, 0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x8F, 0x1F, 0xEF, 0x3F, 0xEF, 0x7C, 0x7F, 0x78,
  0x3F, 0x70, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0x78, 0x1F, 0x78, 0x3F, 0x3F, 0xEF, 0x3F,
  0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x40, 0x3C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0x02,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x8F, 0x8E, 0x7F, 0xBB, 0xFE, 0xFC, 0x7F,
  0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0x4E,
  0xFF, 0xE4, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xE0, 0x04, 0x0E, 0x0F, 0x0F, 0x0E, 0x04, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0xFE, 0xFC, 0xFC, 0x20,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0xFE, 0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0x83,
  0x8E, 0x1E, 0x38, 0xF0, 0xE3, 0xC3, 0x9E, 0x0E, 0x70, 0x3B, 0xE0, 0xEF,
  0x83, 0xFF, 0x0F, 0xBC, 0x3C, 0x70, 0xE1, 0xE3, 0x83, 0x8E, 0x0F, 0x38,
  0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE3,
  0xE0, 0xF8, 0xE7, 0xF1, 0xFE, 0xEF, 0xFB, 0xFE, 0xFC, 0x7B, 0x1F, 0xF8,
  0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE3,
  0xE3, 0x9F, 0xCE, 0xFF, 0xBF, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C,
  0x7C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xE3, 0xE0, 0xE7, 0xF8, 0xEF, 0xF8, 0xFC,
  0x7C, 0xF8, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x1E, 0xFC, 0x3C, 0xEF,
  0xFC, 0xE7, 0xF8, 0xE3, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0x8F, 0x1F, 0xEF, 0x3F, 0xEF, 0x7C, 0x7F, 0x78,
  0x3F, 0x70, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0x78, 0x1F, 0x78, 0x3F, 0x3F, 0xEF, 0x3F,
  0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0xE3, 0xF9, 0xFE, 0xFF, 0xBF, 0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC,
  0xF0, 0x67, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1D, 0x00, 0xEC, 0x0F, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFC, 0x7F, 0x0F, 0xC0, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x7D,
  0xFF, 0x77, 0xFD, 0xCF, 0xE7, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x1C, 0x3C,
  0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xDC, 0x07, 0xC0, 0xF7,
  0x01, 0xF0, 0x3D, 0xE0, 0x7C, 0x0F, 0x78, 0x3F, 0x03, 0x9E, 0x0E, 0xC0,
  0xE3, 0x83, 0xB8, 0x78, 0xE0, 0xEE, 0x1E, 0x3C, 0x3B, 0x87, 0x0F, 0x1C,
  0xE1, 0xC1, 0xC7, 0x38, 0x70, 0x71, 0xC7, 0x3C, 0x1C, 0x71, 0xCF, 0x07,
  0x9C, 0x73, 0x81, 0xEE, 0x1C, 0xE0, 0x3B, 0x87, 0x38, 0x0E, 0xE1, 0xDE,
  0x03, 0xB8, 0x3F, 0x00, 0xEE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0xF0,
  0x1F, 0xE0, 0x79, 0xE0, 0xF3, 0xC1, 0xC3, 0x87, 0x87, 0x8E, 0x07, 0x3C,
  0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF1, 0xC1, 0xC3,
  0xC7, 0x83, 0x8E, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x3C, 0x1C,
  0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x0E, 0x78,
  0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0x00, 0xFC, 0x03, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0xF0, 0x3F,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0, 0x00, 0x3F,
  0x00, 0xBF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE8, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 31, 10, 3, -31 },
  { 21, 11, 11, 17, 3, -31 },
  { 37, 18, 31, 20, 1, -31 },
  { 107, 15, 36, 19, 2, -33 },
  { 175, 26, 32, 29, 2, -32 },
  { 279, 20, 32, 21, 1, -32 },
  { 359, 4, 11, 9, 3, -31 },
  { 365, 10, 39, 13, 2, -32 },
  { 414, 10, 39, 13, 1, -32 },
  { 463, 14, 14, 17, 2, -33 },
  { 488, 17, 21, 19, 1, -26 },
  { 533, 6, 11, 10, 2, -5 },
  { 542, 10, 4, 12, 1, -14 },
  { 547, 4, 5, 10, 3, -5 },
  { 550, 15, 32, 16, 1, -32 },
  { 610, 15, 32, 19, 2, -32 },
  { 670, 10, 31, 19, 3, -31 },
  { 709, 16, 32, 19, 1, -32 },
  { 773, 15, 32, 19, 2, -32 },
  { 833, 17, 32, 19, 1, -32 },
  { 901, 15, 31, 19, 2, -31 },
  { 960, 15, 32, 19, 2, -32 },
  { 1020, 16, 31, 19, 1, -31 },
  { 1082, 16, 32, 19, 1, -32 },
  { 1146, 15, 32, 19, 2, -32 },
  { 1206, 4, 24, 10, 3, -24 },
  { 1218, 6, 30, 10, 2, -24 },
  { 1241, 17, 19, 19, 1, -25 },
  { 1282, 17, 13, 19, 1, -22 },
  { 1310, 17, 19, 19, 1, -25 },
  { 1351, 12, 32, 14, 1, -32 },
  { 1399, 25, 36, 29, 2, -32 },
  { 1512, 20, 31, 20, 0, -31 },
  { 1590, 16, 31, 21, 3, -31 },
  { 1652, 17, 32, 20, 2, -32 },
  { 1720, 18, 31, 23, 3, -31 },
  { 1790, 13, 31, 18, 3, -31 },
  { 1841, 13, 31, 17, 3, -31 },
  { 1892, 20, 32, 24, 2, -32 },
  { 1972, 17, 31, 23, 3, -31 },
  { 2038, 10, 31, 12, 1, -31 },
  { 2077, 9, 39, 10, -2, -31 },
  { 2121, 17, 31, 20, 3, -31 },
  { 2187, 13, 31, 16, 3, -31 },
  { 2238, 25, 31, 32, 3, -31 },
  { 2335, 19, 31, 25, 3, -31 },
  { 2409, 20, 32, 24, 2, -32 },
  { 2489, 15, 31, 19, 3, -31 },
  { 2548, 20, 39, 24, 2, -32 },
  { 2646, 17, 31, 20, 3, -31 },
  { 2712, 15, 32, 18, 2, -32 },
  { 2772, 16, 31, 17, 0, -31 },
  { 2834, 17, 31, 23, 3, -31 },
  { 2900, 19, 31, 19, 0, -31 },
  { 2974, 32, 31, 32, 0, -31 },
  { 3098, 17, 31, 18, 0, -31 },
  { 3164, 17, 31, 17, 0, -31 },
  { 3230, 14, 31, 16, 1, -31 },
  { 3285, 9, 39, 14, 3, -32 },
  { 3329, 15, 32, 16, 1, -32 },
  { 3389, 10, 39, 14, 1, -32 },
  { 3438, 18, 16, 19, 1, -31 },
  { 3474, 19, 2, 19, 0, 4 },
  { 3479, 8, 7, 12, 2, -34 },
  { 3486, 15, 24, 18, 1, -24 },
  { 3531, 16, 33, 20, 3, -33 },
  { 3597, 12, 24, 15, 2, -24 },
  { 3633, 16, 33, 20, 2, -33 },
  { 3699, 15, 24, 18, 2, -24 },
  { 3744, 12, 34, 11, 0, -34 },
  { 3795, 16, 35, 20, 2, -24 },
  { 3865, 14, 33, 20, 3, -33 },
  { 3923, 4, 33, 9, 3, -33 },
  { 3940, 8, 44, 9, -1, -33 },
  { 3984, 14, 33, 18, 3, -33 },
  { 4042, 3, 33, 9, 3, -33 },
  { 4055, 24, 24, 30, 3, -24 },
  { 4127, 14, 24, 20, 3, -24 },
  { 4169, 16, 24, 20, 2, -24 },
  { 4217, 16, 35, 20, 3, -24 },
  { 4287, 16, 35, 20, 2, -24 },
  { 4357, 10, 24, 13, 3, -24 },
  { 4387, 13, 24, 15, 1, -24 },
  { 4426, 10, 29, 11, 1, -29 },
  { 4463, 14, 24, 20, 3, -24 },
  { 4505, 16, 24, 16, 0, -24 },
  { 4553, 26, 24, 27, 0, -24 },
  { 4631, 15, 24, 16, 1, -24 },
  { 4676, 16, 35, 16, 0, -24 },
  { 4746, 11, 24, 13, 1, -24 },
  { 4779, 12, 39, 16, 2, -32 },
  { 4838, 4, 44, 18, 7, -34 },
  { 4860, 12, 39, 16, 2, -32 },
  { 4919, 17, 5, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Regular44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR44PT7B_H_
