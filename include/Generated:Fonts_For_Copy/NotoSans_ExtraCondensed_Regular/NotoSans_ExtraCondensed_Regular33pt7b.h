#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F,
  0xFE, 0xE3, 0xF1, 0xF8, 0xFC, 0x6E, 0x37, 0x1B, 0x8D, 0xC6, 0xE3, 0x00,
  0x0C, 0x30, 0x30, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6,
  0x3F, 0xFF, 0xFF, 0xFC, 0x61, 0x81, 0x8E, 0x06, 0x30, 0x18, 0xC0, 0x63,
  0x01, 0x8C, 0x3F, 0xFE, 0xFF, 0xF8, 0xC3, 0x03, 0x1C, 0x0C, 0x60, 0x31,
  0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFE,
  0x3F, 0xE7, 0x62, 0x66, 0x0E, 0x60, 0xE6, 0x0E, 0x60, 0x76, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x6E, 0x06, 0x70, 0x63, 0x06, 0x70, 0x67,
  0xC6, 0xEF, 0xFC, 0x7F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x1C,
  0x06, 0x03, 0xE0, 0x60, 0x66, 0x0C, 0x06, 0x70, 0xC0, 0x63, 0x0C, 0x0E,
  0x31, 0x80, 0xE3, 0x18, 0x0E, 0x33, 0x80, 0xE3, 0x30, 0x0E, 0x33, 0x00,
  0x63, 0x73, 0xC6, 0x76, 0x7E, 0x66, 0x6E, 0x63, 0xEE, 0xC6, 0x18, 0xCC,
  0x60, 0x0C, 0xC7, 0x01, 0xCC, 0x70, 0x18, 0xC7, 0x01, 0x8C, 0x70, 0x30,
  0xC6, 0x03, 0x0C, 0x60, 0x30, 0x66, 0x06, 0x07, 0xE0, 0x60, 0x3C, 0x0F,
  0x00, 0x3F, 0x00, 0xEE, 0x01, 0x8E, 0x03, 0x1C, 0x06, 0x38, 0x0C, 0x70,
  0x1C, 0xC0, 0x39, 0x80, 0x37, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0E,
  0xE3, 0x9C, 0xE7, 0x71, 0xCC, 0xE1, 0xF9, 0xC1, 0xF3, 0x83, 0xC7, 0x03,
  0x8E, 0x0F, 0x0E, 0x3F, 0x1F, 0xE7, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x0E, 0x0C, 0x18, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0C, 0x38,
  0x70, 0xC3, 0x8E, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x23, 0x3F, 0xFF, 0xFF,
  0xC3, 0x80, 0xD8, 0x3B, 0x8E, 0x38, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x39, 0xDC, 0xE7, 0x31, 0x9C,
  0xFF, 0xFC, 0x6E, 0xFE, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0x0F, 0x01, 0xF8, 0x3F, 0xC3, 0x8E, 0x70, 0xE7, 0x0E, 0x70, 0x66,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0x60, 0x76, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE3, 0x9C, 0x3F, 0xC1,
  0xF8, 0x07, 0x0F, 0x1F, 0x3F, 0x77, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x1F, 0x07, 0xF8, 0xFF, 0xC6, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0x1F, 0x07, 0xFC, 0xFF, 0xC4, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x81, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xEC, 0x1E, 0xFF, 0xCF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x3B,
  0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0E, 0x30, 0x61, 0x87, 0x0C, 0x30, 0x61,
  0x83, 0x18, 0x18, 0xC0, 0xC7, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0xFF, 0x9F, 0xF3, 0xFE, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0xFC, 0x7F, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1D, 0x07, 0x3F, 0xE7,
  0xF0, 0x03, 0xE0, 0xFE, 0x1F, 0xE3, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x78, 0x6F, 0xCF, 0xFE, 0xF0, 0xEF, 0x06, 0xE0, 0x7E,
  0x07, 0x60, 0x76, 0x07, 0x70, 0x77, 0x06, 0x70, 0xE3, 0x9E, 0x3F, 0xC0,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0x66, 0x07, 0x60, 0x67,
  0x06, 0x70, 0xE3, 0x9C, 0x1F, 0x80, 0xF0, 0x1F, 0x83, 0x9C, 0x70, 0xE6,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x3F, 0xE1,
  0xF8, 0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0x0C, 0x60, 0xEE, 0x0E, 0xE0, 0x6E,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0xF7, 0x0F, 0x71, 0xF3, 0xF6, 0x1E, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC4, 0x38, 0x7F, 0x07,
  0xE0, 0x6E, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6E, 0xFE, 0x33, 0x9E,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x73, 0x9C, 0xC6, 0x70,
  0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x01, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0C, 0x00, 0x80, 0x00,
  0x3E, 0x3F, 0xE7, 0xF9, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0xE1,
  0xE0, 0x60, 0x1C, 0x38, 0x03, 0x1C, 0x00, 0xE6, 0x00, 0x19, 0x87, 0xE6,
  0xE3, 0xF9, 0xF1, 0xCE, 0x3C, 0x63, 0x8F, 0x18, 0xE3, 0xC6, 0x38, 0xF1,
  0x8C, 0x3C, 0x63, 0x0F, 0x18, 0xC3, 0xC6, 0x31, 0xF1, 0x9E, 0x6C, 0x7D,
  0xFB, 0x0F, 0x3C, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x18, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0,
  0x38, 0xC0, 0x71, 0xC0, 0xE3, 0x81, 0x87, 0x03, 0x06, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x60, 0x71, 0xC0, 0x63, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0xB8, 0x03, 0x70, 0x07, 0xFC, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE3, 0xEF, 0xF8, 0xFF, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x1E, 0xFF, 0xEF, 0xF8, 0x07, 0xC1, 0xFF, 0x3F, 0xE3, 0x82, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0xC2, 0x1F, 0xE0, 0xFE, 0xFC, 0x07, 0xFC, 0x3F, 0xF9, 0xC1, 0xCE, 0x07,
  0x70, 0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xEE, 0x0F, 0x73, 0xF3, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xB8,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x03, 0xE0, 0x3F, 0xF1, 0xFF,
  0xCF, 0x02, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x77, 0x01, 0xDC, 0x07, 0x78, 0x1C, 0xF0, 0x71, 0xFF, 0xC3,
  0xFE, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x3F,
  0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0xFF, 0xDF, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C,
  0x70, 0xE3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x3B, 0x81, 0xDC, 0x0F,
  0xF0, 0x7F, 0x83, 0xDC, 0x1C, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x71, 0xC1,
  0xCE, 0x0E, 0x70, 0x3B, 0x81, 0xDC, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x06, 0xFB, 0x00, 0xDF, 0x60, 0x3B, 0xEE, 0x06, 0x7D, 0xC0,
  0xCF, 0x98, 0x19, 0xF3, 0x07, 0x3E, 0x70, 0xC7, 0xC6, 0x18, 0xF8, 0xC7,
  0x1F, 0x1C, 0xC3, 0xE3, 0x98, 0x7C, 0x33, 0x0F, 0x86, 0xE1, 0xF0, 0xF8,
  0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3E, 0xC0, 0xFB, 0x83,
  0xE6, 0x0F, 0x9C, 0x3E, 0x70, 0xF8, 0xC3, 0xE3, 0x8F, 0x86, 0x3E, 0x1C,
  0xF8, 0x73, 0xE0, 0xEF, 0x83, 0xBE, 0x06, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x07, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xC3, 0xC7,
  0x03, 0x9C, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0x37, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0x73, 0x81, 0xC7, 0x03, 0x87, 0x9E, 0x07, 0xFC, 0x07,
  0xE0, 0xF8, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x06, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFE, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xC3, 0xC7, 0x03, 0x9C, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x37, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0x73, 0x81, 0xC7, 0x03, 0x87, 0x9E, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0xF8, 0x07,
  0xFC, 0x3F, 0xF1, 0xC3, 0xCE, 0x0E, 0x70, 0x33, 0x81, 0xDC, 0x0E, 0xE0,
  0x77, 0x07, 0x38, 0x39, 0xC3, 0x8F, 0xFC, 0x7F, 0x83, 0x8E, 0x1C, 0x70,
  0xE1, 0x87, 0x0E, 0x38, 0x71, 0xC1, 0xCE, 0x0E, 0x70, 0x3B, 0x81, 0xDC,
  0x0F, 0x0F, 0x87, 0xFD, 0xFF, 0xB8, 0x17, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xE0, 0x0C, 0x03, 0x80, 0x78, 0x0F, 0xC7, 0xBF, 0xF3, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x77, 0x07, 0x3C, 0x78, 0xFF, 0x83,
  0xF8, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07,
  0x1C, 0x0E, 0x18, 0x1C, 0x38, 0x38, 0x70, 0x60, 0xE1, 0xC0, 0xC3, 0x81,
  0xC7, 0x03, 0x8C, 0x07, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x1D, 0x80, 0x3B,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x18,
  0x07, 0xE0, 0x38, 0x06, 0x60, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x3C,
  0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7C, 0x0C, 0x30, 0x6E, 0x1C, 0x38, 0x6E,
  0x1C, 0x38, 0x66, 0x1C, 0x38, 0x66, 0x1C, 0x38, 0xE6, 0x18, 0x18, 0xE7,
  0x38, 0x1C, 0xC7, 0x38, 0x1C, 0xC3, 0x38, 0x1C, 0xC3, 0x38, 0x1D, 0xC3,
  0x30, 0x0D, 0xC3, 0xF0, 0x0D, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0x70, 0x3B,
  0x83, 0x8C, 0x1C, 0x70, 0xE3, 0x8E, 0x0C, 0x70, 0x73, 0x01, 0xB8, 0x0D,
  0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xB8,
  0x1D, 0xC0, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x07, 0x38, 0x39, 0xC0, 0xDC,
  0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xE3,
  0x87, 0x18, 0x1D, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0,
  0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0xFF, 0xFC, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x06, 0xC0, 0x3B, 0x80, 0xCE, 0x07,
  0x18, 0x18, 0x70, 0xE0, 0xC3, 0x03, 0x9C, 0x06, 0xE0, 0x1C, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF1, 0xC3, 0x87, 0x0C, 0x1F, 0x0F, 0xF8, 0xC7, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x3F, 0xEF, 0x9D, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7F, 0x8F, 0x7F, 0xE7, 0xCC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF, 0x9E, 0xF0, 0xEE,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x6F, 0x0E, 0xF8, 0xEF, 0xFC, 0xCF, 0x80, 0x0F, 0x87, 0xF3,
  0xC9, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x00, 0xE1, 0x3F, 0xC7, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xF7, 0x3F, 0xB3, 0xDB, 0x70,
  0xF7, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x76, 0x07, 0x70, 0x77, 0x07, 0x78, 0xF3, 0xFB, 0x1F, 0x30, 0x0F, 0x07,
  0xF8, 0xE7, 0x38, 0x77, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC3, 0x3F, 0xE1, 0xF8, 0x0F,
  0x8F, 0xC7, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x7E, 0xFF, 0x7F, 0x8E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x00, 0x1F, 0x33, 0xFB, 0x39, 0xB7, 0x0F, 0x70, 0x76,
  0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77,
  0x07, 0x70, 0x77, 0x8F, 0x3F, 0xB1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x40, 0xE7, 0xBE, 0x7F, 0xC1, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x3C, 0xFF, 0xDF, 0x3B, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x39, 0xCE, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFB, 0xDC, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xE1, 0xDC,
  0x33, 0x8E, 0x73, 0x8E, 0x61, 0xDC, 0x3B, 0x87, 0xF0, 0xF6, 0x1E, 0xE3,
  0x8C, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x77, 0x06, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xCF, 0x8F, 0x37, 0xF7,
  0xEF, 0xBF, 0xBF, 0xC3, 0x87, 0xE0, 0xE0, 0xF8, 0x38, 0x3E, 0x0E, 0x0F,
  0x83, 0x83, 0xE0, 0xE0, 0xF8, 0x38, 0x3E, 0x0E, 0x0F, 0x83, 0x83, 0xE0,
  0xE0, 0xF8, 0x38, 0x3E, 0x0E, 0x0F, 0x83, 0x83, 0xE0, 0xE0, 0xF8, 0x38,
  0x30, 0xC7, 0x9B, 0xFB, 0xE7, 0x78, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1C, 0x0F, 0x83, 0xFC, 0x3D, 0xE7, 0x06, 0x70, 0x76, 0x07, 0x60,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x77, 0x07, 0x70,
  0x63, 0x8E, 0x3F, 0xC1, 0xF8, 0xC7, 0x8C, 0xFC, 0xF9, 0xEF, 0x0E, 0xE0,
  0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xF0, 0xEF, 0x8E, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0x33, 0xFB, 0x3D,
  0xB7, 0x0F, 0x70, 0x76, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x60, 0x77, 0x07, 0x70, 0x77, 0x8F, 0x3F, 0xB1, 0xF7, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xC7,
  0xCF, 0xDE, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x3F, 0xDC, 0x5C, 0x0E, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0x87, 0xFF,
  0x7F, 0x00, 0x30, 0x60, 0xC3, 0x87, 0xFF, 0xFF, 0xB8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0xE7, 0xC0, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7B, 0x8F, 0x7F, 0x67, 0xCC, 0xE0,
  0x7E, 0x07, 0x60, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x30, 0xE3, 0x8C, 0x39,
  0xC3, 0x9C, 0x19, 0x81, 0x98, 0x1D, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0xE0, 0xF0, 0x76, 0x0F, 0x06, 0x60, 0xF0, 0x67, 0x0F, 0x0E,
  0x70, 0xF0, 0xE7, 0x1F, 0x8E, 0x31, 0xB8, 0xC3, 0x19, 0x8C, 0x39, 0x99,
  0xC3, 0x99, 0x9C, 0x3B, 0x9D, 0x81, 0xB1, 0xD8, 0x1B, 0x0D, 0x81, 0xB0,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0x70, 0x70,
  0x77, 0x0E, 0x38, 0xE3, 0x8C, 0x19, 0xC1, 0xD8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1D, 0x81, 0x9C, 0x38, 0xC3, 0x0E, 0x70,
  0xEE, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x06, 0x70, 0xE3, 0x0E, 0x30,
  0xC3, 0x8C, 0x39, 0xC1, 0x9C, 0x19, 0x81, 0xD8, 0x1D, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0x00,
  0xC1, 0xF0, 0xFC, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x0F, 0x0F, 0x03, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x1F, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x3E, 0x0F, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0xC0, 0x3C, 0x1F, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC3, 0xE0,
  0xF0, 0x00, 0x38, 0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0x80, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 9, 9, 13, 2, -24 },
  { 24, 14, 24, 15, 1, -24 },
  { 66, 12, 27, 14, 1, -25 },
  { 107, 20, 24, 22, 1, -24 },
  { 167, 15, 24, 16, 1, -24 },
  { 212, 3, 9, 7, 2, -24 },
  { 216, 7, 29, 10, 2, -24 },
  { 242, 7, 29, 10, 1, -24 },
  { 268, 11, 11, 13, 1, -25 },
  { 284, 12, 15, 14, 1, -19 },
  { 307, 5, 8, 7, 1, -4 },
  { 312, 7, 2, 9, 1, -10 },
  { 314, 4, 4, 7, 2, -4 },
  { 316, 11, 24, 12, 1, -24 },
  { 349, 12, 24, 14, 1, -24 },
  { 385, 8, 24, 14, 2, -24 },
  { 409, 12, 24, 14, 1, -24 },
  { 445, 12, 24, 14, 1, -24 },
  { 481, 13, 24, 14, 1, -24 },
  { 520, 11, 24, 14, 2, -24 },
  { 553, 12, 24, 14, 1, -24 },
  { 589, 12, 24, 14, 1, -24 },
  { 625, 12, 24, 14, 1, -24 },
  { 661, 12, 24, 14, 1, -24 },
  { 697, 4, 18, 8, 2, -18 },
  { 706, 5, 22, 8, 1, -18 },
  { 720, 12, 15, 14, 1, -19 },
  { 743, 12, 9, 14, 1, -16 },
  { 757, 12, 15, 14, 1, -19 },
  { 780, 10, 24, 11, 0, -24 },
  { 810, 18, 27, 21, 2, -24 },
  { 871, 15, 24, 15, 0, -24 },
  { 916, 12, 24, 16, 2, -24 },
  { 952, 12, 24, 15, 2, -24 },
  { 988, 13, 24, 17, 2, -24 },
  { 1027, 10, 24, 13, 2, -24 },
  { 1057, 10, 24, 13, 2, -24 },
  { 1087, 14, 24, 18, 2, -24 },
  { 1129, 13, 24, 18, 2, -24 },
  { 1168, 7, 24, 9, 1, -24 },
  { 1189, 7, 30, 7, -2, -24 },
  { 1216, 13, 24, 15, 2, -24 },
  { 1255, 10, 24, 12, 2, -24 },
  { 1285, 19, 24, 24, 2, -24 },
  { 1342, 14, 24, 19, 2, -24 },
  { 1384, 15, 24, 18, 2, -24 },
  { 1429, 12, 24, 15, 2, -24 },
  { 1465, 15, 30, 18, 2, -24 },
  { 1522, 13, 24, 15, 2, -24 },
  { 1561, 11, 24, 14, 1, -24 },
  { 1594, 12, 24, 13, 0, -24 },
  { 1630, 13, 24, 17, 2, -24 },
  { 1669, 15, 24, 15, 0, -24 },
  { 1714, 24, 24, 24, 0, -24 },
  { 1786, 13, 24, 13, 0, -24 },
  { 1825, 13, 24, 13, 0, -24 },
  { 1864, 10, 24, 12, 1, -24 },
  { 1894, 7, 29, 10, 2, -24 },
  { 1920, 11, 24, 12, 1, -24 },
  { 1953, 7, 29, 10, 1, -24 },
  { 1979, 14, 13, 15, 0, -24 },
  { 2002, 14, 2, 14, 0, 3 },
  { 2006, 6, 5, 9, 1, -25 },
  { 2010, 11, 18, 14, 1, -18 },
  { 2035, 12, 25, 15, 2, -25 },
  { 2073, 10, 18, 11, 1, -18 },
  { 2096, 12, 25, 15, 1, -25 },
  { 2134, 11, 18, 14, 1, -18 },
  { 2159, 9, 25, 8, 0, -25 },
  { 2188, 12, 26, 15, 1, -18 },
  { 2227, 11, 25, 15, 2, -25 },
  { 2262, 3, 24, 7, 2, -24 },
  { 2271, 5, 32, 7, 0, -24 },
  { 2291, 11, 25, 13, 2, -25 },
  { 2326, 3, 25, 7, 2, -25 },
  { 2336, 18, 18, 23, 2, -18 },
  { 2377, 11, 18, 15, 2, -18 },
  { 2402, 12, 18, 15, 1, -18 },
  { 2429, 12, 26, 15, 2, -18 },
  { 2468, 12, 26, 15, 1, -18 },
  { 2507, 8, 18, 10, 2, -18 },
  { 2525, 9, 18, 11, 1, -18 },
  { 2546, 7, 22, 9, 1, -22 },
  { 2566, 11, 18, 15, 2, -18 },
  { 2591, 12, 18, 12, 0, -18 },
  { 2618, 20, 18, 20, 0, -18 },
  { 2663, 12, 18, 12, 0, -18 },
  { 2690, 12, 26, 12, 0, -18 },
  { 2729, 8, 18, 10, 1, -18 },
  { 2747, 10, 29, 12, 1, -24 },
  { 2784, 3, 33, 13, 5, -25 },
  { 2797, 10, 29, 12, 1, -24 },
  { 2834, 12, 5, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Regular33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR33PT7B_H_
