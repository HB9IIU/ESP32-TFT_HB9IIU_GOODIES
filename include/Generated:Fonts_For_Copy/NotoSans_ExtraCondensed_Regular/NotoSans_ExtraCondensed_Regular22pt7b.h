#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0x92, 0x49, 0x20, 0xBB, 0xCF, 0x3C, 0xF3, 0x4D, 0x30,
  0x09, 0x06, 0x41, 0x90, 0x64, 0x11, 0x1F, 0xF1, 0x30, 0x4C, 0x12, 0x0C,
  0x8F, 0xF8, 0xC8, 0x22, 0x09, 0x82, 0x60, 0x98, 0x10, 0x10, 0x3C, 0x7E,
  0xD0, 0x90, 0xD0, 0xD0, 0x78, 0x1C, 0x16, 0x13, 0x13, 0x92, 0xFE, 0x78,
  0x10, 0x10, 0x70, 0xC6, 0x84, 0x36, 0x21, 0x33, 0x08, 0x90, 0x45, 0x82,
  0x6D, 0x9B, 0x5E, 0xD6, 0x93, 0xB4, 0xC1, 0x26, 0x19, 0x30, 0x89, 0x84,
  0x4C, 0x63, 0x42, 0x0E, 0x38, 0x1F, 0x06, 0xC1, 0x90, 0x6C, 0x1B, 0x03,
  0x80, 0xC0, 0x78, 0x36, 0x6C, 0xDA, 0x1C, 0x87, 0x31, 0xCE, 0xD9, 0xE7,
  0xFF, 0x50, 0x19, 0x88, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x8C, 0x61, 0x0C,
  0x61, 0x8E, 0x8C, 0x66, 0x23, 0x33, 0x31, 0x13, 0x33, 0x32, 0x66, 0xC0,
  0x30, 0x22, 0x4F, 0xF3, 0x8D, 0x1B, 0x24, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x6D, 0x6D, 0x00, 0xFF, 0x5F, 0x80, 0x03,
  0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30, 0x20,
  0x60, 0x60, 0xC0, 0x38, 0x7C, 0x66, 0xC6, 0xC6, 0xC2, 0xC2, 0xC3, 0xC3,
  0xC2, 0xC2, 0xC6, 0xC6, 0xC6, 0x6C, 0x3C, 0x08, 0xCF, 0xD4, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x79, 0xFA, 0x18, 0x30, 0x60, 0xC1, 0x86,
  0x0C, 0x30, 0x61, 0x86, 0x18, 0x3F, 0xFF, 0x79, 0xFA, 0x18, 0x30, 0x60,
  0xC3, 0x3C, 0x7C, 0x0C, 0x18, 0x30, 0x60, 0xF3, 0xFE, 0x07, 0x03, 0x83,
  0xC1, 0x61, 0xB0, 0x98, 0x4C, 0x66, 0x23, 0x31, 0x90, 0xDF, 0xFF, 0xF8,
  0x18, 0x0C, 0x06, 0x7E, 0xFD, 0x06, 0x0C, 0x18, 0x3E, 0x7E, 0x06, 0x0C,
  0x08, 0x10, 0x60, 0xF3, 0xFE, 0x1E, 0x3E, 0x60, 0x60, 0xC0, 0xC0, 0xDC,
  0xFE, 0xC6, 0xC2, 0xC3, 0xC3, 0xC2, 0x46, 0x6E, 0x3C, 0xFF, 0xFF, 0x02,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20,
  0x60, 0x3C, 0x7E, 0xC6, 0xC2, 0xC2, 0xC6, 0x6C, 0x38, 0x7C, 0xE6, 0xC6,
  0xC3, 0xC3, 0xC3, 0xE6, 0x7C, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0x71, 0xE3,
  0xEE, 0xF4, 0x18, 0x30, 0x61, 0xA7, 0x3C, 0x5D, 0x00, 0x00, 0x0B, 0xF0,
  0x5D, 0x00, 0x00, 0x0D, 0xAD, 0xA0, 0x01, 0x03, 0x0E, 0x38, 0xE0, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0,
  0x70, 0x1C, 0x0F, 0x07, 0x1C, 0x70, 0xE0, 0x80, 0x79, 0xF8, 0x30, 0x30,
  0x41, 0x83, 0x0C, 0x10, 0x60, 0xC1, 0x80, 0x04, 0x0C, 0x18, 0x07, 0x01,
  0xDC, 0x30, 0x66, 0x02, 0x42, 0x34, 0xF9, 0xC9, 0x9C, 0x99, 0xD9, 0x9D,
  0x99, 0xD9, 0x9C, 0x9B, 0xCE, 0xE4, 0x44, 0x60, 0x06, 0x00, 0x39, 0x80,
  0xF0, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x16, 0x04, 0x83, 0x30, 0xCC, 0x33,
  0x0F, 0xC7, 0xF9, 0x86, 0x61, 0x98, 0x6C, 0x0F, 0x03, 0xF8, 0xFE, 0x86,
  0x86, 0x86, 0x86, 0x86, 0xFC, 0xFE, 0x86, 0x83, 0x83, 0x83, 0x86, 0xFE,
  0xFC, 0x1F, 0x3F, 0x70, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x3B, 0x1F, 0xF0, 0xFC, 0x86, 0x87, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x86, 0xFC, 0xF8, 0xFF, 0xF8, 0x20,
  0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xFF, 0xFF, 0xF8, 0x20,
  0x82, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x0F, 0x0F, 0xF7,
  0x09, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xF0, 0x3C, 0x0F, 0x03,
  0x60, 0xD8, 0x33, 0x9C, 0x7F, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xFF, 0xFF, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFF, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x6F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x13, 0xBE, 0x83, 0x86, 0x84, 0x8C, 0x98, 0x98, 0xB0, 0xB0, 0xF0,
  0xD8, 0x98, 0x8C, 0x8C, 0x86, 0x86, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xFF, 0xC0, 0x3E, 0x07, 0xE0, 0x7A,
  0x05, 0xA0, 0xFB, 0x0F, 0xB0, 0xB9, 0x0B, 0x99, 0xB9, 0x9B, 0x89, 0x38,
  0xB3, 0x8F, 0x38, 0xE3, 0x86, 0x38, 0x63, 0xC1, 0xE0, 0xF8, 0x7C, 0x3B,
  0x1D, 0x8E, 0x47, 0x33, 0x89, 0xC6, 0xE3, 0x70, 0xF8, 0x7C, 0x1E, 0x0F,
  0x07, 0x1E, 0x0F, 0xC6, 0x19, 0x86, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x61, 0x98, 0x63, 0xF0, 0x78, 0xF1, 0xFA, 0x3C,
  0x38, 0x70, 0xE1, 0xC7, 0xFD, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1E,
  0x0F, 0xC6, 0x19, 0x86, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x61, 0x98, 0x63, 0xF8, 0x7C, 0x03, 0x00, 0xC0, 0x18, 0x07,
  0xF0, 0xFC, 0x8E, 0x86, 0x86, 0x86, 0x86, 0x8C, 0xF8, 0x98, 0x98, 0x8C,
  0x8C, 0x86, 0x86, 0x83, 0x3C, 0xFF, 0x0E, 0x0C, 0x18, 0x38, 0x3C, 0x1C,
  0x1C, 0x18, 0x30, 0x60, 0xFF, 0x7C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x34,
  0x1B, 0x0D, 0xDC, 0x7C, 0xC0, 0xF0, 0x64, 0x19, 0x86, 0x61, 0x98, 0x46,
  0x30, 0xCC, 0x33, 0x0C, 0x83, 0x60, 0x58, 0x1E, 0x07, 0x01, 0xC0, 0x30,
  0xC1, 0x83, 0xC1, 0x83, 0x41, 0x86, 0x63, 0x86, 0x63, 0xC6, 0x63, 0xC6,
  0x62, 0xC4, 0x22, 0x4C, 0x36, 0x4C, 0x36, 0x6C, 0x36, 0x6C, 0x34, 0x68,
  0x14, 0x28, 0x14, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x61, 0xB1, 0x98, 0xC6,
  0xC3, 0x60, 0xB0, 0x70, 0x38, 0x1C, 0x0E, 0x0D, 0x86, 0xC2, 0x63, 0x19,
  0x8D, 0x83, 0xC1, 0xE1, 0x98, 0xCC, 0x46, 0x61, 0xB0, 0xD0, 0x38, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0xFD, 0xF8, 0x30, 0x61,
  0x83, 0x06, 0x18, 0x30, 0x41, 0x83, 0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xFF, 0xC0, 0x60, 0x60, 0x20,
  0x30, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x02, 0x03,
  0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x08, 0x06,
  0x07, 0x02, 0xC3, 0x21, 0x99, 0x84, 0xC3, 0xC0, 0x80, 0xFF, 0xC0, 0xC6,
  0x21, 0x7C, 0xD8, 0x18, 0x30, 0x6F, 0xF9, 0xE3, 0xC7, 0x8F, 0x3B, 0xB0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xE3, 0xF6, 0xDE, 0x3D, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x06, 0x4F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x3B, 0x7F, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x3C, 0xDB, 0x1E, 0x3C, 0x3F,
  0xF0, 0x60, 0xC1, 0x81, 0x89, 0xF0, 0x1C, 0xF3, 0x08, 0x21, 0xEF, 0x88,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3B, 0x7F, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x67, 0x7B, 0x03, 0x03, 0x02, 0xC6, 0xFC,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0x6C, 0x06, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xC6,
  0xCC, 0xC8, 0xD8, 0xF8, 0xE8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xDC, 0xF7, 0xFF, 0xB9, 0xC7, 0x86, 0x3C, 0x21, 0xE1,
  0x0F, 0x08, 0x78, 0x43, 0xC2, 0x1E, 0x10, 0xF0, 0x87, 0x84, 0x30, 0xDC,
  0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C,
  0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x3C, 0xDE,
  0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xF6, 0xDE, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x3B, 0x7F, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0x67, 0x7B, 0x03, 0x03, 0x03, 0x03, 0x03, 0xDF, 0xF9, 0xCC,
  0x63, 0x18, 0xC6, 0x31, 0x80, 0x7F, 0xEC, 0x20, 0xC1, 0xC3, 0x87, 0x0C,
  0x39, 0xBE, 0x21, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC3, 0x9C, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x47, 0x6F, 0x7B, 0xC3,
  0xC3, 0x42, 0x66, 0x66, 0x66, 0x24, 0x34, 0x3C, 0x3C, 0x18, 0x18, 0xC3,
  0x1E, 0x38, 0xD1, 0xC6, 0xCA, 0x26, 0x5B, 0x32, 0xD8, 0xB6, 0xC5, 0x96,
  0x38, 0xA1, 0xC5, 0x0E, 0x38, 0x31, 0xC0, 0xE3, 0x66, 0x26, 0x34, 0x3C,
  0x18, 0x18, 0x3C, 0x34, 0x66, 0x66, 0xC3, 0xC3, 0xC3, 0x42, 0x66, 0x66,
  0x26, 0x24, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0xE0,
  0xFF, 0xC6, 0x63, 0x11, 0x8C, 0xC6, 0x3F, 0xF0, 0x0C, 0x73, 0x0C, 0x30,
  0xC3, 0x0C, 0x33, 0x8E, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xC1, 0xFF,
  0xFF, 0xFC, 0xC3, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x71, 0xCC, 0x30,
  0xC3, 0x0C, 0x30, 0xCE, 0x20, 0xF1, 0x9F, 0x84,
};

const GFXglyph NotoSans_ExtraCondensed_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 16, 5, 1, -16 },
  { 7, 6, 6, 8, 1, -16 },
  { 12, 10, 16, 10, 0, -16 },
  { 32, 8, 18, 9, 1, -17 },
  { 50, 13, 16, 15, 1, -16 },
  { 76, 10, 16, 11, 1, -16 },
  { 96, 2, 6, 5, 1, -16 },
  { 98, 5, 19, 6, 1, -16 },
  { 110, 4, 19, 6, 1, -16 },
  { 120, 7, 8, 9, 1, -17 },
  { 127, 8, 10, 9, 1, -13 },
  { 137, 3, 6, 5, 1, -3 },
  { 140, 4, 2, 6, 1, -7 },
  { 141, 3, 3, 5, 1, -3 },
  { 143, 8, 16, 8, 0, -16 },
  { 159, 8, 16, 9, 1, -16 },
  { 175, 5, 16, 9, 1, -16 },
  { 185, 7, 16, 9, 1, -16 },
  { 199, 7, 16, 9, 1, -16 },
  { 213, 9, 16, 9, 0, -16 },
  { 231, 7, 16, 9, 1, -16 },
  { 245, 8, 16, 9, 1, -16 },
  { 261, 8, 16, 9, 1, -16 },
  { 277, 8, 16, 9, 1, -16 },
  { 293, 7, 16, 9, 1, -16 },
  { 307, 3, 12, 5, 1, -12 },
  { 312, 3, 15, 5, 1, -12 },
  { 318, 8, 10, 9, 1, -13 },
  { 328, 8, 6, 9, 1, -11 },
  { 334, 8, 10, 9, 1, -13 },
  { 344, 7, 16, 7, 0, -16 },
  { 358, 12, 18, 14, 1, -16 },
  { 385, 10, 16, 10, 0, -16 },
  { 405, 8, 16, 11, 2, -16 },
  { 421, 8, 16, 10, 1, -16 },
  { 437, 8, 16, 11, 2, -16 },
  { 453, 6, 16, 9, 2, -16 },
  { 465, 6, 16, 8, 2, -16 },
  { 477, 10, 16, 12, 1, -16 },
  { 497, 8, 16, 12, 2, -16 },
  { 513, 4, 16, 6, 1, -16 },
  { 521, 4, 20, 5, -1, -16 },
  { 531, 8, 16, 10, 2, -16 },
  { 547, 6, 16, 8, 2, -16 },
  { 559, 12, 16, 16, 2, -16 },
  { 583, 9, 16, 13, 2, -16 },
  { 601, 10, 16, 12, 1, -16 },
  { 621, 7, 16, 10, 2, -16 },
  { 635, 10, 20, 12, 1, -16 },
  { 660, 8, 16, 10, 2, -16 },
  { 676, 7, 16, 9, 1, -16 },
  { 690, 8, 16, 8, 0, -16 },
  { 706, 9, 16, 11, 1, -16 },
  { 724, 10, 16, 10, 0, -16 },
  { 744, 16, 16, 16, 0, -16 },
  { 776, 9, 16, 9, 0, -16 },
  { 794, 9, 16, 9, 0, -16 },
  { 812, 7, 16, 8, 1, -16 },
  { 826, 4, 20, 7, 2, -16 },
  { 836, 8, 16, 8, 0, -16 },
  { 852, 4, 20, 7, 1, -16 },
  { 862, 9, 9, 10, 0, -16 },
  { 873, 10, 1, 10, 0, 2 },
  { 875, 4, 4, 6, 1, -17 },
  { 877, 7, 12, 9, 1, -12 },
  { 888, 8, 17, 10, 1, -17 },
  { 905, 6, 12, 8, 1, -12 },
  { 914, 8, 17, 10, 1, -17 },
  { 931, 7, 12, 9, 1, -12 },
  { 942, 6, 17, 6, 0, -17 },
  { 955, 8, 17, 10, 1, -12 },
  { 972, 8, 17, 10, 1, -17 },
  { 989, 2, 16, 5, 1, -16 },
  { 993, 3, 21, 5, 0, -16 },
  { 1001, 8, 17, 9, 1, -17 },
  { 1018, 2, 17, 5, 1, -17 },
  { 1023, 13, 12, 15, 1, -12 },
  { 1043, 8, 12, 10, 1, -12 },
  { 1055, 8, 12, 10, 1, -12 },
  { 1067, 8, 17, 10, 1, -12 },
  { 1084, 8, 17, 10, 1, -12 },
  { 1101, 5, 12, 7, 1, -12 },
  { 1109, 6, 12, 7, 1, -12 },
  { 1118, 5, 14, 6, 0, -14 },
  { 1127, 8, 12, 10, 1, -12 },
  { 1139, 8, 12, 8, 0, -12 },
  { 1151, 13, 12, 13, 0, -12 },
  { 1171, 8, 12, 8, 0, -12 },
  { 1183, 8, 17, 8, 0, -12 },
  { 1200, 5, 12, 7, 1, -12 },
  { 1208, 6, 20, 8, 1, -16 },
  { 1223, 1, 22, 9, 4, -17 },
  { 1226, 6, 20, 8, 1, -16 },
  { 1241, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Regular22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR22PT7B_H_
