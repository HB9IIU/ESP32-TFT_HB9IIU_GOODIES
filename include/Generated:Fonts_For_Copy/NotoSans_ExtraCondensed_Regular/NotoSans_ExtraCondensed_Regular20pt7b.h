#ifndef _NOTOSANS_EXTRACONDENSED_REGULAR20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_REGULAR20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x50, 0xF0, 0xCE, 0x73, 0x9C, 0x80, 0x1B, 0x09, 0x04,
  0x82, 0x47, 0xF8, 0x90, 0xC8, 0x64, 0xFF, 0x7F, 0x89, 0x04, 0x82, 0x41,
  0x20, 0x10, 0x21, 0xFE, 0x89, 0x12, 0x34, 0x3C, 0x1C, 0x2C, 0x58, 0xBD,
  0xDF, 0x04, 0x08, 0xF1, 0x89, 0x10, 0x93, 0x09, 0x20, 0x92, 0x09, 0x6C,
  0x95, 0xE7, 0x52, 0x0D, 0x20, 0x93, 0x09, 0x21, 0x92, 0x11, 0xA3, 0x0E,
  0x78, 0x24, 0x13, 0x09, 0x06, 0x83, 0xC1, 0xC0, 0xA6, 0xDB, 0x47, 0xA3,
  0x90, 0xCC, 0xF3, 0xDC, 0xFF, 0xC0, 0x32, 0x64, 0xCC, 0xCC, 0xCC, 0xCC,
  0xC4, 0x62, 0x30, 0xC4, 0x66, 0x23, 0x33, 0x33, 0x33, 0x26, 0x64, 0x80,
  0x30, 0xCF, 0xCC, 0x7B, 0x30, 0x10, 0x20, 0x40, 0x8F, 0xFF, 0xC4, 0x08,
  0x10, 0x20, 0x7E, 0x80, 0xF0, 0xF0, 0x06, 0x08, 0x10, 0x60, 0x81, 0x06,
  0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x00, 0x78, 0x9B, 0x16, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x16, 0x26, 0xCF, 0x00, 0x19, 0xFE, 0xB1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0xF9, 0x18, 0x10, 0x20, 0x41, 0x83, 0x0C,
  0x10, 0x61, 0x82, 0x0F, 0xFF, 0xC0, 0xFD, 0x18, 0x10, 0x20, 0xC1, 0x9C,
  0x0E, 0x04, 0x0C, 0x18, 0x28, 0xDF, 0x00, 0x06, 0x0E, 0x0E, 0x1E, 0x16,
  0x36, 0x26, 0x66, 0x46, 0xFF, 0xFF, 0x06, 0x06, 0x06, 0xFD, 0x83, 0x06,
  0x0C, 0x1F, 0x3F, 0x06, 0x06, 0x0C, 0x18, 0x28, 0xDF, 0x00, 0x3C, 0xC1,
  0x06, 0x0C, 0x1F, 0x2B, 0x63, 0xC7, 0x8F, 0x1E, 0x36, 0xC7, 0x00, 0xFE,
  0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x00,
  0x7D, 0x8B, 0x1E, 0x3C, 0x4D, 0x8C, 0x3E, 0xC5, 0x0E, 0x1C, 0x3C, 0xCF,
  0x80, 0x79, 0x9B, 0x14, 0x28, 0x78, 0xF3, 0xFF, 0x34, 0x08, 0x30, 0x69,
  0x9E, 0x00, 0xF4, 0x00, 0x3C, 0xF4, 0x00, 0x1F, 0xA0, 0x02, 0x0C, 0x73,
  0x8C, 0x1C, 0x0C, 0x06, 0x06, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81,
  0x81, 0x81, 0xC0, 0xE1, 0xCE, 0x70, 0x80, 0xFA, 0x30, 0xC3, 0x0C, 0x61,
  0x8C, 0x20, 0x80, 0x00, 0x30, 0xC0, 0x1F, 0x86, 0x19, 0x81, 0x22, 0x3C,
  0xF3, 0xB6, 0x64, 0xCC, 0x99, 0x93, 0x32, 0x67, 0x7D, 0x66, 0x64, 0x00,
  0xC0, 0x0E, 0xC0, 0x70, 0x1C, 0x0E, 0x05, 0x02, 0x83, 0x61, 0xB0, 0x88,
  0x44, 0x7F, 0x3F, 0x98, 0xC8, 0x2C, 0x1E, 0x0C, 0xFC, 0xC6, 0xC2, 0xC2,
  0xC2, 0xC6, 0xF8, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xCE, 0xFC, 0x08, 0x7D,
  0x8B, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06, 0x0E, 0x4F, 0x80,
  0xFC, 0xC6, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0xC3, 0xC6,
  0xFE, 0xFC, 0xFF, 0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0xC3, 0x0C, 0x30, 0xFF,
  0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC3, 0x0C, 0x30, 0xC3, 0x00,
  0x3F, 0xB8, 0x98, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0x8F, 0xC1, 0xE0, 0xD0,
  0x6C, 0x33, 0x18, 0xFC, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x6F, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0xC6,
  0xCC, 0xCC, 0xD8, 0xD8, 0xF8, 0xF8, 0xC8, 0xCC, 0xC4, 0xC6, 0xC6, 0xC3,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xD0, 0xFD, 0x0B, 0xD8, 0xBC, 0x9B, 0xC9,
  0x3C, 0xD3, 0xCF, 0x3C, 0x73, 0xC6, 0x3C, 0x63, 0xE1, 0xF0, 0xFC, 0x7E,
  0x3D, 0x9E, 0xCF, 0x27, 0x9B, 0xC5, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x0C,
  0x3E, 0x31, 0x90, 0x58, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x6C, 0x67, 0x71, 0xF0, 0xFD, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xFE, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x00, 0x3E, 0x31, 0x90, 0x58, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0x67, 0x71, 0xF0, 0x18, 0x04, 0x03,
  0x80, 0xFC, 0xCE, 0xC6, 0xC2, 0xC2, 0xC6, 0xCC, 0xF8, 0xC8, 0xCC, 0xC4,
  0xC6, 0xC6, 0xC3, 0x00, 0xFB, 0x16, 0x0C, 0x18, 0x38, 0x38, 0x1C, 0x18,
  0x10, 0x30, 0x5B, 0xBE, 0x00, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x66, 0x3E, 0xC1, 0xE0, 0x90, 0xCC,
  0x66, 0x33, 0x10, 0x88, 0x6C, 0x36, 0x1A, 0x05, 0x03, 0x81, 0xC0, 0xC0,
  0xC3, 0x0F, 0x0C, 0x34, 0x38, 0xD8, 0xE3, 0x66, 0x89, 0x9A, 0x66, 0x49,
  0x89, 0x36, 0x34, 0xD8, 0xF1, 0x43, 0xC5, 0x06, 0x1C, 0x18, 0x70, 0x61,
  0xC0, 0xE3, 0x66, 0x26, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0x3C, 0x34, 0x26,
  0x66, 0x42, 0xC3, 0xC3, 0x42, 0x66, 0x66, 0x24, 0x3C, 0x38, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x31, 0x86, 0x10, 0xC3, 0x18, 0x61,
  0x0C, 0x30, 0xFF, 0xF0, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xF8, 0xC0, 0xC1, 0x81, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xF0, 0x08, 0x0E, 0x05, 0x06, 0xC2, 0x23, 0x1B, 0x06, 0xFF, 0x80, 0xC6,
  0x30, 0xF9, 0x30, 0xC3, 0x0D, 0xFC, 0xE3, 0x8F, 0x3F, 0x40, 0xC1, 0x83,
  0x06, 0x0D, 0xDF, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x7C, 0xF7, 0x00,
  0x3D, 0xEC, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x97, 0x80, 0x06, 0x0C, 0x18,
  0x37, 0x6F, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xDE, 0x80, 0x38,
  0xDB, 0x16, 0x28, 0x7F, 0xE0, 0x60, 0xC0, 0xC9, 0xF0, 0x3C, 0x82, 0x18,
  0x7B, 0xE6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x00, 0x32, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9D, 0xF8, 0x30, 0x60, 0xFF, 0x3C, 0xC1,
  0x83, 0x06, 0x0D, 0xDF, 0xB1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0x80, 0xF4, 0xFF, 0xFF, 0xFC, 0x6C, 0x86, 0xDB, 0x6D, 0xB6, 0xDB, 0x6F,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x79, 0xB2, 0x6C, 0xF1, 0xF3, 0x66, 0x4C,
  0xD8, 0xB1, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xDD, 0xDF, 0xBF, 0x18, 0xE3,
  0x1C, 0x63, 0x8C, 0x71, 0x8E, 0x31, 0xC6, 0x38, 0xC7, 0x18, 0x80, 0xDD,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x38, 0xDB, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xD9, 0xE0, 0xDD, 0xDF, 0x1E, 0x1C, 0x38,
  0x70, 0xE1, 0xC7, 0xCF, 0x76, 0x0C, 0x18, 0x30, 0x60, 0x32, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9D, 0xF8, 0x30, 0x60, 0xC1, 0x83, 0xDF,
  0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x7E, 0xE1, 0x0C, 0x38, 0xE3, 0x0C,
  0xFC, 0x21, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC3, 0x80, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xDD, 0xF8, 0xC3, 0x8D, 0x1A, 0x26,
  0x4D, 0x8B, 0x14, 0x38, 0x70, 0x60, 0xC6, 0x3C, 0x63, 0x46, 0x24, 0xF2,
  0x6F, 0x66, 0x96, 0x29, 0x62, 0x94, 0x29, 0xC3, 0x9C, 0x30, 0xC0, 0xC6,
  0xCD, 0xB1, 0xE3, 0x83, 0x0E, 0x16, 0x6C, 0xCF, 0x18, 0xC3, 0x8D, 0x1B,
  0x26, 0x4D, 0x8B, 0x14, 0x38, 0x30, 0x60, 0x81, 0x06, 0x38, 0x60, 0x7D,
  0xE1, 0x86, 0x10, 0xC3, 0x18, 0x61, 0x0F, 0xC0, 0x19, 0x88, 0x42, 0x10,
  0x8C, 0xC3, 0x08, 0x42, 0x10, 0x86, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0x08, 0x42, 0x10, 0x86, 0x09, 0x88, 0x42, 0x10, 0x8C, 0xC0, 0xF3,
  0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 5, 1, -14 },
  { 5, 5, 5, 8, 1, -14 },
  { 9, 9, 14, 9, 0, -14 },
  { 25, 7, 16, 9, 1, -15 },
  { 39, 12, 14, 13, 1, -14 },
  { 60, 9, 14, 10, 1, -14 },
  { 76, 2, 5, 4, 1, -14 },
  { 78, 4, 17, 6, 1, -14 },
  { 87, 4, 17, 6, 1, -14 },
  { 96, 6, 6, 8, 1, -15 },
  { 101, 7, 10, 9, 1, -12 },
  { 110, 2, 5, 5, 1, -2 },
  { 112, 4, 1, 5, 1, -6 },
  { 113, 2, 2, 5, 1, -2 },
  { 114, 7, 14, 7, 0, -14 },
  { 127, 7, 14, 9, 1, -14 },
  { 140, 5, 14, 9, 1, -14 },
  { 149, 7, 14, 9, 1, -14 },
  { 162, 7, 14, 9, 1, -14 },
  { 175, 8, 14, 9, 0, -14 },
  { 189, 7, 14, 9, 1, -14 },
  { 202, 7, 14, 9, 1, -14 },
  { 215, 7, 14, 9, 1, -14 },
  { 228, 7, 14, 9, 1, -14 },
  { 241, 7, 14, 9, 1, -14 },
  { 254, 2, 11, 5, 1, -11 },
  { 257, 2, 14, 5, 1, -11 },
  { 261, 7, 9, 9, 1, -12 },
  { 269, 7, 6, 9, 1, -10 },
  { 275, 7, 9, 9, 1, -12 },
  { 283, 6, 14, 6, 0, -14 },
  { 294, 11, 16, 13, 1, -14 },
  { 316, 9, 14, 9, 0, -14 },
  { 332, 8, 14, 10, 1, -14 },
  { 346, 7, 15, 9, 1, -15 },
  { 360, 8, 14, 10, 1, -14 },
  { 374, 6, 14, 8, 1, -14 },
  { 385, 6, 14, 8, 1, -14 },
  { 396, 9, 14, 11, 1, -14 },
  { 412, 8, 14, 11, 1, -14 },
  { 426, 4, 14, 6, 1, -14 },
  { 433, 4, 18, 4, -1, -14 },
  { 442, 8, 14, 9, 1, -14 },
  { 456, 6, 14, 7, 1, -14 },
  { 467, 12, 14, 14, 1, -14 },
  { 488, 9, 14, 11, 1, -14 },
  { 504, 9, 14, 11, 1, -14 },
  { 520, 7, 14, 9, 1, -14 },
  { 533, 9, 17, 11, 1, -14 },
  { 553, 8, 14, 9, 1, -14 },
  { 567, 7, 15, 8, 1, -15 },
  { 581, 7, 14, 8, 0, -14 },
  { 594, 8, 14, 10, 1, -14 },
  { 608, 9, 14, 9, 0, -14 },
  { 624, 14, 14, 14, 0, -14 },
  { 649, 8, 14, 8, 0, -14 },
  { 663, 8, 14, 8, 0, -14 },
  { 677, 6, 14, 7, 1, -14 },
  { 688, 5, 17, 6, 1, -14 },
  { 699, 7, 14, 7, 0, -14 },
  { 712, 4, 17, 6, 1, -14 },
  { 721, 9, 7, 9, 0, -14 },
  { 729, 9, 1, 9, 0, 2 },
  { 731, 4, 3, 5, 1, -15 },
  { 733, 6, 11, 8, 1, -11 },
  { 742, 7, 15, 9, 1, -15 },
  { 756, 6, 11, 7, 1, -11 },
  { 765, 7, 15, 9, 1, -15 },
  { 779, 7, 11, 8, 1, -11 },
  { 789, 6, 15, 5, 0, -15 },
  { 801, 7, 16, 9, 1, -11 },
  { 815, 7, 15, 9, 1, -15 },
  { 829, 2, 15, 4, 1, -15 },
  { 833, 3, 20, 4, 0, -15 },
  { 841, 7, 15, 8, 1, -15 },
  { 855, 2, 15, 4, 1, -15 },
  { 859, 11, 11, 14, 1, -11 },
  { 875, 7, 11, 9, 1, -11 },
  { 885, 7, 11, 9, 1, -11 },
  { 895, 7, 16, 9, 1, -11 },
  { 909, 7, 16, 9, 1, -11 },
  { 923, 5, 11, 6, 1, -11 },
  { 930, 5, 11, 7, 1, -11 },
  { 937, 5, 13, 5, 0, -13 },
  { 946, 7, 11, 9, 1, -11 },
  { 956, 7, 11, 7, 0, -11 },
  { 966, 12, 11, 12, 0, -11 },
  { 983, 7, 11, 7, 0, -11 },
  { 993, 7, 16, 7, 0, -11 },
  { 1007, 6, 11, 6, 0, -11 },
  { 1016, 5, 17, 7, 1, -14 },
  { 1027, 2, 20, 8, 3, -15 },
  { 1032, 5, 17, 7, 1, -14 },
  { 1043, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Regular20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Regular20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Regular20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_REGULAR20PT7B_H_
