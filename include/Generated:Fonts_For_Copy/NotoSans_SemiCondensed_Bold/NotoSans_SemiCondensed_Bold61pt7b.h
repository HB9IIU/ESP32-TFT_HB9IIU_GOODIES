#ifndef _NOTOSANS_SEMICONDENSED_BOLD61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0xFE, 0x1E, 0x00, 0xFF, 0x87,
  0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD,
  0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F,
  0xE7, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xF7, 0x3F, 0xCF, 0xF8, 0xE0, 0x71, 0xFE, 0x1C, 0x02,
  0x3F, 0xC3, 0x80, 0x07, 0xF8, 0x70, 0x00, 0xFF, 0x8E, 0x00, 0x1F, 0xF9,
  0xC0, 0x03, 0xFF, 0xB8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1D, 0xFF, 0xC0, 0x03, 0x8F, 0xF8, 0x00, 0x71,
  0xFF, 0x00, 0x0E, 0x1F, 0xF0, 0x01, 0xC3, 0xFF, 0x80, 0x38, 0xFF, 0xFC,
  0x07, 0x3F, 0xFF, 0xFC, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC,
  0x0F, 0x80, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F, 0xE3, 0xF8,
  0xFF, 0xF0, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xFE, 0x1F, 0xC7,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFE,
  0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF8, 0x1F, 0xF1, 0xFF, 0x9F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF,
  0x8F, 0xFC, 0x1F, 0xFB, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xE0,
  0x1F, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0x80, 0xF8, 0x0E, 0x7E, 0x1F, 0x0F, 0xDF, 0xFB, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xC0,
  0x7C, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0x3F, 0x87, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01,
  0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0x9F, 0xC7, 0xFC,
  0xFC, 0x3F, 0xE3, 0xC1, 0xFF, 0x0C, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE, 0x3F,
  0x80, 0x7F, 0xE1, 0xE0, 0x03, 0xFE, 0x0C, 0x00, 0x3F, 0xE0, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xFE, 0x1E, 0x00, 0x7F,
  0xE0, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0xF8,
  0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x7F, 0xC0, 0x01, 0xFD, 0xFF, 0x00,
  0x07, 0xF7, 0xFC, 0x00, 0x3F, 0x9F, 0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x07,
  0xF1, 0xFF, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x07, 0xF0,
  0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x1F,
  0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x07, 0xFC,
  0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFA, 0x00,
  0x01, 0xFF, 0x60, 0x00, 0x7F, 0xEF, 0x80, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF0, 0x04, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x07,
  0xF1, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFC, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F,
  0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFC,
  0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x07,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xCF,
  0xF0, 0x7F, 0xF8, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x81,
  0xEF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xE0, 0xE0,
  0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF7, 0xFE, 0xFF, 0xCF, 0xF9, 0xFF, 0x3F,
  0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF9, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFE, 0x07,
  0xFE, 0x1C, 0x00, 0xFF, 0x84, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xC0, 0x1F, 0xC1, 0xFC, 0x03,
  0xFF, 0xF0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0xC3, 0xF8, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xCF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x7F, 0x07, 0xFF, 0xFF,
  0x83, 0xFB, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xDF, 0x83, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xE0, 0xFC, 0x03, 0xF8, 0x1F,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xFF,
  0x83, 0xF8, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0xE0,
  0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFB, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0x9F, 0xC1, 0xFE, 0x3F,
  0xF9, 0xFC, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0xBF,
  0xFE, 0x1F, 0xC0, 0xFF, 0xF9, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0x87, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0x7F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xCF,
  0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE,
  0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xCF, 0xF8, 0x01, 0xFF,
  0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE7, 0xFC, 0x1F,
  0xFE, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x20, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xC1,
  0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0x1F,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC,
  0x0F, 0xFF, 0x00, 0x0E, 0x0F, 0xFF, 0x00, 0x01, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xCF,
  0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0xF0, 0x0F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFF,
  0x87, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xFF, 0xF7, 0xF0, 0x00, 0xFE, 0xFF,
  0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xFF, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0xFF,
  0x3F, 0x80, 0x1F, 0xDF, 0xFF, 0xF3, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0x3F,
  0x80, 0x3F, 0x9F, 0xFF, 0xF3, 0xFC, 0x03, 0xF9, 0xFF, 0xFF, 0x1F, 0xC0,
  0x7F, 0x1F, 0xFF, 0xF1, 0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F,
  0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0x9F, 0xC1, 0xFF, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xBF, 0x81, 0xFF, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xDF,
  0xF0, 0x07, 0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF,
  0xE3, 0xFE, 0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0x87, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xE0,
  0x3F, 0xE1, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xC7, 0xFF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x81, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x0F,
  0x1F, 0xF0, 0x00, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xA0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x9F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x0F,
  0xF3, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF8,
  0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0x87, 0xF8,
  0xFF, 0x80, 0x0F, 0xF1, 0xFC, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xFC, 0x00,
  0x1F, 0xEF, 0xE0, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x7F,
  0x80, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x03,
  0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x07, 0xFE, 0x02,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xFE, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF3, 0xFF, 0xFC, 0xFF, 0x1F,
  0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x7F, 0xC7, 0xFF,
  0x03, 0xFE, 0x7F, 0xFC, 0x1F, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xF1, 0xFE, 0x7F,
  0xFF, 0x0F, 0xF1, 0xFF, 0xF0, 0x7F, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFC,
  0x7C, 0x7F, 0xE0, 0x0C, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x02, 0x7F, 0xF0, 0x0E, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xC7,
  0xFC, 0x1F, 0xFF, 0x3F, 0xE1, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xF7, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF,
  0xCF, 0xF0, 0x7F, 0xFC, 0x7F, 0x81, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE,
  0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x04, 0x7F, 0xE0, 0x00, 0xC3,
  0xFF, 0x80, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xBC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F,
  0xFF, 0x7F, 0xE0, 0x3F, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF,
  0xE1, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0,
  0x0C, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC8, 0x00, 0x07, 0xFE, 0x78, 0x00, 0x7F,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x83, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x8F, 0xF3,
  0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x1E, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xBF,
  0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xFC,
  0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x8F, 0xF7,
  0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x0F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0xF0, 0x3F, 0xC7, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFD, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x1F,
  0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xFC, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xF7,
  0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x78,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xC1,
  0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE,
  0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xE1, 0xFF, 0xF9, 0xFF,
  0x07, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x0C, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0x80, 0x78, 0xFF, 0x80, 0x08, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x08, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0E, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xE7,
  0xF0, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0x07, 0xF0, 0x03, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x7F,
  0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x3F,
  0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0x7E, 0x07, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F,
  0xF0, 0x7E, 0x7E, 0x07, 0xF8, 0x0F, 0xF0, 0x7E, 0x7F, 0x0F, 0xF8, 0x0F,
  0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x3F, 0x0F, 0xF0, 0x0F,
  0xF8, 0xFC, 0x3F, 0x0F, 0xF0, 0x07, 0xF8, 0xFC, 0x3F, 0x1F, 0xF0, 0x07,
  0xF8, 0xFC, 0x3F, 0x9F, 0xE0, 0x07, 0xF9, 0xFC, 0x1F, 0x9F, 0xE0, 0x07,
  0xF9, 0xF8, 0x1F, 0x9F, 0xE0, 0x03, 0xFD, 0xF8, 0x1F, 0x9F, 0xE0, 0x03,
  0xFD, 0xF8, 0x1F, 0x9F, 0xC0, 0x03, 0xFD, 0xF8, 0x1F, 0xBF, 0xC0, 0x03,
  0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xF0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x10, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x11, 0xFF,
  0x80, 0x01, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xE8, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 45, 17, 3, -44 },
  { 58, 22, 16, 28, 3, -44 },
  { 102, 34, 44, 36, 1, -44 },
  { 289, 27, 50, 33, 3, -46 },
  { 458, 48, 45, 52, 2, -44 },
  { 728, 39, 45, 41, 2, -44 },
  { 948, 9, 16, 16, 3, -44 },
  { 966, 16, 54, 20, 3, -44 },
  { 1074, 17, 54, 20, 1, -44 },
  { 1189, 27, 27, 31, 2, -46 },
  { 1281, 28, 29, 32, 2, -36 },
  { 1383, 11, 15, 17, 2, -7 },
  { 1404, 15, 7, 19, 2, -20 },
  { 1418, 10, 10, 17, 3, -9 },
  { 1431, 25, 44, 25, 0, -44 },
  { 1569, 28, 45, 32, 2, -44 },
  { 1727, 21, 44, 32, 3, -44 },
  { 1843, 28, 44, 32, 2, -44 },
  { 1997, 28, 45, 32, 2, -44 },
  { 2155, 30, 44, 32, 1, -44 },
  { 2320, 27, 45, 32, 3, -44 },
  { 2472, 28, 45, 32, 2, -44 },
  { 2630, 28, 44, 32, 2, -44 },
  { 2784, 28, 45, 32, 2, -44 },
  { 2942, 28, 45, 32, 2, -44 },
  { 3100, 10, 35, 17, 3, -34 },
  { 3144, 11, 42, 17, 2, -34 },
  { 3202, 28, 30, 32, 2, -37 },
  { 3307, 28, 19, 32, 2, -31 },
  { 3374, 28, 30, 32, 2, -37 },
  { 3479, 26, 45, 27, 0, -44 },
  { 3626, 45, 49, 51, 3, -44 },
  { 3902, 38, 44, 38, 0, -44 },
  { 4111, 30, 44, 37, 5, -44 },
  { 4276, 31, 45, 36, 3, -44 },
  { 4451, 33, 44, 41, 5, -44 },
  { 4633, 23, 44, 31, 5, -44 },
  { 4760, 23, 44, 31, 5, -44 },
  { 4887, 33, 45, 41, 3, -44 },
  { 5073, 33, 44, 43, 5, -44 },
  { 5255, 18, 44, 22, 2, -44 },
  { 5354, 18, 57, 19, -4, -44 },
  { 5483, 32, 44, 37, 5, -44 },
  { 5659, 24, 44, 31, 5, -44 },
  { 5791, 44, 44, 54, 5, -44 },
  { 6033, 35, 44, 46, 5, -44 },
  { 6226, 38, 45, 44, 3, -44 },
  { 6440, 28, 44, 35, 5, -44 },
  { 6594, 38, 54, 44, 3, -44 },
  { 6851, 32, 44, 37, 5, -44 },
  { 7027, 26, 45, 31, 2, -44 },
  { 7174, 30, 44, 32, 1, -44 },
  { 7339, 32, 45, 42, 5, -44 },
  { 7519, 36, 44, 36, 0, -44 },
  { 7717, 54, 44, 54, 0, -44 },
  { 8014, 36, 44, 36, 0, -44 },
  { 8212, 35, 44, 35, 0, -44 },
  { 8405, 29, 44, 32, 1, -44 },
  { 8565, 14, 54, 20, 4, -44 },
  { 8660, 25, 44, 25, 0, -44 },
  { 8798, 14, 54, 20, 2, -44 },
  { 8893, 32, 28, 34, 1, -44 },
  { 9005, 25, 5, 25, 0, 5 },
  { 9021, 17, 10, 21, 2, -47 },
  { 9043, 28, 35, 33, 2, -34 },
  { 9166, 29, 47, 36, 4, -46 },
  { 9337, 24, 35, 29, 3, -34 },
  { 9442, 29, 47, 36, 3, -46 },
  { 9613, 28, 35, 33, 3, -34 },
  { 9736, 23, 47, 22, 1, -47 },
  { 9872, 29, 49, 36, 3, -34 },
  { 10050, 28, 46, 36, 4, -46 },
  { 10211, 9, 46, 17, 4, -46 },
  { 10263, 16, 61, 17, -3, -46 },
  { 10385, 31, 46, 35, 4, -46 },
  { 10564, 9, 46, 17, 4, -46 },
  { 10616, 46, 34, 54, 4, -34 },
  { 10812, 28, 34, 36, 4, -34 },
  { 10931, 29, 35, 35, 3, -34 },
  { 11058, 29, 49, 36, 4, -34 },
  { 11236, 29, 49, 36, 3, -34 },
  { 11414, 20, 34, 25, 4, -34 },
  { 11499, 24, 35, 28, 2, -34 },
  { 11604, 21, 41, 24, 1, -40 },
  { 11712, 28, 34, 36, 4, -33 },
  { 11831, 32, 33, 32, 0, -33 },
  { 11963, 48, 33, 48, 0, -33 },
  { 12161, 32, 33, 32, 0, -33 },
  { 12293, 32, 48, 32, 0, -33 },
  { 12485, 24, 33, 27, 2, -33 },
  { 12584, 20, 54, 23, 1, -44 },
  { 12719, 7, 60, 31, 12, -46 },
  { 12772, 20, 54, 23, 2, -44 },
  { 12907, 28, 11, 32, 2, -27 },
};

const GFXfont NotoSans_SemiCondensed_Bold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD61PT7B_H_
