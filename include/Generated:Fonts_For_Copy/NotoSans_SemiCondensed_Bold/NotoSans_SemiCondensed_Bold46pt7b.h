#ifndef _NOTOSANS_SEMICONDENSED_BOLD46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF3, 0x8F, 0x3F, 0x9C, 0x09,
  0xF8, 0xE0, 0x0F, 0xE7, 0x00, 0x7F, 0x38, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xDF, 0xC0, 0x0E, 0x7F, 0x00, 0x73,
  0xFC, 0x03, 0x9F, 0xF8, 0x1C, 0xFD, 0xF8, 0xEF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x07, 0xE7, 0xC0, 0x3E, 0x00, 0x3E, 0x3F,
  0x03, 0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x87, 0xC1, 0xF8, 0x00,
  0xFC, 0x3E, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE3, 0xE0, 0x00, 0x3E,
  0x1F, 0x1F, 0x1F, 0xC1, 0xF1, 0xF9, 0xF1, 0xFF, 0x0F, 0xCF, 0x8F, 0x9F,
  0xFC, 0x3F, 0xFC, 0xF9, 0xFF, 0xF1, 0xFF, 0xC7, 0xCF, 0xDF, 0x87, 0xFC,
  0x7C, 0x7C, 0x7C, 0x1F, 0xC3, 0xE7, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x0F,
  0x80, 0x01, 0xF1, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x07, 0xC0,
  0x07, 0xC0, 0xFC, 0x7E, 0x00, 0x3E, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x1F,
  0x1F, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFE, 0x1F, 0xFC, 0x07, 0xF1, 0xFF, 0xF0,
  0x3F, 0x9F, 0xFF, 0xC3, 0xF9, 0xFE, 0xFF, 0x1F, 0xCF, 0xE3, 0xFC, 0xFE,
  0x7F, 0x0F, 0xFF, 0xE3, 0xF8, 0x3F, 0xFF, 0x1F, 0x80, 0xFF, 0xF0, 0xFE,
  0x03, 0xFF, 0x87, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x09, 0xE3, 0xE3, 0xCF,
  0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F,
  0x8F, 0xC1, 0xFC, 0x7F, 0x03, 0xC1, 0xE0, 0x06, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x9F, 0xCF, 0xC7,
  0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F,
  0x7E, 0x08, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xCF,
  0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xBF,
  0x80, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E,
  0xFE, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0xC1, 0xF8, 0xFF, 0x1F, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E, 0x7F, 0x18, 0x7F,
  0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0x8F, 0xF9, 0xF0, 0x1F,
  0xC6, 0x00, 0xFE, 0x10, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x0F,
  0xF8, 0xC0, 0x1F, 0xC4, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xA0, 0x01, 0xFD, 0xE0, 0x3F, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7C,
  0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xF8, 0x10, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x7E, 0xFF, 0xE3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xBF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC1, 0xFC, 0xFF, 0x1F, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xF3, 0xFC, 0x7F, 0x07, 0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0xC7, 0xF0, 0x7F, 0x9F, 0x80,
  0xFE, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xC1, 0xFF, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xEF, 0xC7, 0xFF, 0x3E, 0x0F, 0xF9,
  0xF8, 0x03, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x08, 0x7E,
  0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E,
  0x18, 0x04, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE1, 0xF1,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7C, 0x3F, 0xCC, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x0F, 0x8F, 0x80, 0xFF, 0xE3, 0xE3, 0xE0, 0xFF, 0xF8, 0x79,
  0xF0, 0x7F, 0xFE, 0x1F, 0x7C, 0x3F, 0x8F, 0x87, 0xDF, 0x0F, 0x83, 0xE1,
  0xFF, 0x87, 0xE0, 0xF8, 0x3F, 0xE1, 0xF0, 0x3E, 0x0F, 0xF8, 0x7C, 0x0F,
  0x83, 0xFE, 0x1F, 0x03, 0xE0, 0xFF, 0x87, 0xC0, 0xF8, 0x7F, 0xE1, 0xF0,
  0x3E, 0x1F, 0xF8, 0x7C, 0x0F, 0x87, 0xFE, 0x1F, 0x07, 0xE1, 0xFF, 0x87,
  0xC1, 0xF8, 0xFB, 0xE1, 0xF8, 0xFF, 0x3E, 0x7C, 0x3F, 0xFB, 0xFF, 0x1F,
  0x07, 0xFE, 0xFF, 0x87, 0xC0, 0xFF, 0x1F, 0xC1, 0xF8, 0x0F, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0x80, 0x07, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xC0, 0x7F, 0xBF, 0x00,
  0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE,
  0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0x00, 0xFE, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFC, 0xFC, 0x1F, 0xE0, 0x0C, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x04, 0x1F, 0xF8, 0x3C, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xFC, 0xFC, 0x01,
  0xFE, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFE, 0xFC, 0x01, 0xFE, 0xFC, 0x03, 0xFC, 0xFC, 0x07, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xF8, 0x7F, 0xC0, 0x08,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0x81,
  0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0xE0, 0x0F, 0xCF,
  0xF8, 0x07, 0xE3, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0xFF,
  0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xC7, 0xFC, 0x1E, 0x00, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x03, 0xF8,
  0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0xC0, 0xFC, 0x7F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00,
  0xFD, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x80,
  0xFC, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFB, 0xE0, 0x07, 0xDF, 0xFF, 0xF8, 0x03, 0xEF, 0xFF, 0xFC, 0x03, 0xF7,
  0xFF, 0xBE, 0x01, 0xF3, 0xFF, 0xDF, 0x00, 0xF9, 0xFF, 0xEF, 0xC0, 0xFD,
  0xFF, 0xF3, 0xE0, 0x7C, 0xFF, 0xF9, 0xF0, 0x3E, 0x7F, 0xFC, 0xFC, 0x1F,
  0x3F, 0xFE, 0x7E, 0x1F, 0x9F, 0xFF, 0x1F, 0x0F, 0x8F, 0xFF, 0x8F, 0xC7,
  0xC7, 0xFF, 0xC7, 0xE7, 0xE3, 0xFF, 0xE1, 0xF3, 0xE1, 0xFF, 0xF0, 0xF9,
  0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8,
  0x1F, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0xFE, 0x07,
  0xFF, 0xCF, 0xE0, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0x1F, 0xC3, 0xFF, 0xE3,
  0xF8, 0x7F, 0xFC, 0x3F, 0x8F, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0x7F, 0x1F,
  0xFE, 0x0F, 0xE3, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x1F, 0xCF, 0xFF, 0x01,
  0xFD, 0xFF, 0xE0, 0x3F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0x80,
  0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFB, 0xF0, 0x3F, 0xDF, 0x87, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F,
  0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xC0, 0x77, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xCF,
  0xC0, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xF0, 0x07, 0xF3, 0xF8, 0x07,
  0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xFF, 0x00,
  0xFC, 0x3F, 0x01, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0xFB, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7D, 0xF0, 0x3F, 0x87, 0xF0, 0x3E, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0xBF, 0x0F, 0xE0, 0x7E, 0x0F, 0x9F, 0x87,
  0xF0, 0x3F, 0x87, 0xC7, 0xC3, 0xF0, 0x0F, 0xC7, 0xE3, 0xE1, 0xF8, 0x07,
  0xE3, 0xF1, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0xFC, 0xFE, 0x01, 0xF8, 0xF8,
  0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0x3F, 0x7E, 0x0F, 0x9F,
  0x80, 0x1F, 0xBF, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x03, 0xFF, 0xE0, 0x03,
  0xEF, 0x80, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xEF, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xE7, 0xC0,
  0x07, 0xC7, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x83, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF9, 0xFF, 0x0C, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF1, 0xFE, 0x1F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x30,
  0x0F, 0xE7, 0xF8, 0x3F, 0xBF, 0xF0, 0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFE, 0xFF, 0x03, 0xFB, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFD, 0xFF, 0xE3, 0xF3, 0xFF, 0x0F, 0x87, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xE0, 0x63, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x27, 0xF8, 0x1C,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x02, 0x07, 0xF0, 0x7F, 0x9F, 0xC7, 0xFF, 0x7F, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0x7F, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xFD, 0xFE, 0x1F, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFE, 0xFC, 0x3F, 0xF3, 0xF0, 0x7F, 0x8F,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xE7, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7F, 0x7E, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0x18, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE3, 0xF1, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xDF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x87, 0xFD, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFD, 0xFC, 0x1F, 0xE7,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE6,
  0x00, 0x3F, 0x9F, 0xC7, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x20, 0x3F, 0x9F, 0xF1,
  0xF9, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xDF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x38, 0x1F,
  0x0F, 0xF8, 0x3F, 0xE3, 0xF3, 0xFF, 0x8F, 0xFE, 0x7E, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0x87, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01,
  0xFC, 0x00, 0x0E, 0x07, 0xC3, 0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x70,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0xDF, 0xC0, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0C,
  0x03, 0xF1, 0xFE, 0x0F, 0xCF, 0xFC, 0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x87, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0x7F, 0xF8, 0xFE, 0xFF, 0xC3, 0xF9, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE3, 0xF1, 0xFF, 0xCF,
  0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xDF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F,
  0x87, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFD,
  0xFC, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0D,
  0xF0, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFB,
  0xF0, 0x09, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC1, 0x1F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFB, 0xE7, 0xFF, 0x9F, 0x0F, 0xF0,
  0xF8, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xC0,
  0x7F, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0xE0, 0x7E, 0x3F, 0x03,
  0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0xE0, 0xFE, 0x3F, 0x07, 0xDE, 0x0F, 0xC3,
  0xF8, 0x7D, 0xF0, 0xFC, 0x1F, 0x87, 0x9F, 0x1F, 0xC1, 0xF8, 0xF9, 0xF1,
  0xFC, 0x1F, 0x8F, 0x9F, 0x1F, 0x81, 0xFC, 0xF8, 0xF1, 0xF8, 0x0F, 0xCF,
  0x8F, 0x9F, 0x80, 0xFC, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00,
  0xFD, 0xF0, 0xFB, 0xF0, 0x07, 0xDF, 0x07, 0xBF, 0x00, 0x7F, 0xE0, 0x7B,
  0xE0, 0x07, 0xFE, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x27, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x03,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x87, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x0B, 0xFF,
  0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFA,
  0x00, 0xFF, 0x90, 0x00, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 34, 13, 2, -33 },
  { 35, 16, 12, 21, 3, -33 },
  { 59, 25, 33, 27, 1, -33 },
  { 163, 21, 38, 25, 2, -35 },
  { 263, 37, 33, 39, 1, -33 },
  { 416, 29, 33, 31, 2, -33 },
  { 536, 6, 12, 12, 3, -33 },
  { 545, 12, 40, 15, 2, -33 },
  { 605, 12, 40, 15, 1, -33 },
  { 665, 21, 20, 23, 1, -35 },
  { 718, 21, 22, 24, 2, -27 },
  { 776, 9, 11, 12, 1, -5 },
  { 789, 12, 6, 14, 1, -15 },
  { 798, 8, 8, 12, 2, -7 },
  { 806, 19, 33, 19, 0, -33 },
  { 885, 21, 33, 24, 2, -33 },
  { 972, 16, 33, 24, 2, -33 },
  { 1038, 21, 33, 24, 2, -33 },
  { 1125, 21, 33, 24, 2, -33 },
  { 1212, 23, 33, 24, 1, -33 },
  { 1307, 20, 33, 24, 2, -33 },
  { 1390, 21, 33, 24, 2, -33 },
  { 1477, 22, 33, 24, 1, -33 },
  { 1568, 22, 33, 24, 1, -33 },
  { 1659, 22, 33, 24, 1, -33 },
  { 1750, 8, 27, 13, 2, -26 },
  { 1777, 9, 32, 13, 1, -26 },
  { 1813, 21, 23, 24, 2, -28 },
  { 1874, 21, 14, 24, 2, -23 },
  { 1911, 21, 23, 24, 2, -28 },
  { 1972, 19, 34, 20, 0, -33 },
  { 2053, 34, 37, 38, 2, -33 },
  { 2211, 29, 33, 29, 0, -33 },
  { 2331, 22, 33, 28, 4, -33 },
  { 2422, 24, 33, 27, 2, -33 },
  { 2521, 24, 33, 31, 4, -33 },
  { 2620, 17, 33, 24, 4, -33 },
  { 2691, 17, 33, 23, 4, -33 },
  { 2762, 25, 33, 31, 2, -33 },
  { 2866, 24, 33, 32, 4, -33 },
  { 2965, 14, 33, 17, 1, -33 },
  { 3023, 13, 43, 14, -3, -33 },
  { 3093, 24, 33, 28, 4, -33 },
  { 3192, 18, 33, 23, 4, -33 },
  { 3267, 33, 33, 40, 4, -33 },
  { 3404, 27, 33, 34, 4, -33 },
  { 3516, 29, 33, 33, 2, -33 },
  { 3636, 21, 33, 26, 4, -33 },
  { 3723, 29, 41, 33, 2, -33 },
  { 3872, 24, 33, 28, 4, -33 },
  { 3971, 19, 33, 23, 2, -33 },
  { 4050, 22, 33, 24, 1, -33 },
  { 4141, 24, 33, 32, 4, -33 },
  { 4240, 27, 33, 27, 0, -33 },
  { 4352, 41, 33, 41, 0, -33 },
  { 4522, 27, 33, 28, 0, -33 },
  { 4634, 26, 33, 26, 0, -33 },
  { 4742, 22, 33, 24, 1, -33 },
  { 4833, 11, 40, 15, 3, -33 },
  { 4888, 19, 33, 19, 0, -33 },
  { 4967, 11, 40, 15, 1, -33 },
  { 5022, 24, 21, 26, 1, -33 },
  { 5085, 19, 3, 19, 0, 4 },
  { 5093, 12, 7, 16, 2, -35 },
  { 5104, 20, 26, 25, 2, -26 },
  { 5169, 22, 35, 27, 3, -35 },
  { 5266, 19, 26, 22, 2, -26 },
  { 5328, 22, 35, 27, 2, -35 },
  { 5425, 21, 26, 25, 2, -26 },
  { 5494, 17, 35, 16, 1, -35 },
  { 5569, 22, 37, 27, 2, -26 },
  { 5671, 21, 35, 27, 3, -35 },
  { 5763, 7, 35, 13, 3, -35 },
  { 5794, 12, 46, 13, -2, -35 },
  { 5863, 23, 35, 26, 3, -35 },
  { 5964, 7, 35, 13, 3, -35 },
  { 5995, 35, 26, 41, 3, -26 },
  { 6109, 21, 26, 27, 3, -26 },
  { 6178, 22, 26, 26, 2, -26 },
  { 6250, 22, 37, 27, 3, -26 },
  { 6352, 22, 37, 27, 2, -26 },
  { 6454, 15, 26, 19, 3, -26 },
  { 6503, 17, 26, 21, 2, -26 },
  { 6559, 16, 30, 18, 1, -30 },
  { 6619, 21, 25, 27, 3, -25 },
  { 6685, 24, 25, 24, 0, -25 },
  { 6760, 36, 25, 36, 0, -25 },
  { 6873, 24, 25, 24, 0, -25 },
  { 6948, 24, 36, 24, 0, -25 },
  { 7056, 18, 25, 20, 1, -25 },
  { 7113, 15, 40, 17, 1, -33 },
  { 7188, 5, 46, 23, 9, -35 },
  { 7217, 15, 40, 17, 2, -33 },
  { 7292, 21, 8, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Bold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD46PT7B_H_
