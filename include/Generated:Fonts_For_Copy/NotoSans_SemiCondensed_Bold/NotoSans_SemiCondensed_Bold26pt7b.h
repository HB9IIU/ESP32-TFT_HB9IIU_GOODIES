#ifndef _NOTOSANS_SEMICONDENSED_BOLD26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xF3, 0xDC, 0xF7, 0x3D, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x06, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF,
  0x1C, 0xE0, 0x73, 0x81, 0x8C, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0x9C,
  0x0E, 0x60, 0x31, 0x80, 0xCE, 0x07, 0x38, 0x00, 0x06, 0x00, 0x60, 0x0F,
  0x83, 0xFF, 0x7F, 0xEF, 0x6E, 0xF6, 0x0F, 0x60, 0x7E, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xE0, 0x6F, 0x06, 0xFC, 0x6F, 0xFF, 0xEF, 0xFC, 0x3F,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x07, 0x07, 0xE0, 0x70, 0xFE, 0x0E,
  0x0E, 0x70, 0xE0, 0xE7, 0x1C, 0x0E, 0x71, 0xC0, 0xE7, 0x38, 0x0E, 0x73,
  0x80, 0xE7, 0x73, 0xEF, 0xE7, 0x7F, 0x7E, 0xEF, 0x73, 0x8E, 0xE7, 0x01,
  0xCE, 0x70, 0x1C, 0xE7, 0x03, 0x8E, 0x70, 0x38, 0xE7, 0x07, 0x07, 0x70,
  0x70, 0x7E, 0x0E, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F,
  0x3C, 0x07, 0x8E, 0x03, 0xC7, 0x00, 0xE7, 0x80, 0x7F, 0x80, 0x1F, 0x80,
  0x1F, 0x87, 0x9F, 0xE3, 0xDF, 0xFB, 0xCF, 0x3F, 0xE7, 0x8F, 0xE3, 0xC3,
  0xF1, 0xF1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF3, 0xE0, 0xF7, 0x77,
  0x77, 0x70, 0x0E, 0x38, 0xF1, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0x87,
  0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x80, 0xE3,
  0x87, 0x1E, 0x38, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xF3, 0x8E, 0x71, 0xCE, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x47, 0x1F, 0xFF,
  0xFF, 0xDF, 0xF0, 0xF8, 0x3B, 0x8F, 0x78, 0xC7, 0x08, 0x80, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x7B, 0x9D, 0xEE, 0x70, 0xFF, 0xFF, 0xFF, 0x77,
  0xFE, 0xE0, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0x9E, 0xF1,
  0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xE7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x03, 0x83,
  0xC3, 0xE3, 0xF7, 0xFF, 0xFD, 0xDE, 0x4F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1F, 0x07, 0xFC, 0xFF,
  0xE7, 0xBE, 0x61, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x07, 0xFC, 0xFF, 0xE7, 0x3E, 0x41, 0xE0, 0x0E, 0x01, 0xE0,
  0x3C, 0x1F, 0x81, 0xF8, 0x1F, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x38,
  0xE1, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x70, 0x07, 0x00, 0x70, 0x07,
  0xF0, 0x7F, 0xC7, 0xFE, 0x23, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xFC,
  0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x03, 0xE1, 0xFE, 0x3F, 0xE3, 0xE2,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x7C, 0xEF, 0xEF, 0xFE, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xEF,
  0x0E, 0x79, 0xE7, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0xC7, 0x9E, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x0F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x0F, 0x03, 0xF8,
  0x7F, 0xCF, 0xBE, 0xF0, 0xEF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0xBF,
  0x7F, 0xF3, 0xFF, 0x18, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x7F, 0xC7, 0xF8,
  0x7E, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x77,
  0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x3B, 0xDC, 0xE0, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0x00,
  0xC0, 0x00, 0x1F, 0x0F, 0xFB, 0xFF, 0x39, 0xF4, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x81, 0xE0, 0x3C, 0x38, 0x01, 0xC7, 0x0F, 0x8E, 0x71, 0xFC, 0xE7, 0x3C,
  0xC6, 0xE7, 0x0C, 0x6E, 0x70, 0xC7, 0xE7, 0x1C, 0x6E, 0x71, 0xC6, 0xE7,
  0x1C, 0xEE, 0x7B, 0xCE, 0xE3, 0xFF, 0xC7, 0x1E, 0x78, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x0E, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x3F, 0xFD, 0xE7, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE,
  0x3E, 0xFF, 0xE7, 0xFE, 0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1E, 0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0x03, 0xE0, 0x7F, 0xC7, 0xFE,
  0x7E, 0xF7, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xC1, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFC, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0xF0, 0xFB, 0xC1,
  0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x7E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x01, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xCF, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0x78, 0x1D, 0xE0,
  0x77, 0x81, 0xCF, 0x07, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0xFE, 0xFE, 0xFC, 0xF0, 0x3F, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3,
  0xCF, 0x0F, 0x7C, 0x3D, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3E, 0xF0,
  0xF3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xDC, 0x1F, 0xFB, 0x83, 0xFF, 0x70, 0xEF, 0xF7, 0x1D, 0xFE, 0xE3,
  0xBF, 0xDC, 0xE7, 0xFB, 0xDC, 0xFF, 0x3B, 0x9F, 0xE7, 0x73, 0xFC, 0xFC,
  0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0x80, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFD, 0xC1, 0xFB, 0xC3,
  0xF3, 0xC7, 0xE7, 0x8F, 0xE7, 0x9F, 0xCF, 0x3F, 0x8F, 0x7F, 0x1E, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xF8, 0x03,
  0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7E, 0x7C, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x3C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07,
  0xF0, 0xFC, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC,
  0x3F, 0x7E, 0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F,
  0x3C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE0, 0xF3, 0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF,
  0x07, 0xC0, 0x0F, 0x87, 0xFD, 0xFF, 0xBF, 0xEF, 0x05, 0xE0, 0x3C, 0x03,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1E, 0x03, 0xE0, 0x7F, 0x0F,
  0xFF, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x0F,
  0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x38, 0x3C,
  0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC1, 0xF0, 0x7B, 0x83, 0xE0, 0xE7,
  0x07, 0xC3, 0xCF, 0x0D, 0x87, 0x9E, 0x3B, 0x8F, 0x1C, 0x77, 0x1E, 0x38,
  0xEE, 0x38, 0x79, 0xDC, 0xF0, 0xF7, 0xBD, 0xE1, 0xEE, 0x3B, 0xC1, 0xDC,
  0x77, 0x03, 0xB8, 0xEE, 0x07, 0x71, 0xDC, 0x0F, 0xC1, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1E, 0xF0, 0x78, 0xF0,
  0xF1, 0xE3, 0xC1, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xDE, 0x07, 0x9E, 0x1E,
  0x3C, 0x7C, 0x3C, 0xF0, 0x7F, 0xE0, 0x78, 0xF0, 0x1E, 0xF0, 0x79, 0xE0,
  0xF3, 0xC3, 0xC3, 0xC7, 0x87, 0x8E, 0x07, 0xBC, 0x0F, 0x70, 0x0F, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xFF, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x0E,
  0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xF0, 0xFF,
  0xFF, 0xFC, 0xF8, 0xF0, 0xF0, 0xF0, 0x3F, 0xC7, 0xFE, 0x39, 0xE0, 0x0F,
  0x00, 0xF0, 0xFF, 0x7F, 0xFF, 0xCF, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF,
  0x7F, 0xF7, 0xE7, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xEF, 0xCE, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xEE, 0xFC, 0x1F, 0xE7, 0xF9,
  0xFF, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE1,
  0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x3F, 0x77, 0xFF, 0x7F, 0xFF, 0x8F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x78, 0xF7, 0xFF, 0x3F, 0xF1, 0xF7, 0x1F,
  0xC3, 0xFE, 0x79, 0xE7, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x78, 0x17, 0xFE, 0x3F, 0xE1, 0xFE, 0x07, 0xC7, 0xF1, 0xFC,
  0xF8, 0x3C, 0x0F, 0x07, 0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0x77, 0xFF,
  0x7F, 0xF7, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x78, 0xF7, 0xFF, 0x3F, 0x71, 0xF7, 0x00, 0x70, 0x07, 0x40, 0xF7, 0xFF,
  0x7F, 0xE7, 0xFC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xEF, 0xCE, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x6F, 0xFE, 0x00,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x0C, 0x3C, 0x78, 0xE0, 0x00,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x8F, 0x7E, 0xFD, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC3, 0xDE, 0x3C, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1,
  0xDE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C,
  0x3D, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF,
  0xCF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x1F, 0x1E, 0xF0, 0xF0, 0xEF,
  0x0F, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F,
  0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xEF, 0xCF,
  0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC,
  0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDE,
  0x3C, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0xEF, 0xCE, 0xFE, 0xFF, 0xEF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE,
  0xEF, 0xEE, 0x7C, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x3F, 0x77, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0x78, 0xF7, 0xFF, 0x3F, 0x71, 0xF7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0xDF, 0xEF, 0x3B,
  0xC0, 0xF0, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x3F, 0xFF, 0xFF,
  0xBF, 0xC0, 0x1C, 0x07, 0x01, 0xC1, 0xFE, 0xFF, 0xBF, 0xE3, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFC, 0x7F, 0x0F, 0xC0,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0x7F, 0xF7, 0xE7, 0xF0, 0x7D, 0xC1,
  0xE7, 0x87, 0x9E, 0x1C, 0x38, 0xF0, 0xF3, 0xC3, 0xCE, 0x07, 0x78, 0x1D,
  0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0xF8,
  0x77, 0x0F, 0x8F, 0x78, 0xF8, 0xF7, 0x9F, 0x8E, 0x79, 0xD8, 0xE3, 0x9D,
  0xDE, 0x39, 0x9D, 0xE3, 0xD9, 0xDC, 0x3F, 0x8D, 0xC1, 0xF8, 0xDC, 0x1F,
  0x8F, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0xF8, 0x7B, 0xC7,
  0x8F, 0x3C, 0x7B, 0xC1, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0xC0,
  0xFF, 0x0F, 0x78, 0x79, 0xE7, 0x87, 0xF8, 0x3C, 0xF0, 0x3D, 0xC1, 0xE7,
  0x87, 0x9E, 0x1C, 0x38, 0xF0, 0xF3, 0xC3, 0xCE, 0x07, 0x78, 0x1F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x3F, 0x1F, 0x0F, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xF8, 0x7C, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0xF8, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F,
  0x0F, 0x1F, 0x3E, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF0,
  0x7C, 0x1F, 0xFF, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 12, 1, -19 },
  { 22, 14, 19, 15, 1, -19 },
  { 56, 12, 22, 14, 1, -20 },
  { 89, 20, 19, 22, 1, -19 },
  { 137, 17, 19, 18, 1, -19 },
  { 178, 4, 7, 7, 1, -19 },
  { 182, 7, 23, 9, 1, -19 },
  { 203, 6, 23, 9, 1, -19 },
  { 221, 11, 12, 13, 1, -20 },
  { 238, 12, 12, 14, 1, -15 },
  { 256, 5, 6, 7, 1, -3 },
  { 260, 6, 4, 8, 1, -9 },
  { 263, 5, 4, 7, 1, -4 },
  { 266, 11, 19, 11, 0, -19 },
  { 293, 12, 19, 14, 1, -19 },
  { 322, 9, 19, 14, 1, -19 },
  { 344, 12, 19, 14, 1, -19 },
  { 373, 12, 19, 14, 1, -19 },
  { 402, 13, 19, 14, 0, -19 },
  { 433, 12, 19, 14, 1, -19 },
  { 462, 12, 19, 14, 1, -19 },
  { 491, 12, 19, 14, 1, -19 },
  { 520, 12, 19, 14, 1, -19 },
  { 549, 12, 19, 14, 1, -19 },
  { 578, 5, 14, 7, 1, -14 },
  { 587, 5, 17, 7, 1, -14 },
  { 598, 12, 13, 14, 1, -16 },
  { 618, 12, 8, 14, 1, -13 },
  { 630, 12, 13, 14, 1, -16 },
  { 650, 11, 19, 11, 0, -19 },
  { 677, 20, 21, 22, 1, -19 },
  { 730, 16, 19, 16, 0, -19 },
  { 768, 13, 19, 16, 2, -19 },
  { 799, 13, 19, 15, 1, -19 },
  { 830, 14, 19, 17, 2, -19 },
  { 864, 10, 19, 13, 2, -19 },
  { 888, 10, 19, 13, 2, -19 },
  { 912, 14, 19, 17, 1, -19 },
  { 946, 14, 19, 18, 2, -19 },
  { 980, 8, 19, 9, 1, -19 },
  { 999, 8, 24, 8, -2, -19 },
  { 1023, 14, 19, 16, 2, -19 },
  { 1057, 10, 19, 13, 2, -19 },
  { 1081, 19, 19, 23, 2, -19 },
  { 1127, 15, 19, 19, 2, -19 },
  { 1163, 16, 19, 19, 1, -19 },
  { 1201, 12, 19, 15, 2, -19 },
  { 1230, 16, 23, 19, 1, -19 },
  { 1276, 14, 19, 16, 2, -19 },
  { 1310, 11, 19, 13, 1, -19 },
  { 1337, 13, 19, 14, 0, -19 },
  { 1368, 14, 19, 18, 2, -19 },
  { 1402, 16, 19, 16, 0, -19 },
  { 1440, 23, 19, 23, 0, -19 },
  { 1495, 15, 19, 16, 0, -19 },
  { 1531, 15, 19, 15, 0, -19 },
  { 1567, 12, 19, 13, 1, -19 },
  { 1596, 6, 23, 8, 2, -19 },
  { 1614, 11, 19, 11, 0, -19 },
  { 1641, 6, 23, 8, 1, -19 },
  { 1659, 13, 12, 14, 1, -19 },
  { 1679, 11, 2, 11, 0, 2 },
  { 1682, 7, 4, 9, 1, -20 },
  { 1686, 12, 14, 14, 1, -14 },
  { 1707, 12, 20, 15, 2, -20 },
  { 1737, 11, 14, 12, 1, -14 },
  { 1757, 12, 20, 15, 1, -20 },
  { 1787, 12, 14, 14, 1, -14 },
  { 1808, 10, 20, 9, 0, -20 },
  { 1833, 12, 20, 15, 1, -14 },
  { 1863, 12, 20, 15, 2, -20 },
  { 1893, 4, 20, 7, 2, -20 },
  { 1903, 7, 26, 7, -1, -20 },
  { 1926, 13, 20, 15, 2, -20 },
  { 1959, 3, 20, 7, 2, -20 },
  { 1967, 20, 14, 23, 2, -14 },
  { 2002, 12, 14, 15, 2, -14 },
  { 2023, 13, 14, 15, 1, -14 },
  { 2046, 12, 20, 15, 2, -14 },
  { 2076, 12, 20, 15, 1, -14 },
  { 2106, 8, 14, 11, 2, -14 },
  { 2120, 10, 14, 12, 1, -14 },
  { 2138, 10, 17, 10, 0, -17 },
  { 2160, 12, 14, 15, 2, -14 },
  { 2181, 14, 14, 14, 0, -14 },
  { 2206, 20, 14, 21, 0, -14 },
  { 2241, 13, 14, 14, 0, -14 },
  { 2264, 14, 20, 14, 0, -14 },
  { 2299, 10, 14, 12, 1, -14 },
  { 2317, 9, 23, 10, 0, -19 },
  { 2343, 3, 26, 13, 5, -20 },
  { 2353, 8, 23, 10, 1, -19 },
  { 2376, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Bold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD26PT7B_H_
