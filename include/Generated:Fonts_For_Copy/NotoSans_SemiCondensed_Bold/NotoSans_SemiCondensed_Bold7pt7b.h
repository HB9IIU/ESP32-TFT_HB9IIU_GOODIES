#ifndef _NOTOSANS_SEMICONDENSED_BOLD7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xC0, 0xB4, 0x5F, 0x6F, 0x60, 0x79, 0x9E, 0xDA, 0xCE, 0xCD,
  0x4C, 0x63, 0x13, 0x6F, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xE9, 0x80,
  0x5D, 0x00, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x76, 0xD6, 0x74, 0x92, 0xE4,
  0xAE, 0xE5, 0x9E, 0x26, 0xAF, 0x20, 0x73, 0x9E, 0x68, 0xEB, 0x60, 0xF2,
  0x24, 0x40, 0x75, 0xDE, 0x77, 0x96, 0xC3, 0xC3, 0x80, 0x38, 0x80, 0xE3,
  0x80, 0xC7, 0x00, 0xE5, 0x04, 0x7A, 0xEB, 0x6E, 0x40, 0xC0, 0x66, 0x5F,
  0x90, 0xF7, 0x5E, 0x7C, 0x8C, 0x70, 0xF6, 0xDE, 0xEE, 0xC0, 0xEE, 0x80,
  0x74, 0xBD, 0x70, 0xB7, 0xDA, 0xD5, 0xC0, 0x55, 0x70, 0xBB, 0x6A, 0xAA,
  0xC0, 0x9C, 0xFB, 0xDE, 0x80, 0x9D, 0xDB, 0xB0, 0x76, 0xE3, 0xB7, 0x00,
  0xD7, 0xC8, 0x76, 0xE3, 0xB7, 0x0C, 0xD7, 0x6A, 0x71, 0x9E, 0xF4, 0x44,
  0x40, 0xB6, 0xDE, 0x99, 0x66, 0x60, 0x96, 0xD7, 0x5A, 0x48, 0x96, 0x66,
  0x90, 0x96, 0x66, 0x60, 0xE5, 0x2E, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70,
  0x46, 0xB0, 0xE0, 0xC0, 0x67, 0xF0, 0x8A, 0xD9, 0xE0, 0x72, 0x30, 0x17,
  0x99, 0x70, 0x69, 0xE6, 0x79, 0x24, 0x79, 0x97, 0x1E, 0x8A, 0xD9, 0x90,
  0xEA, 0x80, 0xEA, 0xA8, 0x89, 0xAE, 0x90, 0xF8, 0xAF, 0x59, 0x65, 0xAD,
  0x99, 0x69, 0x96, 0xAD, 0x9E, 0x88, 0x79, 0x97, 0x11, 0xBA, 0x40, 0x78,
  0xF0, 0x5D, 0x26, 0x99, 0x97, 0x9A, 0x66, 0xAD, 0xD6, 0xB0, 0xB6, 0x6B,
  0x9A, 0x66, 0x48, 0xE9, 0x70, 0x57, 0x50, 0xFE, 0xC9, 0x35, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 4, 0, -5 },
  { 9, 6, 5, 6, 0, -5 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 1, 2, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 6, 2, 0, -5 },
  { 22, 3, 3, 4, 0, -5 },
  { 24, 3, 3, 4, 0, -4 },
  { 26, 2, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 2, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 0, -5 },
  { 52, 3, 5, 4, 0, -5 },
  { 54, 2, 4, 2, 0, -4 },
  { 55, 2, 5, 2, 0, -4 },
  { 57, 3, 3, 4, 0, -4 },
  { 59, 3, 3, 4, 0, -4 },
  { 61, 3, 3, 4, 0, -4 },
  { 63, 3, 5, 3, 0, -5 },
  { 65, 6, 6, 6, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 3, 5, 4, 1, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 5, 1, -5 },
  { 80, 2, 5, 4, 1, -5 },
  { 82, 2, 5, 4, 1, -5 },
  { 84, 4, 5, 5, 0, -5 },
  { 87, 3, 5, 5, 1, -5 },
  { 89, 2, 5, 3, 0, -5 },
  { 91, 2, 6, 2, 0, -5 },
  { 93, 3, 5, 4, 1, -5 },
  { 95, 2, 5, 4, 1, -5 },
  { 97, 5, 5, 6, 1, -5 },
  { 101, 4, 5, 5, 1, -5 },
  { 104, 5, 5, 5, 0, -5 },
  { 108, 3, 5, 4, 1, -5 },
  { 110, 5, 6, 5, 0, -5 },
  { 114, 3, 5, 4, 1, -5 },
  { 116, 3, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 3, 5, 5, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 6, 5, 6, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 3, 5, 4, 0, -5 },
  { 138, 2, 6, 2, 0, -5 },
  { 140, 3, 5, 3, 0, -5 },
  { 142, 2, 6, 2, 0, -5 },
  { 144, 4, 3, 4, 0, -5 },
  { 146, 3, 1, 3, 0, 0 },
  { 147, 2, 1, 2, 0, -5 },
  { 148, 3, 4, 4, 0, -4 },
  { 150, 4, 5, 4, 0, -5 },
  { 153, 3, 4, 3, 0, -4 },
  { 155, 4, 5, 4, 0, -5 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 3, 5, 2, 0, -5 },
  { 162, 4, 6, 4, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 2, 5, 2, 0, -5 },
  { 170, 2, 7, 2, 0, -5 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 1, 5, 2, 0, -5 },
  { 176, 6, 4, 6, 0, -4 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 6, 4, 0, -4 },
  { 186, 4, 6, 4, 0, -4 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 5, 3, 0, -5 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 5, 4, 6, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 6, 4, 0, -4 },
  { 207, 3, 4, 3, 0, -4 },
  { 209, 2, 6, 3, 0, -5 },
  { 211, 1, 7, 4, 1, -5 },
  { 212, 3, 6, 3, 0, -5 },
  { 215, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Bold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD7PT7B_H_
