#ifndef _NOTOSANS_SEMICONDENSED_BOLD28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB8, 0x00, 0x7F,
  0xDE, 0xF0, 0xF7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x07, 0x38,
  0x0E, 0x70, 0x18, 0xE0, 0x71, 0x80, 0xE7, 0x01, 0xCE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0C, 0x70, 0x38, 0xC0, 0x73, 0x80, 0xE7, 0x0F, 0xFF, 0xDF, 0xFF,
  0x8E, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x00,
  0x02, 0x00, 0x10, 0x07, 0xF8, 0x7F, 0xF7, 0xFF, 0x7D, 0x1B, 0xC8, 0x1E,
  0x40, 0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0x7C, 0x09,
  0xF0, 0x4F, 0xF2, 0xF7, 0xFF, 0xBF, 0xF8, 0x3F, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x3E, 0x03, 0x81, 0xFC, 0x0E, 0x0F, 0x70, 0x70, 0x39, 0xE1,
  0xC0, 0xE3, 0x8E, 0x03, 0x8E, 0x38, 0x0E, 0x39, 0xC0, 0x38, 0xE7, 0x00,
  0xE7, 0xB9, 0xF3, 0xDC, 0xEF, 0xE7, 0xF7, 0x3B, 0x8F, 0x9D, 0xE7, 0x00,
  0xE7, 0x1C, 0x03, 0x9C, 0x70, 0x1C, 0x71, 0xC0, 0x71, 0xC7, 0x03, 0x87,
  0x9C, 0x0E, 0x0E, 0xF0, 0x70, 0x3F, 0x83, 0xC0, 0x7C, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0xDF,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xE1, 0xE7, 0xF8, 0x79, 0xFF, 0x1E,
  0xF9, 0xEF, 0x3C, 0x7F, 0xCF, 0x0F, 0xE3, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0x1F, 0xFE, 0xEE, 0xEE, 0xE0, 0x0F, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x0F, 0xE0, 0xE1,
  0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x38, 0x71, 0xE3, 0x8F, 0x1C, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x0C,
  0x63, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x1F, 0xC3, 0x9C, 0x79, 0xE1,
  0x08, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x7B, 0xDD, 0xEF, 0x73, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xDE, 0xF0, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1, 0xE7, 0x8F, 0x78,
  0x7B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC3, 0xCF, 0x1E, 0x78, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80,
  0x07, 0x87, 0xC7, 0xE7, 0xFF, 0xFF, 0xBD, 0x9E, 0x8F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x1F,
  0xC3, 0xFF, 0x3F, 0xFC, 0xF3, 0xE2, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0x1F,
  0xFC, 0xE3, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x1F, 0xC0, 0xF8,
  0x07, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xC1, 0xF7,
  0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xBC, 0x1C, 0xF0, 0x73, 0xC3, 0x8F,
  0x1E, 0x3C, 0x70, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0xE1, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0x7C, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x78, 0xFF, 0xE7, 0xFF, 0xBF, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0x0F, 0x78, 0xF3, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC,
  0xF1, 0xEF, 0x07, 0x38, 0x79, 0xE3, 0xCF, 0xBC, 0x3F, 0xC0, 0xFC, 0x0F,
  0xF8, 0xFB, 0xEF, 0x8F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF,
  0x9F, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFF, 0x1F, 0xF9, 0xF3, 0xEF, 0x0F,
  0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0xF1,
  0xE7, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x03, 0xE3, 0xFE, 0x1F, 0xF0, 0xFE,
  0x00, 0x4F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x23, 0xDE, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEE, 0x77, 0xB9, 0xC0, 0x00, 0x18,
  0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x1F, 0x00, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x07,
  0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x0E, 0x00, 0x40, 0x00, 0x3F, 0x8F, 0xFE,
  0x7F, 0xE6, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0xF8,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xE1, 0xF0, 0x3C,
  0x03, 0xC3, 0xC0, 0x07, 0x1C, 0x3F, 0x39, 0xC7, 0xFC, 0xEE, 0x7D, 0xE7,
  0x73, 0x87, 0x3F, 0x1C, 0x71, 0xF9, 0xE3, 0x8F, 0xCE, 0x1C, 0x7E, 0x78,
  0xE3, 0xF1, 0xC7, 0x1B, 0x8F, 0xFF, 0xCE, 0x3F, 0x7C, 0x70, 0xF1, 0xC3,
  0xC0, 0x00, 0x0F, 0x00, 0x20, 0x3E, 0x0F, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x01, 0xDE, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01,
  0xE1, 0xE0, 0x78, 0x78, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0,
  0x3C, 0x78, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3E,
  0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x07, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF1, 0xF8, 0xE3, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3F, 0x0C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x9F, 0xEF, 0x07, 0xDE, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3E, 0xF3, 0xFD, 0xFF, 0xF3, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xDF, 0xFB, 0xFF, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xF8, 0x3F,
  0xFC, 0xFF, 0xF3, 0xF0, 0xE7, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0x7C, 0x1E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF0, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0,
  0x3F, 0xE0, 0x7B, 0xC1, 0xE7, 0x87, 0xCF, 0x1F, 0x1E, 0x3C, 0x3C, 0xF8,
  0x7B, 0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xBE, 0x1E,
  0x3C, 0x3C, 0x3C, 0x78, 0x7C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF7, 0x81,
  0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x77, 0xFF, 0x07, 0x7F, 0x70,
  0xF7, 0xF7, 0x0E, 0x7F, 0x78, 0xE7, 0xF3, 0x8E, 0x7F, 0x39, 0xC7, 0xF3,
  0x9C, 0x7F, 0x3D, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F,
  0x0F, 0x87, 0xF0, 0xF0, 0x7F, 0x0F, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xEF, 0x0F,
  0xF3, 0xC7, 0xF9, 0xE3, 0xFC, 0x79, 0xFE, 0x3C, 0xFF, 0x0F, 0x7F, 0x87,
  0xBF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0xFC, 0x7C,
  0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0x79,
  0xF0, 0x3E, 0x3F, 0x1F, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xE7, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0xF8, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78,
  0x07, 0xDE, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x3E, 0x3F, 0x1F, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x8F,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xFF, 0xE3,
  0xFF, 0x87, 0xFE, 0x0F, 0x3E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0,
  0xF9, 0xE0, 0xF3, 0xC1, 0xF7, 0x81, 0xF0, 0x1F, 0xE3, 0xFF, 0x7F, 0xF7,
  0x8E, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0x7E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0x7C, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0,
  0x7F, 0x80, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81,
  0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x1C, 0x3C, 0x0F, 0x1E, 0x07,
  0x8F, 0x01, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x07,
  0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x87, 0xE0,
  0xF3, 0xC3, 0xF8, 0x79, 0xE1, 0xDC, 0x78, 0x70, 0xEE, 0x3C, 0x3C, 0x77,
  0x1E, 0x1E, 0x7B, 0x8F, 0x0F, 0x39, 0xE7, 0x03, 0x9C, 0x77, 0x81, 0xEE,
  0x3B, 0xC0, 0xFF, 0x1D, 0xE0, 0x7F, 0x0E, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x3E, 0x0F, 0x0F, 0x0F, 0x87, 0xC7, 0x81, 0xE7, 0xC0, 0xFB,
  0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0x78, 0x3C, 0x3E,
  0x3E, 0x0F, 0x1E, 0x07, 0xDF, 0x01, 0xF0, 0xF8, 0x1F, 0x78, 0x1E, 0x78,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8F, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF,
  0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0xCE,
  0x0E, 0x38, 0x38, 0x71, 0xC1, 0xC7, 0x03, 0xB8, 0x0E, 0xE0, 0x1C, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3C, 0x1E, 0x0F, 0x01, 0x03, 0xFF, 0x0F, 0xFC, 0x7B,
  0xE2, 0x0F, 0x00, 0x3C, 0x07, 0xE7, 0xFF, 0x7F, 0xFF, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFF, 0x0F, 0xFF, 0xFD, 0xFD, 0xE7, 0xC7, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x83, 0xDF, 0x9F, 0xFE, 0xFF, 0xF7, 0xC7,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC7, 0xFF, 0xFD, 0xFF, 0xCE, 0x7C, 0x00, 0x03, 0x01, 0xFF, 0x3F, 0xE7,
  0xFE, 0x78, 0x2F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x27, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x82, 0x3C, 0x7E, 0xE7, 0xF7, 0x7F, 0xFB, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0x7B, 0xC3,
  0xDF, 0xFE, 0x7F, 0x71, 0xF3, 0x80, 0x02, 0x00, 0xFF, 0x0F, 0xFC, 0xFB,
  0xE7, 0x87, 0xB8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0xC1, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0x0F, 0xE3, 0xFC, 0x7F,
  0x0F, 0x01, 0xE0, 0x3C, 0x1F, 0xF7, 0xFE, 0xFF, 0xC3, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x04, 0x00, 0xFD, 0xCF, 0xEE, 0xFF, 0xF7, 0x87, 0xFC, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0xF7, 0x87, 0xBF, 0xFC,
  0xFE, 0xE3, 0xEF, 0x00, 0x78, 0x03, 0xD0, 0x1E, 0xFF, 0xF7, 0xFF, 0x3F,
  0xF0, 0x7E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0xC3, 0xDF, 0x9F, 0xFE, 0xFF, 0xF7, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0x80, 0xFF, 0xF6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x3C, 0x78, 0x60, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFB,
  0xF7, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x07, 0xBC, 0x3C, 0xF1, 0xE3, 0xCF, 0x8F, 0x7C, 0x3D, 0xE0, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x3E, 0xF0, 0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C,
  0x1E, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0xC7, 0x3F, 0x3F, 0xBB, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x8F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0,
  0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87,
  0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0x01, 0x87, 0x3F, 0x3B,
  0xFD, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x03, 0x00,
  0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E, 0x78, 0x78, 0xFF, 0xE3, 0xFF,
  0x03, 0xF0, 0x01, 0x87, 0x3F, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F, 0xFF,
  0xFB, 0xFF, 0x9E, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x04, 0x00, 0xFD, 0xCF, 0xEE, 0xFF, 0xF7, 0x87,
  0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0xF7,
  0x87, 0xBF, 0xFC, 0xFE, 0xE3, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x01, 0xF3, 0xFB, 0xFF, 0xFF, 0xCF,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x04, 0x07, 0xFD, 0xFF, 0x7D, 0xEF, 0x01, 0xE0, 0x3F, 0x03, 0xF8, 0x3F,
  0xC1, 0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0xFF, 0xBF, 0xF7, 0xFC, 0x18, 0x1C,
  0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0xFE, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF8, 0x3F, 0x9F, 0xC7, 0xE0, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xBF, 0xFC, 0xFC, 0xE0, 0xF0, 0x3E, 0xF0,
  0x79, 0xE0, 0xF3, 0xC3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x0E, 0x78,
  0x1E, 0xF0, 0x3D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xF0, 0x78, 0x3D, 0xE3, 0xF0, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F,
  0x1E, 0x78, 0xFC, 0x78, 0xF3, 0x39, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC,
  0x1D, 0xCE, 0xF0, 0x77, 0x1B, 0x81, 0xD8, 0x6E, 0x07, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7D, 0xF1, 0xE3,
  0xCF, 0x87, 0xBC, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0x81, 0xEF, 0x0F, 0x3C, 0x3C, 0x79, 0xE1, 0xFF, 0x83, 0xC0, 0xF8,
  0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1C,
  0x0F, 0x78, 0x1E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x87, 0xC3, 0xE1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0F, 0x0F, 0x9F, 0x8F, 0x87, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x7C, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x07, 0xC3, 0xF0, 0x78, 0xFC, 0xF8, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC7, 0xE3, 0xF1, 0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 8, 1, -20 },
  { 14, 9, 7, 13, 2, -20 },
  { 22, 15, 20, 17, 1, -20 },
  { 60, 13, 23, 15, 1, -21 },
  { 98, 22, 20, 24, 1, -20 },
  { 153, 18, 20, 19, 1, -20 },
  { 198, 4, 7, 7, 2, -20 },
  { 202, 8, 24, 9, 1, -20 },
  { 226, 7, 24, 9, 1, -20 },
  { 247, 12, 12, 14, 1, -21 },
  { 265, 13, 14, 15, 1, -17 },
  { 288, 5, 7, 8, 1, -3 },
  { 293, 7, 3, 9, 1, -9 },
  { 296, 5, 4, 8, 1, -4 },
  { 299, 11, 20, 12, 0, -20 },
  { 327, 13, 20, 15, 1, -20 },
  { 360, 9, 20, 15, 2, -20 },
  { 383, 13, 20, 15, 1, -20 },
  { 416, 13, 20, 15, 1, -20 },
  { 449, 14, 20, 15, 0, -20 },
  { 484, 13, 20, 15, 1, -20 },
  { 517, 13, 20, 15, 1, -20 },
  { 550, 13, 20, 15, 1, -20 },
  { 583, 13, 20, 15, 1, -20 },
  { 616, 13, 20, 15, 1, -20 },
  { 649, 4, 16, 8, 2, -16 },
  { 657, 5, 20, 8, 1, -16 },
  { 670, 13, 14, 15, 1, -17 },
  { 693, 13, 8, 15, 1, -14 },
  { 706, 13, 14, 15, 1, -17 },
  { 729, 12, 20, 12, 0, -20 },
  { 759, 21, 22, 23, 1, -20 },
  { 817, 18, 20, 18, 0, -20 },
  { 862, 14, 20, 17, 2, -20 },
  { 897, 15, 20, 16, 1, -20 },
  { 935, 15, 20, 19, 2, -20 },
  { 973, 11, 20, 14, 2, -20 },
  { 1001, 11, 20, 14, 2, -20 },
  { 1029, 15, 20, 19, 2, -20 },
  { 1067, 15, 20, 20, 2, -20 },
  { 1105, 8, 20, 10, 1, -20 },
  { 1125, 8, 26, 9, -2, -20 },
  { 1151, 15, 20, 17, 2, -20 },
  { 1189, 11, 20, 14, 2, -20 },
  { 1217, 20, 20, 25, 2, -20 },
  { 1267, 17, 20, 21, 2, -20 },
  { 1310, 18, 20, 20, 1, -20 },
  { 1355, 13, 20, 16, 2, -20 },
  { 1388, 18, 25, 20, 1, -20 },
  { 1445, 15, 20, 17, 2, -20 },
  { 1483, 12, 20, 14, 1, -20 },
  { 1513, 14, 20, 15, 0, -20 },
  { 1548, 15, 20, 19, 2, -20 },
  { 1586, 17, 20, 17, 0, -20 },
  { 1629, 25, 20, 25, 0, -20 },
  { 1692, 17, 20, 17, 0, -20 },
  { 1735, 16, 20, 16, 0, -20 },
  { 1775, 13, 20, 15, 1, -20 },
  { 1808, 6, 24, 9, 2, -20 },
  { 1826, 11, 20, 12, 0, -20 },
  { 1854, 6, 24, 9, 1, -20 },
  { 1872, 14, 13, 16, 1, -20 },
  { 1895, 12, 2, 11, 0, 2 },
  { 1898, 8, 4, 10, 1, -21 },
  { 1902, 13, 16, 15, 1, -16 },
  { 1928, 13, 21, 16, 2, -21 },
  { 1963, 12, 16, 13, 1, -16 },
  { 1987, 13, 21, 16, 1, -21 },
  { 2022, 13, 16, 15, 1, -16 },
  { 2048, 11, 21, 10, 0, -21 },
  { 2077, 13, 23, 16, 1, -16 },
  { 2115, 13, 21, 17, 2, -21 },
  { 2150, 4, 21, 8, 2, -21 },
  { 2161, 7, 28, 8, -1, -21 },
  { 2186, 14, 21, 16, 2, -21 },
  { 2223, 4, 21, 8, 2, -21 },
  { 2234, 21, 16, 25, 2, -16 },
  { 2276, 13, 16, 17, 2, -16 },
  { 2302, 14, 16, 16, 1, -16 },
  { 2330, 13, 23, 16, 2, -16 },
  { 2368, 13, 23, 16, 1, -16 },
  { 2406, 9, 16, 12, 2, -16 },
  { 2424, 11, 16, 13, 1, -16 },
  { 2446, 9, 19, 11, 1, -19 },
  { 2468, 13, 15, 17, 2, -15 },
  { 2493, 15, 15, 15, 0, -15 },
  { 2522, 22, 15, 22, 0, -15 },
  { 2564, 14, 15, 15, 0, -15 },
  { 2591, 15, 22, 15, 0, -15 },
  { 2633, 11, 15, 12, 1, -15 },
  { 2654, 9, 24, 11, 0, -20 },
  { 2681, 3, 27, 14, 6, -21 },
  { 2692, 9, 24, 11, 1, -20 },
  { 2719, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Bold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD28PT7B_H_
