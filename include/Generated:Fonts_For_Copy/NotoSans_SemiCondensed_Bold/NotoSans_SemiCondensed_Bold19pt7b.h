#ifndef _NOTOSANS_SEMICONDENSED_BOLD19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7C, 0xC0,
  0x0C, 0xC1, 0xB0, 0x36, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xD8, 0xFF,
  0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x20, 0x6C, 0x00, 0x08, 0x3E, 0xFF, 0xEB,
  0xC8, 0xE8, 0x7C, 0x3E, 0x0F, 0x0B, 0x8B, 0xFF, 0xFE, 0x08, 0x08, 0x70,
  0x61, 0xF0, 0xC3, 0x63, 0x06, 0xE6, 0x0D, 0xD8, 0x1B, 0xB0, 0x36, 0xCF,
  0x7D, 0xB6, 0x77, 0x6E, 0x0C, 0xCC, 0x39, 0x98, 0x63, 0x71, 0xC7, 0xC3,
  0x07, 0x00, 0x1C, 0x07, 0xE0, 0x77, 0x06, 0x70, 0x67, 0x07, 0xE0, 0x3C,
  0x07, 0xCE, 0xEE, 0xEE, 0x7C, 0xE3, 0xCE, 0x3C, 0xFF, 0xE7, 0xEF, 0xFF,
  0xFC, 0x19, 0x9C, 0xCE, 0x73, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x86, 0x38,
  0xE3, 0x0C, 0x63, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9C, 0xCE, 0xE0, 0x0C,
  0x06, 0x1B, 0xEF, 0xF9, 0xC1, 0xF1, 0xDC, 0x24, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x60, 0xFF, 0xFF, 0x80, 0x07, 0x06,
  0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0,
  0x3C, 0x7E, 0xFF, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0xE7,
  0x7E, 0x3C, 0x0C, 0x73, 0xDF, 0xED, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0x3C, 0xFE, 0xFF, 0x47, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0xFF, 0xFF, 0x3C, 0xFE, 0xFF, 0x07, 0x07, 0x06, 0x3C, 0x3E, 0x07,
  0x07, 0x07, 0x87, 0xFF, 0xFC, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x06,
  0xC3, 0x31, 0xCC, 0x63, 0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7E,
  0x7E, 0xFE, 0xE0, 0xE0, 0xFC, 0xFE, 0xFF, 0x07, 0x07, 0x07, 0x87, 0xFE,
  0xFC, 0x0F, 0x3F, 0x7F, 0xE0, 0xE0, 0xDE, 0xFF, 0xE7, 0xE3, 0xC3, 0xE3,
  0xE7, 0x7F, 0x3E, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0x81, 0xC0, 0x3C, 0x7E, 0xE7, 0xE7, 0xE7,
  0x7E, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xE3, 0xFF, 0x7E, 0x38, 0x7E, 0xFF,
  0xC7, 0xC3, 0xC3, 0xE7, 0xFF, 0x7B, 0x03, 0x07, 0x0E, 0xFE, 0xF8, 0x5F,
  0xA0, 0x00, 0xFF, 0x80, 0x5F, 0xA0, 0x00, 0x1F, 0xEC, 0x01, 0x03, 0x0F,
  0x3C, 0xF0, 0xE0, 0x78, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x1E, 0xF8, 0xE0, 0x80, 0x3C,
  0xFE, 0x7F, 0x07, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x38, 0x03, 0x80, 0x7F, 0x83, 0x83, 0x1C, 0x06, 0x67, 0xCF, 0x3B, 0x3C,
  0xCC, 0xF6, 0x33, 0xD8, 0xCF, 0x33, 0x3C, 0xFF, 0xB1, 0xCC, 0x60, 0x00,
  0xE1, 0x81, 0xFE, 0x00, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F,
  0x81, 0x98, 0x39, 0xC3, 0x9C, 0x3F, 0xC7, 0xFE, 0x7F, 0xE7, 0x0E, 0xE0,
  0x7E, 0x07, 0xFC, 0x3F, 0xEF, 0xFB, 0x86, 0xE1, 0xB8, 0xEF, 0xF3, 0xFE,
  0xE3, 0xB8, 0x7E, 0x1F, 0x8F, 0xFF, 0xBF, 0xC0, 0x0F, 0x0F, 0xF7, 0xF9,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xE2, 0x3F,
  0x87, 0xE0, 0xFC, 0x1F, 0xE3, 0xFE, 0x70, 0xEE, 0x1D, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1B, 0x87, 0x73, 0xEF, 0xF9, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x0C, 0x18, 0x3F, 0x7E, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0C, 0x18, 0x3F, 0x7E, 0xFD, 0x83, 0x06, 0x0C, 0x18, 0x00,
  0x0F, 0x8F, 0xF7, 0xFD, 0xC0, 0xE0, 0x38, 0x0E, 0x7F, 0x9F, 0xE7, 0xF8,
  0x3F, 0x0D, 0xC3, 0x3F, 0xC7, 0xF0, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x70,
  0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xEF, 0xFC, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xF7, 0xFF, 0x80, 0xC1, 0xF0, 0xEC,
  0x73, 0x38, 0xCE, 0x37, 0x0F, 0x83, 0xF0, 0xFE, 0x33, 0x8C, 0x73, 0x1C,
  0xC3, 0xB0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF,
  0x8D, 0xEC, 0x6F, 0x63, 0x7B, 0x33, 0xDD, 0x9E, 0x6C, 0xF3, 0xC7, 0x9E,
  0x3C, 0x71, 0xE3, 0x8C, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xB9,
  0xF7, 0x3E, 0x77, 0xCE, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xC0,
  0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x06, 0xF0, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0xFC, 0x7F, 0xBF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x06, 0xF0, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0xF8, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEE, 0x7B,
  0xFC, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE1, 0xF8, 0x70, 0x3C, 0x7F, 0xFE,
  0xE0, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x07, 0xC7, 0xFE, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0x83, 0xB8, 0xE7, 0xFC, 0x3F,
  0x00, 0xE0, 0x7C, 0x1D, 0x83, 0xB8, 0x67, 0x1C, 0x63, 0x8C, 0x61, 0xCC,
  0x3B, 0x83, 0x70, 0x6C, 0x0F, 0x80, 0xF0, 0x1C, 0x00, 0xE1, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xCC, 0x78, 0x67, 0x36, 0x73, 0x9B, 0x39, 0xCD, 0x98,
  0x6E, 0xCC, 0x37, 0x7E, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xE3,
  0xC0, 0xE1, 0xE0, 0xE0, 0xEE, 0x39, 0xC7, 0x1D, 0xC1, 0xB8, 0x3E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0x70, 0xEE, 0x38, 0xE7, 0x1D, 0xC1, 0xC0, 0xE0,
  0xEC, 0x39, 0xC7, 0x38, 0xC3, 0xB8, 0x76, 0x07, 0xC0, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0x70,
  0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0F, 0xFF, 0xFC, 0xFF,
  0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x0C,
  0x03, 0x01, 0xE0, 0x78, 0x1B, 0x0C, 0xC3, 0x19, 0x86, 0xE0, 0xC0, 0xFF,
  0xE3, 0x8E, 0x18, 0x7E, 0x7F, 0x07, 0x07, 0x7F, 0xE7, 0xC7, 0xE7, 0xFF,
  0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x8F, 0xF7, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFE, 0x7F, 0xF7, 0x78, 0x0C, 0x7F, 0x7E, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE2, 0x7E, 0x3E, 0x03, 0x81, 0xC0, 0xE2, 0x77, 0xFF, 0xFF, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0xFB, 0xDC, 0x18, 0x3F, 0x1D, 0xDC,
  0x6E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE1, 0x3F, 0x8F, 0xC0, 0x0D, 0x3E, 0x3E,
  0x30, 0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x10, 0x3F, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xBF, 0xDE,
  0xE0, 0x70, 0x3F, 0xFB, 0xF8, 0x30, 0xE0, 0x70, 0x38, 0x1C, 0x8F, 0xF7,
  0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xC0, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0xFF, 0x98, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE3, 0xB9, 0xCE,
  0xE3, 0xB0, 0xFC, 0x3F, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x11, 0xFE, 0xFB, 0xFF, 0xFF, 0x1C, 0x7E,
  0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E,
  0x38, 0x06, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xE0, 0x18, 0x3F, 0x9F, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xBF, 0x8F, 0x80, 0x04, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xF3, 0xFF, 0xBB, 0xDC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x10, 0x3F, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xBF, 0xDE, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x05, 0xFF, 0xF7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x80, 0x19, 0xFF, 0xB6, 0x0F, 0x0F, 0x8F, 0x87, 0x8F, 0xFF, 0xF0, 0x10,
  0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xF3, 0xE0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0xBE, 0xC0, 0xE1,
  0xD8, 0x67, 0x39, 0xCE, 0x33, 0x0F, 0xC3, 0xF0, 0x78, 0x1E, 0x07, 0x80,
  0xE3, 0x8E, 0xC7, 0x19, 0xDB, 0x33, 0xB6, 0xE7, 0x6D, 0xC6, 0xDB, 0x0D,
  0x16, 0x1E, 0x3C, 0x3C, 0x78, 0x38, 0xE0, 0xF3, 0xDC, 0xE3, 0xF0, 0x78,
  0x1E, 0x07, 0x83, 0xF0, 0xDC, 0x73, 0xB8, 0x70, 0xE1, 0xD8, 0x67, 0x39,
  0xCE, 0x33, 0x0F, 0xC3, 0xF0, 0x78, 0x1E, 0x03, 0x80, 0xC0, 0x70, 0x78,
  0x1E, 0x06, 0x00, 0x7F, 0x7F, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0xFF,
  0xFF, 0x04, 0x71, 0xCE, 0x38, 0xE3, 0x8E, 0xF3, 0xC3, 0x8E, 0x38, 0xE3,
  0x87, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0x8F, 0x1C, 0x71, 0xC7,
  0x1E, 0x1C, 0xF7, 0x1C, 0x71, 0xC7, 0x3C, 0xE0, 0xF9, 0xFF, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 11, 14, 11, 0, -14 },
  { 32, 8, 15, 10, 1, -14 },
  { 47, 15, 14, 16, 1, -14 },
  { 74, 12, 14, 13, 1, -14 },
  { 95, 3, 5, 5, 1, -14 },
  { 97, 5, 17, 6, 1, -14 },
  { 108, 5, 17, 6, 0, -14 },
  { 119, 9, 8, 10, 0, -14 },
  { 128, 8, 9, 10, 1, -11 },
  { 137, 3, 4, 5, 1, -2 },
  { 139, 4, 2, 6, 1, -6 },
  { 140, 3, 3, 5, 1, -3 },
  { 142, 8, 14, 8, 0, -14 },
  { 156, 8, 14, 10, 1, -14 },
  { 170, 6, 14, 10, 1, -14 },
  { 181, 8, 14, 10, 1, -14 },
  { 195, 8, 14, 10, 1, -14 },
  { 209, 10, 14, 10, 0, -14 },
  { 227, 8, 14, 10, 1, -14 },
  { 241, 8, 14, 10, 1, -14 },
  { 255, 9, 14, 10, 0, -14 },
  { 271, 8, 14, 10, 1, -14 },
  { 285, 8, 14, 10, 1, -14 },
  { 299, 3, 11, 5, 1, -11 },
  { 304, 3, 13, 5, 1, -11 },
  { 309, 8, 10, 10, 1, -12 },
  { 319, 8, 6, 10, 1, -10 },
  { 325, 8, 10, 10, 1, -12 },
  { 335, 8, 14, 8, 0, -14 },
  { 349, 14, 16, 16, 1, -14 },
  { 377, 12, 14, 12, 0, -14 },
  { 398, 10, 14, 12, 1, -14 },
  { 416, 10, 14, 11, 1, -14 },
  { 434, 11, 14, 13, 1, -14 },
  { 454, 7, 14, 10, 2, -14 },
  { 467, 7, 14, 10, 2, -14 },
  { 480, 10, 14, 13, 1, -14 },
  { 498, 10, 14, 13, 2, -14 },
  { 516, 5, 14, 7, 1, -14 },
  { 525, 5, 18, 6, -1, -14 },
  { 537, 10, 14, 12, 2, -14 },
  { 555, 8, 14, 10, 1, -14 },
  { 569, 13, 14, 17, 2, -14 },
  { 592, 11, 14, 14, 2, -14 },
  { 612, 12, 14, 14, 1, -14 },
  { 633, 9, 14, 11, 1, -14 },
  { 649, 12, 17, 14, 1, -14 },
  { 675, 10, 14, 11, 1, -14 },
  { 693, 8, 14, 10, 1, -14 },
  { 707, 10, 14, 10, 0, -14 },
  { 725, 11, 14, 13, 1, -14 },
  { 745, 11, 14, 11, 0, -14 },
  { 765, 17, 14, 17, 0, -14 },
  { 795, 11, 14, 11, 0, -14 },
  { 815, 11, 14, 11, 0, -14 },
  { 835, 9, 14, 10, 0, -14 },
  { 851, 5, 17, 6, 1, -14 },
  { 862, 8, 14, 8, 0, -14 },
  { 876, 5, 17, 6, 0, -14 },
  { 887, 10, 9, 11, 0, -14 },
  { 899, 8, 1, 8, 0, 2 },
  { 900, 5, 3, 7, 1, -15 },
  { 902, 8, 11, 10, 1, -11 },
  { 913, 9, 14, 11, 1, -14 },
  { 929, 8, 11, 9, 1, -11 },
  { 940, 9, 14, 11, 1, -14 },
  { 956, 9, 11, 10, 1, -11 },
  { 969, 8, 15, 7, 0, -15 },
  { 984, 9, 16, 11, 1, -11 },
  { 1002, 9, 14, 11, 1, -14 },
  { 1018, 3, 14, 5, 1, -14 },
  { 1024, 5, 19, 5, -1, -14 },
  { 1036, 10, 14, 11, 1, -14 },
  { 1054, 3, 14, 5, 1, -14 },
  { 1060, 15, 11, 17, 1, -11 },
  { 1081, 9, 11, 11, 1, -11 },
  { 1094, 9, 11, 11, 1, -11 },
  { 1107, 9, 16, 11, 1, -11 },
  { 1125, 9, 16, 11, 1, -11 },
  { 1143, 7, 11, 8, 1, -11 },
  { 1153, 7, 11, 9, 1, -11 },
  { 1163, 7, 13, 8, 0, -13 },
  { 1175, 9, 10, 11, 1, -10 },
  { 1187, 10, 10, 10, 0, -10 },
  { 1200, 15, 10, 15, 0, -10 },
  { 1219, 10, 10, 10, 0, -10 },
  { 1232, 10, 15, 10, 0, -10 },
  { 1251, 8, 10, 8, 0, -10 },
  { 1261, 6, 17, 7, 0, -14 },
  { 1274, 2, 18, 10, 4, -14 },
  { 1279, 6, 17, 7, 1, -14 },
  { 1292, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Bold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD19PT7B_H_
