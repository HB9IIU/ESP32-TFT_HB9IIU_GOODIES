#ifndef _NOTOSANS_SEMICONDENSED_BOLD27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDE, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x8E, 0x07, 0x38, 0x1C,
  0x60, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x87, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x8E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xCE, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x03, 0xFF, 0x7F, 0xFF, 0xFE, 0xF6, 0x2F, 0x60, 0xFE, 0x07, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x06, 0xF8, 0x67, 0xE6, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x83, 0xF0,
  0x38, 0x1F, 0xC1, 0xC1, 0xCE, 0x1C, 0x0E, 0x70, 0xE0, 0x73, 0x8E, 0x03,
  0x9C, 0x70, 0x1C, 0xE7, 0x00, 0xE7, 0x39, 0xE7, 0x3B, 0x9F, 0x9F, 0xDD,
  0xFE, 0xFD, 0xCE, 0x70, 0x8E, 0x73, 0x80, 0xE3, 0x9C, 0x07, 0x1C, 0xE0,
  0x70, 0xE7, 0x03, 0x87, 0x38, 0x38, 0x3B, 0xC1, 0xC0, 0xFC, 0x1C, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0x8F, 0x03,
  0xC7, 0x80, 0xE3, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE3,
  0xEF, 0xF9, 0xEF, 0xBC, 0xF7, 0x8F, 0xF3, 0xC3, 0xF9, 0xE0, 0xF8, 0xF8,
  0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xC3, 0xF9, 0xF0, 0xFF, 0xFF, 0xF8, 0x1E,
  0x38, 0xF1, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x38, 0x70, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x80, 0xE0, 0xE1, 0xE1, 0xC3,
  0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x78,
  0xF1, 0xC7, 0x8E, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xE6,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xBC, 0x79, 0xE3, 0x18, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7B, 0xDD, 0xEF, 0x70, 0xFF,
  0xFF, 0xF8, 0x77, 0xFE, 0xF0, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x00, 0x02, 0x01, 0xFC, 0x3F,
  0xC7, 0xFE, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x79, 0xF7, 0xFE, 0x3F,
  0xC1, 0xF8, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0xFB, 0xDC, 0xF2, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x02, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0x60, 0xF2, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xFC, 0xFF,
  0xE7, 0xFF, 0x60, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0xC1, 0xF8, 0x1F,
  0xC1, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xFF, 0xFE, 0xFF,
  0xEF, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xEF, 0x07, 0x3C, 0x1C, 0xF0, 0xE3, 0xC3, 0x8F, 0x1C, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0xFC,
  0x7F, 0xE7, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFC, 0x1F,
  0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x00, 0x80, 0xFE, 0x1F, 0xE3, 0xFE, 0x7C,
  0x07, 0x80, 0x70, 0x0F, 0x10, 0xF7, 0xEF, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x00, 0x02, 0x03, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF,
  0x0F, 0x70, 0xF7, 0x9E, 0x3F, 0xE1, 0xF8, 0x3F, 0xC7, 0xFE, 0x79, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x04, 0x03,
  0xF8, 0x7F, 0xC7, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xF7, 0xF7, 0x3F, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x03, 0xE7,
  0xFC, 0x7F, 0x87, 0xF0, 0x73, 0xFE, 0xF2, 0x00, 0x00, 0x00, 0x00, 0xEF,
  0xFD, 0xE0, 0x73, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xDE,
  0xF7, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x0F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x70, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x03, 0xF1, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0x08, 0x00, 0x04, 0x0F,
  0xFB, 0xFF, 0xBF, 0xF4, 0x1E, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0x03, 0xC1, 0xC0, 0x1E,
  0x38, 0x00, 0xE7, 0x0F, 0xE7, 0x71, 0xFE, 0x77, 0x38, 0xE7, 0xE7, 0x8E,
  0x3E, 0x70, 0xE3, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x1E, 0x7E, 0x3B,
  0xEE, 0x73, 0xF7, 0xE7, 0x1E, 0x3C, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x1C, 0x70,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF1, 0xF0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xFC, 0x01, 0xE0,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFF,
  0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1F, 0xFF, 0xF7, 0xFF, 0xBF, 0xF0, 0x00, 0x80, 0x1F, 0xF1, 0xFF,
  0xCF, 0xFE, 0x3E, 0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x08, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1F, 0x79, 0xFC,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x3F, 0xF8,
  0xFF, 0xE3, 0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xF7, 0x8F, 0xEF, 0x03, 0xDE, 0x07, 0xBE, 0x0F,
  0x3E, 0x1E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0xFF, 0xFF, 0x7E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0xFE, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0xFF, 0xFE, 0xFC, 0x70, 0xF0, 0x3D, 0xE0, 0xF3, 0xC3, 0xE7, 0x8F, 0x8F,
  0x1E, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x07, 0xDE, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x7C, 0xF0, 0x79,
  0xE0, 0xFB, 0xC0, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E,
  0xFF, 0x70, 0xEF, 0xF7, 0x1E, 0xFF, 0x71, 0xCF, 0xF7, 0x9C, 0xFF, 0x39,
  0xCF, 0xF3, 0xB8, 0xFF, 0x3F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x0F, 0xF1,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xF7, 0x8F, 0xF7, 0x8F, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF1, 0xEF, 0xF1, 0xEF, 0xF0, 0xFF, 0xF0, 0xF7, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0x01, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x1E, 0x3E, 0x3F, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8, 0x1E, 0x3E, 0x3F, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0xFB,
  0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0,
  0xF3, 0xE3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x03,
  0xC0, 0x06, 0x03, 0xFF, 0x7F, 0xE7, 0xFE, 0xF8, 0x6F, 0x00, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x1E, 0x00, 0xF8,
  0x0F, 0xE1, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x3C, 0x3E, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E,
  0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0x70, 0x3C, 0x0E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E,
  0x1E, 0x78, 0x7E, 0x1C, 0x38, 0xEF, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7,
  0x3C, 0x3C, 0xE7, 0x3C, 0x1D, 0xE7, 0x38, 0x1D, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x7C, 0x3E, 0x3C, 0x3C, 0x1E, 0x7C,
  0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C,
  0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF0, 0x7D, 0xE0, 0xF1,
  0xE3, 0xE3, 0xC7, 0x83, 0xCF, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xF1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F,
  0xFF, 0xC0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x0E, 0xE0,
  0xE3, 0x87, 0x1C, 0x70, 0x73, 0x83, 0xB8, 0x0F, 0xC0, 0x70, 0xFF, 0xFF,
  0xFC, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0x1F, 0xC7, 0xFE, 0x3F, 0xF3, 0x0F,
  0x00, 0xF0, 0x0F, 0x1F, 0xF7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xF7, 0xF7, 0x3E, 0x70, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xDF, 0x1F, 0xFC, 0xFF, 0xF7, 0xCF, 0xBC, 0x3D, 0xE1,
  0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0xF0, 0xF7, 0xC7, 0xBF, 0xFD,
  0xDF, 0xCE, 0x7C, 0x00, 0x0F, 0xC7, 0xFC, 0xFF, 0xBE, 0x27, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x17, 0xFE, 0x7F, 0xC7,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x7D,
  0xE7, 0xFF, 0x7F, 0xFB, 0xC7, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x7B, 0xC7, 0xDF, 0xFE, 0x7F, 0xF1, 0xF3, 0x80,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0xF0, 0x27, 0xFF, 0x1F, 0xF8, 0x7F,
  0x80, 0x03, 0x81, 0xFC, 0x7F, 0x0F, 0xE3, 0xC0, 0x78, 0x0F, 0xE7, 0xFC,
  0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1F, 0x39, 0xFF, 0xDF, 0xFE, 0xF1,
  0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E,
  0xF1, 0xF7, 0xFF, 0x9F, 0xFC, 0x7D, 0xE0, 0x0F, 0x00, 0x7A, 0x07, 0xDF,
  0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0x4F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x08, 0x3C, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFD, 0xFB, 0xE0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xFE,
  0x1E, 0xF1, 0xE7, 0x9E, 0x3D, 0xF1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x1F, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x3D, 0xE1, 0xEF, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC7,
  0xCE, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0x8F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0,
  0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xDC, 0x1E, 0xF1, 0xF7, 0xFF, 0x1F, 0xF0, 0x3F, 0x00,
  0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xF3, 0xEF, 0x0F, 0x78, 0x7B, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xF1, 0xEF, 0xFF, 0x7F, 0xF3, 0xDF,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F,
  0x39, 0xFF, 0xDF, 0xFE, 0xF1, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF1, 0xF7, 0xFF, 0x9F, 0xFC, 0x7D, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xE7, 0xF7,
  0xFB, 0xFF, 0xEF, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0x1F, 0x9F, 0xFF, 0xFF, 0xC2, 0xF0, 0x3E, 0x07, 0xE0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0xEF, 0xF0, 0x38, 0x1C,
  0x0E, 0x0F, 0xFF, 0xFF, 0xFD, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0x3F, 0x8F, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xFF, 0xF7, 0xF7, 0x3E, 0x70, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9E,
  0x1E, 0x78, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x1C, 0xE0, 0x7F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0xF8, 0x7B,
  0x87, 0xC3, 0xDE, 0x3E, 0x1E, 0xF1, 0xF8, 0xE7, 0x8D, 0xCF, 0x1C, 0xEE,
  0x78, 0xF7, 0x73, 0xC7, 0xB9, 0x9C, 0x3D, 0xCF, 0xE0, 0xEC, 0x7F, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E,
  0x00, 0xF8, 0x7D, 0xE1, 0xE3, 0xCF, 0x0F, 0x3C, 0x1F, 0xE0, 0x7F, 0x80,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0x3C, 0x3C, 0xF1,
  0xE1, 0xEF, 0x87, 0xC0, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9E, 0x1E, 0x38,
  0x78, 0xF1, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xE0, 0x7F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x07,
  0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x87, 0xC3, 0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x3F,
  0x1E, 0x0F, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF8,
  0x7C, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x07, 0xE0, 0xF1, 0xF9, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x8F,
  0xC7, 0xC3, 0xC0, 0x38, 0x1F, 0xF1, 0xFF, 0xFC, 0x7F, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 9, 7, 13, 2, -19 },
  { 21, 15, 19, 16, 1, -19 },
  { 57, 12, 23, 14, 1, -21 },
  { 92, 21, 20, 23, 1, -20 },
  { 145, 17, 20, 18, 1, -20 },
  { 188, 3, 7, 7, 2, -19 },
  { 191, 7, 23, 9, 1, -19 },
  { 212, 7, 23, 9, 1, -19 },
  { 233, 12, 12, 14, 1, -21 },
  { 251, 12, 13, 14, 1, -16 },
  { 271, 5, 6, 7, 1, -3 },
  { 275, 7, 3, 8, 1, -9 },
  { 278, 5, 4, 7, 1, -4 },
  { 281, 11, 19, 11, 0, -19 },
  { 308, 12, 20, 14, 1, -20 },
  { 338, 10, 19, 14, 1, -19 },
  { 362, 12, 20, 14, 1, -20 },
  { 392, 12, 20, 14, 1, -20 },
  { 422, 14, 19, 14, 0, -19 },
  { 456, 12, 19, 14, 1, -19 },
  { 485, 12, 20, 14, 1, -20 },
  { 515, 12, 19, 14, 1, -19 },
  { 544, 12, 20, 14, 1, -20 },
  { 574, 12, 20, 14, 1, -20 },
  { 604, 5, 15, 7, 1, -15 },
  { 614, 5, 18, 7, 1, -15 },
  { 626, 12, 14, 14, 1, -17 },
  { 647, 12, 9, 14, 1, -14 },
  { 661, 12, 14, 14, 1, -17 },
  { 682, 11, 20, 12, 0, -20 },
  { 710, 20, 21, 22, 1, -19 },
  { 763, 17, 19, 17, 0, -19 },
  { 804, 13, 19, 17, 2, -19 },
  { 835, 14, 20, 16, 1, -20 },
  { 870, 15, 19, 18, 2, -19 },
  { 906, 10, 19, 14, 2, -19 },
  { 930, 10, 19, 14, 2, -19 },
  { 954, 15, 20, 18, 1, -20 },
  { 992, 15, 19, 19, 2, -19 },
  { 1028, 8, 19, 10, 1, -19 },
  { 1047, 8, 25, 8, -2, -19 },
  { 1072, 15, 19, 16, 2, -19 },
  { 1108, 11, 19, 14, 2, -19 },
  { 1135, 20, 19, 24, 2, -19 },
  { 1183, 16, 19, 20, 2, -19 },
  { 1221, 17, 20, 19, 1, -20 },
  { 1264, 12, 19, 15, 2, -19 },
  { 1293, 17, 25, 19, 1, -20 },
  { 1347, 14, 19, 16, 2, -19 },
  { 1381, 12, 20, 14, 1, -20 },
  { 1411, 14, 19, 14, 0, -19 },
  { 1445, 15, 19, 19, 2, -19 },
  { 1481, 16, 19, 16, 0, -19 },
  { 1519, 24, 19, 24, 0, -19 },
  { 1576, 16, 19, 16, 0, -19 },
  { 1614, 15, 19, 15, 0, -19 },
  { 1650, 12, 19, 14, 1, -19 },
  { 1679, 6, 23, 9, 2, -19 },
  { 1697, 11, 19, 11, 0, -19 },
  { 1724, 6, 23, 9, 1, -19 },
  { 1742, 13, 12, 15, 1, -19 },
  { 1762, 11, 2, 11, 0, 2 },
  { 1765, 7, 5, 9, 1, -21 },
  { 1770, 12, 15, 15, 1, -15 },
  { 1793, 13, 21, 16, 2, -21 },
  { 1828, 11, 15, 13, 1, -15 },
  { 1849, 13, 21, 16, 1, -21 },
  { 1884, 13, 15, 15, 1, -15 },
  { 1909, 11, 21, 10, 0, -21 },
  { 1938, 13, 21, 16, 1, -15 },
  { 1973, 12, 21, 16, 2, -21 },
  { 2005, 4, 21, 8, 2, -21 },
  { 2016, 7, 27, 8, -1, -21 },
  { 2040, 13, 21, 15, 2, -21 },
  { 2075, 4, 21, 7, 2, -21 },
  { 2086, 20, 15, 24, 2, -15 },
  { 2124, 12, 15, 16, 2, -15 },
  { 2147, 13, 15, 16, 1, -15 },
  { 2172, 13, 21, 16, 2, -15 },
  { 2207, 13, 21, 16, 1, -15 },
  { 2242, 9, 15, 11, 2, -15 },
  { 2259, 10, 15, 12, 1, -15 },
  { 2278, 9, 18, 11, 1, -18 },
  { 2299, 12, 15, 16, 2, -15 },
  { 2322, 14, 15, 14, 0, -15 },
  { 2349, 21, 15, 21, 0, -15 },
  { 2389, 14, 15, 14, 0, -15 },
  { 2416, 14, 21, 14, 0, -15 },
  { 2453, 10, 15, 12, 1, -15 },
  { 2472, 9, 23, 10, 0, -19 },
  { 2498, 3, 27, 14, 5, -21 },
  { 2509, 9, 23, 10, 1, -19 },
  { 2535, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Bold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD27PT7B_H_
