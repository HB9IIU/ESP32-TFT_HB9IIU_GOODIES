#ifndef _NOTOSANS_SEMICONDENSED_BOLD8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x30, 0xEC, 0x32, 0xBE, 0xAE, 0x30, 0x2D, 0xC3, 0xB6, 0x49,
  0x52, 0xD2, 0xD2, 0xA5, 0x80, 0x62, 0x98, 0xD9, 0xBC, 0xD0, 0x5A, 0x94,
  0x95, 0x5C, 0x2F, 0x60, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00,
  0x6D, 0x99, 0xD6, 0x3C, 0x92, 0x40, 0x69, 0x12, 0x4F, 0x69, 0x27, 0x1F,
  0x22, 0x6A, 0xF2, 0x74, 0x6B, 0x1E, 0x34, 0xAD, 0x97, 0xF1, 0x22, 0x64,
  0x6D, 0x67, 0x97, 0x6D, 0x97, 0x16, 0xC3, 0xC1, 0x80, 0x16, 0xC3, 0xFF,
  0x86, 0x3C, 0xF4, 0xA0, 0x80, 0x39, 0x1B, 0xEB, 0xBD, 0x03, 0x80, 0x22,
  0x94, 0xAF, 0xC4, 0xEA, 0xAE, 0xBE, 0x35, 0xCC, 0x47, 0xEB, 0x99, 0xBE,
  0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x71, 0xB4, 0xBC, 0x99, 0x9F,
  0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x5E, 0xBA, 0xCC, 0xAB, 0x92, 0x49,
  0xC0, 0x8E, 0xF7, 0xBE, 0xD4, 0x9D, 0xDB, 0xB9, 0x32, 0x73, 0x94, 0xBC,
  0xD6, 0xF9, 0x00, 0x32, 0x73, 0x94, 0xBC, 0x60, 0xCA, 0xAC, 0xAB, 0x7D,
  0x42, 0x1E, 0xF6, 0x66, 0x66, 0x99, 0x99, 0x9E, 0x8C, 0x94, 0xA6, 0x10,
  0x93, 0x27, 0xBB, 0x66, 0xCD, 0x80, 0xDA, 0x98, 0xC5, 0x6C, 0x9A, 0x98,
  0x42, 0x10, 0xF3, 0x24, 0x4F, 0xFE, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x26,
  0x59, 0xE0, 0xC0, 0x77, 0x9F, 0x93, 0xDB, 0xC0, 0x7C, 0xC6, 0x11, 0x7D,
  0xD7, 0x7F, 0xC7, 0x6B, 0xA4, 0x80, 0x7D, 0xD7, 0x17, 0x93, 0xDB, 0x40,
  0xC5, 0x50, 0xC5, 0x56, 0x88, 0xAC, 0xEB, 0xFC, 0xFE, 0xBA, 0xEB, 0xF6,
  0xD0, 0x7D, 0xD7, 0xF6, 0xF9, 0x00, 0x7D, 0xD7, 0x11, 0xEA, 0xEC, 0xF0,
  0x5D, 0x26, 0xB6, 0xF0, 0x97, 0x66, 0xB5, 0xD7, 0x5A, 0xF6, 0x6D, 0x97,
  0x66, 0x6C, 0xED, 0x70, 0x69, 0x64, 0x98, 0xFF, 0xC9, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 7, 6, 7, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 2, 2, 2, 0, -6 },
  { 22, 2, 7, 3, 0, -6 },
  { 24, 2, 7, 3, 0, -6 },
  { 26, 4, 3, 4, 0, -6 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 2, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 2, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 5, 2, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 4, 2, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -5 },
  { 74, 3, 6, 4, 0, -6 },
  { 77, 6, 7, 7, 0, -6 },
  { 83, 5, 6, 5, 0, -6 },
  { 87, 4, 6, 5, 1, -6 },
  { 90, 4, 6, 5, 0, -6 },
  { 93, 4, 6, 5, 1, -6 },
  { 96, 3, 6, 4, 1, -6 },
  { 99, 3, 6, 4, 1, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 4, 6, 6, 1, -6 },
  { 109, 3, 6, 3, 0, -6 },
  { 112, 3, 8, 2, -1, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 3, 6, 4, 1, -6 },
  { 121, 5, 6, 7, 1, -6 },
  { 125, 4, 6, 6, 1, -6 },
  { 128, 5, 6, 6, 0, -6 },
  { 132, 3, 6, 5, 1, -6 },
  { 135, 5, 7, 6, 0, -6 },
  { 140, 4, 6, 5, 1, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 4, 6, 6, 1, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 7, 6, 7, 0, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 4, 6, 4, 0, -6 },
  { 173, 1, 7, 3, 1, -6 },
  { 174, 3, 6, 3, 0, -6 },
  { 177, 2, 7, 3, 0, -6 },
  { 179, 4, 4, 4, 0, -6 },
  { 181, 3, 1, 3, 0, 0 },
  { 182, 2, 1, 3, 0, -6 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 6, 5, 1, -6 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 6, 5, 0, -6 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 3, 6, 3, 0, -6 },
  { 198, 4, 6, 5, 0, -4 },
  { 201, 3, 6, 5, 1, -6 },
  { 204, 2, 6, 2, 0, -6 },
  { 206, 2, 8, 2, 0, -6 },
  { 208, 4, 6, 5, 1, -6 },
  { 211, 1, 6, 2, 1, -6 },
  { 212, 6, 4, 7, 1, -4 },
  { 215, 3, 4, 5, 1, -4 },
  { 217, 4, 4, 5, 0, -4 },
  { 219, 3, 6, 5, 1, -4 },
  { 222, 4, 6, 5, 0, -4 },
  { 225, 2, 4, 3, 1, -4 },
  { 226, 3, 4, 4, 0, -4 },
  { 228, 3, 5, 3, 0, -5 },
  { 230, 3, 4, 5, 1, -4 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 6, 4, 6, 0, -4 },
  { 237, 4, 4, 4, 0, -4 },
  { 239, 4, 6, 4, 0, -4 },
  { 242, 3, 4, 4, 0, -4 },
  { 244, 3, 7, 3, 0, -6 },
  { 247, 1, 8, 4, 2, -6 },
  { 248, 3, 7, 3, 0, -6 },
  { 251, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Bold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD8PT7B_H_
