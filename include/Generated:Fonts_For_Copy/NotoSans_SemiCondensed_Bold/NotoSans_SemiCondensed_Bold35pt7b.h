#ifndef _NOTOSANS_SEMICONDENSED_BOLD35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xF8, 0xF9, 0xFF, 0x9F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xF7, 0x0F, 0x70, 0xF0, 0x03, 0xC7,
  0x80, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1E,
  0x01, 0xE3, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x78,
  0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xE7, 0x80,
  0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE,
  0x7D, 0x8E, 0x79, 0x80, 0x79, 0x80, 0x7D, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F,
  0x01, 0x9F, 0xC1, 0x9F, 0xFD, 0xBF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x3C, 0x03,
  0xFC, 0x07, 0x80, 0x7F, 0xC0, 0x78, 0x07, 0x9E, 0x0F, 0x00, 0xF1, 0xE0,
  0xF0, 0x0F, 0x1E, 0x1E, 0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x3C, 0x00,
  0xF1, 0xE3, 0xC0, 0x0F, 0x1E, 0x78, 0x00, 0xF1, 0xE7, 0x9F, 0x87, 0x9E,
  0xF3, 0xFC, 0x7F, 0xCF, 0x3F, 0xE3, 0xFD, 0xE7, 0x9E, 0x1F, 0x9E, 0x78,
  0xF0, 0x03, 0xC7, 0x8F, 0x00, 0x3C, 0x78, 0xF0, 0x07, 0x87, 0x8F, 0x00,
  0x78, 0x78, 0xF0, 0x0F, 0x07, 0x8F, 0x00, 0xF0, 0x78, 0xF0, 0x0E, 0x07,
  0x9E, 0x01, 0xE0, 0x3F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xC7, 0xFE, 0x1F, 0x1F, 0xFE, 0x3E, 0x3E, 0x7E, 0xFC, 0xFC, 0x7F,
  0xF1, 0xF0, 0x7F, 0xE3, 0xE0, 0x7F, 0x87, 0xE0, 0x7F, 0x0F, 0xE1, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x70, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0xF0, 0x3C, 0x1F,
  0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E,
  0x1E, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x83, 0xC2, 0x73, 0x8E, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0x78, 0x3E, 0x7C,
  0x1C, 0x38, 0x04, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x78, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF1, 0xFF,
  0x3F, 0xF7, 0xFF, 0xFD, 0xF7, 0x9F, 0x31, 0xF2, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC,
  0x7F, 0xFE, 0xFF, 0xFE, 0x7C, 0x3F, 0x30, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0,
  0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x30, 0x3E, 0x20, 0x3F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0x9F, 0x07,
  0x8F, 0x83, 0xC7, 0xC3, 0xC3, 0xE1, 0xE1, 0xF1, 0xE0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF,
  0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xCC, 0x3F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xFC, 0x0F, 0xDF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x79,
  0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x7E, 0x3E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xFC, 0x7E, 0x7E, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xC0, 0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xFF, 0x80, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x3C,
  0x78, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xF3, 0xFF, 0xE7, 0x07, 0xE8, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xC3, 0xC0, 0xF0, 0x71, 0xE1, 0xFF, 0x9E, 0x70, 0xFF, 0xE3, 0xBC,
  0x7C, 0x78, 0xEF, 0x1E, 0x1E, 0x3F, 0x8F, 0x07, 0x8F, 0xE3, 0xC1, 0xE3,
  0xF8, 0xF0, 0x78, 0xFE, 0x3C, 0x1C, 0x3B, 0x8F, 0x0F, 0x0E, 0xE3, 0xC3,
  0xC7, 0xB8, 0x78, 0xF9, 0xEF, 0x1F, 0xFF, 0xF3, 0xC3, 0xFB, 0xF8, 0xF0,
  0x7C, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x40,
  0x1F, 0xE3, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF9, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xE0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF,
  0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF3, 0xF8, 0x33, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x39, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x87, 0xF9, 0xF0, 0x3F,
  0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0x8F, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFB, 0xFF, 0xDF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF8, 0x18, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x01, 0xF3, 0xF0, 0x3E, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xF8,
  0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F,
  0x8F, 0x8F, 0xC3, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF7, 0xE0, 0xF8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x3F, 0x3E, 0x07,
  0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xDE,
  0x03, 0xFF, 0xEF, 0x01, 0xFF, 0xF7, 0x81, 0xEF, 0xFB, 0xE0, 0xF7, 0xFC,
  0xF0, 0x7B, 0xFE, 0x78, 0x79, 0xFF, 0x3C, 0x3C, 0xFF, 0x8F, 0x1E, 0x7F,
  0xC7, 0x9F, 0x3F, 0xE3, 0xCF, 0x1F, 0xF1, 0xF7, 0x8F, 0xF8, 0x7B, 0xC7,
  0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x07, 0xF0, 0xFF, 0x83, 0xF0,
  0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFC, 0x1F, 0xF0, 0x3C, 0x0F, 0x80, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x7C, 0x0F, 0xF7, 0xE0, 0xFF, 0x3E, 0x0F,
  0xF3, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1, 0xF8, 0xFF, 0x0F, 0x8F, 0xF0, 0xFC,
  0xFF, 0x07, 0xCF, 0xF0, 0x7E, 0xFF, 0x03, 0xEF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xDF, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0x3F,
  0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C,
  0xFC, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x87, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xE7, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x81, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xF7, 0xE1, 0xCF, 0x80, 0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x00, 0xF3,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00,
  0xFB, 0xE0, 0x7F, 0x03, 0xE7, 0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC, 0x0F,
  0x9F, 0x03, 0xB8, 0x1F, 0x1E, 0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8,
  0x7C, 0x3D, 0xE1, 0xF0, 0xF8, 0x7B, 0xC3, 0xE0, 0xF1, 0xF7, 0xC7, 0xC1,
  0xF3, 0xC7, 0x9F, 0x03, 0xE7, 0x8F, 0x3E, 0x07, 0xCF, 0x1E, 0x7C, 0x0F,
  0x9E, 0x3C, 0xF8, 0x0F, 0x78, 0x3D, 0xE0, 0x1E, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F,
  0x81, 0xF0, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x00, 0xFB, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7E,
  0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xF1,
  0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF7, 0xC0,
  0x3E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F,
  0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xDC,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x78, 0x0F, 0x1E, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1E, 0x7F, 0x10, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0xFF, 0x7F, 0xFF, 0x7F,
  0xCF, 0x1F, 0x8F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF9, 0xFC, 0x7D, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFB, 0xF8, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7D, 0xFF, 0x3C, 0x7E,
  0x00, 0x00, 0x40, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0xC0,
  0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x02, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x02, 0x1F, 0x0F, 0xCF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF8, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xF3, 0xC3, 0xF1,
  0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xE7, 0xE7, 0xC1, 0xF3,
  0xE0, 0x79, 0xF0, 0x3E, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x04, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0xC7, 0xFC, 0x3F,
  0xE3, 0xF1, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0x00, 0x07, 0xF3, 0xC7, 0xFD, 0xE7, 0xFF, 0xF3, 0xFF,
  0xFB, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x3F,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFB, 0xE1, 0xF9, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x40, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF9, 0xFC, 0x7D, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xE1, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0,
  0x33, 0xEF, 0xFF, 0x78, 0x80, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x03, 0x03, 0xE0,
  0xFC, 0x3F, 0x07, 0x80, 0x80, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFB,
  0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x1F,
  0x78, 0x1F, 0x3C, 0x1F, 0x1E, 0x1F, 0x8F, 0x1F, 0x87, 0x8F, 0x83, 0xCF,
  0x81, 0xEF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xBE, 0x0F,
  0x9F, 0x87, 0x87, 0xC3, 0xC1, 0xF1, 0xE0, 0xFC, 0xF0, 0x3E, 0x78, 0x1F,
  0xBC, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x08, 0x1E,
  0x3F, 0x8F, 0xF3, 0xEF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xF8, 0x1F, 0xF8,
  0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81,
  0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0,
  0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F,
  0xFC, 0x0F, 0x81, 0xF0, 0x00, 0x20, 0x78, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xF0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF0, 0x00,
  0x40, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xFF, 0xC0, 0xFD,
  0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x20, 0x7C, 0xFE,
  0x3E, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7D, 0xFC, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3E, 0xFF,
  0x9F, 0x3F, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x00, 0x07, 0xF3,
  0xC7, 0xFD, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFB,
  0xE1, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x2F, 0x1F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x01, 0x00, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x73, 0xE0,
  0x4F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F,
  0xF8, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF,
  0x1F, 0xCF, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E,
  0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x7C, 0x1F, 0x1E, 0x07, 0xCF,
  0x80, 0xF3, 0xE0, 0x3E, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0x83,
  0xEF, 0x83, 0xF0, 0x7D, 0xF0, 0xFE, 0x0F, 0xBE, 0x1F, 0xC1, 0xE7, 0xC3,
  0xFC, 0x7C, 0x7C, 0x77, 0x8F, 0x8F, 0x8E, 0xF1, 0xF1, 0xF3, 0xCE, 0x3C,
  0x1E, 0x79, 0xEF, 0x83, 0xCF, 0x3D, 0xF0, 0x7D, 0xC7, 0xBE, 0x0F, 0xB8,
  0x77, 0x80, 0xFF, 0x0E, 0xF0, 0x1F, 0xE1, 0xDE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0xDF, 0x87, 0xE3, 0xE1, 0xF0, 0x7C, 0xFC, 0x1F,
  0x3E, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xEF, 0x81, 0xF3, 0xE0,
  0xFC, 0x7C, 0x3E, 0x1F, 0x9F, 0x03, 0xEF, 0xC0, 0xFC, 0xFC, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3E, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0x07, 0xF0,
  0x3F, 0x0F, 0xF1, 0xFC, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x80, 0x00,
  0x3F, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x80, 0x08,
};

const GFXglyph NotoSans_SemiCondensed_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 25, 10, 2, -25 },
  { 20, 12, 9, 16, 2, -25 },
  { 34, 19, 25, 21, 1, -25 },
  { 94, 16, 29, 19, 1, -27 },
  { 152, 28, 25, 30, 1, -25 },
  { 240, 23, 25, 24, 1, -25 },
  { 312, 5, 9, 9, 2, -25 },
  { 318, 10, 31, 12, 1, -25 },
  { 357, 9, 31, 12, 1, -25 },
  { 392, 16, 16, 18, 1, -27 },
  { 424, 16, 17, 19, 1, -21 },
  { 458, 7, 9, 9, 1, -4 },
  { 466, 9, 5, 11, 1, -12 },
  { 472, 6, 5, 9, 2, -5 },
  { 476, 14, 25, 14, 0, -25 },
  { 520, 16, 25, 19, 1, -25 },
  { 570, 12, 25, 19, 2, -25 },
  { 608, 16, 25, 19, 1, -25 },
  { 658, 16, 25, 19, 1, -25 },
  { 708, 17, 25, 19, 1, -25 },
  { 762, 15, 25, 19, 2, -25 },
  { 809, 16, 25, 19, 1, -25 },
  { 859, 16, 25, 19, 1, -25 },
  { 909, 16, 25, 19, 1, -25 },
  { 959, 16, 25, 19, 1, -25 },
  { 1009, 6, 19, 10, 2, -19 },
  { 1024, 7, 24, 10, 1, -19 },
  { 1045, 16, 17, 19, 1, -21 },
  { 1079, 16, 11, 19, 1, -18 },
  { 1101, 16, 17, 19, 1, -21 },
  { 1135, 15, 25, 15, 0, -25 },
  { 1182, 26, 28, 29, 2, -25 },
  { 1273, 22, 25, 22, 0, -25 },
  { 1342, 17, 25, 21, 3, -25 },
  { 1396, 17, 25, 20, 2, -25 },
  { 1450, 19, 25, 23, 3, -25 },
  { 1510, 13, 25, 18, 3, -25 },
  { 1551, 13, 25, 18, 3, -25 },
  { 1592, 19, 25, 23, 2, -25 },
  { 1652, 19, 25, 25, 3, -25 },
  { 1712, 11, 25, 13, 1, -25 },
  { 1747, 10, 32, 11, -2, -25 },
  { 1787, 18, 25, 21, 3, -25 },
  { 1844, 14, 25, 18, 3, -25 },
  { 1888, 25, 25, 31, 3, -25 },
  { 1967, 20, 25, 26, 3, -25 },
  { 2030, 21, 25, 25, 2, -25 },
  { 2096, 16, 25, 20, 3, -25 },
  { 2146, 21, 31, 25, 2, -25 },
  { 2228, 18, 25, 21, 3, -25 },
  { 2285, 15, 25, 18, 1, -25 },
  { 2332, 17, 25, 18, 1, -25 },
  { 2386, 18, 25, 24, 3, -25 },
  { 2443, 21, 25, 21, 0, -25 },
  { 2509, 31, 25, 31, 0, -25 },
  { 2606, 21, 25, 21, 0, -25 },
  { 2672, 20, 25, 20, 0, -25 },
  { 2735, 16, 25, 18, 1, -25 },
  { 2785, 8, 31, 11, 2, -25 },
  { 2816, 14, 25, 14, 0, -25 },
  { 2860, 8, 31, 11, 1, -25 },
  { 2891, 18, 16, 20, 1, -25 },
  { 2927, 14, 3, 14, 0, 3 },
  { 2933, 10, 6, 12, 1, -27 },
  { 2941, 16, 19, 19, 1, -19 },
  { 2979, 17, 27, 20, 2, -27 },
  { 3037, 15, 20, 17, 1, -20 },
  { 3075, 17, 27, 20, 1, -27 },
  { 3133, 17, 19, 19, 1, -19 },
  { 3174, 13, 27, 12, 1, -27 },
  { 3218, 17, 28, 20, 1, -20 },
  { 3278, 17, 27, 21, 2, -27 },
  { 3336, 6, 27, 10, 2, -27 },
  { 3357, 10, 35, 10, -2, -27 },
  { 3401, 17, 27, 20, 3, -27 },
  { 3459, 5, 27, 10, 2, -27 },
  { 3476, 27, 20, 31, 2, -20 },
  { 3544, 17, 20, 21, 2, -20 },
  { 3587, 18, 20, 20, 1, -20 },
  { 3632, 17, 28, 20, 2, -20 },
  { 3692, 17, 28, 20, 1, -20 },
  { 3752, 12, 20, 14, 2, -20 },
  { 3782, 14, 20, 16, 1, -20 },
  { 3817, 12, 23, 14, 1, -23 },
  { 3852, 16, 19, 21, 2, -19 },
  { 3890, 18, 19, 18, 0, -19 },
  { 3933, 27, 19, 28, 0, -19 },
  { 3998, 18, 19, 18, 0, -19 },
  { 4041, 18, 27, 18, 0, -19 },
  { 4102, 14, 19, 16, 1, -19 },
  { 4136, 12, 31, 13, 0, -25 },
  { 4183, 4, 35, 18, 7, -27 },
  { 4201, 12, 31, 13, 1, -25 },
  { 4248, 16, 6, 19, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_Bold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD35PT7B_H_
