#ifndef _NOTOSANS_SEMICONDENSED_BOLD22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x76, 0x66, 0x60, 0x0F, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0x67, 0x67, 0x06, 0x60, 0x73, 0x03, 0xB8, 0x19, 0xC0, 0xCC, 0x3F,
  0xFD, 0xFF, 0xE3, 0x98, 0x1D, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1, 0x98,
  0x1C, 0xC0, 0xEE, 0x06, 0x60, 0x0C, 0x03, 0x03, 0xF9, 0xFF, 0xFF, 0xBB,
  0x0E, 0xC3, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x37, 0x8D, 0xFB, 0xFF, 0xF9,
  0xFC, 0x0C, 0x03, 0x00, 0x78, 0x18, 0x7E, 0x1C, 0x3B, 0x0C, 0x19, 0xCE,
  0x0C, 0xE6, 0x06, 0x77, 0x03, 0x3B, 0x39, 0xDB, 0xBE, 0x7D, 0x9B, 0x9D,
  0xDD, 0xC0, 0xCE, 0x60, 0xE7, 0x30, 0x63, 0x98, 0x71, 0xDC, 0x30, 0x7C,
  0x38, 0x1E, 0x1E, 0x00, 0xFE, 0x07, 0xF8, 0x1C, 0xE0, 0x73, 0x81, 0xCE,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x3B, 0xFC, 0xEE, 0x7F, 0x38, 0xFC, 0xE1,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xCF, 0xFF, 0xF6, 0xC0, 0x1C, 0xE3, 0x1C,
  0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x86, 0x1C, 0x70, 0xE3, 0xC0,
  0xC7, 0x1C, 0xE3, 0x1C, 0xE7, 0x38, 0xC6, 0x73, 0x9C, 0xE6, 0x73, 0x38,
  0x1C, 0x07, 0x01, 0xC3, 0x36, 0xFF, 0xBF, 0xF3, 0xE0, 0xDC, 0x77, 0x08,
  0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x77, 0xEE, 0xEC, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0xC1, 0xC0, 0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xE3, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0x9D, 0xE7, 0xF0, 0xF8,
  0x07, 0x0F, 0x3F, 0x7F, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x3E, 0x1F, 0xCF, 0xF9, 0x0E, 0x03, 0xC0, 0xE0,
  0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3E, 0x3F, 0xEF, 0xF9, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0xF8, 0x3F, 0x01,
  0xE0, 0x3C, 0x0F, 0x03, 0xF1, 0xEF, 0xFB, 0xF8, 0x01, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0xDC, 0x3B, 0x86, 0x71, 0xDE, 0x33, 0xCE, 0x7B, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0x80, 0xF0, 0x1E, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70,
  0x38, 0x0F, 0xE3, 0xFE, 0x7F, 0x80, 0xF0, 0x3C, 0x07, 0x03, 0xF9, 0xEF,
  0xFB, 0xF8, 0x0F, 0x8F, 0xE7, 0xF9, 0xC0, 0xE0, 0x38, 0x0E, 0xF3, 0xFE,
  0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0xE7, 0xF8, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x1E, 0x1F, 0xEF, 0x7B, 0x8F, 0xE3,
  0xBC, 0xE7, 0xF8, 0xF8, 0x7F, 0x3D, 0xEE, 0x3F, 0x87, 0xE1, 0xF8, 0xFF,
  0xF8, 0xFC, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F,
  0xFF, 0xDF, 0x71, 0x9C, 0x0E, 0x03, 0xA3, 0xC7, 0xF1, 0xF0, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x7E, 0xEE, 0xC0,
  0x00, 0x40, 0x30, 0x3C, 0x3E, 0x3E, 0x3E, 0x0F, 0x01, 0xF0, 0x1F, 0x81,
  0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x3E, 0x7E, 0x3E,
  0x0C, 0x02, 0x00, 0x3E, 0x7F, 0x9F, 0xE8, 0x70, 0x38, 0x1C, 0x1C, 0x1E,
  0x1C, 0x0E, 0x06, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x38, 0x03, 0xE0, 0x0F,
  0xF8, 0x1C, 0x1C, 0x38, 0x06, 0x71, 0xE7, 0x67, 0xF3, 0xE7, 0x33, 0xCE,
  0x33, 0xCE, 0x33, 0xCC, 0x73, 0xCE, 0x73, 0xCE, 0xF7, 0xE7, 0xDE, 0x61,
  0x08, 0x70, 0x00, 0x3C, 0x18, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38,
  0xF0, 0xE1, 0xC3, 0xFF, 0x1F, 0xFC, 0x70, 0x79, 0xC0, 0xEF, 0x03, 0xBC,
  0x0F, 0xFE, 0x3F, 0xEF, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x3B, 0xFC, 0xFF,
  0xB8, 0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0xFF, 0xFB, 0xFC, 0x0F, 0xC3, 0xFC,
  0xFF, 0xBC, 0x17, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0xFF, 0xCF, 0xF8, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xCE,
  0x3E, 0xE1, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE,
  0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x07, 0xE1, 0xFF, 0x3F, 0xE7, 0x82, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x3F, 0xE3, 0xFF, 0x3F, 0xF0, 0x77, 0x07, 0x78, 0x77, 0xEF,
  0x3F, 0xF0, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xEF, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xBE, 0xE0, 0xE0, 0xFC, 0x3F, 0x8F, 0x71,
  0xCE, 0x71, 0xDE, 0x3B, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0x9C, 0x73, 0xCE,
  0x39, 0xC7, 0xB8, 0x7F, 0x07, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x37, 0xFC, 0x37, 0xFC,
  0x77, 0xEC, 0x77, 0xEE, 0x67, 0xEE, 0xE7, 0xE6, 0xE7, 0xE6, 0xC7, 0xE7,
  0xC7, 0xE7, 0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xB8, 0xFD, 0xE7, 0xE7, 0x3F, 0x3D, 0xF8,
  0xEF, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0x0F, 0xC0, 0xFF,
  0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0x9C, 0x0E, 0x78, 0x79, 0xFF, 0xC3, 0xFF, 0x03,
  0xF0, 0xFC, 0x3F, 0xCF, 0xFB, 0x8F, 0xE3, 0xF8, 0x7E, 0x3F, 0x9E, 0xFF,
  0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0xC0, 0xFF,
  0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0x9C, 0x0E, 0x78, 0x79, 0xFF, 0xC3, 0xFF, 0x03,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xFC, 0x1F, 0xF3, 0xFE,
  0x71, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0xFC, 0xFF, 0x1F, 0xE3, 0x9C, 0x73,
  0xCE, 0x39, 0xC7, 0xB8, 0x77, 0x0F, 0x1F, 0x3F, 0xFF, 0xFC, 0x2E, 0x07,
  0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0x78, 0x3F, 0xFF, 0xFD, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0xDF, 0xF1, 0xFC, 0xE0, 0x3F, 0x01, 0xDC,
  0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x18, 0xE0, 0xEE,
  0x07, 0x70, 0x3B, 0x80, 0xD8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0xE0, 0xE0,
  0xFE, 0x0E, 0x0E, 0xF0, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xF0, 0xE7, 0x1F,
  0x1C, 0x71, 0xB9, 0xC3, 0x9B, 0x9C, 0x3B, 0x99, 0xC3, 0xB9, 0xB8, 0x3B,
  0x9F, 0x81, 0xB1, 0xF8, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01,
  0xE0, 0xF0, 0xF0, 0x7B, 0x83, 0x8E, 0x3C, 0x71, 0xC1, 0xDC, 0x0F, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3B, 0x83, 0x8E, 0x3C,
  0x79, 0xC1, 0xDE, 0x0F, 0xF0, 0x7B, 0x83, 0x9C, 0x38, 0x71, 0xC3, 0x9E,
  0x1E, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C,
  0x07, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F,
  0xFE, 0x06, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0x98, 0x39, 0xC3,
  0x0C, 0x70, 0xEE, 0x07, 0xFF, 0x80, 0xF1, 0xC3, 0x87, 0x3F, 0x1F, 0xE2,
  0x38, 0x0F, 0x01, 0xDF, 0xFF, 0x9F, 0x87, 0xE3, 0xF8, 0xFF, 0xFD, 0xF7,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xEF, 0x3F, 0xF7, 0xDE, 0xF1,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFE, 0xF7, 0xFE, 0xEF, 0x80,
  0x3F, 0xBF, 0x9E, 0x5E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x3C, 0xDF,
  0xE7, 0xE0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0x77, 0xFF, 0xCF,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0x3D, 0xFF, 0x3C, 0xC0,
  0x3F, 0x1F, 0xE7, 0x3F, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x1C,
  0x27, 0xF8, 0x7E, 0x0F, 0x8F, 0x8F, 0xC7, 0x03, 0x83, 0xFB, 0xFC, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x3C,
  0xDF, 0xF7, 0x3F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0xF7,
  0xFC, 0xF7, 0x01, 0xC0, 0x76, 0x3D, 0xFE, 0x7F, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xFF, 0x3B, 0xF7, 0xCE, 0xF1, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xE0, 0x6F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC0, 0x00, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xEF, 0xFB, 0xC0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xB8, 0xE7, 0x38, 0xEE, 0x1F,
  0xC3, 0xF0, 0x7F, 0x0F, 0xF1, 0xCE, 0x39, 0xE7, 0x1E, 0xE1, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x9F, 0x7F, 0xFF,
  0xFE, 0xFD, 0xFE, 0x3C, 0x7F, 0x1C, 0x3F, 0x8E, 0x1F, 0xC7, 0x0F, 0xE3,
  0x87, 0xF1, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFE, 0x38, 0x70, 0xEF, 0x9F,
  0xFB, 0xE7, 0x78, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x70, 0x3F, 0x0F, 0xF1, 0xCF, 0x78, 0xEE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xF1, 0xCE, 0x79, 0xFE, 0x0F, 0x80, 0xEF, 0x9D, 0xFB, 0xE7,
  0x78, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFF, 0x7B, 0xFF, 0x7F,
  0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0xDF, 0xF7, 0x3F,
  0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0xF7, 0xFC, 0xF7, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F, 0xFF, 0xE2, 0xE0, 0xF8, 0x7E,
  0x3F, 0x0F, 0x07, 0xC7, 0xFF, 0xFE, 0x18, 0x18, 0x38, 0x7F, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xEF, 0x7D, 0xFF,
  0x9F, 0x70, 0xE0, 0xF7, 0x0E, 0x71, 0xE7, 0x1C, 0x39, 0xC3, 0x9C, 0x3B,
  0x81, 0xB8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0xE1, 0xE3, 0xB8, 0xF1,
  0xDC, 0xF8, 0xEE, 0x6C, 0xE7, 0x36, 0x71, 0xDB, 0xB8, 0xEC, 0xDC, 0x7E,
  0x7C, 0x3E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC3, 0x80, 0xF1, 0xEF,
  0x38, 0xEF, 0x1F, 0xC1, 0xF8, 0x1E, 0x07, 0xC0, 0xFC, 0x3B, 0x87, 0x39,
  0xC7, 0x78, 0x70, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x1C, 0x39, 0xC3, 0x9C,
  0x3B, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xFF, 0x0F, 0x0E, 0x1C, 0x1C, 0x38,
  0x78, 0x70, 0xE0, 0xFF, 0xFF, 0x06, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E,
  0x39, 0xE3, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xE3, 0xC1, 0x83, 0x06,
  0x0C, 0x1C, 0x3C, 0x3C, 0xF9, 0xC3, 0x06, 0x0C, 0x18, 0x71, 0xE3, 0xC0,
  0x20, 0x7F, 0x3F, 0xFE, 0x1E,
};

const GFXglyph NotoSans_SemiCondensed_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 13, 16, 13, 0, -16 },
  { 41, 10, 18, 12, 1, -17 },
  { 64, 17, 16, 19, 1, -16 },
  { 98, 14, 16, 15, 1, -16 },
  { 126, 3, 6, 6, 1, -16 },
  { 129, 6, 19, 7, 1, -16 },
  { 144, 5, 19, 7, 1, -16 },
  { 156, 10, 10, 11, 1, -17 },
  { 169, 10, 11, 12, 1, -13 },
  { 183, 4, 6, 6, 1, -3 },
  { 186, 5, 2, 7, 1, -7 },
  { 188, 4, 3, 6, 1, -3 },
  { 190, 9, 16, 9, 0, -16 },
  { 208, 10, 16, 12, 1, -16 },
  { 228, 8, 16, 12, 1, -16 },
  { 244, 10, 16, 12, 1, -16 },
  { 264, 10, 16, 12, 1, -16 },
  { 284, 11, 16, 12, 0, -16 },
  { 306, 10, 16, 12, 1, -16 },
  { 326, 10, 16, 12, 1, -16 },
  { 346, 10, 16, 12, 1, -16 },
  { 366, 10, 16, 12, 1, -16 },
  { 386, 10, 16, 12, 1, -16 },
  { 406, 4, 12, 6, 1, -12 },
  { 412, 4, 15, 6, 1, -12 },
  { 420, 10, 12, 12, 1, -14 },
  { 435, 10, 7, 12, 1, -11 },
  { 444, 10, 12, 12, 1, -14 },
  { 459, 9, 16, 10, 0, -16 },
  { 477, 16, 18, 18, 1, -16 },
  { 513, 14, 16, 14, 0, -16 },
  { 541, 10, 16, 14, 2, -16 },
  { 561, 11, 16, 13, 1, -16 },
  { 583, 12, 16, 15, 2, -16 },
  { 607, 8, 16, 11, 2, -16 },
  { 623, 8, 16, 11, 2, -16 },
  { 639, 12, 16, 15, 1, -16 },
  { 663, 12, 16, 15, 2, -16 },
  { 687, 6, 16, 8, 1, -16 },
  { 699, 6, 21, 7, -1, -16 },
  { 715, 11, 16, 13, 2, -16 },
  { 737, 9, 16, 11, 2, -16 },
  { 755, 16, 16, 19, 2, -16 },
  { 787, 13, 16, 16, 2, -16 },
  { 813, 14, 16, 16, 1, -16 },
  { 841, 10, 16, 13, 2, -16 },
  { 861, 14, 20, 16, 1, -16 },
  { 896, 11, 16, 13, 2, -16 },
  { 918, 9, 16, 11, 1, -16 },
  { 936, 11, 16, 12, 0, -16 },
  { 958, 11, 16, 15, 2, -16 },
  { 980, 13, 16, 13, 0, -16 },
  { 1006, 20, 16, 19, 0, -16 },
  { 1046, 13, 16, 13, 0, -16 },
  { 1072, 13, 16, 13, 0, -16 },
  { 1098, 11, 16, 11, 0, -16 },
  { 1120, 6, 19, 7, 1, -16 },
  { 1135, 9, 16, 9, 0, -16 },
  { 1153, 5, 19, 7, 1, -16 },
  { 1165, 12, 10, 12, 0, -16 },
  { 1180, 9, 1, 9, 0, 2 },
  { 1182, 6, 4, 8, 1, -17 },
  { 1185, 10, 12, 12, 1, -12 },
  { 1200, 11, 17, 13, 1, -17 },
  { 1224, 9, 12, 10, 1, -12 },
  { 1238, 10, 17, 13, 1, -17 },
  { 1260, 10, 12, 12, 1, -12 },
  { 1275, 9, 17, 8, 0, -17 },
  { 1295, 10, 17, 13, 1, -12 },
  { 1317, 11, 17, 13, 1, -17 },
  { 1341, 4, 17, 6, 1, -17 },
  { 1350, 6, 22, 6, -1, -17 },
  { 1367, 11, 17, 13, 2, -17 },
  { 1391, 4, 17, 6, 1, -17 },
  { 1400, 17, 12, 20, 1, -12 },
  { 1426, 11, 12, 13, 1, -12 },
  { 1443, 11, 12, 13, 1, -12 },
  { 1460, 11, 17, 13, 1, -12 },
  { 1484, 10, 17, 13, 1, -12 },
  { 1506, 8, 12, 9, 1, -12 },
  { 1518, 8, 12, 10, 1, -12 },
  { 1530, 8, 15, 9, 0, -15 },
  { 1545, 11, 12, 13, 1, -12 },
  { 1562, 12, 12, 12, 0, -12 },
  { 1580, 17, 12, 17, 0, -12 },
  { 1606, 11, 12, 11, 0, -12 },
  { 1623, 12, 17, 12, 0, -12 },
  { 1649, 8, 12, 10, 1, -12 },
  { 1661, 7, 19, 8, 0, -16 },
  { 1678, 3, 22, 11, 4, -17 },
  { 1687, 7, 19, 8, 1, -16 },
  { 1704, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Bold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD22PT7B_H_
