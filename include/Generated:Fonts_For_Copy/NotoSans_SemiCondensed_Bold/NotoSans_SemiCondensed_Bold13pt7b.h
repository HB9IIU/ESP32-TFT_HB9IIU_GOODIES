#ifndef _NOTOSANS_SEMICONDENSED_BOLD13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xF9, 0x90, 0x16, 0x69, 0xFB, 0xF2, 0xDF, 0xCA,
  0x34, 0x68, 0x23, 0xFF, 0x4E, 0x3C, 0xF5, 0xF9, 0x08, 0x71, 0x9A, 0x63,
  0x68, 0x6B, 0x67, 0x5C, 0x1A, 0xC2, 0x58, 0xCB, 0x11, 0xC0, 0x3C, 0x36,
  0x1B, 0x07, 0x07, 0xBB, 0xFB, 0x3C, 0xDC, 0x7F, 0x80, 0xE8, 0x7B, 0x49,
  0x24, 0xD9, 0x80, 0xC6, 0x23, 0x33, 0x33, 0x26, 0xC0, 0x30, 0x4F, 0xCC,
  0x68, 0xB0, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x6D, 0x60, 0xF0, 0xF0,
  0x18, 0xC4, 0x62, 0x31, 0x88, 0xC0, 0x79, 0xB4, 0xF1, 0xC5, 0x14, 0xDB,
  0x38, 0x3F, 0xF3, 0x33, 0x33, 0x30, 0xFD, 0x30, 0xC3, 0x18, 0xC3, 0x1F,
  0xFC, 0xFD, 0x30, 0xCE, 0x38, 0x30, 0xF3, 0xF8, 0x1C, 0x38, 0xF1, 0x64,
  0xD9, 0xBF, 0x86, 0x0C, 0xFE, 0x31, 0xEF, 0x8C, 0x77, 0xF0, 0x3D, 0x84,
  0x17, 0xEF, 0x14, 0x5B, 0x38, 0xFC, 0x30, 0xC2, 0x18, 0x63, 0x0C, 0x60,
  0x7D, 0xB6, 0xDF, 0x39, 0xBC, 0x5B, 0x7C, 0x79, 0xBC, 0x73, 0x7C, 0xD0,
  0xE7, 0x78, 0xF0, 0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x77, 0x38, 0x38,
  0x30, 0x40, 0xFF, 0xF0, 0x3F, 0x83, 0x81, 0xC3, 0x3B, 0x88, 0x00, 0xFC,
  0x42, 0x33, 0x10, 0x0C, 0x70, 0x3F, 0x20, 0xB7, 0xB6, 0xDA, 0x6D, 0x36,
  0xFF, 0x92, 0x62, 0x1F, 0x00, 0x1C, 0x3C, 0x3C, 0x34, 0x66, 0x7E, 0x7E,
  0xC3, 0xC3, 0xFF, 0x3C, 0xFF, 0xFF, 0x3C, 0xFF, 0xF8, 0x7F, 0x9C, 0x30,
  0xC3, 0x0C, 0x3F, 0x7C, 0xFD, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xFE, 0xF8,
  0xFE, 0x31, 0xFF, 0xE3, 0x1F, 0xF8, 0xFE, 0x31, 0x8F, 0xE3, 0x18, 0xC0,
  0x7F, 0xCB, 0x06, 0x0D, 0xF8, 0xF1, 0xF7, 0x7E, 0xC7, 0x8F, 0x1F, 0xFF,
  0xF8, 0xF1, 0xE3, 0xC6, 0xF6, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFE, 0xCF, 0x9B, 0x67, 0x8F, 0x1B, 0x37, 0x66, 0xC6, 0xC6,
  0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE1, 0xF1, 0xF8, 0xBE, 0x5F, 0x6E, 0xB7,
  0x73, 0xB9, 0xCC, 0x80, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xC7,
  0xC7, 0x7C, 0xE6, 0xC6, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0x7C, 0xFB, 0x3C,
  0xF3, 0xFB, 0xCC, 0x30, 0xC0, 0x7C, 0xE6, 0xC6, 0xC3, 0xC3, 0xC3, 0xC6,
  0xFE, 0x7C, 0x0C, 0x07, 0xF9, 0x9B, 0x36, 0x6F, 0x9B, 0x36, 0x66, 0xCE,
  0xFE, 0x71, 0xC7, 0x0C, 0x7F, 0xF0, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0x7C, 0xC3, 0x46,
  0x66, 0x66, 0x64, 0x2C, 0x3C, 0x38, 0x18, 0xC6, 0x3C, 0xE6, 0x4E, 0x66,
  0xF6, 0x6B, 0x46, 0xBC, 0x39, 0xC3, 0x9C, 0x31, 0xC0, 0xE7, 0x66, 0x3C,
  0x38, 0x18, 0x3C, 0x6C, 0x66, 0xC7, 0xC6, 0xCD, 0xB1, 0xE3, 0x83, 0x06,
  0x0C, 0x18, 0xFC, 0x31, 0x86, 0x30, 0xC6, 0x3F, 0xFC, 0xF2, 0x49, 0x24,
  0x93, 0x80, 0xC2, 0x18, 0x43, 0x18, 0x43, 0x18, 0xE4, 0x92, 0x49, 0x27,
  0x80, 0x10, 0x70, 0xA3, 0x64, 0x58, 0xC0, 0xF8, 0xCC, 0x7D, 0x30, 0xDF,
  0xCD, 0xB7, 0x40, 0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3, 0xDF, 0xE0, 0x7E,
  0x71, 0x0C, 0x65, 0xE0, 0x0C, 0x30, 0xFF, 0xDF, 0x38, 0xF3, 0xDF, 0xF0,
  0x7B, 0x68, 0xFF, 0x83, 0x27, 0x80, 0x3B, 0xD9, 0xF6, 0x31, 0x8C, 0x63,
  0x00, 0xFF, 0x7C, 0xE3, 0xCF, 0x7F, 0xC3, 0x9B, 0xE0, 0xC3, 0x0C, 0x3E,
  0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0xF3, 0xFF, 0xF0, 0x33, 0x03, 0x33, 0x33,
  0x33, 0x3F, 0xE0, 0xC3, 0x0C, 0x33, 0xDB, 0xCF, 0x36, 0xDB, 0x30, 0xFF,
  0xFF, 0xF0, 0xBB, 0xB3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0xBB,
  0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x7C, 0xE3, 0xCF, 0x67, 0x80, 0xFB,
  0x3C, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x00, 0xFF, 0x7C, 0xE3, 0xCF, 0x7F,
  0xC3, 0x0C, 0x30, 0xBF, 0xCC, 0xCC, 0xC0, 0x7E, 0x58, 0xF1, 0xAD, 0xE0,
  0x23, 0x3E, 0xC6, 0x31, 0x8D, 0x38, 0xCF, 0x3C, 0xF3, 0xCF, 0x7F, 0xC0,
  0xC6, 0x99, 0xB3, 0x62, 0x87, 0x0E, 0x00, 0xCC, 0xD3, 0xB6, 0xE9, 0xEE,
  0x73, 0x8C, 0xE3, 0x30, 0xEE, 0xD8, 0xE1, 0xC3, 0x8D, 0xB3, 0x80, 0xC6,
  0x99, 0xB3, 0x62, 0x87, 0x0E, 0x18, 0xB1, 0xC0, 0xF8, 0xCC, 0x66, 0x33,
  0xE0, 0x32, 0x22, 0x6C, 0x62, 0x23, 0x30, 0xFF, 0xF8, 0xE3, 0x08, 0x43,
  0x0C, 0x84, 0x23, 0x38, 0x67, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 5, 11, 7, 1, -10 },
  { 21, 11, 9, 11, 0, -9 },
  { 34, 9, 9, 9, 0, -9 },
  { 45, 2, 3, 3, 1, -9 },
  { 46, 3, 11, 4, 1, -9 },
  { 51, 4, 11, 4, 0, -9 },
  { 57, 6, 6, 7, 0, -10 },
  { 62, 6, 7, 7, 0, -8 },
  { 68, 3, 4, 4, 0, -2 },
  { 70, 4, 1, 4, 0, -4 },
  { 71, 2, 2, 4, 1, -2 },
  { 72, 5, 9, 5, 0, -9 },
  { 78, 6, 9, 7, 0, -9 },
  { 85, 4, 9, 7, 1, -9 },
  { 90, 6, 9, 7, 0, -9 },
  { 97, 6, 9, 7, 0, -9 },
  { 104, 7, 9, 7, 0, -9 },
  { 112, 5, 9, 7, 1, -9 },
  { 118, 6, 9, 7, 0, -9 },
  { 125, 6, 9, 7, 0, -9 },
  { 132, 6, 9, 7, 0, -9 },
  { 139, 6, 9, 7, 0, -9 },
  { 146, 2, 7, 4, 1, -7 },
  { 148, 3, 9, 4, 0, -7 },
  { 152, 6, 7, 7, 0, -8 },
  { 158, 6, 4, 7, 0, -7 },
  { 161, 6, 7, 7, 0, -8 },
  { 167, 5, 9, 6, 0, -9 },
  { 173, 9, 10, 11, 1, -9 },
  { 185, 8, 9, 8, 0, -9 },
  { 194, 6, 9, 8, 1, -9 },
  { 201, 6, 9, 8, 1, -9 },
  { 208, 7, 9, 9, 1, -9 },
  { 216, 5, 9, 7, 1, -9 },
  { 222, 5, 9, 7, 1, -9 },
  { 228, 7, 9, 9, 1, -9 },
  { 236, 7, 9, 9, 1, -9 },
  { 244, 4, 9, 5, 0, -9 },
  { 249, 4, 12, 4, -1, -9 },
  { 255, 7, 9, 8, 1, -9 },
  { 263, 5, 9, 7, 1, -9 },
  { 269, 9, 9, 11, 1, -9 },
  { 280, 8, 9, 10, 1, -9 },
  { 289, 8, 9, 9, 1, -9 },
  { 298, 6, 9, 7, 1, -9 },
  { 305, 8, 11, 9, 1, -9 },
  { 316, 7, 9, 8, 1, -9 },
  { 324, 5, 9, 7, 1, -9 },
  { 330, 7, 9, 7, 0, -9 },
  { 338, 7, 9, 9, 1, -9 },
  { 346, 8, 9, 8, 0, -9 },
  { 355, 12, 9, 12, 0, -9 },
  { 369, 8, 9, 8, 0, -9 },
  { 378, 7, 9, 7, 0, -9 },
  { 386, 6, 9, 7, 0, -9 },
  { 393, 3, 11, 4, 1, -9 },
  { 398, 5, 9, 5, 0, -9 },
  { 404, 3, 11, 4, 0, -9 },
  { 409, 7, 6, 7, 0, -9 },
  { 415, 5, 1, 5, 0, 1 },
  { 416, 3, 2, 4, 1, -10 },
  { 417, 6, 7, 7, 0, -7 },
  { 423, 6, 10, 8, 1, -10 },
  { 431, 5, 7, 6, 1, -7 },
  { 436, 6, 10, 8, 1, -10 },
  { 444, 6, 7, 7, 1, -7 },
  { 450, 5, 10, 5, 0, -10 },
  { 457, 6, 10, 8, 1, -7 },
  { 465, 6, 10, 8, 1, -10 },
  { 473, 2, 10, 4, 1, -10 },
  { 476, 4, 13, 4, -1, -10 },
  { 483, 6, 10, 7, 1, -10 },
  { 491, 2, 10, 4, 1, -10 },
  { 494, 10, 7, 12, 1, -7 },
  { 503, 6, 7, 8, 1, -7 },
  { 509, 6, 7, 7, 1, -7 },
  { 515, 6, 10, 8, 1, -7 },
  { 523, 6, 10, 8, 1, -7 },
  { 531, 4, 7, 5, 1, -7 },
  { 535, 5, 7, 6, 0, -7 },
  { 540, 5, 9, 5, 0, -9 },
  { 546, 6, 7, 8, 1, -7 },
  { 552, 7, 7, 7, 0, -7 },
  { 559, 10, 7, 10, 0, -7 },
  { 568, 7, 7, 7, 0, -7 },
  { 575, 7, 10, 7, 0, -7 },
  { 584, 5, 7, 6, 0, -7 },
  { 589, 4, 11, 5, 0, -9 },
  { 595, 1, 13, 7, 3, -10 },
  { 597, 5, 11, 5, 0, -9 },
  { 604, 6, 3, 7, 0, -6 },
};

const GFXfont NotoSans_SemiCondensed_Bold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD13PT7B_H_
