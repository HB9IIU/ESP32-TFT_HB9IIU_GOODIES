#ifndef _NOTOSANS_SEMICONDENSED_BOLD16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB0, 0x1F, 0x00, 0xDF, 0x6D, 0xB2, 0x1B, 0x0D, 0x86,
  0xCF, 0xF1, 0x21, 0xB3, 0xFF, 0xFF, 0x36, 0x12, 0x1B, 0x00, 0x10, 0xFF,
  0xF6, 0x8D, 0x1E, 0x0F, 0x0F, 0x17, 0xBF, 0xF0, 0x81, 0x00, 0x30, 0x23,
  0xC6, 0x12, 0x31, 0x9B, 0x04, 0xD8, 0x25, 0xB9, 0xEF, 0xE6, 0xDB, 0x06,
  0xD8, 0x66, 0xC3, 0x36, 0x30, 0xE0, 0x10, 0x1F, 0x06, 0xE3, 0xB0, 0x6C,
  0x1E, 0x0F, 0x9B, 0x76, 0xCF, 0xB1, 0xCF, 0xF1, 0xF7, 0xFF, 0x76, 0xCC,
  0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0xE1, 0x0C, 0x63, 0x0C, 0x63, 0x31, 0x8C,
  0x66, 0x60, 0x18, 0x18, 0x7E, 0xFF, 0x3C, 0x7E, 0x24, 0x30, 0x60, 0xC7,
  0xFF, 0xE6, 0x0C, 0x18, 0x6D, 0xE0, 0xFF, 0xC0, 0xF0, 0x0C, 0x30, 0xC6,
  0x18, 0x63, 0x0C, 0x71, 0x86, 0x30, 0x30, 0xFB, 0xB6, 0x7C, 0x78, 0xF1,
  0xE3, 0xCF, 0x9F, 0xF3, 0xC0, 0x3B, 0xFE, 0xB1, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFB, 0x3C, 0x70, 0xE1, 0x87, 0x1C, 0x71, 0xC3, 0xFF, 0xF0, 0x31,
  0xFB, 0x38, 0x70, 0xCF, 0x1F, 0x07, 0x0E, 0x1F, 0xF7, 0xC0, 0x0E, 0x0E,
  0x1E, 0x36, 0x36, 0x66, 0x46, 0xFF, 0xFF, 0x06, 0x06, 0xFD, 0xFB, 0x06,
  0x0F, 0xDF, 0x83, 0x87, 0x8F, 0xFB, 0xE0, 0x0C, 0xF9, 0xC6, 0x0C, 0x1F,
  0xBB, 0xE3, 0xC7, 0x8F, 0xF3, 0xE0, 0xFF, 0xFF, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x18, 0x18, 0x38, 0x30, 0x31, 0xFB, 0x3E, 0x7E, 0xCF, 0x1F, 0x66,
  0xC7, 0x8F, 0xFB, 0xE0, 0x18, 0x7E, 0x76, 0x67, 0xE3, 0x67, 0x7F, 0x3B,
  0x03, 0x06, 0x7E, 0x78, 0xDF, 0x00, 0x07, 0xC0, 0xDF, 0x00, 0x06, 0xDA,
  0x00, 0x02, 0x1C, 0xF7, 0x8C, 0x0F, 0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x81, 0x81, 0xC0, 0xE0, 0xE7, 0xB8, 0x40, 0x31, 0xF9, 0x38, 0x70,
  0xC3, 0x8E, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x02, 0x03, 0xF8, 0x70, 0xE6,
  0x66, 0xCF, 0xAD, 0x93, 0x91, 0x39, 0x12, 0x9B, 0x6D, 0xFE, 0xC0, 0x07,
  0x08, 0x3F, 0x80, 0x1E, 0x07, 0x81, 0xE0, 0xEC, 0x33, 0x0C, 0xC7, 0xF9,
  0xFE, 0x61, 0xB8, 0x7E, 0x1C, 0xFE, 0xEF, 0xE7, 0xE7, 0xFE, 0xFE, 0xE7,
  0xE3, 0xE7, 0xFF, 0xFC, 0x0C, 0x3F, 0x72, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0xE0, 0x7E, 0x3E, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE7, 0x7F, 0x3F, 0x00, 0xFF, 0xFE, 0x38, 0xFF, 0xFE, 0x38, 0xE3,
  0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8E, 0x00, 0x0C,
  0x3F, 0x7B, 0xE0, 0xE0, 0xC0, 0xCF, 0xCF, 0xE3, 0xE3, 0x7F, 0x3F, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x60,
  0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xFE, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x7F, 0x78, 0xE3, 0xF3, 0x3B, 0x9F, 0x8F, 0x87, 0xE3, 0xB1,
  0xDC, 0xE6, 0x73, 0xB8, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xFF, 0xF8, 0xF0, 0xFF, 0x0F, 0xF0, 0xFD, 0x9B, 0xD9, 0xBD, 0x9B,
  0xCB, 0x3C, 0xF3, 0xCF, 0x3C, 0xE3, 0xC6, 0x30, 0xF1, 0xFC, 0x7F, 0x9F,
  0x67, 0xDD, 0xF3, 0x3C, 0xEF, 0x1B, 0xC7, 0xF0, 0xFC, 0x3C, 0x0C, 0x1F,
  0xC7, 0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xB8, 0xE7, 0xF8,
  0xF8, 0xFE, 0xFE, 0xE7, 0xE7, 0xE6, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0,
  0x0C, 0x1F, 0xC7, 0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xB8,
  0xE7, 0xF8, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0xFE, 0x77, 0x39, 0xDC, 0xEE,
  0x67, 0xE3, 0xF1, 0xDC, 0xE6, 0x73, 0xB8, 0xE0, 0x31, 0xFE, 0xF0, 0xC3,
  0xC7, 0xC7, 0x0E, 0x3F, 0xFE, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xBF, 0x8F, 0x80, 0xE1, 0xD8, 0x66, 0x39, 0x8C, 0x33, 0x0C,
  0xC3, 0x60, 0xD8, 0x1E, 0x07, 0x81, 0xC0, 0xC3, 0x0F, 0x8E, 0x36, 0x79,
  0xD9, 0xE6, 0x67, 0x99, 0x9B, 0x63, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF1,
  0xC3, 0x87, 0x00, 0xE3, 0x9C, 0xC3, 0x70, 0xF8, 0x1E, 0x07, 0x01, 0xE0,
  0xD8, 0x73, 0x18, 0xEE, 0x1C, 0xE3, 0xB1, 0x9D, 0xC6, 0xC3, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x60, 0xFF, 0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF,
  0xC3, 0x86, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x70, 0xC3, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFF, 0x18, 0x0E, 0x0D, 0x06, 0xC6, 0x23, 0x1B, 0x06,
  0xFF, 0xFC, 0xE7, 0xF8, 0xF8, 0x38, 0x7F, 0xF9, 0xF3, 0xFF, 0xF6, 0xC0,
  0xC0, 0xC0, 0xDC, 0xFE, 0xE6, 0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0xDC, 0x3D,
  0xFE, 0x30, 0xC3, 0x0C, 0x3F, 0x7C, 0x06, 0x0C, 0x1B, 0xBF, 0xFC, 0xF1,
  0xE3, 0xC7, 0x8F, 0xFB, 0xF0, 0x38, 0xFB, 0x1E, 0x3F, 0xF8, 0x30, 0x7F,
  0x7E, 0x3C, 0xF7, 0x1F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x77, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x76, 0x0E, 0x1F, 0xF7, 0x80, 0xC1, 0x83,
  0x06, 0xEF, 0xFC, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xF3, 0xFF, 0xFF,
  0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC0, 0xC0, 0xC0, 0xC7,
  0xCE, 0xCC, 0xD8, 0xF8, 0xFC, 0xCE, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xDC,
  0xEF, 0xFF, 0xE7, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x30, 0xDD, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x38, 0x7E, 0xC6,
  0xC6, 0xC7, 0xC6, 0xC6, 0xFE, 0x7C, 0xDC, 0xFE, 0xE6, 0xC7, 0xC7, 0xC7,
  0xE6, 0xFE, 0xDC, 0xC0, 0xC0, 0xC0, 0xC0, 0x77, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xFF, 0x76, 0x0C, 0x18, 0x30, 0x60, 0xDF, 0xF9, 0xCC, 0x63, 0x18,
  0xC0, 0x7F, 0xEC, 0x38, 0xF8, 0xF1, 0xFF, 0xF8, 0x30, 0xC7, 0xFF, 0x71,
  0xC7, 0x1C, 0x71, 0xF3, 0xC0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF,
  0x7A, 0xC3, 0xE3, 0x67, 0x66, 0x76, 0x3E, 0x3C, 0x3C, 0x1C, 0xC7, 0x3F,
  0x39, 0x99, 0xCC, 0xDA, 0x66, 0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x38,
  0xC0, 0xE7, 0x66, 0x3E, 0x3C, 0x1C, 0x3C, 0x3E, 0x66, 0xE7, 0xE3, 0xE3,
  0x67, 0x66, 0x36, 0x3E, 0x3C, 0x1C, 0x1C, 0x18, 0x38, 0x70, 0x60, 0x7E,
  0xFC, 0x30, 0xC3, 0x86, 0x1C, 0x3F, 0xFE, 0x39, 0x8C, 0x63, 0x3B, 0x0E,
  0x31, 0x8C, 0x63, 0x84, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x18, 0xC6, 0x38,
  0x6E, 0x63, 0x18, 0xCE, 0x40, 0xE3, 0xFE, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 7, 1, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 7, 13, 9, 1, -12 },
  { 34, 13, 12, 14, 0, -12 },
  { 54, 10, 12, 11, 1, -12 },
  { 69, 2, 4, 4, 1, -11 },
  { 70, 4, 14, 5, 1, -11 },
  { 77, 5, 14, 5, 0, -11 },
  { 86, 8, 7, 8, 0, -12 },
  { 93, 7, 8, 9, 1, -10 },
  { 100, 3, 4, 4, 0, -2 },
  { 102, 5, 2, 5, 0, -5 },
  { 104, 2, 2, 4, 1, -2 },
  { 105, 6, 12, 7, 0, -12 },
  { 114, 7, 12, 9, 1, -12 },
  { 125, 5, 11, 9, 1, -11 },
  { 132, 7, 12, 9, 1, -12 },
  { 143, 7, 12, 9, 1, -12 },
  { 154, 8, 11, 9, 0, -11 },
  { 165, 7, 11, 9, 1, -11 },
  { 175, 7, 12, 9, 1, -12 },
  { 186, 8, 11, 9, 0, -11 },
  { 197, 7, 12, 9, 1, -12 },
  { 208, 8, 12, 9, 0, -12 },
  { 220, 3, 9, 4, 1, -9 },
  { 224, 3, 11, 4, 1, -9 },
  { 229, 7, 8, 9, 1, -10 },
  { 236, 7, 5, 9, 1, -8 },
  { 241, 7, 8, 9, 1, -10 },
  { 248, 7, 12, 7, 0, -12 },
  { 259, 12, 13, 13, 1, -12 },
  { 279, 10, 11, 10, 0, -11 },
  { 293, 8, 11, 10, 1, -11 },
  { 304, 8, 12, 9, 1, -12 },
  { 316, 9, 11, 11, 1, -11 },
  { 329, 6, 11, 8, 1, -11 },
  { 338, 6, 11, 8, 1, -11 },
  { 347, 8, 12, 11, 1, -12 },
  { 359, 9, 11, 11, 1, -11 },
  { 372, 5, 11, 6, 0, -11 },
  { 379, 5, 14, 5, -1, -11 },
  { 388, 9, 11, 10, 1, -11 },
  { 401, 7, 11, 8, 1, -11 },
  { 411, 12, 11, 14, 1, -11 },
  { 428, 10, 11, 12, 1, -11 },
  { 442, 10, 12, 11, 1, -12 },
  { 457, 8, 11, 9, 1, -11 },
  { 468, 10, 15, 11, 1, -12 },
  { 487, 9, 11, 10, 1, -11 },
  { 500, 6, 12, 8, 1, -12 },
  { 509, 8, 11, 8, 0, -11 },
  { 520, 9, 11, 11, 1, -11 },
  { 533, 10, 11, 10, 0, -11 },
  { 547, 14, 11, 14, 0, -11 },
  { 567, 10, 11, 10, 0, -11 },
  { 581, 9, 11, 9, 0, -11 },
  { 594, 8, 11, 8, 0, -11 },
  { 605, 4, 14, 5, 1, -11 },
  { 612, 6, 12, 7, 0, -12 },
  { 621, 4, 14, 5, 0, -11 },
  { 628, 9, 7, 9, 0, -11 },
  { 636, 7, 2, 7, 0, 1 },
  { 638, 4, 2, 6, 1, -12 },
  { 639, 7, 9, 9, 1, -9 },
  { 647, 8, 12, 9, 1, -12 },
  { 659, 6, 9, 8, 1, -9 },
  { 666, 7, 12, 9, 1, -12 },
  { 677, 7, 9, 9, 1, -9 },
  { 685, 6, 12, 6, 0, -12 },
  { 694, 7, 13, 9, 1, -9 },
  { 706, 7, 12, 10, 1, -12 },
  { 717, 2, 12, 4, 1, -12 },
  { 720, 4, 16, 4, -1, -12 },
  { 728, 8, 12, 9, 1, -12 },
  { 740, 2, 12, 4, 1, -12 },
  { 743, 12, 9, 14, 1, -9 },
  { 757, 7, 9, 10, 1, -9 },
  { 765, 8, 9, 9, 1, -9 },
  { 774, 8, 13, 9, 1, -9 },
  { 787, 7, 13, 9, 1, -9 },
  { 799, 5, 9, 7, 1, -9 },
  { 805, 6, 9, 7, 1, -9 },
  { 812, 6, 11, 6, 0, -11 },
  { 821, 7, 9, 10, 1, -9 },
  { 829, 8, 9, 8, 0, -9 },
  { 838, 13, 9, 13, 0, -9 },
  { 853, 8, 9, 8, 0, -9 },
  { 862, 8, 13, 8, 0, -9 },
  { 875, 7, 9, 7, 0, -9 },
  { 883, 5, 14, 6, 0, -11 },
  { 892, 2, 16, 8, 3, -12 },
  { 896, 5, 14, 6, 1, -11 },
  { 905, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Bold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD16PT7B_H_
