#ifndef _NOTOSANS_SEMICONDENSED_BOLD37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x1F, 0x78, 0x78,
  0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x0F,
  0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1C, 0x38, 0x03, 0xC7, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F,
  0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFD, 0x8E, 0xF9, 0x80, 0xF9,
  0x80, 0xF9, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F, 0x81, 0x9F, 0xE1,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0xC0, 0x78, 0x07, 0x9E, 0x07, 0x80, 0x7C,
  0xF8, 0x3C, 0x03, 0xC3, 0xC3, 0xC0, 0x1E, 0x1E, 0x1E, 0x00, 0xF0, 0xF1,
  0xE0, 0x07, 0x87, 0x8F, 0x00, 0x3C, 0x3C, 0xF0, 0x01, 0xE3, 0xE7, 0x8F,
  0x87, 0x9E, 0x79, 0xFF, 0x3F, 0xF3, 0xCF, 0xF8, 0xFF, 0xBC, 0xFB, 0xE7,
  0xF9, 0xE7, 0x8F, 0x0F, 0x1E, 0x3C, 0x78, 0x00, 0xF1, 0xE3, 0xC0, 0x0F,
  0x0F, 0x1E, 0x00, 0x78, 0x78, 0xF0, 0x07, 0xC3, 0xC7, 0x80, 0x3C, 0x1E,
  0x3C, 0x03, 0xE0, 0xF1, 0xE0, 0x1E, 0x07, 0xDF, 0x01, 0xF0, 0x1F, 0xF0,
  0x0F, 0x00, 0x7F, 0x80, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x3E, 0x3F, 0xF8, 0x7E, 0x7F, 0xFC, 0x7C, 0x7E, 0xFE, 0x7C, 0x7C, 0x7E,
  0xFC, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x0F, 0xF0, 0xFC, 0x07,
  0xE0, 0x7F, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE,
  0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x78, 0x0F, 0x87,
  0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0xF8, 0x1F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0x83, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x04, 0x1C,
  0x13, 0xCE, 0x7B, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x03,
  0xFC, 0x01, 0xEF, 0x01, 0xF7, 0xC1, 0xF1, 0xF0, 0x78, 0xF0, 0x18, 0x20,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xF0, 0xF8, 0xFC,
  0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xF7, 0x9F, 0x31, 0xF2,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1,
  0xE0, 0xF8, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0x80, 0xF8,
  0x80, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x81, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8,
  0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0x3E, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x3F, 0x1F,
  0x7F, 0xCF, 0xBF, 0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0x7C, 0xF8,
  0x7E, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xF3, 0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x1F, 0x1F, 0x0F, 0x8F, 0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xF0, 0x7F, 0xFC, 0x7E, 0x3F, 0x3E, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x1F,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFB, 0xFB, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0x1F, 0xEF, 0x83, 0xC7, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0x11, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x78, 0x08, 0x7D, 0xFB, 0xF7, 0xE7, 0xC2,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFB, 0xE7,
  0xCF, 0x9E, 0x3C, 0xF9, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xE6, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xE0, 0x7C, 0x1E, 0x78, 0x3F, 0xF3,
  0xCF, 0x0F, 0xFE, 0x3F, 0xC3, 0xF7, 0xC7, 0xF8, 0xF8, 0x78, 0xFF, 0x1E,
  0x0F, 0x1F, 0xE3, 0xC1, 0xE3, 0xFC, 0x78, 0x3C, 0x7F, 0x8F, 0x07, 0x8F,
  0xF1, 0xE1, 0xF1, 0xFE, 0x3C, 0x3E, 0x3F, 0xC7, 0x87, 0xC7, 0x78, 0xFB,
  0xFF, 0xEF, 0x0F, 0xFF, 0xF9, 0xF0, 0xFE, 0x7E, 0x1E, 0x07, 0x07, 0x83,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x7F, 0xC7,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF3, 0xE0, 0x07,
  0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0xFC,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFC, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0x87,
  0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0x03, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x8F, 0xF0, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x3F, 0xCF, 0x80, 0xFE, 0xF8, 0x07,
  0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0xFE, 0xF8, 0x1F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0x04, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01,
  0xF7, 0xF0, 0x1F, 0x3F, 0xC3, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFB,
  0xFE, 0xFE, 0x3E, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF,
  0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0,
  0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0x87,
  0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8,
  0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0xFF, 0xFE, 0x03,
  0xDF, 0xFB, 0xC0, 0xFB, 0xFF, 0x78, 0x1E, 0x7F, 0xEF, 0x83, 0xDF, 0xFD,
  0xF0, 0xFB, 0xFF, 0x9E, 0x1E, 0x7F, 0xF3, 0xC3, 0xCF, 0xFE, 0x7C, 0x79,
  0xFF, 0xC7, 0x9F, 0x3F, 0xF8, 0xF3, 0xC7, 0xFF, 0x1F, 0x78, 0xFF, 0xE3,
  0xFF, 0x1F, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x7F, 0xF0, 0xFF, 0x0F,
  0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x07,
  0xC0, 0xFC, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFB, 0xE0, 0x7F, 0xEF, 0xC1, 0xFF, 0x9F, 0x07, 0xFE, 0x7E, 0x1F, 0xF8,
  0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x87, 0xE7, 0xFE, 0x1F, 0x9F, 0xF8, 0x3F,
  0x7F, 0xE0, 0xFD, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x87, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xC0, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF3, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0x83, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F,
  0x9F, 0x03, 0xF3, 0xE0, 0xFC, 0x7C, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0xFC, 0x1F, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0x7E,
  0xF8, 0x0F, 0xDF, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x83, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFE, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7,
  0xF0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E,
  0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xDF, 0x01, 0xFC, 0x07,
  0xCF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0, 0x3F, 0x81,
  0xF9, 0xF8, 0x3F, 0xC0, 0xF8, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E, 0x0F, 0x78,
  0x3E, 0x1F, 0x07, 0xBC, 0x3F, 0x0F, 0x87, 0xDE, 0x1F, 0x03, 0xE3, 0xEF,
  0x8F, 0x81, 0xF1, 0xE7, 0xC7, 0xC0, 0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0xF8,
  0xF3, 0xE0, 0x1F, 0x7C, 0x7D, 0xF0, 0x0F, 0xBC, 0x3E, 0xF8, 0x07, 0xDE,
  0x0F, 0x7C, 0x03, 0xEF, 0x07, 0xBE, 0x00, 0xFF, 0x83, 0xDE, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x87, 0xE0, 0x7C, 0x0F,
  0x83, 0xF0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xC3, 0xF0,
  0x7E, 0x0F, 0x83, 0xE0, 0x7E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xDF, 0x80,
  0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xEF,
  0x00, 0x79, 0xE0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF7, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x70,
  0x00, 0x40, 0x07, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xF7, 0xF0, 0x40,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7F, 0x87, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFC, 0xF1, 0xFC, 0x78, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0xC0, 0xFD, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFE, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFB, 0xF8, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xBF, 0xE3, 0xE3, 0xF0,
  0x00, 0xC0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xC1, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x0C, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0C, 0x1F, 0x1F, 0xCF, 0x9F,
  0xF7, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFB, 0xE3, 0xF8, 0xF0, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xF3, 0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0x08, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0x00, 0x0F, 0xE7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xFE, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFD, 0xF1, 0xFC, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x40, 0x1F, 0xBF, 0x7F, 0x9F, 0xFF, 0xCF,
  0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x40,
  0xFD, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7B, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFB, 0xFC, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x1F, 0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xE1, 0xF8, 0xF8, 0xFC, 0x3E, 0x7E,
  0x0F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFC, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8,
  0x3F, 0x3E, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x06, 0x07, 0xCF, 0xF1, 0xFE,
  0x3E, 0xFF, 0xDF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x0F, 0xF1, 0xFB, 0xF8, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F,
  0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03,
  0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF,
  0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03,
  0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0x80, 0x00, 0x38,
  0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xEF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x00, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xEF,
  0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E, 0x7E, 0x1F,
  0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x30,
  0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xEF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0xFF, 0x1F,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFC, 0xFC, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xE7, 0xCF, 0xFB,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFE, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFD,
  0xF1, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x37,
  0xC7, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFB, 0xFC, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0x9F, 0x81, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0xE0, 0x7D, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFE,
  0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x9F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC1, 0xFD, 0xF8, 0xFF, 0x7F, 0xFF, 0xDF, 0xFD, 0xF3, 0xFF,
  0x7C, 0x7F, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x03,
  0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x7C,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0xFB, 0xE0, 0xFE, 0x0F, 0xDF, 0x07,
  0xF0, 0x7C, 0xF8, 0x3F, 0x83, 0xE3, 0xE1, 0xDE, 0x1F, 0x1F, 0x1E, 0xF1,
  0xF0, 0xF8, 0xF7, 0x8F, 0x87, 0xC7, 0xBC, 0x7C, 0x1F, 0x3C, 0xE3, 0xE0,
  0xF9, 0xC7, 0xBE, 0x07, 0xDE, 0x3D, 0xF0, 0x3E, 0xF1, 0xEF, 0x80, 0xF7,
  0x87, 0x7C, 0x07, 0xBC, 0x3B, 0xC0, 0x3F, 0xC1, 0xDE, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3E, 0x0F,
  0x8F, 0xC1, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0x7C, 0x07, 0xEF, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x87, 0xC1, 0xF9, 0xF8,
  0x3F, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F,
  0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0xC3, 0xFC,
  0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x07, 0xF0,
  0xFF, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0x00, 0x3F, 0x00,
  0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 9, 17, 2, -26 },
  { 36, 20, 26, 22, 1, -26 },
  { 101, 16, 30, 20, 2, -28 },
  { 161, 29, 27, 32, 1, -27 },
  { 259, 24, 27, 25, 1, -27 },
  { 340, 5, 9, 9, 2, -26 },
  { 346, 9, 32, 12, 2, -26 },
  { 382, 10, 32, 12, 1, -26 },
  { 422, 17, 16, 19, 1, -28 },
  { 456, 17, 18, 20, 1, -22 },
  { 495, 7, 9, 10, 1, -4 },
  { 503, 10, 4, 12, 1, -12 },
  { 508, 6, 6, 10, 2, -6 },
  { 513, 15, 27, 15, 0, -27 },
  { 564, 17, 27, 20, 1, -27 },
  { 622, 12, 26, 20, 2, -26 },
  { 661, 17, 27, 20, 1, -27 },
  { 719, 17, 27, 20, 1, -27 },
  { 777, 18, 26, 20, 1, -26 },
  { 836, 16, 26, 20, 2, -26 },
  { 888, 17, 27, 20, 1, -27 },
  { 946, 17, 26, 20, 1, -26 },
  { 1002, 17, 27, 20, 1, -27 },
  { 1060, 17, 27, 20, 1, -27 },
  { 1118, 6, 21, 10, 2, -21 },
  { 1134, 7, 26, 10, 1, -21 },
  { 1157, 17, 19, 20, 1, -23 },
  { 1198, 17, 11, 20, 1, -19 },
  { 1222, 17, 19, 20, 1, -23 },
  { 1263, 15, 27, 16, 0, -27 },
  { 1314, 27, 30, 31, 2, -27 },
  { 1416, 23, 26, 23, 0, -26 },
  { 1491, 18, 26, 23, 3, -26 },
  { 1550, 19, 27, 22, 2, -27 },
  { 1615, 20, 26, 25, 3, -26 },
  { 1680, 14, 26, 19, 3, -26 },
  { 1726, 14, 26, 19, 3, -26 },
  { 1772, 20, 27, 25, 2, -27 },
  { 1840, 20, 26, 26, 3, -26 },
  { 1905, 11, 26, 13, 1, -26 },
  { 1941, 10, 34, 11, -2, -26 },
  { 1984, 20, 26, 23, 3, -26 },
  { 2049, 15, 26, 19, 3, -26 },
  { 2098, 27, 26, 33, 3, -26 },
  { 2186, 22, 26, 28, 3, -26 },
  { 2258, 23, 27, 27, 2, -27 },
  { 2336, 17, 26, 21, 3, -26 },
  { 2392, 23, 33, 27, 2, -27 },
  { 2487, 19, 26, 22, 3, -26 },
  { 2549, 15, 27, 19, 2, -27 },
  { 2600, 18, 26, 19, 1, -26 },
  { 2659, 20, 26, 25, 3, -26 },
  { 2724, 22, 26, 22, 0, -26 },
  { 2796, 33, 26, 33, 0, -26 },
  { 2904, 22, 26, 22, 0, -26 },
  { 2976, 21, 26, 21, 0, -26 },
  { 3045, 17, 26, 19, 1, -26 },
  { 3101, 9, 32, 12, 2, -26 },
  { 3137, 15, 27, 15, 0, -27 },
  { 3188, 9, 32, 12, 1, -26 },
  { 3224, 19, 16, 21, 1, -26 },
  { 3262, 15, 3, 15, 0, 3 },
  { 3268, 10, 6, 13, 1, -28 },
  { 3276, 17, 21, 20, 1, -21 },
  { 3321, 18, 28, 22, 2, -28 },
  { 3384, 15, 21, 18, 2, -21 },
  { 3424, 17, 28, 22, 2, -28 },
  { 3484, 17, 21, 20, 2, -21 },
  { 3529, 14, 28, 13, 1, -28 },
  { 3578, 17, 30, 22, 2, -21 },
  { 3642, 18, 28, 22, 2, -28 },
  { 3705, 6, 28, 10, 2, -28 },
  { 3726, 10, 37, 10, -2, -28 },
  { 3773, 18, 28, 21, 3, -28 },
  { 3836, 6, 28, 10, 2, -28 },
  { 3857, 29, 21, 33, 2, -21 },
  { 3934, 18, 21, 22, 2, -21 },
  { 3982, 18, 21, 21, 2, -21 },
  { 4030, 18, 30, 22, 2, -21 },
  { 4098, 17, 30, 22, 2, -21 },
  { 4162, 13, 21, 15, 2, -21 },
  { 4197, 15, 21, 17, 1, -21 },
  { 4237, 13, 25, 15, 1, -25 },
  { 4278, 18, 20, 22, 2, -20 },
  { 4323, 19, 20, 19, 0, -20 },
  { 4371, 29, 20, 29, 0, -20 },
  { 4444, 19, 20, 19, 0, -20 },
  { 4492, 19, 29, 19, 0, -20 },
  { 4561, 14, 20, 16, 1, -20 },
  { 4596, 13, 32, 14, 0, -26 },
  { 4648, 4, 36, 19, 7, -28 },
  { 4666, 12, 32, 14, 1, -26 },
  { 4714, 17, 6, 20, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_Bold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD37PT7B_H_
