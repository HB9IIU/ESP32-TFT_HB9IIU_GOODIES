#ifndef _NOTOSANS_SEMICONDENSED_BOLD10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xB4, 0x28, 0xA7, 0xCC, 0xF9, 0x45, 0x00, 0x23, 0xFA, 0xC3,
  0x1F, 0xE4, 0x20, 0x66, 0xB4, 0xA8, 0x6F, 0x15, 0x15, 0x27, 0x70, 0xB1,
  0xC3, 0xBD, 0x59, 0x9F, 0x80, 0xC0, 0x69, 0x6C, 0x92, 0x20, 0xC9, 0x92,
  0x5A, 0x80, 0x21, 0x3E, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0,
  0xC0, 0x12, 0x26, 0x44, 0xC0, 0x72, 0xF7, 0x9D, 0xAD, 0xC0, 0x77, 0xB6,
  0xD8, 0xF2, 0xC6, 0x22, 0x23, 0xE0, 0xF0, 0xC4, 0xE1, 0xCF, 0xC0, 0x11,
  0x94, 0xAF, 0xFC, 0x40, 0x72, 0x18, 0xF1, 0xCF, 0xC0, 0x7A, 0x3D, 0xFC,
  0xAD, 0xC0, 0xF8, 0xC4, 0x63, 0x11, 0x80, 0x72, 0xDC, 0xED, 0xE5, 0xC0,
  0x76, 0xF2, 0xF2, 0x89, 0xC0, 0xCC, 0x50, 0x1C, 0x09, 0xB0, 0x60, 0x80,
  0xF8, 0x3E, 0xC3, 0x86, 0xC8, 0x00, 0xF1, 0x36, 0x44, 0x60, 0x3E, 0x42,
  0x5D, 0xE5, 0xE5, 0x5E, 0x62, 0x3C, 0x30, 0xE6, 0x9A, 0x7F, 0x3C, 0x40,
  0xF4, 0xE5, 0xE9, 0xCF, 0xC0, 0x7E, 0x21, 0x08, 0x65, 0xC0, 0xF4, 0xE3,
  0x18, 0xCF, 0xC0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8E, 0x88, 0x80, 0x7E,
  0x21, 0x79, 0xED, 0xE0, 0x8C, 0x63, 0xF8, 0xC6, 0x20, 0xED, 0xB6, 0xF8,
  0x24, 0x92, 0x49, 0xE0, 0x9D, 0xA9, 0xCB, 0x4A, 0x60, 0x88, 0x88, 0x88,
  0xF0, 0xC7, 0x9F, 0xAD, 0x5A, 0xB6, 0x64, 0x80, 0xCF, 0x3E, 0xEF, 0x9E,
  0x78, 0xC0, 0xFB, 0x28, 0xE3, 0x8F, 0x27, 0x80, 0xF9, 0x9F, 0x88, 0x80,
  0xFB, 0x28, 0xE3, 0x8F, 0x27, 0x86, 0x0C, 0xF4, 0xA5, 0xEB, 0x4A, 0x60,
  0x7E, 0x10, 0xE1, 0xCF, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x8C, 0x63,
  0x18, 0xED, 0xC0, 0xCD, 0x24, 0x96, 0x78, 0xC3, 0x00, 0xC9, 0xEC, 0xD5,
  0x4A, 0xA5, 0x73, 0xB8, 0x98, 0xCD, 0xE3, 0x0C, 0x71, 0x2C, 0xC0, 0xCD,
  0x67, 0x0C, 0x30, 0xC3, 0x00, 0xF8, 0x8C, 0x46, 0x23, 0xE0, 0xEA, 0xAA,
  0xC0, 0xC4, 0x46, 0x22, 0x10, 0xED, 0xB6, 0xDB, 0xE0, 0x21, 0x95, 0x90,
  0xF0, 0xC4, 0x33, 0xC6, 0xFD, 0xB4, 0x88, 0xAF, 0x99, 0x9F, 0x37, 0xCC,
  0x57, 0x08, 0x4A, 0xFC, 0xE5, 0x2F, 0x23, 0xF3, 0xF4, 0x3C, 0x37, 0x4E,
  0x44, 0x44, 0x23, 0xF3, 0x94, 0xBC, 0x2F, 0x88, 0xAF, 0x99, 0x99, 0xDF,
  0x51, 0x55, 0x70, 0x84, 0x23, 0x6E, 0x72, 0xD3, 0xFF, 0x25, 0xFE, 0x4C,
  0x99, 0x32, 0x40, 0x2F, 0x99, 0x99, 0x23, 0xF3, 0x94, 0xBC, 0x2F, 0x99,
  0x9F, 0x88, 0x23, 0xF3, 0x94, 0xBC, 0x21, 0x3E, 0x49, 0x00, 0x2F, 0xC7,
  0x1F, 0x44, 0xF4, 0x44, 0x70, 0x99, 0x99, 0xF0, 0xDA, 0xD4, 0xE3, 0x00,
  0xDB, 0x5A, 0x5A, 0x66, 0x66, 0xDB, 0x8C, 0xAD, 0x80, 0xDA, 0xD4, 0xE3,
  0x13, 0x80, 0xF2, 0x64, 0xF0, 0x6D, 0xBC, 0xDB, 0x20, 0xFF, 0xC0, 0xC4,
  0x46, 0x34, 0x44, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 5, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 8, 7, 9, 0, -7 },
  { 22, 7, 7, 7, 0, -7 },
  { 29, 1, 2, 3, 1, -7 },
  { 30, 3, 9, 3, 0, -7 },
  { 34, 3, 9, 3, 0, -7 },
  { 38, 5, 5, 5, 0, -8 },
  { 42, 5, 5, 5, 0, -6 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 1, 2, 3, 1, -2 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 3, 7, 5, 1, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 5, 7, 5, 0, -7 },
  { 96, 5, 7, 5, 0, -7 },
  { 101, 1, 6, 3, 1, -6 },
  { 102, 2, 7, 3, 0, -6 },
  { 104, 5, 5, 5, 0, -6 },
  { 108, 5, 3, 5, 0, -5 },
  { 110, 5, 5, 5, 0, -6 },
  { 114, 4, 7, 4, 0, -7 },
  { 118, 8, 8, 8, 0, -7 },
  { 126, 6, 7, 6, 0, -7 },
  { 132, 5, 7, 6, 1, -7 },
  { 137, 5, 7, 6, 1, -7 },
  { 142, 5, 7, 7, 1, -7 },
  { 147, 4, 7, 5, 1, -7 },
  { 151, 4, 7, 5, 1, -7 },
  { 155, 5, 7, 7, 1, -7 },
  { 160, 5, 7, 7, 1, -7 },
  { 165, 3, 7, 4, 0, -7 },
  { 168, 3, 9, 3, -1, -7 },
  { 172, 5, 7, 6, 1, -7 },
  { 177, 4, 7, 5, 1, -7 },
  { 181, 7, 7, 9, 1, -7 },
  { 188, 6, 7, 7, 1, -7 },
  { 194, 6, 7, 7, 1, -7 },
  { 200, 4, 7, 6, 1, -7 },
  { 204, 6, 9, 7, 1, -7 },
  { 211, 5, 7, 6, 1, -7 },
  { 216, 5, 7, 5, 0, -7 },
  { 221, 5, 7, 5, 0, -7 },
  { 226, 5, 7, 7, 1, -7 },
  { 231, 6, 7, 6, 0, -7 },
  { 237, 9, 7, 9, 0, -7 },
  { 245, 6, 7, 6, 0, -7 },
  { 251, 6, 7, 6, 0, -7 },
  { 257, 5, 7, 5, 0, -7 },
  { 262, 2, 9, 3, 1, -7 },
  { 265, 4, 7, 4, 0, -7 },
  { 269, 3, 9, 3, 0, -7 },
  { 273, 5, 4, 6, 0, -7 },
  { 276, 4, 1, 4, 0, 1 },
  { 277, 3, 2, 3, 0, -8 },
  { 278, 5, 6, 5, 0, -6 },
  { 282, 4, 8, 6, 1, -8 },
  { 286, 4, 6, 5, 0, -6 },
  { 289, 5, 8, 6, 0, -8 },
  { 294, 5, 6, 5, 0, -6 },
  { 298, 4, 8, 4, 0, -8 },
  { 302, 5, 8, 6, 0, -6 },
  { 307, 4, 8, 6, 1, -8 },
  { 311, 1, 8, 3, 1, -8 },
  { 312, 2, 10, 3, 0, -8 },
  { 315, 5, 8, 6, 1, -8 },
  { 320, 1, 8, 3, 1, -8 },
  { 321, 7, 6, 9, 1, -6 },
  { 327, 4, 6, 6, 1, -6 },
  { 330, 5, 6, 6, 0, -6 },
  { 334, 4, 8, 6, 1, -6 },
  { 338, 5, 8, 6, 0, -6 },
  { 343, 3, 6, 4, 1, -6 },
  { 346, 4, 6, 5, 0, -6 },
  { 349, 4, 7, 4, 0, -7 },
  { 353, 4, 5, 6, 1, -5 },
  { 356, 5, 5, 5, 0, -5 },
  { 360, 8, 5, 8, 0, -5 },
  { 365, 5, 5, 5, 0, -5 },
  { 369, 5, 7, 5, 0, -5 },
  { 374, 4, 5, 4, 0, -5 },
  { 377, 3, 9, 4, 0, -7 },
  { 381, 1, 10, 5, 2, -8 },
  { 383, 4, 9, 4, 0, -7 },
  { 388, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Bold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD10PT7B_H_
