#ifndef _NOTOSANS_SEMICONDENSED_BOLD29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3B, 0x8E, 0x07, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xC0,
  0x39, 0xC0, 0x39, 0xC0, 0x03, 0x00, 0x18, 0x03, 0xF8, 0x7F, 0xF7, 0xFF,
  0xBF, 0xFB, 0xCC, 0x5E, 0x60, 0xFB, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x0D, 0xE0, 0x6F, 0xC3, 0x7F, 0xDF, 0xFF, 0xFD, 0xFF,
  0xC0, 0xF8, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x3E, 0x01, 0xC0, 0xFE, 0x07,
  0x01, 0xFC, 0x0E, 0x07, 0xBC, 0x38, 0x0E, 0x38, 0x70, 0x1C, 0x71, 0xE0,
  0x38, 0xE3, 0x80, 0x71, 0xCF, 0x00, 0xE3, 0x9C, 0x61, 0xEF, 0x7B, 0xF1,
  0xFC, 0xEF, 0xF3, 0xFB, 0xDC, 0xE3, 0xE7, 0x39, 0xE0, 0x1E, 0x71, 0xC0,
  0x38, 0xE3, 0x80, 0xF1, 0xC7, 0x01, 0xC3, 0x9E, 0x07, 0x87, 0x3C, 0x0E,
  0x0F, 0xF0, 0x3C, 0x0F, 0xE0, 0x70, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C,
  0x01, 0xEF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0x3F, 0xE3,
  0xE7, 0xBE, 0x79, 0xF3, 0xEF, 0x3C, 0x3F, 0xC7, 0x83, 0xF8, 0xF8, 0x3E,
  0x1F, 0x8F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x7E, 0xFF, 0xFF,
  0xEE, 0xEE, 0x0F, 0x0E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C,
  0x3C, 0x1E, 0x0E, 0x0F, 0xE0, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x0F, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E,
  0x3C, 0xF1, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x0E, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEE, 0x1E, 0x78, 0x71, 0xE0, 0x88,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x7B, 0xDE, 0xEF, 0x7B, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE7, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0x78, 0xFB, 0xE7,
  0x8F, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x03, 0x87, 0xC7, 0xE7, 0xF7, 0xFF,
  0xFF, 0xDE, 0xCF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x0F, 0x81, 0xFF, 0x3F, 0xFD, 0xFF,
  0xF7, 0x0F, 0x90, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF, 0xF2,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFE, 0x0F, 0xFF, 0xFD,
  0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x38, 0xF0, 0xF1,
  0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFF,
  0x9F, 0xFC, 0x43, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xFF,
  0x0F, 0xBF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x87, 0xFC,
  0x7F, 0x27, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF7, 0xE7, 0xFF, 0xBF,
  0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x78, 0x7B, 0xE7,
  0xCF, 0xFC, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xF7,
  0x87, 0xB8, 0x3D, 0xE1, 0xEF, 0x9E, 0x3F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F,
  0xC7, 0xDF, 0x7C, 0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0xC3, 0xDF, 0xFE,
  0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0xFE, 0xFF, 0x73,
  0xFF, 0x8F, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x1F, 0x9F, 0xF8, 0xFF,
  0x87, 0xF0, 0x00, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x7B,
  0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x77, 0xBD, 0xC0,
  0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x01, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x0F,
  0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0xFF, 0xE7, 0xFF, 0x40,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xC0, 0x7C,
  0x1C, 0x00, 0x70, 0xE0, 0x60, 0xE7, 0x8F, 0xF3, 0x9C, 0x7F, 0xC7, 0x73,
  0xC7, 0x1D, 0xCE, 0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE3, 0x87,
  0x1F, 0x8E, 0x1C, 0x6E, 0x38, 0xF3, 0x9C, 0xFF, 0xFE, 0x71, 0xFB, 0xF1,
  0xE1, 0xC3, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x10, 0x1F, 0x87, 0x80, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xEE, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xC0, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFE, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE3,
  0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xE3, 0xE0, 0x4F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x38, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xE0, 0x5F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7C, 0x1E, 0xFC, 0x3C,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x3F, 0xDF, 0xFF, 0xF8,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3D, 0xFE, 0xFF, 0x7F, 0x3F, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8,
  0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF9, 0xF0, 0xF9, 0xE0, 0xFB, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF9,
  0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0xF8,
  0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFE, 0xE0, 0xFF, 0xF7, 0x87, 0x7F, 0xBC, 0x3B, 0xFC,
  0xE3, 0xDF, 0xE7, 0x1C, 0xFF, 0x3C, 0xE7, 0xF8, 0xEF, 0x3F, 0xC7, 0x71,
  0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1,
  0xF0, 0xFF, 0x07, 0x07, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xEF, 0x0F, 0xF3, 0xC7,
  0xF9, 0xE3, 0xFC, 0x79, 0xFE, 0x3E, 0xFF, 0x0F, 0x3F, 0x87, 0xDF, 0xC1,
  0xEF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E,
  0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x0F, 0x78, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7D,
  0xF0, 0x1F, 0x3E, 0x0F, 0x8F, 0xEF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE1,
  0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xE3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xE3, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3E, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x0F, 0x78, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80,
  0x7D, 0xF0, 0x1F, 0x3E, 0x0F, 0x8F, 0xEF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x87, 0x9F,
  0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x79, 0xF3, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFE, 0x1F, 0x3C, 0x3E, 0x7C, 0x7C, 0x78, 0xF8, 0xF9, 0xF0, 0xF3,
  0xE1, 0xF7, 0xC1, 0xFF, 0x83, 0xE0, 0x0F, 0xC1, 0xFF, 0xDF, 0xFC, 0xFF,
  0xE7, 0x82, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xF7, 0x8F, 0xBF,
  0xFD, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xF0, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7,
  0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x0F,
  0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x81, 0xFF, 0x83, 0xE0, 0x79, 0xE0, 0xFC,
  0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC3, 0xE7, 0x87, 0xF0, 0xF0, 0xF1,
  0xFC, 0x3C, 0x3C, 0x77, 0x8F, 0x0F, 0x1D, 0xE3, 0xC3, 0xCF, 0x39, 0xE0,
  0x73, 0xCE, 0x78, 0x1E, 0xF3, 0xDE, 0x07, 0xB8, 0xF7, 0x81, 0xEE, 0x1D,
  0xE0, 0x7F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0xBE,
  0x0F, 0x8F, 0x07, 0xC7, 0xC7, 0xC1, 0xE3, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0,
  0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x3D, 0xE0, 0x3E, 0x78, 0x1E, 0x3E, 0x1F, 0x0F, 0x1F,
  0x07, 0xCF, 0x81, 0xEF, 0x80, 0xF8, 0xF8, 0x0F, 0xBC, 0x0F, 0x9F, 0x07,
  0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3E, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF,
  0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x1C, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xCE, 0x0F, 0x38, 0x38, 0x71,
  0xE1, 0xE7, 0x03, 0x9C, 0x0F, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x1E, 0x0F, 0x1F, 0xC1, 0xFF, 0x8F, 0xFC, 0x61, 0xF0, 0x07, 0x80, 0x3C,
  0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F, 0xFF,
  0xFD, 0xFE, 0xE7, 0xE7, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x3E, 0x3D, 0xFC, 0xFF, 0xF3, 0xF3, 0xEF, 0x87, 0xBC,
  0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xE1, 0xEF,
  0x8F, 0xBF, 0xFE, 0xFF, 0xF3, 0x9F, 0x80, 0x0F, 0xE1, 0xFF, 0x3F, 0xE7,
  0xE6, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x37, 0xFF, 0x3F, 0xF0, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF1, 0xF3, 0xCF, 0xEF, 0x7F, 0xFD, 0xF3,
  0xF7, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3D, 0xE1, 0xF7, 0xC7, 0xDF, 0xFF, 0x3F, 0xBC, 0x7E, 0x70, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x1F, 0x1E, 0x78, 0x7B, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x08, 0xFF, 0xE3, 0xFF,
  0x83, 0xFC, 0x07, 0xE3, 0xFC, 0x7F, 0x8F, 0x11, 0xE0, 0x3C, 0x0F, 0xF7,
  0xFE, 0xFF, 0xC3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x3C, 0xFE,
  0xF7, 0xFF, 0xDF, 0x3F, 0x78, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x83, 0xDE, 0x0F, 0x7C, 0x7D, 0xFF, 0xF3, 0xFB, 0xC7,
  0xCF, 0x00, 0x3C, 0x00, 0xF4, 0x07, 0xDF, 0x7E, 0x7F, 0xF9, 0xFF, 0xC3,
  0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xCF, 0x9E, 0xFE, 0xFF, 0xFF, 0xE7, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3C, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF,
  0xFF, 0xEF, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x1F, 0x78, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x87,
  0xBE, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xF9, 0xE1, 0xE3,
  0xE3, 0xC3, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE3, 0xF3, 0xFF,
  0xDF, 0xEF, 0xFF, 0xFF, 0xBF, 0x7F, 0x9F, 0xF8, 0x7C, 0x7F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xFC, 0x1E, 0x0F, 0xE3, 0xE7, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0x87,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F,
  0x1E, 0x78, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xDE, 0x0F, 0x7C, 0x7C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0xE3, 0xE3,
  0xDF, 0xCF, 0xFF, 0xBF, 0x3E, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBE, 0x1E, 0xFC, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3D, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0x3F, 0x78, 0x7F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xDE, 0x0F,
  0x7C, 0x7D, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xE3, 0xF9, 0xEF, 0xFB,
  0xFE, 0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0xCF, 0xFF, 0xFF, 0x78, 0x6F, 0x01, 0xF0,
  0x1F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF3, 0xFC, 0x1C, 0x0F, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xF7, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF1, 0x3F, 0xCF,
  0xF1, 0xFC, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F, 0xFF,
  0xFD, 0xFE, 0xE7, 0xE7, 0xF0, 0x1F, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x0E, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x3B,
  0xC0, 0x77, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x7C,
  0x1E, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF3, 0xC7, 0xF1, 0xE7, 0x8E, 0xE3,
  0xC7, 0x9D, 0xCF, 0x0F, 0x3B, 0x9E, 0x1E, 0x77, 0x3C, 0x3D, 0xC7, 0x78,
  0x3B, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0xF8, 0xF8,
  0xF1, 0xE1, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xE7, 0x87, 0x8F, 0x9F, 0x0F,
  0x7C, 0x1F, 0xF8, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE3, 0xC3, 0xC7,
  0x8F, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x3B, 0xC0, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC1, 0xF0, 0xFC,
  0x3E, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE3, 0xF8, 0xFC,
  0x3F, 0x0F, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0xFC, 0x3F, 0x07, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x7F, 0x0F, 0xC3, 0xF1, 0xFC, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0xC3, 0xF0, 0xF8, 0x20,
  0x00, 0x10, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 10, 8, 14, 2, -21 },
  { 22, 16, 21, 17, 1, -21 },
  { 64, 13, 24, 15, 1, -22 },
  { 103, 23, 21, 25, 1, -21 },
  { 164, 19, 21, 20, 1, -21 },
  { 214, 4, 8, 7, 2, -21 },
  { 218, 8, 26, 10, 1, -21 },
  { 244, 7, 26, 10, 1, -21 },
  { 267, 13, 13, 15, 1, -22 },
  { 289, 13, 14, 15, 1, -17 },
  { 312, 5, 7, 8, 1, -3 },
  { 317, 7, 4, 9, 1, -10 },
  { 321, 4, 4, 8, 2, -4 },
  { 323, 12, 21, 12, 0, -21 },
  { 355, 13, 21, 15, 1, -21 },
  { 390, 9, 21, 15, 2, -21 },
  { 414, 13, 21, 15, 1, -21 },
  { 449, 13, 21, 15, 1, -21 },
  { 484, 15, 21, 15, 0, -21 },
  { 524, 13, 21, 15, 1, -21 },
  { 559, 13, 21, 15, 1, -21 },
  { 594, 13, 21, 15, 1, -21 },
  { 629, 13, 21, 15, 1, -21 },
  { 664, 13, 21, 15, 1, -21 },
  { 699, 4, 16, 8, 2, -16 },
  { 707, 5, 20, 8, 1, -16 },
  { 720, 13, 15, 15, 1, -18 },
  { 745, 13, 9, 15, 1, -15 },
  { 760, 13, 15, 15, 1, -18 },
  { 785, 12, 21, 13, 0, -21 },
  { 817, 22, 23, 24, 1, -21 },
  { 881, 18, 21, 18, 0, -21 },
  { 929, 14, 21, 18, 2, -21 },
  { 966, 15, 21, 17, 1, -21 },
  { 1006, 16, 21, 19, 2, -21 },
  { 1048, 11, 21, 15, 2, -21 },
  { 1077, 11, 21, 15, 2, -21 },
  { 1106, 15, 21, 19, 2, -21 },
  { 1146, 16, 21, 20, 2, -21 },
  { 1188, 9, 21, 11, 1, -21 },
  { 1212, 9, 27, 9, -2, -21 },
  { 1243, 16, 21, 18, 2, -21 },
  { 1285, 12, 21, 15, 2, -21 },
  { 1317, 21, 21, 26, 2, -21 },
  { 1373, 17, 21, 22, 2, -21 },
  { 1418, 18, 21, 21, 1, -21 },
  { 1466, 14, 21, 17, 2, -21 },
  { 1503, 18, 26, 21, 1, -21 },
  { 1562, 15, 21, 17, 2, -21 },
  { 1602, 13, 21, 15, 1, -21 },
  { 1637, 15, 21, 15, 0, -21 },
  { 1677, 16, 21, 20, 2, -21 },
  { 1719, 17, 21, 17, 0, -21 },
  { 1764, 26, 21, 26, 0, -21 },
  { 1833, 17, 21, 17, 0, -21 },
  { 1878, 17, 21, 17, 0, -21 },
  { 1923, 13, 21, 15, 1, -21 },
  { 1958, 7, 26, 9, 2, -21 },
  { 1981, 12, 21, 12, 0, -21 },
  { 2013, 7, 26, 9, 1, -21 },
  { 2036, 14, 13, 16, 1, -21 },
  { 2059, 12, 2, 12, 0, 3 },
  { 2062, 8, 4, 10, 1, -22 },
  { 2066, 13, 16, 16, 1, -16 },
  { 2092, 14, 22, 17, 2, -22 },
  { 2131, 12, 16, 14, 1, -16 },
  { 2155, 14, 22, 17, 1, -22 },
  { 2194, 14, 16, 16, 1, -16 },
  { 2222, 11, 22, 10, 0, -22 },
  { 2253, 14, 23, 17, 1, -16 },
  { 2294, 13, 22, 17, 2, -22 },
  { 2330, 4, 22, 8, 2, -22 },
  { 2341, 7, 29, 8, -1, -22 },
  { 2367, 15, 22, 17, 2, -22 },
  { 2409, 4, 22, 8, 2, -22 },
  { 2420, 22, 16, 26, 2, -16 },
  { 2464, 13, 16, 17, 2, -16 },
  { 2490, 14, 16, 17, 1, -16 },
  { 2518, 14, 23, 17, 2, -16 },
  { 2559, 14, 23, 17, 1, -16 },
  { 2600, 10, 16, 12, 2, -16 },
  { 2620, 11, 16, 13, 1, -16 },
  { 2642, 10, 19, 11, 1, -19 },
  { 2666, 13, 16, 17, 2, -16 },
  { 2692, 15, 16, 15, 0, -16 },
  { 2722, 23, 16, 23, 0, -16 },
  { 2768, 15, 16, 15, 0, -16 },
  { 2798, 15, 23, 15, 0, -16 },
  { 2842, 11, 16, 13, 1, -16 },
  { 2864, 10, 26, 11, 0, -21 },
  { 2897, 3, 29, 15, 6, -22 },
  { 2908, 10, 26, 11, 1, -21 },
  { 2941, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Bold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD29PT7B_H_
