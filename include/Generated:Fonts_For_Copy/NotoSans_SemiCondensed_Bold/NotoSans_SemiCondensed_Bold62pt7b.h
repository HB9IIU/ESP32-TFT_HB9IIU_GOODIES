#ifndef _NOTOSANS_SEMICONDENSED_BOLD62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x1F, 0xC7, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0x1F, 0xC0, 0xE0, 0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF,
  0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0,
  0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF,
  0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0x0F, 0x8F, 0xF8, 0xF0,
  0x10, 0xFF, 0x0F, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x0F,
  0xF8, 0xF0, 0x00, 0xFF, 0xCF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x7F,
  0xE0, 0x00, 0xF3, 0xFE, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0xF1, 0xFF, 0x80,
  0x0F, 0x1F, 0xEE, 0x00, 0xF3, 0xFE, 0xFC, 0x0F, 0x7F, 0xEF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x07,
  0xFF, 0x07, 0xF0, 0xFE, 0x3F, 0x8F, 0xFF, 0xC3, 0xF8, 0xFF, 0x1F, 0xC7,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0x8F, 0xE3, 0xFC, 0x7F, 0x07, 0xFF, 0x87, 0xF1,
  0xFC, 0x3F, 0x81, 0xFF, 0x87, 0xF0, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF8,
  0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x0F,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0xC0,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFC,
  0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xFF,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x9F, 0xF0, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF8, 0xFC,
  0x7E, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x01, 0xF8, 0x06,
  0x7C, 0x1F, 0x83, 0xE7, 0xF9, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x7E, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xF1, 0xFF, 0x3F,
  0xEF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00,
  0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xDF, 0xFD, 0xFF,
  0xFF, 0xDF, 0xF7, 0xFC, 0xFF, 0x9F, 0xC7, 0xFC, 0x7C, 0x3F, 0xE1, 0x81,
  0xFF, 0x08, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x7F, 0xE0,
  0xF8, 0x01, 0xFF, 0x03, 0x80, 0x0F, 0xFC, 0x18, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x7F, 0xE0, 0x60, 0x01, 0xFF, 0x02,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0x00, 0x00, 0x7F, 0xEC, 0x00, 0x07,
  0xFF, 0x7C, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7E, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0x3F, 0xE0,
  0x01, 0xFC, 0x7F, 0xC0, 0x03, 0xF8, 0xFF, 0x80, 0x0F, 0xE1, 0xFF, 0x00,
  0x1F, 0xC3, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x03,
  0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xF0, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xEF, 0xC0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x40, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x78, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xF0, 0x03, 0xFC,
  0x7F, 0xF0, 0x1F, 0xE7, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F,
  0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F,
  0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFB,
  0xFC, 0x0F, 0xFF, 0x9F, 0xE0, 0x3F, 0xF8, 0xFF, 0x00, 0x1E, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE8, 0x00, 0x00, 0x3F, 0x8F,
  0xF9, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xF3, 0xFE, 0x3F, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x1F,
  0xC3, 0xFE, 0x3F, 0xE3, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0xE3, 0xFE, 0x1F,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0xC6,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x0F, 0xC3, 0xF8, 0x0F, 0xFF,
  0xFC, 0x3F, 0x8F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x7F, 0x03, 0xFF, 0xFF,
  0xC1, 0xF9, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0x81, 0xFC,
  0x1F, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x0F,
  0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFF,
  0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xFF,
  0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFB, 0xF0,
  0x3F, 0x00, 0xFE, 0x07, 0xEF, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xBF, 0x83,
  0xF8, 0x1F, 0xF0, 0xFC, 0xFE, 0x0F, 0xF9, 0xFF, 0xEF, 0xF3, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0xFF, 0x7F, 0xFC, 0x1F, 0xC0, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x3F, 0xF3, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x00, 0xFF,
  0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xF8, 0x3F, 0xF8, 0x00, 0x30, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xC3, 0xFF, 0xF0, 0x1F, 0x83,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xC0, 0x07, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xC0, 0x07, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x1F, 0x07, 0xFF, 0x80, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x7F,
  0xC3, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF8,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF9,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xC0, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F,
  0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xFF, 0xF7, 0xF0, 0x00, 0xFE, 0xFF,
  0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xFF, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0xFF,
  0x3F, 0x80, 0x1F, 0xCF, 0xFF, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xFF, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0,
  0x3F, 0x8F, 0xFF, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F,
  0x0F, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F,
  0xFF, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF9, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFF, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xF7, 0xFC, 0x00, 0xFF,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xF0,
  0x0F, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF,
  0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0x01, 0xFF,
  0x0F, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0xF0,
  0x0F, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xCF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF,
  0xFF, 0x00, 0x3F, 0xEF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0xFE, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0x83, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x3F, 0x3F, 0xF0, 0x01, 0x8F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xBF, 0xC0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x1F,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF7, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F,
  0xF0, 0x03, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1,
  0xFC, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x0F, 0xE7, 0xFC, 0x00,
  0x3F, 0xE7, 0xF0, 0x1F, 0xCF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0x9F,
  0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x00,
  0x7F, 0x7F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xF0, 0xFF, 0xE0, 0x78, 0x03, 0xFF, 0x02, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x1F, 0xF7, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFE, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x87, 0xF0, 0x7F,
  0xE0, 0x3F, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF3, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0x7F, 0xF0,
  0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xDF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFE, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF,
  0xF8, 0x7F, 0x8F, 0xFF, 0x83, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1E, 0x3F, 0xF0, 0x01, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x4F, 0xFE, 0x01, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0x80, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x3F, 0xE1,
  0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xBF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x80, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x7F,
  0x83, 0xFF, 0xE1, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xE7,
  0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x02, 0x7F, 0xF0, 0x00, 0xE3, 0xFF, 0xC0,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFE, 0x04, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF,
  0xCF, 0xF1, 0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xF8, 0x3F,
  0xFE, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x00, 0x60, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x40, 0x00, 0x1F, 0xF3, 0xC0, 0x03, 0xFF, 0x9F, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x7F, 0xFE, 0x1F, 0xF7, 0xFF, 0xF8, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF,
  0xF9, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x03,
  0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0x8F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x08, 0x01, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC7, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x07, 0xF0, 0x3F, 0xF0,
  0x3F, 0x87, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFE, 0x7F,
  0xBF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0,
  0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00,
  0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFC, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xC3,
  0xFF, 0xC1, 0xFE, 0x3F, 0xFF, 0x0F, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x3F, 0xF7,
  0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xBF, 0xFF, 0x87, 0xFC, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x01,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0x7F, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0,
  0x7F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFE, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x00, 0x60, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x47, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0x7F, 0xBF, 0xFB, 0xFD,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xBF, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xC0, 0xFC, 0x7F, 0x80, 0x18, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x10, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x18, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xDF, 0xE3, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xC7, 0xF8, 0x1F,
  0xF8, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0,
  0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x9F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xE3, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7E, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xBF, 0x81, 0xFE, 0x07,
  0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xC7, 0xE0, 0xFF, 0x80,
  0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF1, 0xF8, 0x3F, 0xC0,
  0x3F, 0xE3, 0xF8, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFC, 0x7F, 0x1F, 0xF0,
  0x07, 0xF8, 0xFC, 0x1F, 0x8F, 0xF0, 0x03, 0xFC, 0x7E, 0x0F, 0xC7, 0xF8,
  0x01, 0xFE, 0x3F, 0x07, 0xE3, 0xFC, 0x00, 0x7F, 0xBF, 0x83, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xC1, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xC0, 0x7E, 0xFF,
  0x00, 0x0F, 0xF7, 0xE0, 0x3F, 0x7F, 0x80, 0x03, 0xFB, 0xF0, 0x1F, 0xBF,
  0x80, 0x01, 0xFD, 0xF8, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0x3F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xE4, 0x00, 0x03, 0xFC,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 45, 17, 3, -44 },
  { 63, 22, 16, 29, 3, -44 },
  { 107, 35, 44, 37, 1, -44 },
  { 300, 28, 51, 33, 3, -47 },
  { 479, 49, 46, 53, 2, -45 },
  { 761, 40, 46, 42, 2, -45 },
  { 991, 9, 16, 16, 3, -44 },
  { 1009, 16, 54, 20, 3, -44 },
  { 1117, 17, 54, 20, 1, -44 },
  { 1232, 28, 27, 31, 2, -47 },
  { 1327, 29, 30, 33, 2, -37 },
  { 1436, 11, 15, 17, 2, -7 },
  { 1457, 16, 7, 19, 2, -20 },
  { 1471, 11, 11, 17, 3, -10 },
  { 1487, 25, 45, 25, 0, -45 },
  { 1628, 29, 46, 33, 2, -45 },
  { 1795, 21, 44, 33, 3, -44 },
  { 1911, 29, 45, 33, 2, -45 },
  { 2075, 29, 46, 33, 2, -45 },
  { 2242, 31, 44, 33, 1, -44 },
  { 2413, 27, 45, 33, 3, -44 },
  { 2565, 29, 46, 33, 2, -45 },
  { 2732, 29, 44, 33, 2, -44 },
  { 2892, 29, 46, 33, 2, -45 },
  { 3059, 29, 46, 33, 2, -45 },
  { 3226, 11, 35, 17, 3, -34 },
  { 3275, 12, 42, 17, 2, -34 },
  { 3338, 29, 31, 33, 2, -38 },
  { 3451, 29, 18, 33, 2, -31 },
  { 3517, 29, 31, 33, 2, -38 },
  { 3630, 26, 46, 27, 0, -45 },
  { 3780, 46, 50, 52, 3, -45 },
  { 4068, 39, 44, 39, 0, -44 },
  { 4283, 30, 44, 38, 5, -44 },
  { 4448, 31, 46, 36, 3, -45 },
  { 4627, 33, 44, 41, 5, -44 },
  { 4809, 23, 44, 32, 5, -44 },
  { 4936, 23, 44, 31, 5, -44 },
  { 5063, 34, 46, 41, 3, -45 },
  { 5259, 33, 44, 43, 5, -44 },
  { 5441, 19, 44, 22, 2, -44 },
  { 5546, 18, 57, 19, -4, -44 },
  { 5675, 33, 44, 38, 5, -44 },
  { 5857, 25, 44, 31, 5, -44 },
  { 5995, 44, 44, 55, 5, -44 },
  { 6237, 36, 44, 46, 5, -44 },
  { 6435, 38, 46, 45, 3, -45 },
  { 6654, 28, 44, 36, 5, -44 },
  { 6808, 38, 56, 45, 3, -45 },
  { 7074, 32, 44, 37, 5, -44 },
  { 7250, 26, 46, 31, 3, -45 },
  { 7400, 30, 44, 32, 1, -44 },
  { 7565, 33, 45, 43, 5, -44 },
  { 7751, 37, 44, 37, 0, -44 },
  { 7955, 55, 44, 55, 0, -44 },
  { 8258, 37, 44, 37, 0, -44 },
  { 8462, 35, 44, 35, 0, -44 },
  { 8655, 30, 44, 32, 1, -44 },
  { 8820, 15, 54, 20, 4, -44 },
  { 8922, 25, 45, 25, 0, -45 },
  { 9063, 14, 54, 20, 2, -44 },
  { 9158, 32, 28, 35, 1, -44 },
  { 9270, 26, 4, 25, 0, 6 },
  { 9283, 17, 9, 21, 2, -47 },
  { 9303, 28, 35, 34, 2, -34 },
  { 9426, 29, 48, 36, 4, -47 },
  { 9600, 25, 36, 29, 3, -35 },
  { 9713, 29, 48, 36, 3, -47 },
  { 9887, 28, 35, 34, 3, -34 },
  { 10010, 24, 47, 22, 1, -47 },
  { 10151, 29, 50, 36, 3, -35 },
  { 10333, 29, 47, 37, 4, -47 },
  { 10504, 10, 47, 17, 4, -47 },
  { 10563, 16, 62, 17, -3, -47 },
  { 10687, 31, 47, 35, 4, -47 },
  { 10870, 9, 47, 17, 4, -47 },
  { 10923, 47, 35, 55, 4, -35 },
  { 11129, 29, 35, 37, 4, -35 },
  { 11256, 30, 36, 36, 3, -35 },
  { 11391, 29, 50, 36, 4, -35 },
  { 11573, 29, 50, 36, 3, -35 },
  { 11755, 21, 35, 25, 4, -35 },
  { 11847, 24, 36, 28, 2, -35 },
  { 11955, 22, 42, 25, 1, -41 },
  { 12071, 29, 35, 37, 4, -34 },
  { 12198, 32, 34, 32, 0, -34 },
  { 12334, 49, 34, 49, 0, -34 },
  { 12543, 32, 34, 32, 0, -34 },
  { 12679, 32, 49, 32, 0, -34 },
  { 12875, 24, 34, 28, 2, -34 },
  { 12977, 20, 54, 23, 1, -44 },
  { 13112, 7, 61, 32, 12, -47 },
  { 13166, 21, 54, 23, 2, -44 },
  { 13308, 29, 10, 33, 2, -27 },
};

const GFXfont NotoSans_SemiCondensed_Bold62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD62PT7B_H_
