#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_Bold
// Headers: 67

#include "NotoSans_SemiCondensed_Bold6pt7b.h"
#include "NotoSans_SemiCondensed_Bold7pt7b.h"
#include "NotoSans_SemiCondensed_Bold8pt7b.h"
#include "NotoSans_SemiCondensed_Bold9pt7b.h"
#include "NotoSans_SemiCondensed_Bold10pt7b.h"
#include "NotoSans_SemiCondensed_Bold11pt7b.h"
#include "NotoSans_SemiCondensed_Bold12pt7b.h"
#include "NotoSans_SemiCondensed_Bold13pt7b.h"
#include "NotoSans_SemiCondensed_Bold14pt7b.h"
#include "NotoSans_SemiCondensed_Bold15pt7b.h"
#include "NotoSans_SemiCondensed_Bold16pt7b.h"
#include "NotoSans_SemiCondensed_Bold17pt7b.h"
#include "NotoSans_SemiCondensed_Bold18pt7b.h"
#include "NotoSans_SemiCondensed_Bold19pt7b.h"
#include "NotoSans_SemiCondensed_Bold20pt7b.h"
#include "NotoSans_SemiCondensed_Bold21pt7b.h"
#include "NotoSans_SemiCondensed_Bold22pt7b.h"
#include "NotoSans_SemiCondensed_Bold23pt7b.h"
#include "NotoSans_SemiCondensed_Bold24pt7b.h"
#include "NotoSans_SemiCondensed_Bold25pt7b.h"
#include "NotoSans_SemiCondensed_Bold26pt7b.h"
#include "NotoSans_SemiCondensed_Bold27pt7b.h"
#include "NotoSans_SemiCondensed_Bold28pt7b.h"
#include "NotoSans_SemiCondensed_Bold29pt7b.h"
#include "NotoSans_SemiCondensed_Bold30pt7b.h"
#include "NotoSans_SemiCondensed_Bold31pt7b.h"
#include "NotoSans_SemiCondensed_Bold32pt7b.h"
#include "NotoSans_SemiCondensed_Bold33pt7b.h"
#include "NotoSans_SemiCondensed_Bold34pt7b.h"
#include "NotoSans_SemiCondensed_Bold35pt7b.h"
#include "NotoSans_SemiCondensed_Bold36pt7b.h"
#include "NotoSans_SemiCondensed_Bold37pt7b.h"
#include "NotoSans_SemiCondensed_Bold38pt7b.h"
#include "NotoSans_SemiCondensed_Bold39pt7b.h"
#include "NotoSans_SemiCondensed_Bold40pt7b.h"
#include "NotoSans_SemiCondensed_Bold41pt7b.h"
#include "NotoSans_SemiCondensed_Bold42pt7b.h"
#include "NotoSans_SemiCondensed_Bold43pt7b.h"
#include "NotoSans_SemiCondensed_Bold44pt7b.h"
#include "NotoSans_SemiCondensed_Bold45pt7b.h"
#include "NotoSans_SemiCondensed_Bold46pt7b.h"
#include "NotoSans_SemiCondensed_Bold47pt7b.h"
#include "NotoSans_SemiCondensed_Bold48pt7b.h"
#include "NotoSans_SemiCondensed_Bold49pt7b.h"
#include "NotoSans_SemiCondensed_Bold50pt7b.h"
#include "NotoSans_SemiCondensed_Bold51pt7b.h"
#include "NotoSans_SemiCondensed_Bold52pt7b.h"
#include "NotoSans_SemiCondensed_Bold53pt7b.h"
#include "NotoSans_SemiCondensed_Bold54pt7b.h"
#include "NotoSans_SemiCondensed_Bold55pt7b.h"
#include "NotoSans_SemiCondensed_Bold56pt7b.h"
#include "NotoSans_SemiCondensed_Bold57pt7b.h"
#include "NotoSans_SemiCondensed_Bold58pt7b.h"
#include "NotoSans_SemiCondensed_Bold59pt7b.h"
#include "NotoSans_SemiCondensed_Bold60pt7b.h"
#include "NotoSans_SemiCondensed_Bold61pt7b.h"
#include "NotoSans_SemiCondensed_Bold62pt7b.h"
#include "NotoSans_SemiCondensed_Bold63pt7b.h"
#include "NotoSans_SemiCondensed_Bold64pt7b.h"
#include "NotoSans_SemiCondensed_Bold65pt7b.h"
#include "NotoSans_SemiCondensed_Bold66pt7b.h"
#include "NotoSans_SemiCondensed_Bold67pt7b.h"
#include "NotoSans_SemiCondensed_Bold68pt7b.h"
#include "NotoSans_SemiCondensed_Bold69pt7b.h"
#include "NotoSans_SemiCondensed_Bold70pt7b.h"
#include "NotoSans_SemiCondensed_Bold71pt7b.h"
#include "NotoSans_SemiCondensed_Bold72pt7b.h"
