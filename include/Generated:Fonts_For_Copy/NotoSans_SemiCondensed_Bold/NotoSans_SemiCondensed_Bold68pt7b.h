#ifndef _NOTOSANS_SEMICONDENSED_BOLD68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xDF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x83, 0xC0, 0xFF, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81,
  0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01,
  0xFE, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xCF, 0xFE, 0x78, 0x1E,
  0x3F, 0xF1, 0xE0, 0x08, 0xFF, 0x87, 0x80, 0x03, 0xFE, 0x1E, 0x00, 0x0F,
  0xFC, 0x78, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0xFF, 0xE7, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1E, 0x7F, 0xF0,
  0x00, 0x78, 0xFF, 0xC0, 0x01, 0xE1, 0xFF, 0x00, 0x07, 0x87, 0xFC, 0x00,
  0x1E, 0x1F, 0xFC, 0x00, 0x78, 0x7F, 0xFC, 0x01, 0xE3, 0xFF, 0xFE, 0x07,
  0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x83, 0xFF, 0x01, 0xFC, 0x1F, 0xE1, 0xFC,
  0x3F, 0xFF, 0x07, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF, 0xFE, 0x1F, 0xF3, 0xFC,
  0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F,
  0x83, 0xFF, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xFF, 0x87, 0xF8, 0x7F,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE7,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x9F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x40,
  0x0F, 0xE0, 0x08, 0xF8, 0x1F, 0x80, 0xF9, 0xFE, 0x3F, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFB, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xDF, 0xF1, 0xFF, 0x9F,
  0xC3, 0xFF, 0x3F, 0x07, 0xFE, 0x3C, 0x0F, 0xFC, 0x20, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0x00, 0x0F, 0xFC, 0x0E, 0x00, 0x0F,
  0xFE, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC0, 0x3F, 0xFC, 0x1E, 0x00, 0x3F, 0xF8, 0x30, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0x87, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFF, 0x80, 0x00,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0x1F, 0xE7, 0xFE, 0x00,
  0x0F, 0xF1, 0xFF, 0x80, 0x03, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0x07, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x07, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xB8, 0x00, 0x0F, 0xFE, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0x7F, 0xC3, 0xFF, 0x80,
  0x7F, 0xCF, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF, 0xF8,
  0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x07, 0xFE,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xF9, 0xFE,
  0x07, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x18, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1E, 0x0F, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xF8, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0x80, 0x03, 0x80, 0xFF, 0x07, 0xFC, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0x83, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F,
  0xF1, 0xE0, 0x03, 0xFF, 0x18, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xC7, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFF, 0xBF, 0xE0,
  0x7F, 0x3F, 0xC0, 0xFF, 0x81, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xDF, 0xC1, 0xFE, 0x00,
  0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xEF, 0xE0,
  0x7F, 0x00, 0x7F, 0x81, 0xFD, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xBF,
  0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0x9F, 0xC0, 0xFF, 0x01, 0xFF, 0x07,
  0xF3, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xFD,
  0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0x01, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x01, 0xE0, 0x3F, 0xFC,
  0x00, 0x04, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0C, 0x0F, 0xFF, 0xC0,
  0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0x80, 0x03, 0xFF,
  0xCF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xE3, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xF8, 0x00, 0x3C, 0x1F, 0xFF, 0x00,
  0x00, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x03, 0xFF,
  0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x0F, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF8, 0xFF,
  0x80, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0xF0, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF,
  0x80, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x03,
  0xFD, 0xFF, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0xFF, 0x3F, 0xC0, 0x03,
  0xFD, 0xFF, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0xFF, 0x3F, 0xC0, 0x07,
  0xF9, 0xFF, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0xFF, 0x1F, 0xE0, 0x07,
  0xF1, 0xFF, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF1, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F,
  0xE1, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x1F,
  0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x3F,
  0x81, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0x83, 0xFC, 0x7F,
  0x81, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0xFF,
  0x01, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xDF,
  0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0x0F, 0xFF, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFE, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF9, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFF,
  0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xE3, 0xFF, 0x80, 0x3E,
  0x1F, 0xF8, 0x00, 0x31, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x01,
  0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFD, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF3, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03,
  0xFC, 0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0x8F, 0xF0, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x00,
  0x3F, 0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x1F, 0xFC, 0x06, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0x80, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xDF,
  0xFC, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF,
  0xFE, 0x1F, 0xE0, 0x7F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0xFF,
  0x87, 0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF,
  0xBF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xBF, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0xC0, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0x87, 0xFF, 0x00, 0x31, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x06, 0xFF, 0xF0, 0x03,
  0xCF, 0xFF, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0x03, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x1F,
  0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFC, 0x3F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x07,
  0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x47, 0xFF, 0x00, 0x03, 0x0F,
  0xFF, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0x03, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0x07, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF,
  0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFB, 0xFF,
  0x03, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3C, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x30, 0x00, 0x0F, 0xFE,
  0x3E, 0x00, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x7F, 0xC3,
  0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0xE3, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x1E, 0x07,
  0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE0, 0x00, 0x3C,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x8F,
  0xF8, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x3F,
  0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0x9F, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F,
  0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x1F,
  0xFC, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0x1F, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF,
  0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF,
  0x8F, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0x07,
  0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x3F,
  0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFB, 0xFF, 0x03,
  0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1C, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xE7, 0xFC, 0xFF, 0xC0, 0x1E,
  0x7F, 0xC0, 0x03, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x8F, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF,
  0x7F, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xF9, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x81,
  0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0x1F, 0xE1, 0xFF,
  0x00, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xF0, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0xFE, 0x0F,
  0xE3, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x7F, 0x3F, 0xE0, 0x07, 0xFC, 0xFE,
  0x07, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x7F, 0x3F, 0xE0, 0x07, 0xFC,
  0xFE, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x7F, 0x7F, 0xC0, 0x03,
  0xFD, 0xFC, 0x03, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x7F, 0x80,
  0x01, 0xFF, 0xFC, 0x03, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x0F, 0xFE, 0x00, 0x01, 0x3F, 0xFF, 0x80, 0x07,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0xE0, 0x01, 0xFF, 0xFC, 0xC0, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 50, 19, 4, -49 },
  { 70, 24, 18, 32, 4, -49 },
  { 124, 38, 48, 40, 1, -48 },
  { 352, 30, 56, 36, 3, -52 },
  { 562, 54, 50, 58, 2, -49 },
  { 900, 44, 50, 46, 2, -49 },
  { 1175, 10, 18, 17, 4, -49 },
  { 1198, 18, 60, 22, 3, -49 },
  { 1333, 18, 60, 22, 2, -49 },
  { 1468, 31, 31, 34, 2, -52 },
  { 1589, 31, 32, 36, 3, -40 },
  { 1713, 13, 17, 18, 2, -8 },
  { 1741, 17, 8, 21, 2, -22 },
  { 1758, 11, 11, 18, 4, -10 },
  { 1774, 27, 49, 28, 1, -49 },
  { 1940, 32, 50, 36, 2, -49 },
  { 2140, 23, 49, 36, 4, -49 },
  { 2281, 32, 49, 36, 2, -49 },
  { 2477, 31, 50, 36, 2, -49 },
  { 2671, 34, 49, 36, 1, -49 },
  { 2880, 30, 50, 36, 3, -49 },
  { 3068, 32, 50, 36, 2, -49 },
  { 3268, 32, 49, 36, 2, -49 },
  { 3464, 32, 50, 36, 2, -49 },
  { 3664, 32, 50, 36, 2, -49 },
  { 3864, 11, 39, 19, 4, -38 },
  { 3918, 13, 47, 19, 2, -38 },
  { 3995, 32, 35, 36, 2, -42 },
  { 4135, 31, 20, 36, 3, -34 },
  { 4213, 31, 35, 36, 3, -42 },
  { 4349, 28, 50, 30, 0, -49 },
  { 4524, 51, 54, 57, 3, -49 },
  { 4869, 43, 49, 43, 0, -49 },
  { 5133, 34, 49, 42, 5, -49 },
  { 5342, 35, 50, 40, 3, -49 },
  { 5561, 37, 49, 45, 5, -49 },
  { 5788, 25, 49, 35, 6, -49 },
  { 5942, 25, 49, 34, 6, -49 },
  { 6096, 36, 50, 45, 4, -49 },
  { 6321, 36, 49, 48, 6, -49 },
  { 6542, 21, 49, 25, 2, -49 },
  { 6671, 19, 63, 21, -4, -49 },
  { 6821, 36, 49, 41, 6, -49 },
  { 7042, 27, 49, 34, 5, -49 },
  { 7208, 48, 49, 60, 6, -49 },
  { 7502, 39, 49, 51, 6, -49 },
  { 7741, 42, 50, 49, 3, -49 },
  { 8004, 31, 49, 39, 5, -49 },
  { 8194, 42, 61, 49, 3, -49 },
  { 8515, 36, 49, 41, 5, -49 },
  { 8736, 29, 50, 34, 3, -49 },
  { 8918, 33, 49, 36, 1, -49 },
  { 9121, 37, 50, 47, 5, -49 },
  { 9353, 41, 49, 41, 0, -49 },
  { 9605, 61, 49, 60, 0, -49 },
  { 9979, 40, 49, 41, 0, -49 },
  { 10224, 39, 49, 39, 0, -49 },
  { 10463, 33, 49, 35, 1, -49 },
  { 10666, 16, 60, 22, 4, -49 },
  { 10786, 27, 49, 28, 0, -49 },
  { 10952, 16, 60, 22, 2, -49 },
  { 11072, 34, 31, 38, 2, -49 },
  { 11204, 28, 5, 28, 0, 6 },
  { 11222, 18, 11, 23, 3, -52 },
  { 11247, 31, 39, 37, 2, -38 },
  { 11399, 32, 53, 40, 5, -52 },
  { 11611, 27, 39, 32, 3, -38 },
  { 11743, 32, 53, 40, 3, -52 },
  { 11955, 31, 39, 37, 3, -38 },
  { 12107, 26, 52, 24, 1, -52 },
  { 12276, 32, 54, 40, 3, -38 },
  { 12492, 31, 52, 40, 5, -52 },
  { 12694, 11, 52, 19, 4, -52 },
  { 12766, 18, 68, 19, -3, -52 },
  { 12919, 34, 52, 39, 5, -52 },
  { 13140, 9, 52, 19, 5, -52 },
  { 13199, 51, 38, 61, 5, -38 },
  { 13442, 31, 38, 40, 5, -38 },
  { 13590, 33, 39, 39, 3, -38 },
  { 13751, 32, 54, 40, 5, -38 },
  { 13967, 32, 54, 40, 3, -38 },
  { 14183, 22, 38, 28, 5, -38 },
  { 14288, 25, 39, 31, 3, -38 },
  { 14410, 24, 46, 27, 1, -45 },
  { 14548, 32, 38, 40, 4, -37 },
  { 14700, 36, 37, 36, 0, -37 },
  { 14867, 52, 37, 54, 1, -37 },
  { 15108, 35, 37, 35, 0, -37 },
  { 15270, 36, 53, 36, 0, -37 },
  { 15509, 26, 37, 30, 2, -37 },
  { 15630, 22, 60, 26, 1, -49 },
  { 15795, 7, 68, 35, 14, -52 },
  { 15855, 22, 60, 26, 3, -49 },
  { 16020, 32, 12, 36, 2, -30 },
};

const GFXfont NotoSans_SemiCondensed_Bold68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD68PT7B_H_
