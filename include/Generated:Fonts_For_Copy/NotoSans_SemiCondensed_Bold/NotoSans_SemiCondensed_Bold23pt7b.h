#ifndef _NOTOSANS_SEMICONDENSED_BOLD23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x60, 0x2F, 0xFF, 0xF7, 0xE7, 0xE7,
  0x67, 0x63, 0x63, 0x06, 0x70, 0x33, 0x03, 0x98, 0x1C, 0xC7, 0xFF, 0xBF,
  0xFC, 0x33, 0x01, 0x98, 0x1C, 0xC7, 0xFF, 0xFF, 0xFE, 0x33, 0x81, 0x98,
  0x0C, 0xC0, 0xE6, 0x07, 0x70, 0x0C, 0x07, 0xC7, 0xFF, 0xFF, 0xEC, 0xBB,
  0x0F, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x37, 0x8D, 0xFF, 0xFF, 0xF9,
  0xFC, 0x0C, 0x03, 0x00, 0x30, 0x00, 0x1F, 0x07, 0x0F, 0xE1, 0x83, 0x38,
  0xE0, 0xCE, 0x30, 0x33, 0x9C, 0x0C, 0xE6, 0x03, 0x3B, 0xBC, 0xFE, 0xDF,
  0x9F, 0x77, 0x73, 0x19, 0x9C, 0x0E, 0x67, 0x03, 0x19, 0xC1, 0xC6, 0x70,
  0x61, 0xDC, 0x38, 0x7E, 0x1C, 0x0F, 0x00, 0x0E, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x1C,
  0xFE, 0x7B, 0xDE, 0xE7, 0x1F, 0xCE, 0x1F, 0x1E, 0x1E, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x3E, 0xFE, 0xE6, 0x66, 0x1C, 0xE3, 0x1C, 0x73, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0xE1, 0xC7, 0x0E,
  0x38, 0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x71, 0xCE, 0x30,
  0x1C, 0x07, 0x00, 0xC2, 0x33, 0xFF, 0xFF, 0xF1, 0xE0, 0xFC, 0x77, 0x1C,
  0xE1, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x77, 0xEE, 0xEC, 0xFF, 0xFF, 0xC0, 0x2F, 0xFF,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x00, 0x0C, 0x0F, 0xC7, 0xF9,
  0xCF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0x0F, 0x1F, 0x3F, 0xFF, 0x77, 0x47,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1E, 0x1F,
  0xEF, 0xF9, 0x8F, 0x41, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x3F, 0xEF, 0xF9,
  0x8F, 0x01, 0xC0, 0x70, 0x38, 0xFC, 0x3E, 0x0F, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0xFE, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x0D, 0xC1, 0xDC, 0x19, 0xC3, 0x9C, 0x71, 0xC7, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE7, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0xFB, 0xFE, 0x47, 0xC0, 0x70, 0x1C, 0x07, 0x83, 0xFF, 0xFF,
  0xFB, 0xFC, 0x03, 0x87, 0xE3, 0xF9, 0xE0, 0x70, 0x38, 0x0E, 0x73, 0xFE,
  0xFF, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x77, 0xFD, 0xFE, 0x1F, 0x00,
  0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x0C, 0x0F, 0xE7, 0xFF,
  0xC7, 0xE1, 0xFC, 0x77, 0xB8, 0xFE, 0x1E, 0x1F, 0xEF, 0x3F, 0x87, 0xE1,
  0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xCF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF7, 0xDC, 0x07, 0x01, 0xC0, 0xE4,
  0xF9, 0xFC, 0x7E, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x02, 0xFF, 0x70, 0x6F,
  0xF7, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xEC, 0x00, 0x40, 0x70, 0x7C, 0x7C,
  0x7C, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF0, 0x0C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x7C, 0x7E, 0x7C, 0x3C, 0x0C, 0x02, 0x00, 0x1C, 0x1F,
  0xCF, 0xF9, 0x8F, 0x03, 0xC0, 0xF0, 0x38, 0x3C, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x00, 0x02, 0x01, 0xC0, 0xF0, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0xFC,
  0x07, 0xCF, 0x87, 0x00, 0xE3, 0x00, 0x33, 0x9F, 0xDD, 0x9F, 0xE7, 0xCC,
  0x73, 0xEE, 0x39, 0xE7, 0x18, 0xF3, 0x8C, 0x79, 0xC6, 0x7E, 0x7F, 0xF7,
  0x3E, 0xF1, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x18, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x03, 0x9C,
  0x07, 0x3C, 0x0E, 0x38, 0x3C, 0x70, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7,
  0x83, 0x8E, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xFF, 0x9F, 0xFB, 0x8F, 0xF0,
  0xFE, 0x1F, 0xC3, 0xBF, 0xF7, 0xF8, 0xFF, 0xDC, 0x3F, 0x83, 0xF0, 0x7E,
  0x1F, 0xFF, 0xFF, 0xF7, 0xF8, 0x03, 0x81, 0xFF, 0x3F, 0xE7, 0xC6, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x81, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0xE3, 0xEE,
  0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0xFD, 0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0xFF, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x7F, 0xCF, 0xFC,
  0x78, 0x67, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE0, 0xF7, 0x07, 0xBC, 0x3C, 0xFF, 0xE7, 0xFF, 0x0F, 0xF0, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF,
  0xFD, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F,
  0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0xFF, 0xEF, 0x00, 0xE0, 0xFE, 0x1E, 0xE3,
  0xCE, 0x38, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFF, 0x0F, 0x70, 0xE7,
  0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xEC, 0x37, 0xEE, 0x77, 0xEE, 0x77, 0xE6, 0x67, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xF0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xF7, 0x1F, 0xBC, 0xFC, 0xE7, 0xE7,
  0xBF, 0x1D, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xE1,
  0xE3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0x3F, 0xEE, 0x7F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3F, 0xFF, 0xFF, 0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70,
  0x3D, 0xE1, 0xE3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0xFF, 0x8F, 0xFC, 0xE3, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE3, 0xCF, 0xF8, 0xFF, 0x0F, 0xF0, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1C,
  0xE1, 0xEE, 0x0F, 0x0E, 0x0F, 0xF7, 0xFB, 0xC6, 0xE0, 0x38, 0x0F, 0x01,
  0xF0, 0x3F, 0x07, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xFF, 0xFB, 0xFE, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0xFE, 0x7F, 0xE3,
  0xF8, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x38, 0x70, 0xE1, 0xC3,
  0x8F, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0xF0, 0x7F, 0x0F, 0x07, 0x70, 0xF0,
  0x77, 0x0F, 0x8F, 0x70, 0xF8, 0xE7, 0x1F, 0x8E, 0x39, 0xD8, 0xE3, 0x9D,
  0xDE, 0x39, 0x9D, 0xC3, 0xB9, 0xDC, 0x3B, 0x8D, 0xC1, 0xF8, 0xDC, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x78, 0xF8, 0x79, 0xE1,
  0xC3, 0xCF, 0x07, 0x38, 0x1F, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x0F,
  0x80, 0x3F, 0x01, 0xFC, 0x07, 0x38, 0x3C, 0xF1, 0xE1, 0xC7, 0x87, 0xBC,
  0x0F, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0x71, 0xC3, 0xDE, 0x0E, 0xE0, 0x7F,
  0x01, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0xFF, 0xFF, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF,
  0xF0, 0x0C, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xB8, 0x67, 0x1C, 0x73, 0x0E,
  0xE0, 0xF8, 0x1C, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x87, 0x1F, 0x1F, 0xE7,
  0xFC, 0x87, 0x01, 0xC7, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7F, 0x3F, 0xFF,
  0x7C, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3F, 0xEF, 0xFF, 0xCF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFE, 0xCF, 0x00,
  0x0F, 0x1F, 0xDF, 0xEE, 0x1F, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x1F,
  0xEF, 0xF1, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0xCE, 0xFD, 0xDF,
  0xFF, 0x8F, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xDE, 0xFB,
  0xFF, 0x3E, 0xE0, 0x0E, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xE3, 0x3F, 0xE1, 0xFC, 0x07, 0x0F, 0xCF,
  0xE7, 0x83, 0x81, 0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1C, 0xEF, 0xDD, 0xFF, 0xF8, 0xFF,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xEF, 0xBF, 0x73, 0xEE,
  0x01, 0xC0, 0x7A, 0x1E, 0x7F, 0xCF, 0xF0, 0x20, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE7, 0x3F, 0xEF, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x27, 0xF6, 0x07, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x08, 0x73, 0xC6, 0x00, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3F, 0xEF, 0x90, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x1F, 0xC7, 0xB8, 0xE7, 0x38, 0xEF, 0x1F, 0xC3,
  0xF8, 0x7F, 0x8F, 0x71, 0xCF, 0x38, 0xF7, 0x0E, 0xE1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xCF, 0x1E, 0x6F, 0xDF, 0xBF, 0xFF, 0xFE,
  0x7C, 0xFE, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3,
  0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x38, 0xCF, 0x37, 0xEF,
  0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xC0, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xF0, 0xFE, 0x3D, 0xEF, 0x1F, 0xE1, 0xF8, 0xC7, 0x3F, 0xEF, 0xFF,
  0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFE, 0xEF,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1C, 0xEF, 0xDD, 0xFF,
  0xF8, 0xFF, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xEF, 0xBF,
  0x73, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xC7,
  0xBF, 0xFF, 0xDE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x3E,
  0x3F, 0xBF, 0xDC, 0x2F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0x83, 0xF1, 0xDF,
  0xEF, 0xE0, 0x18, 0x38, 0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x3D, 0x3F, 0x1F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xEE, 0x3D, 0xFF, 0xBF, 0xF3, 0xEE, 0xE0,
  0x7F, 0x0F, 0x70, 0xE7, 0x0E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xE1, 0xE1, 0xFC, 0x78, 0x77,
  0x1E, 0x39, 0xC7, 0xCE, 0x73, 0xF3, 0x8E, 0xEC, 0xE3, 0xB3, 0x70, 0xEC,
  0xDC, 0x3B, 0x3F, 0x07, 0xCF, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x00, 0xF0, 0xF7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x01,
  0xF8, 0x1F, 0x83, 0xFC, 0x39, 0xC7, 0x9E, 0xF0, 0xF0, 0xF0, 0x7F, 0x0F,
  0x70, 0xE7, 0x0E, 0x79, 0xE3, 0x9C, 0x39, 0xC1, 0xDC, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x7C, 0x07, 0x80,
  0x20, 0x00, 0xFF, 0x7F, 0xBF, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78,
  0x38, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0xFC, 0xF0, 0xF8, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xF1, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x3E, 0x1C, 0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xF3, 0xC6,
  0x00, 0x78, 0x7F, 0xFD, 0xFE, 0x0E,
};

const GFXglyph NotoSans_SemiCondensed_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 11, 1, -16 },
  { 15, 13, 16, 14, 0, -16 },
  { 41, 10, 18, 12, 1, -17 },
  { 64, 18, 17, 20, 1, -17 },
  { 103, 15, 17, 16, 1, -17 },
  { 135, 4, 6, 6, 1, -16 },
  { 138, 6, 20, 8, 1, -16 },
  { 153, 6, 20, 8, 1, -16 },
  { 168, 10, 11, 12, 1, -18 },
  { 182, 10, 11, 12, 1, -14 },
  { 196, 4, 6, 6, 1, -3 },
  { 199, 6, 3, 7, 1, -8 },
  { 202, 4, 4, 6, 1, -4 },
  { 204, 9, 17, 9, 0, -17 },
  { 224, 10, 17, 12, 1, -17 },
  { 246, 8, 16, 12, 1, -16 },
  { 262, 10, 17, 12, 1, -17 },
  { 284, 10, 17, 12, 1, -17 },
  { 306, 12, 16, 12, 0, -16 },
  { 330, 10, 16, 12, 1, -16 },
  { 350, 10, 17, 12, 1, -17 },
  { 372, 10, 16, 12, 1, -16 },
  { 392, 10, 17, 12, 1, -17 },
  { 414, 10, 17, 12, 1, -17 },
  { 436, 4, 13, 6, 1, -13 },
  { 443, 4, 16, 6, 1, -13 },
  { 451, 10, 12, 12, 1, -14 },
  { 466, 10, 7, 12, 1, -12 },
  { 475, 10, 12, 12, 1, -14 },
  { 490, 10, 17, 10, 0, -17 },
  { 512, 17, 19, 19, 1, -17 },
  { 553, 15, 16, 15, 0, -16 },
  { 583, 11, 16, 14, 2, -16 },
  { 605, 12, 17, 13, 1, -17 },
  { 631, 12, 16, 15, 2, -16 },
  { 655, 9, 16, 12, 2, -16 },
  { 673, 9, 16, 12, 2, -16 },
  { 691, 13, 17, 15, 1, -17 },
  { 719, 12, 16, 16, 2, -16 },
  { 743, 7, 16, 8, 1, -16 },
  { 757, 7, 21, 7, -2, -16 },
  { 776, 12, 16, 14, 2, -16 },
  { 800, 9, 16, 12, 2, -16 },
  { 818, 16, 16, 20, 2, -16 },
  { 850, 13, 16, 17, 2, -16 },
  { 876, 14, 17, 17, 1, -17 },
  { 906, 10, 16, 13, 2, -16 },
  { 926, 14, 21, 17, 1, -17 },
  { 963, 12, 16, 14, 2, -16 },
  { 987, 10, 17, 12, 1, -17 },
  { 1009, 12, 16, 12, 0, -16 },
  { 1033, 12, 16, 16, 2, -16 },
  { 1057, 14, 16, 14, 0, -16 },
  { 1085, 20, 16, 20, 0, -16 },
  { 1125, 14, 16, 14, 0, -16 },
  { 1153, 13, 16, 13, 0, -16 },
  { 1179, 11, 16, 12, 0, -16 },
  { 1201, 6, 20, 7, 1, -16 },
  { 1216, 9, 17, 9, 0, -17 },
  { 1236, 5, 20, 7, 1, -16 },
  { 1249, 11, 10, 13, 1, -16 },
  { 1263, 9, 2, 9, 0, 2 },
  { 1266, 6, 4, 8, 1, -18 },
  { 1269, 10, 13, 13, 1, -13 },
  { 1286, 10, 17, 13, 2, -17 },
  { 1308, 9, 13, 11, 1, -13 },
  { 1323, 11, 17, 13, 1, -17 },
  { 1347, 11, 13, 13, 1, -13 },
  { 1365, 9, 18, 8, 0, -18 },
  { 1386, 11, 19, 13, 1, -13 },
  { 1413, 10, 17, 14, 2, -17 },
  { 1435, 4, 18, 6, 1, -18 },
  { 1444, 6, 24, 6, -1, -18 },
  { 1462, 11, 17, 13, 2, -17 },
  { 1486, 3, 17, 6, 2, -17 },
  { 1493, 17, 13, 21, 2, -13 },
  { 1521, 10, 13, 14, 2, -13 },
  { 1538, 11, 13, 13, 1, -13 },
  { 1556, 10, 19, 13, 2, -13 },
  { 1580, 11, 19, 13, 1, -13 },
  { 1607, 7, 13, 9, 2, -13 },
  { 1619, 9, 13, 10, 1, -13 },
  { 1634, 8, 15, 9, 0, -15 },
  { 1649, 11, 13, 14, 1, -13 },
  { 1667, 12, 13, 12, 0, -13 },
  { 1687, 18, 13, 18, 0, -13 },
  { 1717, 12, 13, 12, 0, -13 },
  { 1737, 12, 19, 12, 0, -13 },
  { 1766, 9, 13, 10, 1, -13 },
  { 1781, 8, 20, 9, 0, -16 },
  { 1801, 2, 22, 12, 5, -17 },
  { 1807, 7, 20, 9, 1, -16 },
  { 1825, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Bold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD23PT7B_H_
