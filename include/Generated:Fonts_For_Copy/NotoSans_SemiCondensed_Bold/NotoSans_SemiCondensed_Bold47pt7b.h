#ifndef _NOTOSANS_SEMICONDENSED_BOLD47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x18,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E,
  0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x07, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81,
  0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0x9F, 0x3F, 0x9C, 0x19, 0xFC, 0xE0,
  0x0F, 0xE7, 0x00, 0x7F, 0x38, 0x03, 0xFD, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0E, 0xFF, 0x00, 0x73, 0xF8, 0x03,
  0x8F, 0xE0, 0x1C, 0x7F, 0xC0, 0xE7, 0xFF, 0xC7, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x01,
  0xF1, 0xF8, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x1F, 0x0F, 0x81,
  0xF0, 0x00, 0xFC, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x3E, 0x00, 0x0F,
  0xC3, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0xF8, 0x18, 0x07, 0xC3, 0xE3, 0xE3, 0xFC, 0x1F,
  0x1F, 0x9F, 0x1F, 0xF8, 0x7F, 0xFC, 0x7C, 0xFF, 0xF0, 0xFF, 0xF3, 0xE3,
  0xFF, 0xE1, 0xFF, 0x8F, 0x9F, 0x9F, 0x83, 0xFC, 0x7C, 0x7C, 0x3E, 0x07,
  0xE1, 0xF1, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xC3, 0xF0, 0x00, 0x3E, 0x1F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x00,
  0x3F, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0x7C,
  0x3E, 0x00, 0x1F, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x03, 0xE7, 0xE0, 0x03,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x7F, 0xF8,
  0x1F, 0xC3, 0xFF, 0xF0, 0x7F, 0x1F, 0xFF, 0xE1, 0xFC, 0xFF, 0x3F, 0xCF,
  0xE3, 0xF8, 0x7F, 0x3F, 0x8F, 0xE0, 0xFE, 0xFE, 0x3F, 0x83, 0xFF, 0xF0,
  0xFE, 0x07, 0xFF, 0xC3, 0xF8, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xCF, 0xF8, 0x1F, 0xFC,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78,
  0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0x07, 0x83, 0x9F,
  0x9E, 0x7E, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFD, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x01, 0xC1, 0xE0, 0x01,
  0x02, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x18, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0xFF, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFC, 0xFD, 0xF1, 0xFB, 0xC3, 0xF3, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xF8, 0x3F, 0xC7, 0x00,
  0xFE, 0x10, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xE0, 0x3F, 0xC4, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x81, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x07,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x86, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFD, 0x80, 0x1F, 0xEF, 0xC3, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x7E, 0x7F,
  0xC3, 0xF7, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xFE,
  0x07, 0xF7, 0xF8, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xF0, 0x3F, 0x9F,
  0xC0, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0,
  0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xC7, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xFD,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE,
  0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x87,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x0F, 0xFC, 0xFC,
  0x1F, 0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xC0,
  0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x38, 0x0F,
  0xE2, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0x83, 0xE0, 0x3F, 0xE0, 0xF8, 0xF8, 0x1F, 0xFF, 0x1F, 0x1F,
  0x07, 0xFF, 0xE3, 0xE7, 0xC1, 0xFF, 0xFC, 0x3E, 0xF8, 0x7F, 0x0F, 0x87,
  0xDF, 0x0F, 0x81, 0xF0, 0xFF, 0xC3, 0xF0, 0x3E, 0x1F, 0xF8, 0x7C, 0x07,
  0xC3, 0xFF, 0x0F, 0x80, 0xF8, 0x7F, 0xE1, 0xF0, 0x3F, 0x0F, 0xFC, 0x3E,
  0x07, 0xE1, 0xFF, 0x87, 0xC0, 0xF8, 0x3F, 0xF0, 0xF8, 0x1F, 0x07, 0xFE,
  0x1F, 0x03, 0xE1, 0xF7, 0xC3, 0xF0, 0xFE, 0x3E, 0xF8, 0x3F, 0x3F, 0xEF,
  0x8F, 0x87, 0xFF, 0xFF, 0xF1, 0xF0, 0x7F, 0xE7, 0xFC, 0x3E, 0x07, 0xF8,
  0x7F, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0xE0, 0x00,
  0xFF, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0xFF, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0x81, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE7, 0xF0, 0x7F, 0xCF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7,
  0xF0, 0x1F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x1C, 0x3F, 0xE0, 0x04, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x06, 0x1F, 0xFC, 0x7E, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0xF9,
  0xFC, 0x07, 0xFC, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x7F, 0x9F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC0, 0x38, 0x7F, 0x80, 0x04, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFF,
  0x87, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xC3, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x07,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F,
  0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFB, 0xF8, 0x07, 0xF1, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xDF, 0x00, 0x7F, 0xFF, 0xF7, 0xC0, 0x1F, 0x7F, 0xFD, 0xF8, 0x0F,
  0xDF, 0xFF, 0x7E, 0x03, 0xF7, 0xFF, 0xCF, 0x80, 0xF9, 0xFF, 0xF3, 0xF0,
  0x3E, 0x7F, 0xFC, 0xFC, 0x1F, 0x9F, 0xFF, 0x1F, 0x07, 0xC7, 0xFF, 0xC7,
  0xC1, 0xF1, 0xFF, 0xF1, 0xF8, 0xFC, 0x7F, 0xFC, 0x7E, 0x3E, 0x1F, 0xFF,
  0x0F, 0x8F, 0x87, 0xFF, 0xC3, 0xF7, 0xE1, 0xFF, 0xF0, 0xFD, 0xF0, 0x7F,
  0xFC, 0x1F, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFE, 0x03, 0xFF,
  0xCF, 0xE0, 0x7F, 0xF9, 0xFC, 0x0F, 0xFF, 0x1F, 0xC1, 0xFF, 0xE3, 0xF8,
  0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0x7F, 0x1F, 0xFE,
  0x0F, 0xE3, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x1F, 0xCF, 0xFF, 0x01, 0xFD,
  0xFF, 0xE0, 0x3F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF8, 0x7F,
  0xDF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0,
  0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x03, 0xCF, 0xE0, 0x04, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0, 0x1F, 0xE7, 0xFE, 0x3F,
  0xF3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFE, 0x00,
  0xFE, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x3F, 0x00,
  0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xDF, 0x81, 0xF8, 0x1F, 0x81, 0xF7, 0xE0, 0xFE,
  0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x3E, 0x0F, 0xE0, 0x7F,
  0x0F, 0xCF, 0x83, 0xF0, 0x0F, 0xC3, 0xF3, 0xF0, 0xFC, 0x03, 0xF0, 0xF8,
  0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x1F, 0x1F, 0xC0, 0x3F, 0x9F, 0x87, 0xC7,
  0xE0, 0x0F, 0xE7, 0xE1, 0xF9, 0xF8, 0x01, 0xF9, 0xF0, 0x7E, 0x7E, 0x00,
  0x7E, 0x7C, 0x1F, 0xBF, 0x80, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0x07, 0xEF,
  0xC0, 0xFB, 0xF0, 0x00, 0xFF, 0xE0, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF,
  0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3,
  0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x0F,
  0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0x03, 0xF8, 0x20, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xBF, 0x3F, 0xF9, 0xF8, 0xFF, 0x07, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xF0, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xF3, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0xCF, 0xCF, 0xFE, 0x3F, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xCF, 0x9F, 0xE0, 0x23, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x27,
  0xFC, 0x1C, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0xC3, 0xFF, 0x3F, 0x1F,
  0xFE, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xF3, 0xFF, 0x7F, 0x83,
  0xFD, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07,
  0xF7, 0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF0,
  0xFF, 0xCF, 0xC1, 0xFE, 0x1F, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x02,
  0x7F, 0x80, 0x30, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x7C, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x3F, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x0F, 0xFC, 0xFC, 0x1F,
  0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF6, 0x00, 0x3F, 0xDF, 0x83, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE3, 0xF8, 0x3F, 0x9F, 0xF8, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFB, 0xFE, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x39,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0xFF, 0xFF, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xCF, 0xFE, 0x1F, 0xF8, 0xFD,
  0xFF, 0xF3, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0xFF, 0xFB, 0xFE, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xC0, 0x7F, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF8,
  0x3F, 0x83, 0xF3, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0x7F, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xBF, 0xEF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x00,
  0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x87,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFC, 0x3F, 0x83, 0xF1, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0x3F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0xFF, 0xE3, 0xF9,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x3F,
  0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x3F,
  0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xBF, 0x0F, 0xFC, 0xFC, 0x1F, 0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFD, 0xFE, 0xFD, 0xFE,
  0xFF, 0xFE, 0xFF, 0xF6, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0x81, 0xCF, 0xC0, 0x13, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE1, 0x1F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xBF, 0x1F, 0xFC, 0xFC, 0x3F, 0xE3, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFB, 0xF0, 0x0F,
  0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x80, 0xFC, 0xFE, 0x07, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0xE0, 0x7F, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0xFC, 0x1F, 0x7C,
  0x1F, 0x87, 0xF0, 0xFB, 0xE1, 0xFC, 0x1F, 0x87, 0xDF, 0x0F, 0xE0, 0xFC,
  0x3E, 0xF8, 0x7E, 0x07, 0xE1, 0xE3, 0xE3, 0xF0, 0x3F, 0x9F, 0x1F, 0x1F,
  0x80, 0xFC, 0xF8, 0xF9, 0xFC, 0x07, 0xE7, 0xC7, 0xCF, 0xC0, 0x3F, 0x3E,
  0x1E, 0x7E, 0x01, 0xF9, 0xE0, 0xF3, 0xF0, 0x07, 0xFF, 0x07, 0xDF, 0x80,
  0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0xC3, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE3, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x8F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02,
  0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC3, 0xFF, 0x07, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFF,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Bold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 35, 13, 2, -34 },
  { 36, 16, 13, 22, 3, -34 },
  { 62, 26, 34, 28, 1, -34 },
  { 173, 21, 39, 25, 2, -36 },
  { 276, 38, 34, 40, 1, -34 },
  { 438, 30, 34, 32, 2, -34 },
  { 566, 6, 13, 12, 3, -34 },
  { 576, 12, 41, 16, 2, -34 },
  { 638, 12, 41, 16, 1, -34 },
  { 700, 22, 21, 24, 1, -36 },
  { 758, 21, 23, 25, 2, -28 },
  { 819, 9, 11, 13, 1, -5 },
  { 832, 12, 6, 15, 1, -16 },
  { 841, 8, 8, 13, 2, -7 },
  { 849, 19, 34, 19, 0, -34 },
  { 930, 21, 34, 25, 2, -34 },
  { 1020, 15, 34, 25, 3, -34 },
  { 1084, 21, 34, 25, 2, -34 },
  { 1174, 21, 34, 25, 2, -34 },
  { 1264, 23, 34, 25, 1, -34 },
  { 1362, 21, 34, 25, 2, -34 },
  { 1452, 21, 34, 25, 2, -34 },
  { 1542, 22, 34, 25, 1, -34 },
  { 1636, 22, 34, 25, 1, -34 },
  { 1730, 22, 34, 25, 1, -34 },
  { 1824, 7, 27, 13, 3, -26 },
  { 1848, 9, 32, 13, 1, -26 },
  { 1884, 21, 24, 25, 2, -29 },
  { 1947, 21, 14, 25, 2, -24 },
  { 1984, 21, 24, 25, 2, -29 },
  { 2047, 20, 35, 21, 0, -34 },
  { 2135, 35, 38, 39, 2, -34 },
  { 2302, 30, 34, 30, 0, -34 },
  { 2430, 23, 34, 29, 4, -34 },
  { 2528, 24, 34, 27, 2, -34 },
  { 2630, 25, 34, 31, 4, -34 },
  { 2737, 18, 34, 24, 4, -34 },
  { 2814, 17, 34, 24, 4, -34 },
  { 2887, 25, 34, 31, 3, -34 },
  { 2994, 25, 34, 33, 4, -34 },
  { 3101, 15, 34, 17, 1, -34 },
  { 3165, 14, 44, 15, -3, -34 },
  { 3242, 25, 34, 29, 4, -34 },
  { 3349, 18, 34, 24, 4, -34 },
  { 3426, 34, 34, 41, 4, -34 },
  { 3571, 27, 34, 35, 4, -34 },
  { 3686, 29, 34, 34, 2, -34 },
  { 3810, 21, 34, 27, 4, -34 },
  { 3900, 29, 42, 34, 2, -34 },
  { 4053, 24, 34, 28, 4, -34 },
  { 4155, 20, 34, 24, 2, -34 },
  { 4240, 23, 34, 25, 1, -34 },
  { 4338, 25, 34, 32, 4, -34 },
  { 4445, 28, 34, 28, 0, -34 },
  { 4564, 42, 34, 42, 0, -34 },
  { 4743, 28, 34, 28, 0, -34 },
  { 4862, 27, 34, 27, 0, -34 },
  { 4977, 22, 34, 24, 1, -34 },
  { 5071, 11, 41, 15, 3, -34 },
  { 5128, 19, 34, 19, 0, -34 },
  { 5209, 11, 41, 15, 1, -34 },
  { 5266, 24, 22, 26, 1, -34 },
  { 5332, 19, 3, 19, 0, 4 },
  { 5340, 12, 8, 16, 2, -36 },
  { 5352, 21, 26, 26, 2, -26 },
  { 5421, 22, 36, 27, 3, -36 },
  { 5520, 19, 26, 22, 2, -26 },
  { 5582, 22, 36, 27, 2, -36 },
  { 5681, 22, 26, 26, 2, -26 },
  { 5753, 18, 36, 17, 1, -36 },
  { 5834, 22, 37, 27, 2, -26 },
  { 5936, 22, 36, 28, 3, -36 },
  { 6035, 7, 36, 13, 3, -36 },
  { 6067, 12, 47, 13, -2, -36 },
  { 6138, 24, 36, 27, 3, -36 },
  { 6246, 7, 36, 13, 3, -36 },
  { 6278, 36, 26, 42, 3, -26 },
  { 6395, 22, 26, 28, 3, -26 },
  { 6467, 23, 26, 27, 2, -26 },
  { 6542, 22, 37, 27, 3, -26 },
  { 6644, 22, 37, 27, 2, -26 },
  { 6746, 16, 26, 19, 3, -26 },
  { 6798, 18, 26, 21, 2, -26 },
  { 6857, 16, 31, 19, 1, -31 },
  { 6919, 22, 26, 28, 3, -26 },
  { 6991, 25, 26, 25, 0, -26 },
  { 7073, 37, 26, 37, 0, -26 },
  { 7194, 24, 26, 24, 0, -26 },
  { 7272, 25, 37, 25, 0, -26 },
  { 7388, 19, 26, 21, 1, -26 },
  { 7450, 15, 41, 18, 1, -34 },
  { 7527, 6, 47, 24, 9, -36 },
  { 7563, 15, 41, 18, 2, -34 },
  { 7640, 21, 7, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Bold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD47PT7B_H_
