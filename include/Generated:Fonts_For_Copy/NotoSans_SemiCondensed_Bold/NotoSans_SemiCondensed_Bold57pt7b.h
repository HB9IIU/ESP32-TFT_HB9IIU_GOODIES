#ifndef _NOTOSANS_SEMICONDENSED_BOLD57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x06,
  0x00, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0x38, 0x3C, 0x7F, 0x8E, 0x02, 0x1F, 0xC3, 0x80, 0x07, 0xF0, 0xE0, 0x01,
  0xFE, 0x38, 0x00, 0x7F, 0xCE, 0x00, 0x1F, 0xFB, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3B, 0xFF, 0x00, 0x0E, 0x7F, 0xC0, 0x03, 0x8F,
  0xF0, 0x00, 0xE3, 0xFE, 0x00, 0x38, 0xFF, 0xF0, 0x0E, 0x3F, 0xFF, 0x83,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0xC7, 0xE0, 0x7E, 0x07, 0xF0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x87,
  0xE3, 0xF8, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x8F, 0xC7, 0xFF, 0xF8, 0x7F, 0xF8, 0xFE,
  0x7F, 0x0F, 0xC1, 0xFF, 0x87, 0xE3, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0x1F,
  0x83, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xE0,
  0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x00,
  0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0xFC, 0x01, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xCF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F,
  0xF3, 0xFC, 0x3F, 0xE0, 0xFF, 0xBF, 0xE1, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x02,
  0x01, 0xF0, 0x08, 0xF0, 0x7C, 0x1E, 0x7F, 0x9F, 0x3F, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F, 0xC0, 0x07, 0x01, 0xC0, 0x00, 0x40,
  0x40, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8,
  0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x7F, 0x06, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xCF, 0xF7,
  0xF1, 0xFE, 0x7C, 0x3F, 0xC7, 0x07, 0xF8, 0x40, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xFE, 0x3E,
  0x00, 0xFF, 0x87, 0x00, 0x1F, 0xE0, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x78, 0x07,
  0xFE, 0x18, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xEF, 0xE0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x7E,
  0xFF, 0x00, 0x0F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0x8F, 0xF0,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x0F, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0xFF,
  0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x60, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x80, 0x01, 0xFF, 0x70,
  0x01, 0xFF, 0xBF, 0x83, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x10, 0x01, 0xFC, 0x7F, 0xE0, 0xFF, 0x3F, 0xFC, 0x3F,
  0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFC, 0x3F, 0xE1,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0xFF,
  0x80, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFC,
  0x7F, 0xFF, 0x7F, 0x1F, 0xFF, 0xBF, 0xC1, 0xFF, 0xCF, 0xF0, 0x1F, 0x83,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x82,
  0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0xFE, 0x0C, 0x00, 0x06, 0x07, 0xF0, 0xFF, 0x3F, 0xE7, 0xFE, 0xFF,
  0xDF, 0xF1, 0xFE, 0x3F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3E, 0x01, 0xFF, 0x18, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x20, 0x03, 0xF0, 0xFE, 0x01, 0xFF, 0xE0,
  0xFC, 0x3F, 0x01, 0xFF, 0xFE, 0x1F, 0x9F, 0xC0, 0xFF, 0xFF, 0x87, 0xE7,
  0xE0, 0x7F, 0xFF, 0xE1, 0xF9, 0xF8, 0x3F, 0xF3, 0xF8, 0x3F, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xFF, 0x07, 0xF0, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x0F,
  0xE0, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xFF, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0xC3, 0xF0, 0x0F, 0xC0, 0xFF, 0xF0,
  0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0x0F, 0xC0,
  0x3F, 0x03, 0xEF, 0xC3, 0xF8, 0x0F, 0xC1, 0xFB, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0xFC, 0x1F, 0xC1, 0xFE, 0x3F, 0x3F, 0x07, 0xF9, 0xFF, 0xDF, 0xCF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0xFE, 0x7F, 0xF8, 0x7E, 0x07,
  0xFF, 0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x03, 0x00,
  0x0C, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF,
  0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07,
  0xFC, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x7C, 0x1F, 0xF8,
  0x00, 0x41, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x20, 0xFF, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xF8, 0xFF, 0x80, 0x3F,
  0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x03,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3C,
  0x1F, 0xFC, 0x00, 0x10, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x3F, 0xDF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x3F, 0xF0, 0x01,
  0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0x7F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFE,
  0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF4, 0x1F, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC, 0xFF, 0x00,
  0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x7F, 0xE0, 0x0F,
  0xF1, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC,
  0x03, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF8, 0xFF, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x03,
  0xFE, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x7F, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0xFE, 0xFE, 0x00, 0x7E, 0x7F, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x00,
  0xFC, 0x7F, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7F, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xFE, 0x0F, 0xE7, 0xE0, 0x7F, 0xFE,
  0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0xF7, 0xFC,
  0x03, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFE, 0x3F,
  0xC0, 0x7F, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xF8,
  0x1F, 0xF1, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0xFF,
  0x01, 0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF,
  0xE0, 0x0F, 0xFB, 0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F,
  0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE,
  0x03, 0xFF, 0x7F, 0xC3, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE,
  0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0xFC,
  0x7F, 0xC0, 0x0C, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF,
  0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0A, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x7E, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xF9, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x3F, 0x81,
  0xFE, 0x01, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x7E,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF1,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x3F,
  0x87, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC0, 0x07, 0xF8,
  0xFE, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x1F, 0x81, 0xFC, 0xFF, 0x00, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0xFE, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0xDF, 0xC0, 0x7E, 0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0x7E, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0,
  0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1C, 0x03, 0xFE, 0x04, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xCF,
  0xFF, 0xE7, 0xF1, 0xFF, 0xF1, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x81, 0xE0, 0x0F, 0xF1, 0xFF, 0x81, 0xFE, 0x7F, 0xF8,
  0x3F, 0xDF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0x87, 0xFE, 0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x7F,
  0xE0, 0x7F, 0xEF, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFE, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0x83, 0xF0,
  0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFC, 0x1E, 0x3F, 0xE0, 0x08, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0x3F, 0xE0, 0x06, 0x7F, 0xF0, 0x7C, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3E, 0x0F, 0xF0, 0x3F, 0xF1,
  0xFE, 0x0F, 0xFF, 0x3F, 0xC3, 0xFF, 0xF3, 0xF8, 0xFF, 0xFF, 0x7F, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xBF, 0xF0, 0x1F,
  0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xDF, 0xE0,
  0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x1F, 0xF3, 0xFF, 0x0F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xCF, 0xE0,
  0xFF, 0xF1, 0xFC, 0x07, 0xFC, 0x1F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xE1, 0xFF, 0x03,
  0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x87, 0xFE,
  0x00, 0x70, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0x0C,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x1F, 0xFF,
  0x3F, 0x87, 0xFF, 0xF7, 0xF1, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x07,
  0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF,
  0x7F, 0xE0, 0x3F, 0xE7, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xC1, 0xFF, 0xE7, 0xF8,
  0x0F, 0xF8, 0xFF, 0x00, 0x18, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x60, 0x00, 0xFF, 0xCF,
  0x80, 0x3F, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x07, 0x00, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xFF,
  0x8F, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F,
  0xFC, 0x7F, 0xF0, 0x3E, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xC0, 0x1F, 0xF9, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xFC,
  0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01,
  0xFF, 0xBF, 0xC0, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x83, 0xFF, 0x01, 0xFF, 0xC3, 0xF9,
  0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0x07, 0xFF, 0x0F, 0xE3,
  0xFF, 0xE3, 0xF9, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFC, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F,
  0xC3, 0xFF, 0x03, 0xF8, 0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0x0F, 0xEF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x07, 0xFC, 0xFF,
  0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xE0,
  0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xFE, 0x3F, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFE, 0xFF,
  0xFC, 0x3F, 0xCF, 0xFF, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x03, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0xE1, 0xFC, 0x1F, 0xFF, 0x3F, 0x87, 0xFF, 0xF7, 0xF1, 0xFF, 0xFE,
  0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0x83, 0xFF, 0x7F,
  0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF0,
  0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x3F, 0xE7, 0xFE, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF,
  0xBF, 0xC1, 0xFF, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0x10, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFD, 0xFD, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFC, 0x5F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0x3F, 0xC0, 0x1C, 0xFF, 0x00,
  0x13, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x83, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0A, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0x9F, 0xC7, 0xFF, 0xC7, 0xF0, 0x7F,
  0xE0, 0xFC, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x9F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xE3, 0xFC, 0x07, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xF7, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xBF, 0x03, 0xFC, 0x1F,
  0xE0, 0xFD, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xEF, 0xC1, 0xFE, 0x07, 0xF8,
  0x3F, 0x3E, 0x0F, 0xF0, 0x3F, 0xC3, 0xF1, 0xF8, 0x7F, 0x80, 0xFF, 0x1F,
  0x8F, 0xC3, 0xF8, 0x07, 0xF8, 0xFC, 0x7E, 0x3F, 0xC0, 0x3F, 0xC7, 0xE3,
  0xF1, 0xFE, 0x00, 0xFE, 0x3E, 0x0F, 0x8F, 0xF0, 0x07, 0xF3, 0xF0, 0x7E,
  0x7F, 0x00, 0x3F, 0xDF, 0x83, 0xF3, 0xF8, 0x01, 0xFE, 0xFC, 0x1F, 0xBF,
  0xC0, 0x07, 0xF7, 0xE0, 0xFD, 0xFC, 0x00, 0x3F, 0xBE, 0x03, 0xEF, 0xE0,
  0x01, 0xFD, 0xF0, 0x1F, 0x7F, 0x00, 0x0F, 0xEF, 0x80, 0xFB, 0xF8, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x80, 0x03, 0xFF, 0x20, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 42, 16, 3, -41 },
  { 49, 20, 15, 27, 3, -41 },
  { 87, 32, 41, 34, 1, -41 },
  { 251, 26, 46, 30, 2, -43 },
  { 401, 45, 42, 49, 2, -41 },
  { 638, 37, 42, 39, 2, -41 },
  { 833, 8, 15, 14, 3, -41 },
  { 848, 15, 50, 19, 2, -41 },
  { 942, 15, 50, 19, 1, -41 },
  { 1036, 26, 25, 29, 1, -43 },
  { 1118, 26, 28, 30, 2, -34 },
  { 1209, 10, 14, 15, 2, -7 },
  { 1227, 14, 7, 18, 2, -19 },
  { 1240, 9, 10, 15, 3, -9 },
  { 1252, 23, 41, 23, 0, -41 },
  { 1370, 26, 42, 30, 2, -41 },
  { 1507, 19, 41, 30, 3, -41 },
  { 1605, 26, 41, 30, 2, -41 },
  { 1739, 26, 42, 30, 2, -41 },
  { 1876, 28, 41, 30, 1, -41 },
  { 2020, 25, 42, 30, 3, -41 },
  { 2152, 26, 42, 30, 2, -41 },
  { 2289, 27, 41, 30, 1, -41 },
  { 2428, 26, 42, 30, 2, -41 },
  { 2565, 26, 42, 30, 2, -41 },
  { 2702, 9, 33, 16, 3, -32 },
  { 2740, 11, 39, 16, 2, -32 },
  { 2794, 26, 29, 30, 2, -35 },
  { 2889, 26, 17, 30, 2, -29 },
  { 2945, 26, 29, 30, 2, -35 },
  { 3040, 24, 42, 25, 0, -41 },
  { 3166, 42, 46, 47, 3, -41 },
  { 3408, 36, 41, 36, 0, -41 },
  { 3593, 28, 41, 35, 4, -41 },
  { 3737, 29, 42, 33, 3, -41 },
  { 3890, 31, 41, 38, 4, -41 },
  { 4049, 21, 41, 29, 5, -41 },
  { 4157, 21, 41, 29, 5, -41 },
  { 4265, 31, 42, 38, 3, -41 },
  { 4428, 30, 41, 40, 5, -41 },
  { 4582, 17, 41, 21, 2, -41 },
  { 4670, 17, 53, 18, -4, -41 },
  { 4783, 30, 41, 35, 5, -41 },
  { 4937, 23, 41, 29, 4, -41 },
  { 5055, 40, 41, 50, 5, -41 },
  { 5260, 33, 41, 43, 5, -41 },
  { 5430, 35, 42, 41, 3, -41 },
  { 5614, 27, 41, 33, 4, -41 },
  { 5753, 35, 51, 41, 3, -41 },
  { 5977, 30, 41, 34, 4, -41 },
  { 6131, 25, 42, 29, 2, -41 },
  { 6263, 28, 41, 30, 1, -41 },
  { 6407, 31, 42, 39, 4, -41 },
  { 6570, 34, 41, 34, 0, -41 },
  { 6745, 51, 41, 51, 0, -41 },
  { 7007, 34, 41, 34, 0, -41 },
  { 7182, 32, 41, 32, 0, -41 },
  { 7346, 27, 41, 30, 1, -41 },
  { 7485, 13, 50, 18, 4, -41 },
  { 7567, 23, 41, 23, 0, -41 },
  { 7685, 14, 50, 18, 1, -41 },
  { 7773, 29, 26, 32, 1, -41 },
  { 7868, 23, 4, 23, 0, 5 },
  { 7880, 15, 9, 20, 2, -44 },
  { 7897, 26, 33, 31, 2, -32 },
  { 8005, 27, 44, 33, 4, -43 },
  { 8154, 23, 33, 27, 2, -32 },
  { 8249, 27, 44, 33, 2, -43 },
  { 8398, 27, 33, 31, 2, -32 },
  { 8510, 22, 44, 20, 1, -44 },
  { 8631, 27, 46, 33, 2, -32 },
  { 8787, 26, 43, 34, 4, -43 },
  { 8927, 8, 43, 16, 4, -43 },
  { 8970, 15, 57, 16, -3, -43 },
  { 9077, 29, 43, 32, 4, -43 },
  { 9233, 8, 43, 16, 4, -43 },
  { 9276, 43, 32, 51, 4, -32 },
  { 9448, 26, 32, 34, 4, -32 },
  { 9552, 28, 33, 33, 2, -32 },
  { 9668, 27, 46, 33, 4, -32 },
  { 9824, 27, 46, 33, 2, -32 },
  { 9980, 19, 32, 23, 4, -32 },
  { 10056, 22, 33, 26, 2, -32 },
  { 10147, 20, 39, 23, 1, -38 },
  { 10245, 26, 32, 34, 4, -31 },
  { 10349, 30, 31, 30, 0, -31 },
  { 10466, 45, 31, 45, 0, -31 },
  { 10641, 29, 31, 30, 0, -31 },
  { 10754, 30, 45, 30, 0, -31 },
  { 10923, 23, 31, 25, 1, -31 },
  { 11013, 18, 50, 21, 1, -41 },
  { 11126, 7, 56, 29, 11, -43 },
  { 11175, 19, 50, 21, 2, -41 },
  { 11294, 26, 10, 30, 2, -25 },
};

const GFXfont NotoSans_SemiCondensed_Bold57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD57PT7B_H_
