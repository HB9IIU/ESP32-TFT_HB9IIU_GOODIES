#ifndef _JETBRAINSMONO_LIGHTITALIC68PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x8F, 0x1F, 0xC0, 0x07, 0xE0, 0xF0,
  0xFC, 0x00, 0xFC, 0x0E, 0x07, 0xE0, 0x0F, 0x81, 0xE0, 0x7E, 0x01, 0xF8,
  0x1E, 0x07, 0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3F, 0x01, 0xE0, 0x7E, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x03, 0xF8,
  0x3C, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x00,
  0x1F, 0xF3, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0x7F, 0xC0, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x00, 0x0F, 0x0F,
  0xE0, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x01,
  0xE0, 0x3F, 0x00, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0x00,
  0x00, 0x1E, 0x03, 0xF0, 0x7E, 0x01, 0xE0, 0x3F, 0x07, 0xC0, 0x1C, 0x03,
  0xE0, 0x7C, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x7E, 0x03,
  0xC0, 0x7C, 0x07, 0xE0, 0x3C, 0x0F, 0xC0, 0x3F, 0x03, 0xC1, 0xF8, 0x03,
  0xFC, 0x38, 0x7F, 0x80, 0x1F, 0xF3, 0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xE0,
  0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0x00, 0x0F, 0xF3,
  0xF8, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x87, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xE1, 0xF8,
  0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x43, 0xF0, 0xFC, 0x00, 0x7C, 0x3F,
  0x07, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x3E, 0x00,
  0x7E, 0x3F, 0x01, 0xF0, 0x01, 0xF9, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x07,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0xC1,
  0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x0F,
  0x80, 0x02, 0x3C, 0x00, 0xF8, 0x01, 0xE7, 0xF0, 0x0F, 0x00, 0xFE, 0x7F,
  0xE0, 0xF0, 0x7F, 0xEF, 0xFF, 0x0F, 0x1F, 0xFE, 0xFF, 0xFC, 0xE7, 0xFF,
  0xF1, 0xFF, 0xEE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC1, 0xFE, 0x3F, 0xE7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xC0,
  0x3F, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0xF8, 0x1F, 0xC0, 0xF8, 0x1F, 0x07,
  0xF8, 0x1F, 0x07, 0xE0, 0xFF, 0x03, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F,
  0x81, 0xFC, 0x1F, 0x83, 0xE0, 0x1E, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0xF8, 0x00, 0x07, 0xF9, 0xF0,
  0x00, 0x3F, 0xC3, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x60, 0x01, 0xF0, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x03, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x01,
  0xF1, 0xFF, 0xFC, 0x00, 0xF9, 0xFF, 0xFF, 0x00, 0x7D, 0xFF, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x18, 0x00, 0x01, 0xF9, 0xFF, 0xC0,
  0x03, 0xF7, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x84, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF7, 0xC0, 0x0F, 0xFF, 0xEF, 0xC0,
  0x07, 0xFF, 0x9F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xFC, 0x3E, 0x0F, 0x80, 0x07, 0xFF,
  0x3E, 0x0F, 0x80, 0x0F, 0xFF, 0xBE, 0x0F, 0x80, 0x1F, 0xFF, 0xBE, 0x0F,
  0x80, 0x3F, 0x83, 0xBC, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0xE0, 0x7C, 0x01, 0xFF, 0xFD,
  0xE0, 0xF8, 0x00, 0xFF, 0xFB, 0xE0, 0xF8, 0x00, 0x7F, 0xF3, 0xE0, 0xF8,
  0x00, 0x3F, 0xC3, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x0F, 0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x81, 0xF0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0xFF, 0x87, 0xC0, 0x3F, 0xFF,
  0xC3, 0xE0, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x40, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xBC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1E, 0xF8, 0x00, 0xF7, 0x80,
  0x7B, 0xE0, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x07, 0x9E, 0x00,
  0xFB, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9F, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x0F,
  0x9F, 0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x03, 0xE3, 0xC1, 0xF1, 0xF0, 0x0F,
  0x8F, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x3E, 0x3E, 0x01, 0xF0, 0x78, 0xF0,
  0xF8, 0x07, 0xC1, 0xE7, 0xC3, 0xE0, 0x1F, 0x07, 0x9E, 0x0F, 0x80, 0x7C,
  0x1E, 0xF8, 0x3E, 0x01, 0xF0, 0x7B, 0xC1, 0xF8, 0x0F, 0xC1, 0xFF, 0x07,
  0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x0F,
  0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0x3E,
  0x01, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0x78, 0x00, 0x3E, 0x01, 0xF7, 0xC0,
  0x07, 0xE0, 0x1F, 0x7C, 0x00, 0x7C, 0x03, 0xF7, 0xC0, 0x07, 0xC0, 0x3E,
  0x3C, 0x00, 0x7C, 0x03, 0xE3, 0xC0, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0x7C,
  0x03, 0xE3, 0xE0, 0x0F, 0xC0, 0x3E, 0x3E, 0x00, 0xFC, 0x07, 0xE1, 0xE0,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0x01, 0xF8,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x3E,
  0x3E, 0x01, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x00, 0x3E, 0x7E, 0x03, 0xF0,
  0x01, 0xE7, 0xC0, 0x3F, 0x00, 0x1F, 0x7C, 0x03, 0xE0, 0x01, 0xF7, 0xC0,
  0x3E, 0x00, 0x1F, 0x7C, 0x03, 0xE0, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x0F,
  0x7C, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xF8, 0x07, 0xC0,
  0x00, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x7C, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xE0,
  0x07, 0xC7, 0xC0, 0x1D, 0xC0, 0x1F, 0x0F, 0x80, 0x3B, 0x80, 0x3E, 0x1E,
  0x00, 0xF7, 0x00, 0x7C, 0x3C, 0x01, 0xEE, 0x00, 0xF0, 0xF8, 0x03, 0x9C,
  0x03, 0xE1, 0xF0, 0x0F, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0xF0, 0x0F, 0x87,
  0xC0, 0x3D, 0xE0, 0x3E, 0x0F, 0x80, 0x73, 0xC0, 0x7C, 0x1F, 0x01, 0xE7,
  0x80, 0xF8, 0x3E, 0x03, 0xCF, 0x01, 0xF0, 0x7C, 0x07, 0x1E, 0x07, 0xC0,
  0xF8, 0x1E, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x78, 0x1F, 0x03, 0xE0, 0x78,
  0xF0, 0x3C, 0x07, 0xC0, 0xE1, 0xE0, 0xF8, 0x0F, 0x83, 0xC3, 0xC1, 0xF0,
  0x1F, 0x07, 0x87, 0x83, 0xE0, 0x3E, 0x0E, 0x0E, 0x07, 0x80, 0x7C, 0x3C,
  0x1C, 0x1F, 0x00, 0xF8, 0x78, 0x38, 0x3E, 0x01, 0xF0, 0xE0, 0x70, 0x78,
  0x03, 0xC1, 0xC0, 0xE1, 0xF0, 0x07, 0x87, 0x81, 0xC3, 0xE0, 0x0F, 0x0F,
  0x03, 0x87, 0xC0, 0x1E, 0x1C, 0x07, 0x0F, 0x00, 0x3C, 0x78, 0x0E, 0x3E,
  0x00, 0x78, 0xF0, 0x1C, 0x7C, 0x01, 0xF1, 0xC0, 0x38, 0xF8, 0x03, 0xE3,
  0x80, 0x71, 0xE0, 0x07, 0xCF, 0x00, 0xE7, 0xC0, 0x0F, 0x9E, 0x03, 0xCF,
  0x80, 0x1F, 0x38, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x0F, 0x3C, 0x00, 0x7D,
  0xE0, 0x1E, 0xF8, 0x00, 0xFB, 0x80, 0x3D, 0xF0, 0x01, 0xF7, 0x00, 0x7B,
  0xC0, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0x70, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x04, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x7E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xC0, 0x0F, 0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF,
  0xFD, 0xF8, 0x0F, 0xE0, 0x0E, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xC0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1D, 0xF0, 0x1F, 0xF0, 0x3E,
  0xF8, 0x07, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFE, 0x7E, 0x00, 0x7F, 0xFE,
  0x3F, 0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x80, 0x07, 0xE1, 0xFF, 0xE0, 0x07, 0xE7, 0xFF, 0xF8, 0x07, 0xCF,
  0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xFC, 0x07, 0xDE, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7F, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFD, 0xFF, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0x00, 0xF8, 0xFF,
  0xFE, 0x00, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0xFE, 0x1F, 0x00,
  0x0F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFF, 0xDF,
  0x80, 0x3F, 0x80, 0x3B, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xDF, 0x00, 0x7F, 0xC0, 0xFB, 0xE0, 0x07, 0xFF, 0xFE, 0xFC, 0x00,
  0x7F, 0xFF, 0x9F, 0x80, 0x07, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFB,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0x1F, 0x01,
  0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xBF, 0x03, 0xF8, 0x03, 0xFE, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFB, 0xE0, 0x1F, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0xF3, 0xE0, 0x0F,
  0xFF, 0xC3, 0xE0, 0x03, 0xFF, 0x87, 0xE0, 0x00, 0x18, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x07,
  0xE1, 0xFF, 0xE0, 0x07, 0xE7, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xFC, 0x07,
  0xDF, 0xFF, 0xFC, 0x07, 0xDC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x10, 0x3E, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0xFF, 0x87, 0xFC, 0x07, 0xDF, 0xFC,
  0xFF, 0xE0, 0x7D, 0xFF, 0xDF, 0xFE, 0x07, 0xF0, 0xFD, 0x87, 0xF0, 0x7E,
  0x07, 0xF0, 0x3F, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x1F,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0x80, 0x3E,
  0x1F, 0x00, 0x78, 0x07, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x0F, 0x87, 0xC0, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0x0F, 0x87, 0xC0,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC0,
  0x1F, 0x0F, 0x80, 0x3C, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xE1, 0xFF, 0xE0, 0x07,
  0xE7, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xFC, 0x07,
  0xDC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x1F, 0xFE, 0x00, 0x1F, 0x9F, 0xFF, 0xE0, 0x07, 0xCF, 0xFF, 0xFC,
  0x01, 0xF7, 0xFF, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F,
  0xE0, 0x03, 0xF8, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xE7, 0xFF, 0xFE, 0x00,
  0xF9, 0xFF, 0xFF, 0x00, 0x3E, 0x3F, 0xFF, 0x80, 0x0F, 0x83, 0xFF, 0x80,
  0x07, 0xE0, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x87,
  0xC0, 0x1F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xFD,
  0xF8, 0x1F, 0xE0, 0x0E, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1D, 0xF0, 0x1F, 0xF0, 0x3E, 0xF8,
  0x07, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFE, 0x7E, 0x00, 0x7F, 0xFE, 0x3E,
  0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xF0, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0xFF, 0x80,
  0x7D, 0xFE, 0xFF, 0xE0, 0x3E, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x7B, 0xC0, 0x0F, 0xC0, 0x1F, 0x78, 0x03, 0xF8,
  0x03, 0xEF, 0x00, 0x77, 0x00, 0x79, 0xE0, 0x0E, 0xE0, 0x0F, 0x3C, 0x03,
  0xDC, 0x03, 0xE7, 0x80, 0x7B, 0x80, 0x7C, 0xF0, 0x0E, 0x70, 0x0F, 0x1E,
  0x03, 0xCE, 0x03, 0xE3, 0xC0, 0x79, 0xC0, 0x7C, 0x78, 0x0E, 0x38, 0x0F,
  0x0F, 0x03, 0xC7, 0x03, 0xE1, 0xE0, 0x78, 0xE0, 0x7C, 0x3C, 0x0E, 0x1C,
  0x0F, 0x07, 0x83, 0xC3, 0x83, 0xE0, 0xF0, 0x78, 0x70, 0x7C, 0x1E, 0x0E,
  0x0E, 0x0F, 0x03, 0xC3, 0xC1, 0xC1, 0xE0, 0x78, 0x78, 0x38, 0x7C, 0x0F,
  0x0E, 0x07, 0x0F, 0x01, 0xE3, 0xC0, 0xE1, 0xE0, 0x3C, 0x78, 0x1C, 0x7C,
  0x07, 0x8E, 0x03, 0x8F, 0x00, 0xF3, 0xC0, 0x71, 0xE0, 0x1E, 0x78, 0x0E,
  0x7C, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x39, 0xE0, 0x0F, 0x78,
  0x07, 0x7C, 0x01, 0xEE, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x1D, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xE1, 0xFB, 0xE0, 0x1F, 0xFF,
  0xF3, 0xE0, 0x1F, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0xC7, 0xE0, 0x03, 0xFF,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x83, 0xFF, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x07, 0xE3,
  0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xFC, 0x01, 0xF3, 0xF0, 0x7E, 0x00, 0xF9,
  0xF0, 0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x7E, 0xF8, 0x03, 0xF8, 0x7E,
  0x7C, 0x00, 0xFF, 0xFF, 0x3E, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x1F, 0xFF,
  0x0F, 0x80, 0x03, 0xFF, 0x07, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 15, 50, 41, 13, -50 },
  { 95, 22, 21, 41, 13, -50 },
  { 153, 39, 50, 41, 2, -50 },
  { 397, 36, 69, 41, 3, -59 },
  { 708, 47, 50, 41, -2, -50 },
  { 1002, 37, 51, 41, 2, -50 },
  { 1238, 8, 21, 41, 20, -50 },
  { 1259, 28, 66, 41, 11, -57 },
  { 1490, 28, 66, 41, 3, -57 },
  { 1721, 36, 34, 41, 4, -41 },
  { 1874, 32, 31, 41, 5, -38 },
  { 1998, 17, 21, 41, 7, -10 },
  { 2043, 22, 5, 41, 10, -25 },
  { 2057, 12, 11, 41, 12, -10 },
  { 2074, 40, 63, 41, 1, -56 },
  { 2389, 35, 51, 41, 4, -50 },
  { 2613, 31, 50, 41, 3, -50 },
  { 2807, 35, 50, 41, 3, -50 },
  { 3026, 34, 51, 41, 4, -50 },
  { 3243, 31, 50, 41, 5, -50 },
  { 3437, 33, 51, 41, 5, -50 },
  { 3648, 32, 51, 41, 4, -50 },
  { 3852, 33, 50, 41, 8, -50 },
  { 4059, 34, 51, 41, 4, -50 },
  { 4276, 32, 50, 41, 7, -50 },
  { 4476, 16, 39, 41, 12, -38 },
  { 4554, 22, 49, 41, 7, -38 },
  { 4689, 32, 35, 41, 6, -40 },
  { 4829, 32, 21, 41, 5, -33 },
  { 4913, 32, 35, 41, 4, -40 },
  { 5053, 27, 50, 41, 10, -50 },
  { 5222, 40, 62, 41, 1, -50 },
  { 5532, 33, 50, 41, 1, -50 },
  { 5739, 34, 50, 41, 4, -50 },
  { 5952, 33, 51, 41, 5, -50 },
  { 6163, 34, 50, 41, 4, -50 },
  { 6376, 36, 50, 41, 4, -50 },
  { 6601, 37, 50, 41, 4, -50 },
  { 6833, 33, 51, 41, 5, -50 },
  { 7044, 35, 50, 41, 4, -50 },
  { 7263, 34, 50, 41, 4, -50 },
  { 7476, 36, 51, 41, 2, -50 },
  { 7706, 38, 50, 41, 4, -50 },
  { 7944, 29, 50, 41, 5, -50 },
  { 8126, 38, 50, 41, 2, -50 },
  { 8364, 36, 50, 41, 3, -50 },
  { 8589, 33, 51, 41, 5, -50 },
  { 8800, 36, 50, 41, 4, -50 },
  { 9025, 34, 62, 41, 4, -50 },
  { 9289, 36, 50, 41, 4, -50 },
  { 9514, 36, 51, 41, 3, -50 },
  { 9744, 34, 50, 41, 8, -50 },
  { 9957, 34, 51, 41, 5, -50 },
  { 10174, 33, 50, 41, 9, -50 },
  { 10381, 39, 50, 41, 5, -50 },
  { 10625, 42, 50, 41, 0, -50 },
  { 10888, 35, 50, 41, 8, -50 },
  { 11107, 36, 50, 41, 3, -50 },
  { 11332, 26, 63, 41, 10, -56 },
  { 11537, 20, 63, 41, 11, -56 },
  { 11695, 27, 63, 41, 6, -56 },
  { 11908, 30, 27, 41, 6, -50 },
  { 12010, 33, 4, 41, 0, 2 },
  { 12027, 12, 9, 41, 18, -53 },
  { 12041, 33, 39, 41, 4, -38 },
  { 12202, 32, 51, 41, 4, -50 },
  { 12406, 32, 39, 41, 5, -38 },
  { 12562, 35, 51, 41, 4, -50 },
  { 12786, 31, 39, 41, 5, -38 },
  { 12938, 46, 62, 41, -3, -50 },
  { 13295, 32, 50, 41, 5, -38 },
  { 13495, 32, 50, 41, 4, -50 },
  { 13695, 32, 53, 41, 3, -53 },
  { 13907, 35, 65, 41, 1, -53 },
  { 14192, 36, 50, 41, 4, -50 },
  { 14417, 28, 50, 41, 7, -50 },
  { 14592, 36, 38, 41, 2, -38 },
  { 14763, 32, 38, 41, 4, -38 },
  { 14915, 31, 39, 41, 5, -38 },
  { 15067, 34, 50, 41, 2, -38 },
  { 15280, 33, 50, 41, 4, -38 },
  { 15487, 33, 38, 41, 5, -38 },
  { 15644, 32, 39, 41, 4, -38 },
  { 15800, 32, 48, 41, 6, -48 },
  { 15992, 32, 38, 41, 5, -37 },
  { 16144, 32, 37, 41, 7, -37 },
  { 16292, 35, 37, 41, 6, -37 },
  { 16454, 38, 37, 41, 1, -37 },
  { 16630, 32, 49, 41, 5, -37 },
  { 16826, 34, 37, 41, 3, -37 },
  { 16984, 34, 63, 41, 7, -56 },
  { 17252, 15, 63, 41, 14, -56 },
  { 17371, 34, 63, 41, 2, -56 },
  { 17639, 33, 14, 41, 5, -31 },
};

const GFXfont JetBrainsMono_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_LIGHTITALIC68PT7B_H_
