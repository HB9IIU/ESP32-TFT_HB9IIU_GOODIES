#ifndef _JETBRAINSMONO_LIGHTITALIC45PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x78, 0x3D, 0xE0, 0xF7, 0x83,
  0xDE, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0x81,
  0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0xC0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x0E, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00,
  0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xC0,
  0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xE7, 0x7C, 0x03, 0xC6, 0x1E, 0x07, 0x86, 0x1E, 0x07, 0x06, 0x0E, 0x0F,
  0x06, 0x0E, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x0C, 0x00, 0x0F, 0x8C, 0x00, 0x07, 0xCC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x19, 0xF0, 0x00, 0x38, 0xF8, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00,
  0x30, 0x78, 0x70, 0x30, 0x78, 0x70, 0x30, 0x78, 0x70, 0x30, 0x70, 0x78,
  0x70, 0xF0, 0x78, 0x71, 0xF0, 0x7E, 0x73, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x70, 0x0F, 0xFC, 0x01, 0xE0, 0x38,
  0x38, 0x03, 0x80, 0x70, 0x78, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x03, 0x81,
  0xC0, 0xE0, 0x07, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x0E, 0x00, 0x1C, 0x0E,
  0x1C, 0x00, 0x38, 0x1C, 0x70, 0x00, 0x70, 0x71, 0xC0, 0x00, 0xFF, 0xE7,
  0x00, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0xE3, 0xFC, 0x00, 0x03, 0x8F, 0xFC, 0x00, 0x0F, 0x3C, 0x38,
  0x00, 0x1C, 0x70, 0x78, 0x00, 0x71, 0xC0, 0x70, 0x01, 0xC3, 0x81, 0xC0,
  0x07, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x0E, 0x00,
  0xE0, 0x38, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x00, 0xFF, 0xE0, 0x38,
  0x00, 0xFF, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x8F, 0x1E, 0x07, 0x8F, 0x0F, 0x03, 0x87, 0x03, 0xC3, 0xC3, 0x81, 0xE3,
  0xC3, 0xC0, 0x79, 0xC1, 0xE0, 0x3D, 0xE0, 0xF0, 0x0F, 0xE0, 0x78, 0x03,
  0xE0, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xF8, 0x0E, 0x00, 0xFC, 0x07, 0x80,
  0xFF, 0x03, 0xC0, 0xF7, 0x81, 0xFF, 0xF1, 0xE0, 0x7F, 0xF0, 0x78, 0x1F,
  0xE0, 0x3C, 0x00, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0xBC, 0xF3, 0xCF, 0x38,
  0xE3, 0x80, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x1C, 0x03, 0x7C,
  0x1C, 0x1F, 0x7F, 0x1C, 0x7F, 0xFF, 0xD9, 0xFF, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xCF, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x07, 0xC0, 0x1E,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x08, 0x01, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x05,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x7E, 0x7F, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x07, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x00, 0x07, 0x0E, 0x1E, 0x0E, 0x3C, 0x3E, 0x3C, 0x78, 0x7C, 0x78,
  0xF0, 0xF8, 0xF1, 0xE1, 0xE1, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x80, 0x3C, 0x0F, 0x81,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xF7, 0x00, 0x1F, 0x38, 0x03,
  0xE1, 0xC0, 0x3E, 0x1E, 0x01, 0xC0, 0xF0, 0x0C, 0x07, 0x80, 0x40, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x03,
  0xE0, 0x78, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x20, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0xF0,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x01, 0xC1, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x1E,
  0x7F, 0x80, 0x77, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x3E, 0x00,
  0xF0, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xF0, 0x3E,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x7F, 0x00,
  0xF7, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x81, 0xF8, 0x78, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x1E,
  0x00, 0x3C, 0x7C, 0x01, 0xE0, 0xF8, 0x1F, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0x9C, 0x00,
  0x3C, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0xF0, 0x03,
  0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x38,
  0x3C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x7C, 0x3C, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0x0F, 0x80, 0x78, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xE3, 0xC0,
  0x03, 0x8E, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x1E, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x1F,
  0x00, 0x7C, 0x7E, 0x03, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFD,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x8F, 0xF1, 0xFC, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x07, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07,
  0x87, 0x00, 0x78, 0xE0, 0xE0, 0x3F, 0xDC, 0x3C, 0x0F, 0xFF, 0x87, 0x03,
  0xC1, 0xF0, 0xE0, 0x70, 0x1E, 0x1C, 0x0E, 0x03, 0xC3, 0x83, 0xC0, 0x70,
  0x70, 0x70, 0x0E, 0x1E, 0x0E, 0x01, 0xC3, 0xC1, 0xC0, 0x38, 0x70, 0x38,
  0x07, 0x0E, 0x0F, 0x01, 0xE1, 0xC1, 0xE0, 0x3C, 0x38, 0x3C, 0x07, 0x0F,
  0x07, 0x80, 0xE1, 0xE0, 0xF0, 0x3C, 0x38, 0x1F, 0x0F, 0x87, 0x01, 0xFF,
  0x70, 0xE0, 0x1F, 0xCE, 0x1C, 0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0xF1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x3C,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3C, 0x0F, 0xE0, 0x70, 0x03, 0xE0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x70, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x1F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x70, 0x03, 0xC0,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x1E, 0x0E, 0x01, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x78, 0x03, 0xC1,
  0xF0, 0x1E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3C, 0x1F, 0xC0, 0x70,
  0x07, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x03,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x3F, 0xF8, 0xE0, 0xFF, 0xE7, 0x83, 0xFF, 0x9E, 0x0F, 0xFC, 0x78,
  0x00, 0x71, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00,
  0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x78, 0x03, 0xC1,
  0xF0, 0x1E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07,
  0x80, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E,
  0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x38,
  0x00, 0xF0, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xE0,
  0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x00,
  0x3C, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1E, 0x00,
  0x38, 0x0F, 0x00, 0x0E, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x01, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x76, 0x03, 0xB8, 0x3B, 0x81, 0xDC, 0x1D, 0xC1, 0xDC,
  0x0E, 0xE0, 0xEE, 0x0E, 0x70, 0xE7, 0x07, 0x18, 0x73, 0x83, 0x8E, 0x71,
  0xC1, 0xC7, 0x39, 0xE0, 0xE3, 0xB8, 0xF0, 0x71, 0xDC, 0x70, 0x78, 0xFC,
  0x38, 0x3C, 0x3E, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x00,
  0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x1E,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x07, 0xE0,
  0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xE0,
  0x0E, 0x0F, 0xF0, 0x1E, 0x0F, 0x70, 0x1E, 0x0F, 0x70, 0x1E, 0x0E, 0x70,
  0x1E, 0x0E, 0x70, 0x1C, 0x0E, 0x78, 0x1C, 0x0E, 0x38, 0x1C, 0x1E, 0x38,
  0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1C, 0x1C, 0x38, 0x1C, 0x1C,
  0x38, 0x1C, 0x1C, 0x38, 0x3C, 0x1C, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x0E,
  0x78, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0x70, 0x78, 0x0F,
  0x70, 0x78, 0x07, 0x70, 0x78, 0x07, 0xF0, 0x70, 0x07, 0xE0, 0x70, 0x07,
  0xE0, 0x70, 0x07, 0xE0, 0x70, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0x78,
  0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70,
  0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00,
  0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x1C, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x3E, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0xC0, 0x70, 0x01, 0xF0, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03,
  0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C,
  0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x38, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0,
  0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x03,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xF0, 0x3E, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0x80, 0xFE, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1F,
  0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x7C, 0x1E, 0x03, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x00,
  0x3C, 0x07, 0x80, 0x38, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x7E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x81,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0,
  0x0F, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x81, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x70, 0x03,
  0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0x80, 0x03, 0xDE, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x0F, 0x01, 0xDE, 0x07, 0xC0, 0xF7,
  0x81, 0xF0, 0x39, 0xE0, 0x7C, 0x0E, 0x78, 0x1F, 0x07, 0x9E, 0x0F, 0xC1,
  0xC7, 0x83, 0x70, 0x71, 0xC0, 0xD8, 0x1C, 0x70, 0x76, 0x0F, 0x1C, 0x1D,
  0x83, 0x87, 0x06, 0x60, 0xE1, 0xC1, 0x98, 0x38, 0x70, 0xE6, 0x1E, 0x1C,
  0x31, 0x87, 0x07, 0x0C, 0x61, 0xC1, 0xC7, 0x18, 0x70, 0x71, 0xC6, 0x38,
  0x1C, 0x61, 0x8E, 0x07, 0x18, 0x63, 0x81, 0xCE, 0x19, 0xE0, 0x73, 0x06,
  0x70, 0x1C, 0xC1, 0x9C, 0x07, 0x70, 0x67, 0x01, 0xD8, 0x1B, 0x80, 0x76,
  0x06, 0xE0, 0x3D, 0x83, 0xB8, 0x0E, 0xE0, 0xEE, 0x03, 0xB0, 0x3F, 0x00,
  0xEC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0xC0, 0x01,
  0xC7, 0x80, 0x07, 0x87, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0,
  0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C,
  0x38, 0x03, 0x83, 0x80, 0x78, 0x38, 0x07, 0x03, 0xC0, 0xF0, 0x1C, 0x1E,
  0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xEF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x00, 0xFE, 0x3C, 0x0F, 0xFC, 0xE0, 0x7F,
  0xFB, 0x83, 0xE0, 0x6E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8,
  0x78, 0x07, 0xC1, 0xF0, 0x37, 0x07, 0xFF, 0xDC, 0x0F, 0xFE, 0xF0, 0x1F,
  0xE3, 0xC0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x1F, 0xC0, 0x3D, 0xFF, 0xC0, 0xEF, 0xFF, 0x03, 0xB0, 0x3E, 0x0F,
  0x80, 0x78, 0x7C, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF8, 0x1F,
  0x07, 0x7F, 0xF8, 0x1C, 0xFF, 0xC0, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0x3C, 0x00, 0x78, 0xE0,
  0x03, 0xC7, 0x80, 0x3C, 0x3E, 0x03, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xFE, 0x3C, 0x07, 0xFE, 0x70, 0x1F, 0xFE, 0xE0, 0x7C,
  0x0D, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x07,
  0x80, 0x7C, 0x0F, 0x81, 0xB8, 0x1F, 0xFF, 0x70, 0x1F, 0xFD, 0xE0, 0x1F,
  0xE3, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x9E, 0x00, 0x1C, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC7, 0x80, 0x3C, 0x3E, 0x03, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x3C, 0x0F, 0xFC, 0xE0,
  0x7F, 0xFB, 0x83, 0xE0, 0x6E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1C,
  0x00, 0x38, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x03,
  0xF8, 0x3F, 0xFD, 0xC0, 0x7F, 0xE7, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x1F, 0xC0, 0x3D, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xB0, 0x3E, 0x0F, 0x80,
  0x78, 0x7C, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xC0, 0x1F, 0x03, 0x80, 0x7C,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0xE0, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0E, 0x7C,
  0x7C, 0x0E, 0xFE, 0xFE, 0x0F, 0xFE, 0xFF, 0x0F, 0x0F, 0x0F, 0x1E, 0x0E,
  0x07, 0x1E, 0x0E, 0x07, 0x1C, 0x0E, 0x0F, 0x1C, 0x0E, 0x0F, 0x1C, 0x0E,
  0x0F, 0x1C, 0x1C, 0x0E, 0x3C, 0x1C, 0x0E, 0x3C, 0x1C, 0x0E, 0x38, 0x1C,
  0x0E, 0x38, 0x1C, 0x1E, 0x38, 0x1C, 0x1E, 0x38, 0x1C, 0x1C, 0x78, 0x38,
  0x1C, 0x78, 0x38, 0x1C, 0x78, 0x38, 0x1C, 0x70, 0x38, 0x3C, 0x70, 0x38,
  0x3C, 0x70, 0x38, 0x38, 0x70, 0x70, 0x38, 0xF0, 0x70, 0x38, 0xF0, 0x70,
  0x38, 0x0F, 0x1F, 0xC0, 0x3D, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xB0, 0x3E,
  0x0F, 0x80, 0x78, 0x7C, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x0F,
  0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x9E, 0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0,
  0x03, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x78,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x3E, 0x07, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x07, 0x8F, 0xE0, 0x0F, 0x7F, 0xF0, 0x1D, 0xFF,
  0xE0, 0x3B, 0x03, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x03, 0x83, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xF0,
  0x07, 0x83, 0xE0, 0x0F, 0x07, 0x60, 0x7C, 0x0E, 0xFF, 0xF0, 0x1C, 0xFF,
  0xC0, 0x78, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x3C, 0x0F, 0xFC, 0xE0, 0x7F, 0xFB, 0x83,
  0xE0, 0x7E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0x78, 0x07,
  0xC1, 0xF0, 0x37, 0x07, 0xFF, 0xDC, 0x0F, 0xFE, 0xF0, 0x1F, 0xE3, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x1F,
  0xC0, 0x39, 0xFF, 0x80, 0xEF, 0xFF, 0x03, 0xF0, 0x3E, 0x1F, 0x80, 0x78,
  0x7C, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0x01, 0xE1, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x7C, 0x03, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0,
  0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38,
  0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF0,
  0x70, 0x07, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00,
  0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x1F, 0x81, 0xE0,
  0x77, 0x03, 0xC0, 0xEE, 0x0F, 0x81, 0xDC, 0x1B, 0x07, 0x38, 0x36, 0x0E,
  0x70, 0xEC, 0x1C, 0xE1, 0x98, 0x39, 0xC3, 0x30, 0xE3, 0x8E, 0x61, 0xC7,
  0x18, 0xC3, 0x8E, 0x31, 0x8E, 0x1C, 0xE3, 0x1C, 0x39, 0x86, 0x38, 0x73,
  0x0C, 0xE0, 0xEE, 0x19, 0xC1, 0xD8, 0x33, 0x83, 0xB0, 0x6E, 0x07, 0xE0,
  0xDC, 0x0F, 0x81, 0xB8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xE0,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE1, 0xC0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x38, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x0F,
  0x87, 0x80, 0x3E, 0x1F, 0x03, 0xF0, 0x3F, 0xFD, 0xC0, 0x7F, 0xE7, 0x00,
  0xFE, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x1C, 0xFF, 0x80, 0xF3, 0xFF, 0x03, 0xDE, 0x3E, 0x0E, 0x70, 0x78, 0x3B,
  0xC0, 0xFB, 0xEF, 0x01, 0xFF, 0x3C, 0x03, 0xF8, 0x00, 0x03, 0x80,
};

const GFXglyph JetBrainsMono_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 10, 33, 27, 9, -33 },
  { 43, 14, 14, 27, 9, -33 },
  { 68, 26, 33, 27, 1, -33 },
  { 176, 24, 45, 27, 2, -39 },
  { 311, 31, 33, 27, -1, -33 },
  { 439, 25, 33, 27, 1, -33 },
  { 543, 6, 14, 27, 13, -33 },
  { 554, 19, 44, 27, 7, -38 },
  { 659, 18, 44, 27, 2, -38 },
  { 758, 24, 23, 27, 2, -27 },
  { 827, 22, 21, 27, 3, -25 },
  { 885, 11, 14, 27, 5, -7 },
  { 905, 15, 3, 27, 6, -16 },
  { 911, 8, 7, 27, 8, -7 },
  { 918, 26, 42, 27, 1, -37 },
  { 1055, 23, 33, 27, 3, -33 },
  { 1150, 21, 33, 27, 2, -33 },
  { 1237, 23, 33, 27, 2, -33 },
  { 1332, 23, 33, 27, 2, -33 },
  { 1427, 21, 33, 27, 3, -33 },
  { 1514, 22, 33, 27, 3, -33 },
  { 1605, 22, 33, 27, 2, -33 },
  { 1696, 21, 33, 27, 6, -33 },
  { 1783, 23, 33, 27, 2, -33 },
  { 1878, 22, 33, 27, 4, -33 },
  { 1969, 11, 25, 27, 8, -25 },
  { 2004, 14, 32, 27, 5, -25 },
  { 2060, 21, 24, 27, 4, -27 },
  { 2123, 22, 14, 27, 3, -22 },
  { 2162, 22, 24, 27, 2, -27 },
  { 2228, 18, 33, 27, 7, -33 },
  { 2303, 27, 41, 27, 0, -33 },
  { 2442, 23, 33, 27, 0, -33 },
  { 2537, 23, 33, 27, 2, -33 },
  { 2632, 22, 33, 27, 3, -33 },
  { 2723, 23, 33, 27, 2, -33 },
  { 2818, 24, 33, 27, 3, -33 },
  { 2917, 24, 33, 27, 3, -33 },
  { 3016, 22, 33, 27, 3, -33 },
  { 3107, 24, 33, 27, 2, -33 },
  { 3206, 22, 33, 27, 3, -33 },
  { 3297, 24, 33, 27, 1, -33 },
  { 3396, 26, 33, 27, 2, -33 },
  { 3504, 20, 33, 27, 3, -33 },
  { 3587, 25, 33, 27, 2, -33 },
  { 3691, 24, 33, 27, 2, -33 },
  { 3790, 22, 33, 27, 3, -33 },
  { 3881, 25, 33, 27, 2, -33 },
  { 3985, 22, 41, 27, 3, -33 },
  { 4098, 24, 33, 27, 2, -33 },
  { 4197, 24, 33, 27, 2, -33 },
  { 4296, 23, 33, 27, 5, -33 },
  { 4391, 23, 33, 27, 3, -33 },
  { 4486, 22, 33, 27, 6, -33 },
  { 4577, 26, 33, 27, 3, -33 },
  { 4685, 28, 33, 27, 0, -33 },
  { 4801, 23, 33, 27, 5, -33 },
  { 4896, 24, 33, 27, 2, -33 },
  { 4995, 17, 42, 27, 7, -37 },
  { 5085, 13, 42, 27, 8, -37 },
  { 5154, 18, 42, 27, 4, -37 },
  { 5249, 20, 18, 27, 4, -33 },
  { 5294, 22, 3, 27, 0, 1 },
  { 5303, 8, 6, 27, 12, -35 },
  { 5309, 22, 25, 27, 3, -25 },
  { 5378, 22, 33, 27, 2, -33 },
  { 5469, 21, 25, 27, 3, -25 },
  { 5535, 23, 33, 27, 3, -33 },
  { 5630, 21, 25, 27, 3, -25 },
  { 5696, 30, 41, 27, -2, -33 },
  { 5850, 22, 33, 27, 3, -25 },
  { 5941, 22, 33, 27, 2, -33 },
  { 6032, 21, 35, 27, 2, -35 },
  { 6124, 23, 43, 27, 1, -35 },
  { 6248, 23, 33, 27, 3, -33 },
  { 6343, 18, 33, 27, 5, -33 },
  { 6418, 24, 25, 27, 1, -25 },
  { 6493, 22, 25, 27, 2, -25 },
  { 6562, 21, 25, 27, 3, -25 },
  { 6628, 23, 33, 27, 1, -25 },
  { 6723, 22, 33, 27, 3, -25 },
  { 6814, 22, 25, 27, 3, -25 },
  { 6883, 21, 25, 27, 3, -25 },
  { 6949, 21, 32, 27, 4, -32 },
  { 7033, 22, 25, 27, 3, -25 },
  { 7102, 21, 25, 27, 5, -25 },
  { 7168, 23, 25, 27, 4, -25 },
  { 7240, 25, 25, 27, 1, -25 },
  { 7319, 22, 33, 27, 3, -25 },
  { 7410, 22, 25, 27, 2, -25 },
  { 7479, 23, 42, 27, 4, -37 },
  { 7600, 10, 42, 27, 9, -37 },
  { 7653, 23, 42, 27, 1, -37 },
  { 7774, 22, 9, 27, 3, -20 },
};

const GFXfont JetBrainsMono_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_LIGHTITALIC45PT7B_H_
