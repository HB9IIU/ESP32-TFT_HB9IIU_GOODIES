#ifndef _JETBRAINSMONO_LIGHTITALIC57PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x00, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xFB, 0xE0,
  0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xCE, 0x7F, 0x00, 0xF8, 0x70, 0xF8, 0x0F, 0x83,
  0x83, 0xE0, 0x78, 0x1C, 0x1F, 0x07, 0xC0, 0xE0, 0xF8, 0x3E, 0x0F, 0x07,
  0xC1, 0xE0, 0x70, 0x3E, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03,
  0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x07, 0xF3,
  0xC0, 0x00, 0x1F, 0xDC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0x3F, 0x80, 0x00, 0x38, 0x7E, 0x00, 0x01,
  0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x38, 0x0F, 0x1F, 0x01, 0xC0, 0x78, 0xF8, 0x0E, 0x07, 0xC7,
  0xC0, 0x70, 0x3E, 0x3E, 0x07, 0x83, 0xE0, 0xF8, 0x38, 0x1F, 0x07, 0xC1,
  0xC1, 0xF0, 0x3F, 0x8E, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x00, 0x38,
  0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x1F, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x07, 0x80,
  0x70, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0x01, 0xF0,
  0x3C, 0x38, 0x00, 0x01, 0xF1, 0xF0, 0xF0, 0x00, 0x03, 0xFF, 0xE3, 0xC0,
  0x00, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x01, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0x8F, 0xFF, 0x00, 0x00, 0x1E, 0x1F,
  0xFF, 0x00, 0x00, 0x3C, 0x78, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x0E,
  0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x0F, 0xC7, 0xC0,
  0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x0F, 0x8F, 0xC0, 0x3E, 0x1F,
  0x07, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x3E,
  0x01, 0xF1, 0xF0, 0x3E, 0x01, 0xF1, 0xE0, 0x3C, 0x00, 0xFB, 0xE0, 0x3C,
  0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x7F, 0x80, 0x7C, 0x01, 0xFF, 0xC0, 0x7E, 0x03, 0xF7, 0xC0, 0x3F,
  0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0xC3, 0xE0, 0x1F, 0xFF, 0x01, 0xF0, 0x0F,
  0xFC, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x20, 0x03, 0xC0, 0x04, 0xE0, 0x0F, 0x00, 0xE7,
  0xF0, 0x38, 0x1F, 0xDF, 0xF0, 0xE1, 0xFF, 0xFF, 0xE3, 0x9F, 0xFC, 0xFF,
  0xED, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x07, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xF9, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x81, 0xE0,
  0x7C, 0x3C, 0x1F, 0x83, 0xE1, 0xE0, 0xFC, 0x1E, 0x1F, 0x07, 0xE0, 0xF0,
  0xF8, 0x3F, 0x07, 0x87, 0xC0, 0xF0, 0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x9F, 0x00,
  0x1F, 0xC7, 0x80, 0x1F, 0xC1, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0x70, 0x0F, 0x80, 0x10, 0x03, 0xE0, 0x08, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00,
  0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x03, 0xC0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x07, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x80,
  0x0F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x0F,
  0x82, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x7D, 0xFF, 0x80,
  0x1F, 0x7F, 0xFC, 0x03, 0xDF, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFB, 0xE0, 0x0F, 0xFE, 0xF8, 0x00,
  0x7F, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x3E, 0x1E, 0x00, 0x7F, 0x9E,
  0x1E, 0x00, 0xFF, 0xEF, 0x0F, 0x00, 0xFF, 0xFF, 0x87, 0x80, 0x7C, 0x0F,
  0xC3, 0xC0, 0x7C, 0x03, 0xE1, 0xE0, 0x3C, 0x01, 0xF0, 0xF0, 0x1E, 0x00,
  0xF0, 0xF8, 0x1E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x3C, 0x3C, 0x07, 0x80,
  0x1E, 0x1E, 0x03, 0xC0, 0x0F, 0x0F, 0x01, 0xE0, 0x07, 0x87, 0x80, 0xF0,
  0x07, 0x87, 0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x78, 0x01, 0xE1, 0xE0, 0x3C,
  0x00, 0xF0, 0xF0, 0x1E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x7C, 0x3C, 0x07,
  0x80, 0x3E, 0x1E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xFE, 0xF7, 0x0F, 0x00,
  0x7F, 0xF7, 0x87, 0x80, 0x1F, 0xF3, 0xC3, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C,
  0x03, 0xE0, 0x03, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x3E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00,
  0x7C, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xFE, 0x03, 0xC0, 0x03, 0xF0, 0x1E,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0x80, 0x03, 0xF0, 0x3C, 0x00,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x3C, 0x07, 0xFC, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0x80,
  0x0F, 0xC0, 0x3C, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0xFC, 0x3C, 0x07, 0xFF, 0xC3, 0xC0, 0xFF, 0xFC, 0x3C,
  0x0F, 0xFF, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xB8,
  0x00, 0xFE, 0x03, 0xB8, 0x00, 0xEE, 0x03, 0xBC, 0x01, 0xEE, 0x03, 0xBC,
  0x01, 0xDE, 0x03, 0xBC, 0x03, 0xDE, 0x07, 0xBC, 0x03, 0x9C, 0x07, 0x9C,
  0x07, 0x9C, 0x07, 0x9C, 0x07, 0x3C, 0x07, 0x9E, 0x0F, 0x3C, 0x07, 0x9E,
  0x0E, 0x3C, 0x07, 0x9E, 0x1E, 0x3C, 0x0F, 0x8E, 0x1C, 0x7C, 0x0F, 0x0E,
  0x3C, 0x78, 0x0F, 0x0E, 0x3C, 0x78, 0x0F, 0x0F, 0x78, 0x78, 0x0F, 0x0F,
  0x78, 0x78, 0x0F, 0x0F, 0xF0, 0xF8, 0x1F, 0x07, 0xF0, 0xF8, 0x1F, 0x07,
  0xE0, 0xF0, 0x1F, 0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xF8,
  0x00, 0x7C, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0xFE, 0x00,
  0x1E, 0x03, 0xF8, 0x00, 0x78, 0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x07,
  0x81, 0xEF, 0x00, 0x3E, 0x07, 0xBC, 0x00, 0xF8, 0x1E, 0xF0, 0x03, 0xC0,
  0x79, 0xE0, 0x0F, 0x01, 0xE7, 0x80, 0x3C, 0x07, 0x9E, 0x00, 0xF0, 0x3E,
  0x78, 0x07, 0xC0, 0xF9, 0xE0, 0x1F, 0x03, 0xC3, 0xC0, 0x7C, 0x0F, 0x0F,
  0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x07, 0xC1, 0xE0,
  0xF8, 0x1F, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE0, 0x78, 0x3C,
  0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x0F, 0x0F, 0x03,
  0xE0, 0x3C, 0x7C, 0x0F, 0x80, 0xF1, 0xF0, 0x3C, 0x03, 0xC7, 0x80, 0xF0,
  0x07, 0x9E, 0x03, 0xC0, 0x1E, 0x78, 0x0F, 0x00, 0x79, 0xE0, 0x7C, 0x01,
  0xE7, 0x81, 0xF0, 0x07, 0xFE, 0x07, 0x80, 0x0F, 0xF0, 0x1E, 0x00, 0x3F,
  0xC0, 0x78, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x0F, 0x80, 0x0F, 0xF0,
  0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7F, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x78, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x3F,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7C,
  0x78, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3C,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x1F, 0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x9E, 0x01,
  0xF8, 0x07, 0x8F, 0x00, 0xFC, 0x03, 0xC7, 0x80, 0x7E, 0x01, 0xE3, 0xC0,
  0x3F, 0x01, 0xF1, 0xE0, 0x3B, 0x80, 0xF1, 0xF0, 0x1D, 0xC0, 0x78, 0xF8,
  0x0E, 0xE0, 0x3C, 0x7C, 0x0E, 0x60, 0x3C, 0x3C, 0x07, 0x30, 0x1E, 0x1E,
  0x03, 0xB8, 0x0F, 0x0F, 0x01, 0xDC, 0x0F, 0x87, 0x81, 0xCE, 0x07, 0x83,
  0xC0, 0xE7, 0x03, 0xC1, 0xE0, 0x73, 0x81, 0xE0, 0xF0, 0x71, 0xC1, 0xE0,
  0x78, 0x38, 0xE0, 0xF0, 0x3C, 0x1C, 0x70, 0x78, 0x1E, 0x0E, 0x38, 0x3C,
  0x0F, 0x0E, 0x1C, 0x3C, 0x07, 0x87, 0x0E, 0x1E, 0x03, 0xC3, 0x87, 0x0F,
  0x01, 0xE3, 0x83, 0x87, 0x80, 0xF1, 0xC1, 0xC7, 0x80, 0x78, 0xE0, 0xE3,
  0xC0, 0x3C, 0x70, 0x71, 0xE0, 0x1E, 0x70, 0x39, 0xE0, 0x0F, 0x38, 0x1C,
  0xF0, 0x07, 0x9C, 0x0E, 0x78, 0x03, 0x9C, 0x07, 0x3C, 0x03, 0xCE, 0x03,
  0xBC, 0x01, 0xE7, 0x01, 0xDE, 0x00, 0xF3, 0x80, 0xEF, 0x00, 0x7B, 0x80,
  0x67, 0x00, 0x3D, 0xC0, 0x37, 0x80, 0x1E, 0xE0, 0x3B, 0xC0, 0x0F, 0xE0,
  0x1D, 0xE0, 0x07, 0xF0, 0x0E, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0xC0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x3E, 0x07, 0x80,
  0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x03, 0xC7, 0xC0, 0x01,
  0xE3, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFC, 0x3C, 0x07, 0xFF, 0xCF, 0x81, 0xFF, 0xFD, 0xF0,
  0x7F, 0x03, 0xBE, 0x1F, 0x80, 0x3F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0xE0,
  0x7F, 0xFF, 0x7C, 0x07, 0xFF, 0xCF, 0x00, 0x7F, 0xE1, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x03, 0xC3, 0xFF, 0x00, 0x79, 0xFF, 0xF8, 0x0F, 0x7F,
  0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0xF6, 0x00, 0xFC, 0x1E, 0xF8,
  0xFF, 0x07, 0xDF, 0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0x1F, 0x1F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x78,
  0x00, 0xFF, 0xC3, 0xC0, 0x1F, 0xFF, 0x3E, 0x01, 0xFF, 0xFD, 0xF0, 0x1F,
  0xC0, 0xEF, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0xFF, 0x01, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0x3C,
  0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F,
  0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x1E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x3C, 0x07, 0xFF,
  0xEF, 0x81, 0xFF, 0xFD, 0xF0, 0x7F, 0x03, 0xFE, 0x1F, 0x80, 0x3F, 0x83,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x3B, 0xC0, 0xFF, 0xFE, 0x78, 0x0F, 0xFF,
  0xDF, 0x00, 0xFF, 0xE3, 0xE0, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xC7, 0xFF, 0x00, 0x79, 0xFF, 0xF8, 0x0F, 0x7F, 0xFF,
  0x03, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x01, 0xF8, 0x1E, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x80, 0x0F,
  0x00, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xF8, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x7E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xF0, 0x1E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0x81, 0xF0, 0x0F, 0x3F, 0x87, 0xF0, 0x1E, 0xFF, 0x9F, 0xF0, 0x3D,
  0xFF, 0x7F, 0xE0, 0x7C, 0x1E, 0x83, 0xE0, 0xF0, 0x3E, 0x07, 0xC3, 0xE0,
  0x3C, 0x0F, 0x87, 0xC0, 0x70, 0x1F, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x03,
  0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x01, 0xE1, 0xF0, 0x1E,
  0x03, 0xC3, 0xE0, 0x38, 0x0F, 0x87, 0x80, 0xF0, 0x1F, 0x0F, 0x01, 0xE0,
  0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x01,
  0xE1, 0xF0, 0x1C, 0x07, 0xC3, 0xC0, 0x38, 0x0F, 0x87, 0x80, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0,
  0xF8, 0x0F, 0x01, 0xE1, 0xF0, 0x1C, 0x07, 0xC3, 0xC0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x7C,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF1, 0xFF, 0xC0, 0x1E, 0x7F,
  0xFE, 0x03, 0xDF, 0xFF, 0xC0, 0xFF, 0x81, 0xFC, 0x1F, 0xC0, 0x0F, 0x83,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x3F, 0xCF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x79,
  0xFF, 0xF8, 0x03, 0xDF, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0x01, 0xFC, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3D, 0x80, 0x3F, 0x01, 0xEF, 0x8F, 0xF0,
  0x1F, 0x7F, 0xFF, 0x00, 0xF9, 0xFF, 0xF0, 0x07, 0xC7, 0xFE, 0x00, 0x3C,
  0x03, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x7C, 0x07, 0xFF, 0xCF, 0x81, 0xFF,
  0xFD, 0xF0, 0x7F, 0x03, 0xBE, 0x1F, 0x80, 0x3F, 0x83, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0x78, 0x3F, 0x00, 0xFF, 0x07, 0xF8,
  0x7B, 0xE0, 0x7F, 0xFF, 0x7C, 0x07, 0xFF, 0xCF, 0x00, 0x7F, 0xE1, 0xE0,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x78, 0xFF, 0xE0, 0x07, 0x9F, 0xFF, 0x80, 0x7B, 0xFF, 0xFC,
  0x0F, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xC1, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x81, 0xF8, 0x07, 0xE0, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C,
  0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x01, 0xEF, 0x01, 0xF8, 0x0F,
  0x78, 0x1D, 0xC0, 0x7B, 0xC0, 0xEE, 0x07, 0x9E, 0x07, 0x70, 0x3C, 0xF0,
  0x73, 0x81, 0xE7, 0x03, 0x9C, 0x1E, 0x38, 0x1C, 0xE0, 0xF1, 0xC1, 0xC7,
  0x07, 0x8E, 0x0E, 0x38, 0x38, 0x70, 0x71, 0xC3, 0xC3, 0x87, 0x0E, 0x1E,
  0x1C, 0x38, 0x70, 0xE0, 0xE1, 0xC3, 0x8F, 0x07, 0x1C, 0x1C, 0x78, 0x38,
  0xE0, 0xE3, 0x81, 0xC7, 0x07, 0x3C, 0x0E, 0x70, 0x39, 0xE0, 0x73, 0x81,
  0xCE, 0x03, 0x9C, 0x0E, 0xF0, 0x1D, 0xC0, 0x77, 0x80, 0xEE, 0x03, 0xB8,
  0x07, 0x70, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1E, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xF0,
  0x3F, 0x83, 0xDE, 0x07, 0xFF, 0xF7, 0xC0, 0x7F, 0xFC, 0xF8, 0x07, 0xFF,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0xFF, 0x80, 0x1F, 0x1F, 0xFC, 0x01,
  0xE3, 0xFF, 0xE0, 0x1E, 0x7C, 0x3E, 0x01, 0xE7, 0x81, 0xF0, 0x1E, 0x78,
  0x0F, 0x83, 0xEF, 0x80, 0xFC, 0x7C, 0xF8, 0x07, 0xFF, 0x8F, 0x00, 0x3F,
  0xF8, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 13, 42, 34, 11, -42 },
  { 70, 18, 17, 34, 11, -42 },
  { 109, 33, 42, 34, 1, -42 },
  { 283, 29, 58, 34, 3, -50 },
  { 494, 39, 42, 34, -2, -42 },
  { 699, 32, 43, 34, 1, -42 },
  { 871, 7, 17, 34, 16, -42 },
  { 886, 24, 55, 34, 9, -48 },
  { 1051, 23, 55, 34, 3, -48 },
  { 1210, 30, 30, 34, 3, -35 },
  { 1323, 27, 27, 34, 4, -32 },
  { 1415, 14, 18, 34, 6, -9 },
  { 1447, 19, 4, 34, 8, -21 },
  { 1457, 10, 10, 34, 10, -9 },
  { 1470, 34, 53, 34, 1, -47 },
  { 1696, 29, 43, 34, 3, -42 },
  { 1852, 26, 42, 34, 3, -42 },
  { 1989, 29, 42, 34, 3, -42 },
  { 2142, 29, 43, 34, 3, -42 },
  { 2298, 27, 42, 34, 4, -42 },
  { 2440, 28, 43, 34, 4, -42 },
  { 2591, 27, 43, 34, 3, -42 },
  { 2737, 27, 42, 34, 7, -42 },
  { 2879, 29, 43, 34, 3, -42 },
  { 3035, 27, 42, 34, 6, -42 },
  { 3177, 14, 33, 34, 10, -32 },
  { 3235, 18, 41, 34, 6, -32 },
  { 3328, 27, 30, 34, 5, -34 },
  { 3430, 27, 18, 34, 4, -28 },
  { 3491, 27, 30, 34, 3, -34 },
  { 3593, 23, 42, 34, 8, -42 },
  { 3714, 33, 52, 34, 1, -42 },
  { 3929, 28, 42, 34, 1, -42 },
  { 4076, 29, 42, 34, 3, -42 },
  { 4229, 28, 43, 34, 4, -42 },
  { 4380, 29, 42, 34, 3, -42 },
  { 4533, 31, 42, 34, 3, -42 },
  { 4696, 31, 42, 34, 3, -42 },
  { 4859, 28, 43, 34, 4, -42 },
  { 5010, 30, 42, 34, 3, -42 },
  { 5168, 28, 42, 34, 4, -42 },
  { 5315, 31, 43, 34, 1, -42 },
  { 5482, 32, 42, 34, 3, -42 },
  { 5650, 25, 42, 34, 4, -42 },
  { 5782, 32, 42, 34, 2, -42 },
  { 5950, 30, 42, 34, 3, -42 },
  { 6108, 28, 43, 34, 4, -42 },
  { 6259, 31, 42, 34, 3, -42 },
  { 6422, 28, 52, 34, 4, -42 },
  { 6604, 30, 42, 34, 3, -42 },
  { 6762, 30, 43, 34, 3, -42 },
  { 6924, 28, 42, 34, 7, -42 },
  { 7071, 29, 43, 34, 4, -42 },
  { 7227, 28, 42, 34, 7, -42 },
  { 7374, 33, 42, 34, 4, -42 },
  { 7548, 35, 42, 34, 0, -42 },
  { 7732, 30, 42, 34, 6, -42 },
  { 7890, 31, 42, 34, 2, -42 },
  { 8053, 23, 53, 34, 8, -47 },
  { 8206, 16, 53, 34, 10, -47 },
  { 8312, 22, 53, 34, 5, -47 },
  { 8458, 25, 23, 34, 5, -42 },
  { 8530, 28, 4, 34, 0, 1 },
  { 8544, 10, 8, 34, 15, -45 },
  { 8554, 27, 33, 34, 4, -32 },
  { 8666, 27, 43, 34, 3, -42 },
  { 8812, 27, 33, 34, 4, -32 },
  { 8924, 29, 43, 34, 4, -42 },
  { 9080, 26, 33, 34, 4, -32 },
  { 9188, 38, 52, 34, -2, -42 },
  { 9435, 27, 42, 34, 4, -32 },
  { 9577, 27, 42, 34, 3, -42 },
  { 9719, 27, 44, 34, 2, -44 },
  { 9868, 29, 54, 34, 1, -44 },
  { 10064, 30, 42, 34, 3, -42 },
  { 10222, 23, 42, 34, 6, -42 },
  { 10343, 31, 32, 34, 1, -32 },
  { 10467, 27, 32, 34, 3, -32 },
  { 10575, 26, 33, 34, 4, -32 },
  { 10683, 29, 42, 34, 1, -32 },
  { 10836, 27, 42, 34, 4, -32 },
  { 10978, 28, 32, 34, 4, -32 },
  { 11090, 27, 33, 34, 3, -32 },
  { 11202, 27, 40, 34, 5, -40 },
  { 11337, 27, 32, 34, 4, -31 },
  { 11445, 27, 31, 34, 6, -31 },
  { 11550, 29, 31, 34, 5, -31 },
  { 11663, 32, 31, 34, 1, -31 },
  { 11787, 27, 41, 34, 4, -31 },
  { 11926, 28, 31, 34, 3, -31 },
  { 12035, 28, 53, 34, 6, -47 },
  { 12221, 13, 53, 34, 11, -47 },
  { 12308, 28, 53, 34, 2, -47 },
  { 12494, 28, 12, 34, 4, -26 },
};

const GFXfont JetBrainsMono_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_LIGHTITALIC57PT7B_H_
