#ifndef _JETBRAINSMONO_LIGHTITALIC46PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x78, 0x1E, 0xF0, 0x3D,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0,
  0x39, 0xE0, 0x73, 0xC1, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x01,
  0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0x7E,
  0x03, 0xC7, 0x1E, 0x07, 0x87, 0x0F, 0x07, 0x87, 0x0F, 0x07, 0x06, 0x0F,
  0x0F, 0x06, 0x0F, 0x0F, 0x06, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x8E, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x18, 0xF8, 0x00, 0x18, 0x78, 0x00, 0x18, 0x3C, 0x00, 0x38, 0x3C,
  0x00, 0x38, 0x3C, 0x70, 0x38, 0x38, 0x70, 0x30, 0x38, 0x78, 0x30, 0x78,
  0x78, 0x30, 0x70, 0x7C, 0x70, 0xF0, 0x7E, 0x73, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x0E, 0x03, 0xFC, 0x00, 0x38, 0x0F, 0xFC, 0x00, 0xE0,
  0x3C, 0x3C, 0x03, 0xC0, 0x70, 0x38, 0x07, 0x01, 0xE0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x70, 0x07, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x07, 0x00, 0x1C,
  0x0E, 0x1E, 0x00, 0x38, 0x1C, 0x38, 0x00, 0x70, 0x78, 0xE0, 0x00, 0xF1,
  0xE3, 0x80, 0x01, 0xFF, 0x8E, 0x00, 0x01, 0xFE, 0x38, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x01, 0xC7, 0xFC, 0x00, 0x07, 0x1F,
  0xFC, 0x00, 0x1E, 0x78, 0x38, 0x00, 0x38, 0xE0, 0x70, 0x00, 0xE1, 0xC0,
  0xE0, 0x03, 0x87, 0x81, 0xC0, 0x0E, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x07,
  0x00, 0xF0, 0x38, 0x1E, 0x03, 0xC0, 0x70, 0x38, 0x07, 0x00, 0xF0, 0xF0,
  0x1C, 0x01, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0x01, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x1F,
  0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBE, 0x03, 0xC7, 0x8F, 0x01, 0xE7,
  0x83, 0xC1, 0xE3, 0x81, 0xE1, 0xE1, 0xC0, 0x78, 0xE1, 0xE0, 0x3C, 0xF0,
  0xF0, 0x0F, 0xF0, 0x78, 0x07, 0xF0, 0x3C, 0x01, 0xF0, 0x1C, 0x00, 0x78,
  0x0E, 0x00, 0x7C, 0x07, 0x00, 0x7F, 0x03, 0xC0, 0x7F, 0x81, 0xF0, 0x7D,
  0xE0, 0xFF, 0xFC, 0x78, 0x3F, 0xF8, 0x3C, 0x0F, 0xF8, 0x0F, 0x00, 0x3C,
  0xF3, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xCF, 0x3C, 0xF3, 0x80, 0x00, 0x00,
  0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x3C, 0x0E, 0xFC, 0x38, 0x7E, 0xFF, 0x19, 0xFF, 0x7F, 0xD3, 0xFC,
  0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xDE, 0x00, 0x03, 0x8F, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x0F, 0x80,
  0x1E, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x18, 0x03, 0x80,
  0x10, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3F, 0x7F, 0x7F, 0xFF, 0x7E,
  0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0x8F, 0xE0, 0x78, 0x07, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0x71, 0xE0,
  0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x07, 0x8F, 0x04, 0x0F, 0x1C, 0x3E,
  0x1E, 0x38, 0x7C, 0x3C, 0xF0, 0xF8, 0x71, 0xE1, 0xF0, 0xE3, 0xC1, 0xC3,
  0xC7, 0x80, 0x07, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x38,
  0xF0, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xBC, 0x01, 0xF1, 0xE0, 0x1F, 0x0E, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x80, 0x40, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFE, 0x07,
  0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70,
  0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3C, 0x01,
  0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x00, 0x0F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE3, 0xF8, 0x03, 0xDF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE1, 0xF8, 0x1F, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x1F,
  0x01, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x7B, 0xFE, 0x03, 0xDF, 0xFC, 0x0F, 0xE3, 0xF8, 0x7C, 0x03,
  0xE1, 0xE0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x7E,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x7E, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00,
  0x1E, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xE7, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x38, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0x87, 0xE1,
  0xE0, 0x0F, 0x1E, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF8, 0x03, 0xE3, 0xE0, 0x7E,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFE, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0xFE, 0x1F, 0xC7, 0xF8, 0x7E, 0x0F, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x01, 0xFC, 0xE1, 0xE0,
  0x3F, 0xEE, 0x1E, 0x07, 0xEE, 0xE1, 0xE0, 0xF0, 0x3E, 0x1C, 0x0F, 0x01,
  0xC1, 0xC0, 0xE0, 0x1C, 0x1C, 0x0E, 0x01, 0xC1, 0xC1, 0xE0, 0x1C, 0x3C,
  0x1E, 0x03, 0xC3, 0xC1, 0xC0, 0x3C, 0x38, 0x1C, 0x03, 0x83, 0x81, 0xC0,
  0x38, 0x38, 0x1C, 0x03, 0x83, 0x83, 0xC0, 0x78, 0x78, 0x3C, 0x07, 0x87,
  0x83, 0xC0, 0xF8, 0x70, 0x1E, 0x1F, 0x07, 0x01, 0xFF, 0x70, 0x70, 0x0F,
  0xE7, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC,
  0x00, 0x07, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x0E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x07, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x00,
  0xE1, 0xE0, 0x01, 0xC7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1E,
  0x07, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x78,
  0x0E, 0x00, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x1E, 0x03, 0xF0, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x78, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x8F, 0xE0,
  0x7C, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x78, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0x00, 0x1E, 0x07,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x1F, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x8F, 0xE0, 0x7C, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x3F, 0xF0,
  0xE0, 0xFF, 0xE1, 0xC1, 0xFF, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0,
  0x03, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x01,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x78,
  0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03,
  0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xEE, 0x03,
  0xB8, 0x77, 0x01, 0xD8, 0x3B, 0x81, 0xDC, 0x1D, 0xC0, 0xEE, 0x0E, 0xE0,
  0xE7, 0x07, 0x30, 0x73, 0x87, 0x9C, 0x73, 0xC3, 0xCE, 0x39, 0xC1, 0xC7,
  0x38, 0xE0, 0xE3, 0x9C, 0x70, 0x71, 0xCC, 0x38, 0x38, 0x6E, 0x3C, 0x3C,
  0x3E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x80, 0x03, 0x83,
  0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x83,
  0xF0, 0x03, 0x81, 0xF8, 0x01, 0xC0, 0xFC, 0x01, 0xE0, 0x7E, 0x00, 0xF0,
  0x3F, 0x80, 0x78, 0x1D, 0xC0, 0x3C, 0x0E, 0xE0, 0x1C, 0x0F, 0x70, 0x0E,
  0x07, 0xB8, 0x07, 0x03, 0xDE, 0x07, 0x81, 0xC7, 0x03, 0xC0, 0xE3, 0x81,
  0xE0, 0x71, 0xC0, 0xE0, 0x78, 0xE0, 0x70, 0x3C, 0x78, 0x38, 0x1E, 0x1C,
  0x3C, 0x0F, 0x0E, 0x1E, 0x07, 0x07, 0x0F, 0x03, 0x83, 0xC7, 0x83, 0xC0,
  0xE3, 0x81, 0xE0, 0x71, 0xC0, 0xF0, 0x39, 0xE0, 0x78, 0x1C, 0xF0, 0x38,
  0x0F, 0x78, 0x1C, 0x03, 0xBC, 0x0E, 0x01, 0xDC, 0x0F, 0x00, 0xEE, 0x07,
  0x80, 0x77, 0x03, 0xC0, 0x3F, 0x81, 0xC0, 0x0F, 0xC0, 0xE0, 0x07, 0xE0,
  0x70, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0x78, 0x07, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0,
  0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0x87, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x03, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x78, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E,
  0x03, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x8F, 0xE0, 0x7C, 0x07, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x38, 0x70, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0,
  0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x03,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x78, 0x03,
  0xF0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x01,
  0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C,
  0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x0F,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0,
  0x07, 0x87, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xE0, 0x1E,
  0x07, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x03,
  0x81, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x01, 0xCE, 0x00,
  0x07, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x0F, 0x01, 0xE7,
  0x01, 0xE0, 0x38, 0xE0, 0x3C, 0x07, 0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xB0,
  0x38, 0xF0, 0x36, 0x07, 0x1E, 0x0E, 0xC0, 0xE3, 0xC1, 0xD8, 0x3C, 0x78,
  0x33, 0x07, 0x0F, 0x06, 0xE0, 0xE1, 0xE1, 0xDC, 0x3C, 0x38, 0x33, 0x87,
  0x87, 0x06, 0x70, 0xE0, 0xE1, 0xCE, 0x1C, 0x1C, 0x39, 0xC7, 0x83, 0x86,
  0x38, 0xE0, 0x70, 0xC7, 0x1C, 0x0E, 0x38, 0xE3, 0x81, 0xC6, 0x1C, 0xF0,
  0x38, 0xC3, 0x1C, 0x07, 0x38, 0x63, 0x80, 0xE7, 0x0C, 0x70, 0x1C, 0xC1,
  0x9C, 0x03, 0xB8, 0x33, 0x80, 0x77, 0x06, 0x70, 0x0E, 0xC0, 0xDE, 0x01,
  0xD8, 0x1B, 0x80, 0x3F, 0x03, 0x70, 0x0F, 0xE0, 0x6E, 0x01, 0xD8, 0x0F,
  0xC0, 0x3B, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0E,
  0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x9C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x08, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x03, 0xC3,
  0x80, 0x38, 0x3C, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xC1, 0xE0,
  0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x3C, 0x1E,
  0x1E, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xFC, 0xF0, 0x3F, 0xFB, 0xC1, 0xFD,
  0xEF, 0x0F, 0x00, 0xFC, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x78,
  0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00,
  0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x0F, 0x87, 0xC0, 0xFE, 0x0F, 0xFF, 0x78, 0x3F, 0xF9, 0xC0, 0x3F,
  0xC7, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x1E, 0x7F, 0xC0, 0x3D, 0xFF, 0xE0, 0x7F, 0xDF,
  0xC0, 0xEC, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x80, 0x3C, 0x1F, 0x80, 0xF8, 0x3F, 0xFF, 0xE0, 0x73, 0xFF,
  0x81, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F,
  0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0x78,
  0x01, 0xE1, 0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x1C, 0x01, 0xFF, 0x3C, 0x03, 0xFF,
  0xBC, 0x07, 0xF7, 0xBC, 0x0F, 0x00, 0xFC, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00,
  0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x0F,
  0xE0, 0x3F, 0xFD, 0xE0, 0x3F, 0xF9, 0xC0, 0x0F, 0xF1, 0xC0, 0x00, 0x3E,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xCF, 0xE0, 0xF0, 0x0F, 0x0F,
  0x00, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x03,
  0xCE, 0x00, 0x1E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x1E, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0xF0, 0x3F, 0xFB, 0xC1, 0xFD,
  0xFF, 0x0F, 0x80, 0xFC, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x78,
  0x00, 0x71, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7E, 0x07, 0xE0,
  0xFF, 0xF7, 0x81, 0xFF, 0x9E, 0x03, 0xFC, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x1E, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0xDF, 0xC0, 0xEC,
  0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7E, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x1E, 0x00, 0xF8, 0x1C, 0x01, 0xF0, 0x1C, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x38, 0x1C, 0x07, 0x3F, 0x3F, 0x83, 0xBF, 0xBF,
  0xC1, 0xE3, 0xD1, 0xE0, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x38,
  0x1C, 0x3C, 0x1C, 0x0E, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0x87, 0x03,
  0x83, 0xC7, 0x81, 0xC1, 0xE3, 0xC1, 0xC0, 0xF1, 0xE0, 0xE0, 0x70, 0xE0,
  0x70, 0x38, 0x70, 0x38, 0x1C, 0x38, 0x1C, 0x1E, 0x3C, 0x0E, 0x0F, 0x1E,
  0x0F, 0x07, 0x8F, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC3, 0x81, 0xC0, 0xE1,
  0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x38, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0xDF,
  0xC0, 0xEC, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xE1, 0xE0, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xEF, 0xE0, 0xF8, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00,
  0xF3, 0x80, 0x07, 0x9C, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x01, 0xE1, 0xF0, 0x1E, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0x9F, 0xF8, 0x07, 0xBF, 0xFC, 0x07, 0xFD,
  0xFC, 0x07, 0x60, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3F, 0x01, 0xF0, 0x3B, 0xFF,
  0xE0, 0x39, 0xFF, 0xC0, 0x78, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC,
  0xF0, 0x7F, 0xFB, 0xC3, 0xFD, 0xEF, 0x0F, 0x00, 0xFC, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80,
  0x07, 0x8E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0xFE, 0x1F, 0xFF,
  0x78, 0x3F, 0xF9, 0xC0, 0x7F, 0xC7, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x7F, 0xC0, 0x3D,
  0xFF, 0xC0, 0x77, 0x9F, 0xC0, 0xFC, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C,
  0x70, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xEF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0xF0,
  0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x9E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xF0, 0x3E, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF,
  0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0x70,
  0x0F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x01, 0xC1, 0xC0, 0x07,
  0x0F, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC,
  0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x3C, 0x0F, 0xE0, 0x7C, 0x0E, 0xE0, 0x7C, 0x0E,
  0xE0, 0x7C, 0x1E, 0xE0, 0xFC, 0x1C, 0xE0, 0xDC, 0x1C, 0xE0, 0xDC, 0x3C,
  0xE1, 0xDC, 0x38, 0xE1, 0x9C, 0x38, 0xE1, 0x9C, 0x38, 0xE3, 0x9C, 0x70,
  0xE3, 0x1C, 0x70, 0xE3, 0x1C, 0x70, 0xE7, 0x1C, 0xE0, 0xE6, 0x1C, 0xE0,
  0xE6, 0x1C, 0xE0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEC, 0x1D, 0xC0,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x01,
  0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0F,
  0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x83, 0xF8, 0x3F, 0xFD, 0xE0, 0x7F,
  0xE7, 0x80, 0xFF, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1E,
  0x3F, 0xC0, 0x38, 0xFF, 0xC0, 0x73, 0xE7, 0xC0, 0xE7, 0x87, 0x83, 0xCE,
  0x07, 0x87, 0xBC, 0x0F, 0xFE, 0x78, 0x0F, 0xF8, 0xF0, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 34, 28, 9, -34 },
  { 44, 15, 14, 28, 9, -34 },
  { 71, 27, 34, 28, 1, -34 },
  { 186, 24, 46, 28, 2, -40 },
  { 324, 31, 34, 28, -1, -34 },
  { 456, 25, 34, 28, 1, -34 },
  { 563, 6, 14, 28, 13, -34 },
  { 574, 18, 45, 28, 8, -39 },
  { 676, 19, 45, 28, 2, -39 },
  { 783, 24, 24, 28, 3, -28 },
  { 855, 22, 22, 28, 3, -26 },
  { 916, 11, 14, 28, 5, -7 },
  { 936, 15, 3, 28, 7, -17 },
  { 942, 8, 7, 28, 8, -7 },
  { 949, 27, 43, 28, 1, -38 },
  { 1095, 23, 34, 28, 3, -34 },
  { 1193, 21, 34, 28, 2, -34 },
  { 1283, 24, 34, 28, 2, -34 },
  { 1385, 24, 34, 28, 2, -34 },
  { 1487, 22, 34, 28, 3, -34 },
  { 1581, 23, 34, 28, 3, -34 },
  { 1679, 22, 34, 28, 2, -34 },
  { 1773, 22, 34, 28, 6, -34 },
  { 1867, 24, 34, 28, 2, -34 },
  { 1969, 21, 34, 28, 5, -34 },
  { 2059, 11, 26, 28, 8, -26 },
  { 2095, 14, 33, 28, 5, -26 },
  { 2153, 22, 24, 28, 4, -27 },
  { 2219, 22, 14, 28, 3, -22 },
  { 2258, 22, 24, 28, 2, -27 },
  { 2324, 18, 34, 28, 7, -34 },
  { 2401, 28, 42, 28, 0, -34 },
  { 2548, 23, 34, 28, 0, -34 },
  { 2646, 24, 34, 28, 2, -34 },
  { 2748, 23, 34, 28, 3, -34 },
  { 2846, 24, 34, 28, 2, -34 },
  { 2948, 24, 34, 28, 3, -34 },
  { 3050, 24, 34, 28, 3, -34 },
  { 3152, 23, 34, 28, 3, -34 },
  { 3250, 24, 34, 28, 2, -34 },
  { 3352, 23, 34, 28, 3, -34 },
  { 3450, 25, 34, 28, 1, -34 },
  { 3557, 26, 34, 28, 2, -34 },
  { 3668, 20, 34, 28, 3, -34 },
  { 3753, 25, 34, 28, 2, -34 },
  { 3860, 25, 34, 28, 2, -34 },
  { 3967, 23, 34, 28, 3, -34 },
  { 4065, 25, 34, 28, 2, -34 },
  { 4172, 23, 42, 28, 3, -34 },
  { 4293, 25, 34, 28, 2, -34 },
  { 4400, 24, 34, 28, 2, -34 },
  { 4502, 23, 34, 28, 5, -34 },
  { 4600, 24, 34, 28, 3, -34 },
  { 4702, 22, 34, 28, 6, -34 },
  { 4796, 27, 34, 28, 3, -34 },
  { 4911, 28, 34, 28, 0, -34 },
  { 5030, 24, 34, 28, 5, -34 },
  { 5132, 24, 34, 28, 2, -34 },
  { 5234, 18, 43, 28, 7, -38 },
  { 5331, 13, 43, 28, 8, -38 },
  { 5401, 18, 43, 28, 4, -38 },
  { 5498, 20, 18, 28, 4, -34 },
  { 5543, 23, 3, 28, 0, 1 },
  { 5552, 8, 6, 28, 12, -36 },
  { 5558, 22, 26, 28, 3, -26 },
  { 5630, 23, 34, 28, 2, -34 },
  { 5728, 22, 26, 28, 3, -26 },
  { 5800, 24, 34, 28, 3, -34 },
  { 5902, 21, 26, 28, 3, -26 },
  { 5971, 31, 42, 28, -2, -34 },
  { 6134, 22, 34, 28, 3, -26 },
  { 6228, 23, 34, 28, 2, -34 },
  { 6326, 22, 36, 28, 2, -36 },
  { 6425, 23, 44, 28, 1, -36 },
  { 6552, 24, 34, 28, 3, -34 },
  { 6654, 19, 34, 28, 5, -34 },
  { 6735, 25, 26, 28, 1, -26 },
  { 6817, 23, 26, 28, 2, -26 },
  { 6892, 21, 26, 28, 3, -26 },
  { 6961, 24, 34, 28, 1, -26 },
  { 7063, 22, 34, 28, 3, -26 },
  { 7157, 23, 26, 28, 3, -26 },
  { 7232, 21, 26, 28, 3, -26 },
  { 7301, 22, 32, 28, 4, -32 },
  { 7389, 22, 25, 28, 3, -25 },
  { 7458, 22, 25, 28, 5, -25 },
  { 7527, 24, 25, 28, 4, -25 },
  { 7602, 25, 25, 28, 1, -25 },
  { 7681, 22, 33, 28, 3, -25 },
  { 7772, 23, 25, 28, 2, -25 },
  { 7844, 24, 43, 28, 4, -38 },
  { 7973, 11, 43, 28, 9, -38 },
  { 8033, 23, 43, 28, 1, -38 },
  { 8157, 23, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_LIGHTITALIC46PT7B_H_
