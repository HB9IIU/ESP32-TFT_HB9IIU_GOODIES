#ifndef _JETBRAINSMONO_LIGHTITALIC18PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x8C, 0x63, 0x10, 0x84, 0x20, 0x00, 0xCE, 0x00, 0x65, 0x34,
  0xD3, 0xC8, 0x04, 0x60, 0x88, 0x33, 0x04, 0x43, 0xFE, 0x33, 0x04, 0x40,
  0x88, 0x7F, 0x94, 0x40, 0x88, 0x23, 0x04, 0x40, 0x02, 0x02, 0x01, 0x03,
  0xE3, 0x59, 0x25, 0x90, 0x48, 0x38, 0x0F, 0x02, 0xC1, 0x20, 0x96, 0x5B,
  0x48, 0xF8, 0x10, 0x08, 0x04, 0x00, 0x1E, 0x19, 0x91, 0x08, 0x98, 0x44,
  0x83, 0x68, 0x0E, 0x80, 0x08, 0x00, 0x9C, 0x0D, 0x20, 0xD1, 0x04, 0x88,
  0x44, 0xCC, 0x1C, 0x00, 0x0F, 0x86, 0x61, 0x08, 0x40, 0x18, 0x06, 0x03,
  0xC1, 0x93, 0x47, 0x90, 0xC4, 0x31, 0x1E, 0x78, 0x80, 0x5F, 0xC0, 0x06,
  0x18, 0x61, 0x82, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x10, 0x78, 0x10, 0x30, 0x60, 0x41, 0x83, 0x06, 0x08, 0x10,
  0x20, 0xC1, 0x04, 0x30, 0xC0, 0x04, 0x06, 0x03, 0x1D, 0x37, 0xF0, 0x40,
  0xD0, 0xCC, 0x42, 0x00, 0x0C, 0x06, 0x02, 0x1F, 0xFF, 0xF8, 0x40, 0x60,
  0x30, 0x33, 0x64, 0xC8, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x18, 0xD8, 0x2C,
  0x14, 0x1A, 0x4D, 0x36, 0x82, 0xC1, 0x60, 0xB0, 0xC8, 0xC7, 0xC0, 0x0E,
  0x1E, 0x26, 0x44, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0xFF,
  0x1F, 0x18, 0xD8, 0x28, 0x10, 0x18, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x0F, 0xF0, 0x3F, 0x80, 0xC0, 0x80, 0x80, 0x80, 0xF0, 0x0C, 0x02,
  0x01, 0x61, 0xB0, 0xD8, 0xC7, 0xC0, 0x01, 0x81, 0x01, 0x01, 0x81, 0x81,
  0x88, 0x84, 0x82, 0xC3, 0x7F, 0x80, 0xC0, 0x40, 0x20, 0x3F, 0x90, 0x08,
  0x04, 0x06, 0xE3, 0xF9, 0x84, 0x02, 0x01, 0x00, 0xB0, 0xD8, 0xC7, 0xC0,
  0x03, 0x02, 0x03, 0x03, 0x03, 0x01, 0xF1, 0x8C, 0x82, 0xC1, 0x60, 0xB0,
  0xD8, 0xC7, 0xC0, 0x7F, 0xE0, 0xF0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x0C, 0x06, 0x00, 0x1F, 0x18, 0xC8, 0x24, 0x32, 0x11,
  0xF0, 0x70, 0xC6, 0x41, 0x60, 0xB0, 0xD8, 0xC7, 0xC0, 0x3E, 0x63, 0xC1,
  0x81, 0x81, 0xC3, 0xC6, 0x7E, 0x0C, 0x18, 0x10, 0x20, 0x60, 0x31, 0x88,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x18, 0xF1, 0x00, 0x00, 0x00, 0x0C, 0x31,
  0x86, 0x30, 0x80, 0x01, 0x03, 0x0E, 0x70, 0xC0, 0xC0, 0x60, 0x18, 0x0E,
  0x02, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x18, 0x38, 0x70, 0xE0, 0x40, 0x00, 0x78, 0x18, 0x18, 0x30,
  0x41, 0x9E, 0x20, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x0F, 0xC3, 0x08, 0xC1,
  0x90, 0x36, 0x36, 0xCD, 0x91, 0x12, 0x62, 0x4C, 0x49, 0x19, 0x33, 0x63,
  0xCC, 0x00, 0x80, 0x18, 0x01, 0xE0, 0x07, 0x02, 0x81, 0x41, 0xA0, 0x90,
  0xC8, 0x44, 0x22, 0x3F, 0x90, 0xD8, 0x68, 0x3C, 0x08, 0x3F, 0x10, 0xC8,
  0x6C, 0x36, 0x1B, 0x39, 0xF8, 0x86, 0x41, 0x20, 0xB0, 0xD8, 0xCF, 0xC0,
  0x1F, 0x18, 0xC8, 0x2C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0xB0,
  0xC8, 0xC7, 0xC0, 0x3F, 0x10, 0xC8, 0x6C, 0x36, 0x1B, 0x0D, 0x04, 0x82,
  0x41, 0x21, 0xB0, 0xD8, 0xCF, 0x80, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x60,
  0x1F, 0xC7, 0xF1, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xFF, 0x00, 0x3F,
  0xC8, 0x02, 0x00, 0x80, 0x60, 0x18, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x00, 0x1F, 0x18, 0xC8, 0x2C, 0x06, 0x02, 0x01, 0x3E,
  0x9E, 0x41, 0x60, 0xB0, 0xC8, 0xC7, 0xC0, 0x20, 0x90, 0x48, 0x6C, 0x36,
  0x1B, 0x09, 0xFC, 0x82, 0x41, 0x21, 0xB0, 0xD8, 0x48, 0x20, 0x3F, 0x82,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x0F,
  0xE0, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x90, 0x64, 0x11, 0x8C, 0x3E, 0x00, 0x20, 0xC8, 0x62, 0x11, 0x8C, 0x66,
  0x19, 0x07, 0xC1, 0x10, 0x46, 0x11, 0x8C, 0x23, 0x0C, 0x83, 0x00, 0x30,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xFF,
  0x31, 0xDC, 0x65, 0x39, 0x4A, 0x56, 0x97, 0x64, 0xD9, 0x04, 0xC1, 0x30,
  0x48, 0x12, 0x0C, 0x83, 0x00, 0x30, 0x98, 0x4C, 0x2F, 0x36, 0x9A, 0x49,
  0x24, 0x9A, 0x4D, 0x63, 0xB1, 0xD8, 0xE8, 0x60, 0x1F, 0x18, 0xC8, 0x6C,
  0x36, 0x1A, 0x0D, 0x04, 0x82, 0x41, 0x61, 0xB0, 0xC8, 0xC7, 0xC0, 0x3F,
  0x08, 0x62, 0x0D, 0x83, 0x60, 0x98, 0x67, 0xF1, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x00, 0x1F, 0x18, 0xC8, 0x2C, 0x16, 0x1A, 0x0D, 0x04,
  0x82, 0xC1, 0x60, 0xB0, 0xC8, 0xC7, 0xC0, 0x60, 0x10, 0x0C, 0x3F, 0x10,
  0xC8, 0x2C, 0x16, 0x0B, 0x0D, 0xFC, 0x88, 0x44, 0x23, 0x30, 0x98, 0x48,
  0x30, 0x1F, 0x18, 0xC8, 0x2C, 0x02, 0x01, 0xC0, 0x78, 0x06, 0x01, 0x00,
  0xB0, 0xD8, 0x47, 0xC0, 0xFF, 0x84, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x00, 0x20, 0x90, 0x48, 0x2C, 0x36,
  0x1B, 0x09, 0x04, 0x82, 0x41, 0x61, 0xB0, 0xC8, 0xC7, 0xC0, 0xC1, 0xE0,
  0x90, 0x48, 0x64, 0x22, 0x31, 0x10, 0x98, 0x68, 0x34, 0x1E, 0x0E, 0x03,
  0x00, 0x46, 0x69, 0x89, 0x31, 0x26, 0x64, 0xC8, 0xA9, 0x15, 0x62, 0xA8,
  0xE5, 0x1C, 0xA3, 0x9C, 0x73, 0x0C, 0x60, 0x30, 0x62, 0x18, 0x62, 0x04,
  0x80, 0xF0, 0x0C, 0x01, 0x80, 0x50, 0x1A, 0x02, 0x60, 0x84, 0x30, 0xCC,
  0x18, 0xC1, 0xA0, 0x90, 0xCC, 0x42, 0x41, 0x60, 0xE0, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x02, 0x00, 0x3F, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20,
  0x30, 0x30, 0x10, 0x10, 0x18, 0x0F, 0xF0, 0x3E, 0x60, 0x81, 0x02, 0x0C,
  0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0xF0, 0xC6, 0x10,
  0x84, 0x31, 0x84, 0x21, 0x8C, 0x21, 0x08, 0x63, 0x08, 0x3E, 0x08, 0x10,
  0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0xF0,
  0x0C, 0x28, 0xD1, 0x26, 0x28, 0x60, 0x80, 0xFF, 0xFF, 0xC0, 0xCC, 0x1F,
  0x99, 0xD8, 0x48, 0x24, 0x12, 0x0B, 0x0D, 0x86, 0x47, 0x3D, 0x00, 0x20,
  0x10, 0x08, 0x0D, 0xE7, 0x33, 0x09, 0x04, 0x82, 0x41, 0x21, 0xB0, 0xD8,
  0xCB, 0xC0, 0x1E, 0x19, 0x98, 0x68, 0x04, 0x02, 0x03, 0x01, 0x86, 0x46,
  0x3E, 0x00, 0x00, 0x80, 0x40, 0x23, 0xF3, 0x3B, 0x09, 0x04, 0x82, 0x41,
  0x61, 0xB0, 0xC8, 0xE7, 0xA0, 0x1E, 0x19, 0x98, 0x48, 0x27, 0xF2, 0x03,
  0x01, 0x86, 0x42, 0x3E, 0x00, 0x01, 0xF0, 0x30, 0x02, 0x00, 0x20, 0x1F,
  0xE0, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x0F, 0x80, 0x1F, 0x99, 0xD8, 0x48, 0x24, 0x12, 0x09,
  0x0C, 0x86, 0x7F, 0x01, 0x00, 0x80, 0xC7, 0xC0, 0x20, 0x10, 0x08, 0x0D,
  0xE7, 0x33, 0x09, 0x04, 0x82, 0x41, 0x21, 0xB0, 0xD8, 0x68, 0x20, 0x06,
  0x06, 0x00, 0x00, 0x3C, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xF8, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x18, 0xF8, 0x00, 0x30, 0x10, 0x08,
  0x04, 0x36, 0x13, 0x11, 0x18, 0xF8, 0x7C, 0x22, 0x31, 0x98, 0x4C, 0x30,
  0xF8, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x03, 0xE0,
  0x2D, 0xCD, 0x92, 0x45, 0x93, 0x64, 0xD1, 0x24, 0x49, 0x32, 0x48, 0xB2,
  0x60, 0x6F, 0x39, 0x98, 0x48, 0x24, 0x12, 0x09, 0x0D, 0x86, 0xC3, 0x41,
  0x00, 0x1E, 0x19, 0x98, 0x48, 0x24, 0x12, 0x0B, 0x0D, 0x86, 0x46, 0x3E,
  0x00, 0x37, 0x8E, 0x63, 0x08, 0x82, 0x20, 0x88, 0x22, 0x19, 0x86, 0x63,
  0x17, 0x84, 0x01, 0x00, 0xC0, 0x00, 0x1F, 0x99, 0xD8, 0x48, 0x24, 0x12,
  0x0B, 0x0D, 0x86, 0x46, 0x3D, 0x00, 0x80, 0x40, 0x60, 0x2F, 0x18, 0xD8,
  0x6C, 0x36, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x00, 0x1F, 0x10, 0x98,
  0x2C, 0x03, 0xC0, 0x78, 0x0C, 0x06, 0xC2, 0x3F, 0x00, 0x18, 0x10, 0x10,
  0xFF, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x62, 0x3C, 0x61, 0xB0,
  0xD8, 0x48, 0x24, 0x12, 0x0B, 0x0D, 0x86, 0x46, 0x3E, 0x00, 0x81, 0xC3,
  0xC2, 0x46, 0x44, 0x4C, 0x48, 0x78, 0x70, 0x30, 0xCC, 0xF3, 0x2C, 0xCB,
  0x52, 0xD5, 0x35, 0x4E, 0x51, 0x98, 0x66, 0x11, 0x80, 0x30, 0xC4, 0x61,
  0x90, 0x28, 0x0E, 0x03, 0x81, 0xA0, 0xCC, 0x21, 0x30, 0x60, 0x61, 0xB0,
  0xD8, 0x48, 0x24, 0x12, 0x0B, 0x0C, 0x86, 0x7E, 0x01, 0x00, 0x80, 0xC7,
  0xC0, 0x3F, 0xA0, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x7F,
  0x00, 0x03, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0xE0, 0x0C,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x20, 0x1C, 0x00, 0x32, 0x22, 0x26,
  0x66, 0x44, 0x4C, 0xCC, 0x88, 0x80, 0x1C, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x11, 0x03, 0x83, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0xE0, 0x00, 0x78, 0xA4, 0xF3, 0xC0,
};

const GFXglyph JetBrainsMono_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 5, 11, 3, -13 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 9, 19, 11, 1, -16 },
  { 54, 13, 13, 11, -1, -13 },
  { 76, 10, 13, 11, 0, -13 },
  { 93, 2, 5, 11, 5, -13 },
  { 95, 7, 17, 11, 3, -15 },
  { 110, 7, 17, 11, 1, -15 },
  { 125, 9, 9, 11, 1, -11 },
  { 136, 9, 8, 11, 1, -10 },
  { 145, 4, 6, 11, 2, -3 },
  { 148, 6, 2, 11, 3, -7 },
  { 150, 3, 3, 11, 3, -3 },
  { 152, 11, 17, 11, 0, -15 },
  { 176, 9, 13, 11, 1, -13 },
  { 191, 8, 13, 11, 1, -13 },
  { 204, 9, 13, 11, 1, -13 },
  { 219, 9, 13, 11, 1, -13 },
  { 234, 9, 13, 11, 1, -13 },
  { 249, 9, 13, 11, 1, -13 },
  { 264, 9, 13, 11, 1, -13 },
  { 279, 9, 13, 11, 2, -13 },
  { 294, 9, 13, 11, 1, -13 },
  { 309, 8, 13, 11, 2, -13 },
  { 322, 5, 10, 11, 3, -10 },
  { 329, 6, 13, 11, 2, -10 },
  { 339, 8, 10, 11, 2, -11 },
  { 349, 9, 6, 11, 1, -9 },
  { 356, 9, 10, 11, 1, -11 },
  { 368, 7, 13, 11, 3, -13 },
  { 380, 11, 16, 11, 0, -13 },
  { 402, 9, 13, 11, 0, -13 },
  { 417, 9, 13, 11, 1, -13 },
  { 432, 9, 13, 11, 1, -13 },
  { 447, 9, 13, 11, 1, -13 },
  { 462, 10, 13, 11, 1, -13 },
  { 479, 10, 13, 11, 1, -13 },
  { 496, 9, 13, 11, 1, -13 },
  { 511, 9, 13, 11, 1, -13 },
  { 526, 9, 13, 11, 1, -13 },
  { 541, 10, 13, 11, 0, -13 },
  { 558, 10, 13, 11, 1, -13 },
  { 575, 8, 13, 11, 1, -13 },
  { 588, 10, 13, 11, 1, -13 },
  { 605, 9, 13, 11, 1, -13 },
  { 620, 9, 13, 11, 1, -13 },
  { 635, 10, 13, 11, 1, -13 },
  { 652, 9, 16, 11, 1, -13 },
  { 670, 9, 13, 11, 1, -13 },
  { 685, 9, 13, 11, 1, -13 },
  { 700, 9, 13, 11, 2, -13 },
  { 715, 9, 13, 11, 1, -13 },
  { 730, 9, 13, 11, 2, -13 },
  { 745, 11, 13, 11, 1, -13 },
  { 763, 11, 13, 11, 0, -13 },
  { 781, 9, 13, 11, 2, -13 },
  { 796, 9, 13, 11, 1, -13 },
  { 811, 7, 17, 11, 3, -15 },
  { 826, 5, 17, 11, 3, -15 },
  { 837, 7, 17, 11, 2, -15 },
  { 852, 7, 7, 11, 2, -13 },
  { 859, 9, 2, 11, 0, 0 },
  { 862, 3, 2, 11, 5, -14 },
  { 863, 9, 10, 11, 1, -10 },
  { 875, 9, 13, 11, 1, -13 },
  { 890, 9, 10, 11, 1, -10 },
  { 902, 9, 13, 11, 1, -13 },
  { 917, 9, 10, 11, 1, -10 },
  { 929, 12, 16, 11, -1, -13 },
  { 953, 9, 13, 11, 1, -10 },
  { 968, 9, 13, 11, 1, -13 },
  { 983, 8, 14, 11, 1, -14 },
  { 997, 9, 17, 11, 0, -14 },
  { 1017, 9, 13, 11, 1, -13 },
  { 1032, 7, 13, 11, 2, -13 },
  { 1044, 10, 10, 11, 0, -10 },
  { 1057, 9, 10, 11, 1, -10 },
  { 1069, 9, 10, 11, 1, -10 },
  { 1081, 10, 13, 11, 0, -10 },
  { 1098, 9, 13, 11, 1, -10 },
  { 1113, 9, 10, 11, 1, -10 },
  { 1125, 9, 10, 11, 1, -10 },
  { 1137, 8, 13, 11, 2, -13 },
  { 1150, 9, 10, 11, 1, -10 },
  { 1162, 8, 10, 11, 2, -10 },
  { 1172, 10, 10, 11, 1, -10 },
  { 1185, 10, 10, 11, 0, -10 },
  { 1198, 9, 13, 11, 1, -10 },
  { 1213, 9, 10, 11, 1, -10 },
  { 1225, 9, 17, 11, 2, -15 },
  { 1245, 4, 17, 11, 4, -15 },
  { 1254, 10, 17, 11, 0, -15 },
  { 1276, 9, 3, 11, 1, -8 },
};

const GFXfont JetBrainsMono_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_LIGHTITALIC18PT7B_H_
