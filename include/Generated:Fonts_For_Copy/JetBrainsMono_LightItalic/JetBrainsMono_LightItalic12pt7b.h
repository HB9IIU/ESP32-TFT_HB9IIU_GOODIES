#ifndef _JETBRAINSMONO_LIGHTITALIC12PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x80, 0xC0, 0x55, 0x99, 0x12, 0x24, 0x53, 0x72, 0x45,
  0x3F, 0x24, 0xD0, 0x10, 0xE5, 0x54, 0x61, 0xC2, 0x8A, 0xAB, 0xC2, 0x10,
  0x31, 0x52, 0x54, 0x78, 0x10, 0x1E, 0x32, 0x52, 0x8C, 0x1C, 0x48, 0x81,
  0x07, 0x2A, 0x93, 0x44, 0x74, 0x56, 0x19, 0x10, 0x84, 0x42, 0x10, 0x82,
  0x18, 0x20, 0x61, 0x11, 0x11, 0x11, 0x22, 0xC8, 0x12, 0x9D, 0x88, 0x52,
  0x60, 0x10, 0x82, 0x7E, 0x20, 0x80, 0x29, 0x40, 0xF0, 0x70, 0x02, 0x0C,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x39, 0x18, 0x61, 0xAA,
  0x28, 0xA2, 0xF0, 0x13, 0xA4, 0x21, 0x08, 0x84, 0xF8, 0x39, 0x18, 0x42,
  0x08, 0x46, 0x30, 0xF8, 0x7C, 0x21, 0x08, 0x18, 0x20, 0xA2, 0xF0, 0x08,
  0x84, 0x44, 0xC7, 0xE1, 0x18, 0x7D, 0x04, 0x1C, 0xC8, 0x20, 0xA2, 0xF0,
  0x18, 0x88, 0x8F, 0xC6, 0x31, 0xF0, 0x7D, 0x18, 0x82, 0x10, 0x42, 0x08,
  0x40, 0x39, 0x14, 0x52, 0x33, 0x28, 0xA2, 0xF0, 0x39, 0x18, 0x61, 0xD9,
  0xA1, 0x08, 0x40, 0x6C, 0x00, 0xB0, 0x33, 0x00, 0x02, 0x44, 0x80, 0x0C,
  0xCC, 0x30, 0x30, 0x20, 0xFC, 0x00, 0x3E, 0xC1, 0x06, 0x36, 0x40, 0xE0,
  0x84, 0x26, 0x22, 0x00, 0xC0, 0x1C, 0x45, 0x0A, 0x75, 0x2A, 0x64, 0xCE,
  0x81, 0x01, 0xC0, 0x08, 0x61, 0x8A, 0x24, 0x97, 0xD1, 0x84, 0x79, 0x34,
  0x62, 0xF2, 0x28, 0xA2, 0xF0, 0x39, 0x14, 0x60, 0x82, 0x08, 0x22, 0xF0,
  0x71, 0x24, 0x62, 0x8A, 0x28, 0xA2, 0xF0, 0x7D, 0x04, 0x10, 0xFA, 0x08,
  0x20, 0xF8, 0x7D, 0x04, 0x10, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x14, 0x60,
  0x82, 0xE8, 0xA2, 0xF0, 0x45, 0x14, 0x62, 0xFA, 0x28, 0xA2, 0x88, 0x7C,
  0x41, 0x08, 0x20, 0x82, 0x08, 0xF8, 0x0E, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x64, 0x78, 0x45, 0x34, 0xA4, 0xF2, 0x49, 0x22, 0x88, 0x42, 0x10, 0x84,
  0x42, 0x10, 0xF8, 0x22, 0xCD, 0x5A, 0xD5, 0xC8, 0x91, 0x22, 0x84, 0x45,
  0x96, 0x6A, 0xAA, 0xA9, 0xA6, 0x98, 0x39, 0x34, 0x62, 0x8A, 0x28, 0xA2,
  0xF0, 0x79, 0x14, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x14, 0x61, 0x8A,
  0x28, 0xA2, 0xF0, 0x41, 0x00, 0x79, 0x14, 0x61, 0xFA, 0x49, 0x24, 0x88,
  0x39, 0x14, 0x10, 0x30, 0x20, 0xA2, 0xF0, 0xFC, 0x41, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x45, 0x14, 0x62, 0x8A, 0x28, 0xA2, 0xF0, 0x8C, 0x65, 0x29,
  0x52, 0x98, 0xC0, 0x93, 0x2A, 0xD5, 0xAB, 0x5B, 0x36, 0x4C, 0x90, 0x22,
  0x48, 0x90, 0xC1, 0x03, 0x0A, 0x22, 0x84, 0x86, 0x89, 0x22, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x7C, 0x30, 0x84, 0x20, 0x84, 0x20, 0xF8, 0x74, 0x44,
  0x44, 0x48, 0x88, 0xE0, 0x88, 0x44, 0x44, 0x42, 0x22, 0x30, 0x38, 0x44,
  0x21, 0x08, 0x42, 0x21, 0x38, 0x11, 0x8A, 0x98, 0x80, 0xFC, 0xC0, 0x35,
  0x28, 0xA2, 0x8A, 0x2F, 0x80, 0x42, 0x1C, 0x98, 0xC6, 0x31, 0xF0, 0x32,
  0x63, 0x08, 0x47, 0xC0, 0x04, 0x13, 0x52, 0x8A, 0x28, 0xA2, 0xF8, 0x32,
  0x63, 0xF8, 0x47, 0xC0, 0x0F, 0x10, 0x10, 0x7E, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0xE0, 0x35, 0x28, 0xA2, 0x8A, 0x66, 0x84, 0xF0, 0x42, 0x1C,
  0x98, 0xC6, 0x31, 0x88, 0x08, 0x03, 0x82, 0x08, 0x41, 0x04, 0xFC, 0x04,
  0x03, 0xC1, 0x08, 0x20, 0x82, 0x08, 0x4F, 0x00, 0x41, 0x04, 0x52, 0x93,
  0x89, 0x24, 0x88, 0xE1, 0x08, 0x42, 0x11, 0x08, 0x38, 0x74, 0xB5, 0x4A,
  0xA5, 0x52, 0xA5, 0x00, 0x72, 0x63, 0x18, 0xC6, 0x20, 0x32, 0x63, 0x18,
  0xC7, 0xC0, 0x38, 0x94, 0x51, 0x45, 0x17, 0x90, 0x80, 0x35, 0x28, 0xA2,
  0x8A, 0x6E, 0x84, 0x10, 0x79, 0x24, 0x62, 0x82, 0x08, 0x00, 0x3A, 0x60,
  0xE0, 0xC7, 0xC0, 0x23, 0xF2, 0x08, 0x21, 0x04, 0x0E, 0x46, 0x28, 0xA2,
  0x8A, 0x2F, 0x00, 0x86, 0x24, 0x94, 0x51, 0x86, 0x00, 0x96, 0xDB, 0x76,
  0xDB, 0x69, 0x00, 0x62, 0x48, 0xA0, 0x82, 0x8D, 0x31, 0x00, 0x46, 0x28,
  0xA2, 0x8A, 0x66, 0x84, 0xF0, 0x78, 0x44, 0x44, 0x43, 0xE0, 0x0C, 0x41,
  0x04, 0x13, 0x82, 0x08, 0x20, 0x83, 0x80, 0x24, 0x94, 0x92, 0x4A, 0x00,
  0x30, 0x21, 0x04, 0x10, 0x31, 0x04, 0x20, 0x8E, 0x00, 0xE6, 0x60,
};

const GFXglyph JetBrainsMono_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 4, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 12, 7, 1, -10 },
  { 24, 8, 9, 7, 0, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 2, 4, 7, 3, -9 },
  { 42, 5, 12, 7, 2, -10 },
  { 50, 4, 12, 7, 1, -10 },
  { 56, 6, 6, 7, 1, -7 },
  { 61, 6, 6, 7, 1, -7 },
  { 66, 3, 4, 7, 1, -2 },
  { 68, 4, 1, 7, 2, -4 },
  { 69, 2, 2, 7, 2, -2 },
  { 70, 7, 11, 7, 0, -10 },
  { 80, 6, 9, 7, 1, -9 },
  { 87, 5, 9, 7, 1, -9 },
  { 93, 6, 9, 7, 1, -9 },
  { 100, 6, 9, 7, 1, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 6, 9, 7, 1, -9 },
  { 120, 5, 9, 7, 1, -9 },
  { 126, 6, 9, 7, 1, -9 },
  { 133, 6, 9, 7, 1, -9 },
  { 140, 6, 9, 7, 1, -9 },
  { 147, 3, 7, 7, 2, -7 },
  { 150, 4, 9, 7, 1, -7 },
  { 155, 6, 6, 7, 1, -7 },
  { 160, 6, 4, 7, 1, -6 },
  { 163, 5, 6, 7, 1, -7 },
  { 167, 5, 9, 7, 2, -9 },
  { 173, 7, 11, 7, 0, -9 },
  { 183, 6, 9, 7, 0, -9 },
  { 190, 6, 9, 7, 1, -9 },
  { 197, 6, 9, 7, 1, -9 },
  { 204, 6, 9, 7, 1, -9 },
  { 211, 6, 9, 7, 1, -9 },
  { 218, 6, 9, 7, 1, -9 },
  { 225, 6, 9, 7, 1, -9 },
  { 232, 6, 9, 7, 1, -9 },
  { 239, 6, 9, 7, 1, -9 },
  { 246, 7, 9, 7, 0, -9 },
  { 254, 6, 9, 7, 1, -9 },
  { 261, 5, 9, 7, 1, -9 },
  { 267, 7, 9, 7, 0, -9 },
  { 275, 6, 9, 7, 1, -9 },
  { 282, 6, 9, 7, 1, -9 },
  { 289, 6, 9, 7, 1, -9 },
  { 296, 6, 11, 7, 1, -9 },
  { 305, 6, 9, 7, 1, -9 },
  { 312, 6, 9, 7, 1, -9 },
  { 319, 6, 9, 7, 1, -9 },
  { 326, 6, 9, 7, 1, -9 },
  { 333, 5, 9, 7, 2, -9 },
  { 339, 7, 9, 7, 1, -9 },
  { 347, 7, 9, 7, 0, -9 },
  { 355, 7, 9, 7, 1, -9 },
  { 363, 6, 9, 7, 1, -9 },
  { 370, 4, 11, 7, 2, -10 },
  { 376, 4, 11, 7, 2, -10 },
  { 382, 5, 11, 7, 1, -10 },
  { 389, 5, 5, 7, 1, -9 },
  { 393, 6, 1, 7, 0, 0 },
  { 394, 2, 1, 7, 3, -9 },
  { 395, 6, 7, 7, 1, -7 },
  { 401, 5, 9, 7, 1, -9 },
  { 407, 5, 7, 7, 1, -7 },
  { 412, 6, 9, 7, 1, -9 },
  { 419, 5, 7, 7, 1, -7 },
  { 424, 8, 11, 7, 0, -9 },
  { 435, 6, 9, 7, 1, -7 },
  { 442, 5, 9, 7, 1, -9 },
  { 448, 6, 9, 7, 0, -9 },
  { 455, 6, 11, 7, 0, -9 },
  { 464, 6, 9, 7, 1, -9 },
  { 471, 5, 9, 7, 1, -9 },
  { 477, 7, 7, 7, 0, -7 },
  { 484, 5, 7, 7, 1, -7 },
  { 489, 5, 7, 7, 1, -7 },
  { 494, 6, 9, 7, 0, -7 },
  { 501, 6, 9, 7, 1, -7 },
  { 508, 6, 7, 7, 1, -7 },
  { 514, 5, 7, 7, 1, -7 },
  { 519, 6, 8, 7, 1, -8 },
  { 525, 6, 7, 7, 1, -7 },
  { 531, 6, 7, 7, 1, -7 },
  { 537, 6, 7, 7, 1, -7 },
  { 543, 7, 7, 7, 0, -7 },
  { 550, 6, 9, 7, 1, -7 },
  { 557, 5, 7, 7, 1, -7 },
  { 562, 6, 11, 7, 1, -10 },
  { 571, 3, 11, 7, 2, -10 },
  { 576, 6, 11, 7, 0, -10 },
  { 585, 6, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_LIGHTITALIC12PT7B_H_
