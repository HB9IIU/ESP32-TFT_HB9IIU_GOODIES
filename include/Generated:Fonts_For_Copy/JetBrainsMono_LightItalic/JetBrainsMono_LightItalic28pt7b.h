#ifndef _JETBRAINSMONO_LIGHTITALIC28PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x00, 0x00, 0x00, 0xE3, 0xC3, 0x80, 0x71, 0xB8, 0xD8, 0x6C, 0x76,
  0x3B, 0x1B, 0x8D, 0x86, 0x01, 0x86, 0x03, 0x06, 0x03, 0x04, 0x03, 0x0C,
  0x06, 0x0C, 0x3F, 0xFF, 0x3F, 0xFF, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x30,
  0x18, 0x30, 0x18, 0x60, 0x18, 0x60, 0xFF, 0xFC, 0x30, 0xC0, 0x30, 0xC0,
  0x60, 0xC0, 0x61, 0x80, 0x61, 0x80, 0xC1, 0x80, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x07, 0x00, 0x7F, 0x81, 0xFB, 0x83, 0x33, 0x8C, 0x67, 0x18,
  0xCE, 0x31, 0x00, 0x62, 0x00, 0xE4, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x9C, 0x01, 0x18, 0x02, 0x30, 0x0C, 0x63, 0x18, 0xC6, 0x33, 0x8E,
  0x4E, 0x0F, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x01, 0xF8, 0x0C, 0x33, 0x83, 0x0C, 0x30, 0xC1, 0x86,
  0x30, 0x30, 0x8C, 0x06, 0x33, 0x00, 0xC6, 0x60, 0x1F, 0x98, 0x01, 0xC6,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x19, 0xF0, 0x02, 0x77, 0x00, 0xC8,
  0x60, 0x33, 0x0C, 0x0C, 0x61, 0x83, 0x0C, 0x30, 0xC1, 0x8C, 0x30, 0x3F,
  0x8E, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0xE0, 0x38, 0xE0, 0x60, 0xC1, 0x81,
  0x83, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xFC, 0x03,
  0x98, 0x76, 0x38, 0xCC, 0x33, 0x38, 0x7C, 0x60, 0x78, 0xC0, 0x61, 0x81,
  0xE3, 0x86, 0xC7, 0xF9, 0xC7, 0xE1, 0xC0, 0x76, 0x6E, 0xEC, 0xCC, 0x00,
  0x20, 0x1C, 0x0F, 0x83, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x38,
  0x01, 0x00, 0x08, 0x00, 0x70, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0x60, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0xC3, 0x0F, 0xCC, 0xF7, 0xEF, 0x83, 0xF0, 0x07, 0x00,
  0x36, 0x01, 0x9C, 0x0E, 0x70, 0x70, 0xE1, 0x81, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x1E, 0x38, 0xE1, 0xC7, 0x0E,
  0x18, 0x60, 0xFF, 0xFF, 0xC0, 0x77, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x3F, 0xC1, 0xE3, 0x8E, 0x06, 0x30, 0x1C, 0xC0, 0x77, 0x01,
  0xD8, 0x06, 0x60, 0x19, 0x8C, 0x66, 0x71, 0x99, 0xC6, 0xE0, 0x3B, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8E, 0x0E, 0x1F, 0xF0, 0x3F,
  0x80, 0x01, 0xE0, 0x3F, 0x03, 0x98, 0x38, 0xC1, 0x0E, 0x10, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x61, 0x80, 0xE7, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xCF,
  0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xE0, 0xE0,
  0xFF, 0x80, 0xFC, 0x00, 0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x39, 0xC1, 0x8C, 0x0C, 0xC0, 0x6E,
  0x03, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x1F, 0xFC, 0x7F, 0xE1, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0D, 0xF8, 0x3F, 0xF1, 0xC0, 0xC7, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x83, 0x87, 0xFC, 0x0F, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x10, 0x1B, 0xF0, 0xF1, 0xE3, 0x81, 0x9C, 0x07, 0x60, 0x1D, 0x80,
  0x76, 0x01, 0x98, 0x06, 0x60, 0x39, 0xC1, 0xC3, 0xFE, 0x07, 0xF0, 0x7F,
  0xFD, 0xFF, 0xF6, 0x01, 0x98, 0x0E, 0xE0, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x3F, 0xC1, 0xE3, 0x86, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8E, 0x0E,
  0x18, 0x70, 0x3F, 0x00, 0x78, 0x07, 0x70, 0x30, 0x61, 0x81, 0xCE, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x01, 0xCE, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x03,
  0x80, 0xFF, 0x0F, 0x3C, 0xE0, 0x76, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x37, 0x03, 0xB8, 0x3C, 0xFF, 0xC3, 0xEC, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C, 0x7C,
  0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x3E, 0x78,
  0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x30, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x18,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x20, 0x00, 0x60, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC3, 0xF0, 0xF8, 0x18,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0xC0, 0x61, 0xC0, 0x38, 0xC0,
  0x0C, 0x60, 0x06, 0x60, 0x26, 0x30, 0xFF, 0x18, 0x63, 0x8C, 0x60, 0xC6,
  0x30, 0x63, 0x18, 0x33, 0x0C, 0x39, 0x86, 0x18, 0xC6, 0x0C, 0x63, 0x06,
  0x31, 0xC7, 0x18, 0x7D, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0E, 0xE0, 0x31, 0x80, 0xC6, 0x06, 0x18,
  0x18, 0x60, 0xE1, 0x83, 0x06, 0x1C, 0x18, 0x7F, 0xE1, 0x81, 0x8E, 0x07,
  0x30, 0x0D, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0x1F, 0xF0, 0xFF, 0xE3, 0x01,
  0x8C, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x9C, 0x0C, 0x7F, 0xE1, 0xFF,
  0x06, 0x0F, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0C, 0xC0,
  0x73, 0x03, 0x8F, 0xFC, 0x3F, 0xC0, 0x01, 0xC0, 0x3F, 0xC1, 0xE3, 0x86,
  0x06, 0x30, 0x1C, 0xC0, 0x73, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x0C, 0xC0, 0x33,
  0x81, 0x8E, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xF0, 0x60,
  0x70, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x06, 0x38, 0x0C,
  0x60, 0x38, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x06, 0x30,
  0x1C, 0x60, 0x30, 0xC1, 0xC1, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x7F,
  0xF3, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xF1, 0xFF, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0xC1, 0xE3, 0x86, 0x06, 0x30, 0x1C, 0xC0, 0x73, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0xFE, 0x63, 0xF9, 0x80, 0xCE, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x81, 0x8E, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x18,
  0x0C, 0xE0, 0x33, 0x81, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x9C,
  0x06, 0x7F, 0xF9, 0xFF, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE,
  0x07, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x18, 0x1F, 0xFC,
  0x7F, 0xE0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x0C,
  0x07, 0x1C, 0x0E, 0x18, 0x0C, 0x18, 0x1C, 0x18, 0x38, 0x18, 0x30, 0x18,
  0x70, 0x38, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0xE0, 0x30, 0x60, 0x70, 0x60, 0x60, 0x70, 0x60, 0x30, 0x60, 0x30, 0x60,
  0x38, 0xE0, 0x18, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x1C, 0x0F, 0x1E,
  0x0A, 0x1E, 0x1E, 0x16, 0x1E, 0x36, 0x36, 0x36, 0x36, 0x32, 0x6C, 0x33,
  0x6C, 0x33, 0xCC, 0x33, 0xCC, 0x33, 0x8C, 0x70, 0x1C, 0x60, 0x1C, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xC0, 0x38, 0xC0,
  0x30, 0x0E, 0x06, 0x3C, 0x0C, 0x78, 0x18, 0xF0, 0x71, 0xB0, 0xC3, 0x61,
  0x86, 0xC3, 0x1D, 0x86, 0x31, 0x8C, 0x63, 0x38, 0xC6, 0x61, 0x8C, 0xC3,
  0x19, 0x8E, 0x1B, 0x18, 0x36, 0x30, 0x6C, 0x60, 0xF0, 0xC1, 0xE1, 0x81,
  0xC7, 0x03, 0x80, 0x01, 0xC0, 0x3F, 0xC1, 0xE3, 0x86, 0x06, 0x30, 0x18,
  0xC0, 0x63, 0x01, 0x9C, 0x06, 0x70, 0x19, 0x80, 0x66, 0x03, 0x98, 0x0E,
  0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x81, 0x8E, 0x0E,
  0x1F, 0xF0, 0x3F, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x18, 0x0E, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x3F, 0xF8,
  0x3F, 0xF0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3F, 0xC1,
  0xE7, 0x8E, 0x06, 0x30, 0x1C, 0xC0, 0x77, 0x01, 0x9C, 0x06, 0x60, 0x19,
  0x80, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x3B, 0x80, 0xCC, 0x03, 0x30, 0x0C,
  0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x1F, 0xF0, 0x3F, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x60, 0x38,
  0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x7F,
  0xF0, 0xFF, 0x81, 0x86, 0x03, 0x0C, 0x06, 0x1C, 0x1C, 0x18, 0x30, 0x30,
  0x60, 0x70, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0xF0,
  0x3C, 0x70, 0x60, 0x71, 0x80, 0xE3, 0x01, 0xC6, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x0C, 0xE0, 0x33, 0x01, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x9C,
  0x06, 0x70, 0x39, 0x80, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xCE,
  0x03, 0x30, 0x1C, 0xE0, 0x63, 0x83, 0x87, 0xFC, 0x0F, 0xE0, 0xC0, 0x1E,
  0x01, 0xB0, 0x0D, 0x80, 0xEC, 0x06, 0x60, 0x33, 0x03, 0x1C, 0x18, 0xE1,
  0xC3, 0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x30, 0x33, 0x01, 0x98, 0x0D, 0xC0,
  0x6C, 0x03, 0x60, 0x0E, 0x00, 0x70, 0x00, 0x61, 0xC3, 0x61, 0xC6, 0x63,
  0xC6, 0x63, 0xC6, 0x62, 0xC6, 0x62, 0x8C, 0x66, 0x8C, 0xC4, 0x8C, 0xC4,
  0x8C, 0xCC, 0x98, 0xCC, 0x98, 0xC8, 0x98, 0xD8, 0xB0, 0xD8, 0xB0, 0xD0,
  0xB0, 0xD0, 0xB0, 0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0x0C,
  0x03, 0x87, 0x03, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x31, 0xC0, 0x18, 0xC0,
  0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x6C,
  0x00, 0x76, 0x00, 0x33, 0x80, 0x30, 0xC0, 0x38, 0x70, 0x38, 0x18, 0x18,
  0x0C, 0x1C, 0x07, 0x1C, 0x01, 0x80, 0xE0, 0x0E, 0xC0, 0x31, 0x80, 0xE3,
  0x81, 0x83, 0x07, 0x06, 0x0C, 0x0E, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x3E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xE1,
  0xFC, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xFE, 0x1F, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x38, 0x18, 0x18,
  0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07,
  0x0F, 0xC7, 0xF0, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0xFE, 0x3F, 0x00, 0x03, 0x80, 0x78,
  0x06, 0x80, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0x67, 0x06, 0x60, 0x6C, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC6, 0x63, 0x07, 0x00, 0xFE, 0xCF, 0x1E, 0x60,
  0x77, 0x03, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x0D,
  0x80, 0xEE, 0x06, 0x70, 0x71, 0xFD, 0x87, 0xCC, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0xC0, 0x6F, 0xE1, 0xE3, 0x8E, 0x07, 0x38, 0x1C,
  0xC0, 0x73, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x67, 0x01, 0x9C, 0x0E,
  0x70, 0x31, 0xC1, 0xC7, 0xFE, 0x3B, 0xF0, 0x03, 0x80, 0x7F, 0x07, 0x1C,
  0x60, 0x77, 0x01, 0xB0, 0x0D, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x6E, 0x06, 0x70, 0x71, 0xFF, 0x07, 0xF0, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x07, 0x18, 0x7F, 0x63, 0xC7, 0x8C, 0x0E, 0x70,
  0x39, 0x80, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x30,
  0x1C, 0xE0, 0x63, 0x83, 0x87, 0xF6, 0x0F, 0x98, 0x03, 0x80, 0x7F, 0x07,
  0x1C, 0x60, 0x67, 0x03, 0xB0, 0x1D, 0x80, 0xCF, 0xFE, 0x7F, 0xF7, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x07, 0x70, 0x71, 0xFF, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0xFE, 0xCF, 0x1E, 0x60, 0x77, 0x03, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0x60,
  0x37, 0x01, 0xB8, 0x1D, 0xC0, 0xE7, 0x0E, 0x3F, 0xB0, 0xF9, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x70, 0xFF, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0xC0, 0x6F, 0xE1, 0xE3, 0x8E, 0x07, 0x38,
  0x1C, 0xC0, 0x73, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x67, 0x01, 0x98,
  0x0E, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x38, 0x0C, 0x00, 0x40, 0x07, 0x80,
  0x3C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x73, 0x03, 0x8C,
  0x1C, 0x70, 0xE1, 0x87, 0x06, 0x18, 0x1F, 0xC0, 0x7F, 0x01, 0x8E, 0x0E,
  0x18, 0x38, 0x70, 0xC0, 0xC3, 0x03, 0x8C, 0x06, 0x30, 0x1C, 0xFE, 0x1F,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0x18, 0x7F, 0x78, 0xE7, 0x39, 0x8C, 0x73, 0x18, 0xCC,
  0x31, 0x98, 0x63, 0x30, 0x86, 0x63, 0x0C, 0xC6, 0x19, 0x8C, 0x76, 0x18,
  0xCC, 0x31, 0x98, 0x63, 0x31, 0x86, 0x63, 0x0C, 0x00, 0xC0, 0x6F, 0xE1,
  0xE3, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0x8C, 0x06, 0x30, 0x19,
  0xC0, 0x67, 0x01, 0x98, 0x0E, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x38, 0x0C,
  0x03, 0x80, 0x7F, 0x07, 0x1C, 0x60, 0x67, 0x03, 0xB0, 0x1D, 0x80, 0xEC,
  0x06, 0x60, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0xEE, 0x06, 0x70, 0x71, 0xFF,
  0x07, 0xE0, 0x00, 0xC0, 0x6F, 0xE1, 0xE3, 0x8E, 0x07, 0x38, 0x1C, 0xC0,
  0x73, 0x01, 0x8C, 0x06, 0x30, 0x19, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x70,
  0x31, 0xC1, 0xC7, 0xFE, 0x1B, 0xF0, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0xFE, 0xCF, 0x16, 0x60, 0x77, 0x03, 0xB0,
  0x1D, 0x80, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x1D, 0x80, 0xEE, 0x06,
  0x70, 0x71, 0xFD, 0x87, 0xCC, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x08, 0xC0, 0xDF, 0xC3, 0x47, 0x8E, 0x06, 0x30, 0x18, 0xC0,
  0x67, 0x01, 0x9C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x03, 0xC0, 0xFF, 0x8F, 0x1E, 0x60,
  0x77, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x6C, 0x07, 0x70, 0x33, 0xFF, 0x8F, 0xF0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x30, 0x19, 0x80, 0xDC, 0x06, 0xC0, 0x76,
  0x03, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x37, 0x01, 0xB0, 0x1D, 0xC0,
  0xCE, 0x0E, 0x3F, 0xE0, 0xFC, 0x00, 0xC0, 0x3F, 0x01, 0x98, 0x1C, 0xC0,
  0xC6, 0x06, 0x30, 0x61, 0x83, 0x0E, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0,
  0x6C, 0x03, 0x60, 0x1E, 0x00, 0x70, 0x00, 0xC3, 0x87, 0x87, 0x1B, 0x0E,
  0x36, 0x3C, 0x6C, 0x59, 0x98, 0xB3, 0x33, 0x66, 0x64, 0xC8, 0xC9, 0xB1,
  0xB3, 0x63, 0x46, 0x86, 0x8F, 0x0F, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x00,
  0x1C, 0x07, 0x0E, 0x0C, 0x06, 0x1C, 0x07, 0x38, 0x03, 0x70, 0x03, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x0E, 0x70, 0x1C, 0x30,
  0x18, 0x38, 0x30, 0x18, 0xF0, 0x1C, 0x30, 0x19, 0x80, 0xDC, 0x06, 0xC0,
  0x76, 0x03, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1C,
  0xE1, 0xC7, 0xF6, 0x0F, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x38, 0xC3,
  0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x18, 0x1D,
  0xF8, 0x66, 0x71, 0xB0, 0xC6, 0xC3, 0xF3, 0x03, 0x80,
};

const GFXglyph JetBrainsMono_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 20, 17, 5, -20 },
  { 19, 9, 8, 17, 5, -20 },
  { 28, 16, 20, 17, 1, -20 },
  { 68, 15, 28, 17, 1, -24 },
  { 121, 19, 21, 17, -1, -21 },
  { 171, 15, 21, 17, 1, -21 },
  { 211, 4, 8, 17, 8, -20 },
  { 215, 11, 28, 17, 5, -24 },
  { 254, 12, 28, 17, 1, -24 },
  { 296, 14, 14, 17, 2, -17 },
  { 321, 13, 13, 17, 2, -16 },
  { 343, 7, 8, 17, 3, -4 },
  { 350, 9, 2, 17, 4, -10 },
  { 353, 5, 4, 17, 5, -4 },
  { 356, 16, 26, 17, 1, -23 },
  { 408, 14, 21, 17, 2, -21 },
  { 445, 13, 20, 17, 1, -20 },
  { 478, 15, 21, 17, 1, -21 },
  { 518, 15, 20, 17, 1, -20 },
  { 556, 13, 20, 17, 2, -20 },
  { 589, 14, 20, 17, 2, -20 },
  { 624, 14, 20, 17, 1, -20 },
  { 659, 14, 20, 17, 3, -20 },
  { 694, 14, 21, 17, 2, -21 },
  { 731, 13, 21, 17, 3, -21 },
  { 766, 7, 16, 17, 5, -16 },
  { 780, 9, 20, 17, 3, -16 },
  { 803, 14, 15, 17, 2, -17 },
  { 830, 13, 9, 17, 2, -14 },
  { 845, 14, 15, 17, 1, -17 },
  { 872, 11, 20, 17, 4, -20 },
  { 900, 17, 26, 17, 0, -21 },
  { 956, 14, 20, 17, 0, -20 },
  { 991, 14, 20, 17, 2, -20 },
  { 1026, 14, 21, 17, 2, -21 },
  { 1063, 15, 20, 17, 1, -20 },
  { 1101, 14, 20, 17, 2, -20 },
  { 1136, 15, 20, 17, 2, -20 },
  { 1174, 14, 21, 17, 2, -21 },
  { 1211, 14, 20, 17, 2, -20 },
  { 1246, 14, 20, 17, 2, -20 },
  { 1281, 15, 20, 17, 1, -20 },
  { 1319, 16, 20, 17, 1, -20 },
  { 1359, 12, 20, 17, 2, -20 },
  { 1389, 16, 20, 17, 1, -20 },
  { 1429, 15, 20, 17, 1, -20 },
  { 1467, 14, 21, 17, 2, -21 },
  { 1504, 16, 20, 17, 1, -20 },
  { 1544, 14, 26, 17, 2, -21 },
  { 1590, 15, 20, 17, 1, -20 },
  { 1628, 15, 21, 17, 1, -21 },
  { 1668, 14, 20, 17, 3, -20 },
  { 1703, 14, 20, 17, 2, -20 },
  { 1738, 13, 20, 17, 4, -20 },
  { 1771, 16, 20, 17, 2, -20 },
  { 1811, 17, 20, 17, 0, -20 },
  { 1854, 15, 20, 17, 3, -20 },
  { 1892, 15, 20, 17, 1, -20 },
  { 1930, 11, 26, 17, 4, -23 },
  { 1966, 8, 26, 17, 5, -23 },
  { 1992, 10, 26, 17, 3, -23 },
  { 2025, 12, 10, 17, 3, -20 },
  { 2040, 14, 2, 17, 0, 1 },
  { 2044, 4, 4, 17, 8, -22 },
  { 2046, 13, 16, 17, 2, -16 },
  { 2072, 14, 20, 17, 1, -20 },
  { 2107, 13, 16, 17, 2, -16 },
  { 2133, 14, 20, 17, 2, -20 },
  { 2168, 13, 16, 17, 2, -16 },
  { 2194, 19, 25, 17, -1, -20 },
  { 2254, 13, 21, 17, 2, -16 },
  { 2289, 14, 20, 17, 1, -20 },
  { 2324, 13, 22, 17, 1, -22 },
  { 2360, 15, 27, 17, 0, -22 },
  { 2411, 14, 20, 17, 2, -20 },
  { 2446, 11, 20, 17, 3, -20 },
  { 2474, 15, 16, 17, 1, -16 },
  { 2504, 14, 16, 17, 1, -16 },
  { 2532, 13, 16, 17, 2, -16 },
  { 2558, 14, 21, 17, 1, -16 },
  { 2595, 13, 21, 17, 2, -16 },
  { 2630, 14, 16, 17, 2, -16 },
  { 2658, 13, 16, 17, 2, -16 },
  { 2684, 13, 20, 17, 3, -20 },
  { 2717, 13, 15, 17, 2, -15 },
  { 2742, 13, 15, 17, 3, -15 },
  { 2767, 15, 15, 17, 2, -15 },
  { 2796, 16, 15, 17, 0, -15 },
  { 2826, 13, 20, 17, 2, -15 },
  { 2859, 14, 15, 17, 1, -15 },
  { 2886, 14, 26, 17, 3, -23 },
  { 2932, 6, 26, 17, 6, -23 },
  { 2952, 14, 26, 17, 1, -23 },
  { 2998, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_LIGHTITALIC28PT7B_H_
