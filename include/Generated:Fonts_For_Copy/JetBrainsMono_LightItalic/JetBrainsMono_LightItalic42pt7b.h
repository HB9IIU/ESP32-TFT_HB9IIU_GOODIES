#ifndef _JETBRAINSMONO_LIGHTITALIC42PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0,
  0xFC, 0x3F, 0x07, 0x80, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x78,
  0x79, 0xC1, 0xE7, 0x07, 0x9C, 0x1C, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0x80,
  0x06, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0C, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xF0, 0x0F, 0x33, 0xE0, 0x78, 0xC7, 0x83, 0xC3, 0x0E, 0x0F, 0x0C, 0x3C,
  0x38, 0x30, 0xF0, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x3C,
  0x60, 0x00, 0xF9, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x33, 0xE0, 0x00, 0xC7, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x60, 0xF3, 0xC1, 0x83, 0x8F, 0x06,
  0x0E, 0x1C, 0x18, 0x78, 0x78, 0xE1, 0xC1, 0xF3, 0x9F, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x38, 0x1F, 0xE0, 0x03, 0x81, 0xFF, 0x80, 0x38, 0x0E, 0x1C,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x07, 0x03, 0x03, 0x80, 0x38, 0x18, 0x38,
  0x01, 0xC1, 0xC1, 0xC0, 0x0C, 0x0E, 0x1C, 0x00, 0xE0, 0x71, 0xC0, 0x03,
  0x07, 0x1C, 0x00, 0x1E, 0x79, 0xC0, 0x00, 0xFF, 0x9C, 0x00, 0x03, 0xF8,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x63, 0xFE, 0x00,
  0x07, 0x38, 0x38, 0x00, 0x71, 0xC1, 0xC0, 0x07, 0x1C, 0x0E, 0x00, 0x70,
  0xE0, 0x70, 0x07, 0x07, 0x03, 0x80, 0x70, 0x38, 0x18, 0x03, 0x81, 0xC1,
  0xC0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0x79, 0xE0, 0x38, 0x01, 0xFE, 0x03,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3C, 0x78, 0x1E, 0x70, 0xF0, 0x78, 0xE0, 0xF0, 0xE3, 0xC0,
  0xE3, 0x87, 0x81, 0xEF, 0x0E, 0x01, 0xDC, 0x1C, 0x03, 0xF0, 0x38, 0x03,
  0xE0, 0x70, 0x07, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x03, 0xC1, 0xFF,
  0x07, 0xFF, 0x8E, 0x07, 0xFE, 0x1E, 0x07, 0xF8, 0x1E, 0x00, 0x3B, 0xDE,
  0xF7, 0xBD, 0xDE, 0xF7, 0xB9, 0xCE, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x02, 0x03, 0x80, 0x5E, 0x0E, 0x07, 0x7E, 0x38, 0xFF, 0xFE, 0xCF,
  0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00,
  0x1D, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x20, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7D, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0x03, 0xE0, 0xF0, 0x0F,
  0x0F, 0x00, 0x38, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x3C, 0x38, 0x79,
  0xE3, 0xC3, 0x8E, 0x1F, 0x1C, 0x70, 0xF0, 0xE3, 0x83, 0x87, 0x1C, 0x00,
  0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x3C, 0x01, 0xE1, 0xF0, 0x1E,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFB, 0x80, 0x3E, 0x70, 0x1F, 0x1E, 0x03,
  0xC3, 0xC0, 0x60, 0x78, 0x08, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x07, 0x00,
  0x78, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0,
  0xF0, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0xF0,
  0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x39, 0xE0, 0x07, 0x38, 0x01, 0xEF, 0x00,
  0x3D, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC7, 0xE0, 0x1D, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x80, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x9F, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF0, 0x3E, 0x3E,
  0x01, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E,
  0x78, 0x03, 0xC7, 0xC0, 0x78, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x00, 0x0F, 0x70,
  0x00, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0x81, 0xF0, 0x78, 0x07, 0x83, 0x80, 0x1C, 0x3C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0xC0, 0x3C,
  0x0E, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xF7, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x00, 0x7C, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x03, 0xC3,
  0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01,
  0xE3, 0x80, 0x0F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xC1, 0xF0, 0x3E, 0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x3F, 0xFF, 0x83,
  0xFF, 0x70, 0x0F, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x02,
  0x03, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0,
  0xFE, 0x3F, 0x8F, 0xC3, 0xE0, 0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3E, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x3C,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE3, 0x80, 0x7E, 0x71, 0xC0, 0xFF, 0xB0, 0xE0, 0x78,
  0x78, 0x70, 0x78, 0x1C, 0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x07, 0x1C, 0x1C,
  0x03, 0x8E, 0x0E, 0x03, 0x87, 0x07, 0x01, 0xC3, 0x83, 0x80, 0xE1, 0xC1,
  0xC0, 0x70, 0xE0, 0xE0, 0x38, 0xE0, 0xF0, 0x3C, 0x70, 0x38, 0x1E, 0x38,
  0x1C, 0x1E, 0x1C, 0x0F, 0xFF, 0x0E, 0x03, 0xFB, 0x87, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x38,
  0x1C, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xC0, 0x0E, 0x1E, 0x00,
  0x70, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80, 0x03, 0xBC,
  0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xC0, 0xFC, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x87,
  0x80, 0x3C, 0x1C, 0x01, 0xE0, 0x70, 0x3F, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x3C,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78,
  0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x3C, 0x1C, 0x03, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0E, 0x0F, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80,
  0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x3E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F,
  0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x7F, 0xE3, 0xC3, 0xFF, 0x1C, 0x1F,
  0xF8, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E,
  0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE0, 0xF0, 0x1E,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01,
  0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xF0, 0x03, 0x83, 0xC0,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E,
  0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x81,
  0xE0, 0x0F, 0x03, 0xE0, 0x3C, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0E, 0x00,
  0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x70, 0x03, 0xC0,
  0x70, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x6C, 0x03, 0xE0, 0xDC, 0x0E,
  0xC1, 0xB8, 0x1F, 0x87, 0x70, 0x77, 0x0E, 0xE0, 0xEE, 0x1C, 0xC3, 0x9C,
  0x39, 0x87, 0x70, 0x73, 0x9C, 0xE0, 0xE7, 0x39, 0xC3, 0xCE, 0xE3, 0x87,
  0x1D, 0xC7, 0x0E, 0x1B, 0x1E, 0x1C, 0x3E, 0x38, 0x38, 0x78, 0x70, 0x70,
  0xF0, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00,
  0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C, 0x1F, 0x00, 0x70, 0x7C, 0x01,
  0xC3, 0xF0, 0x0F, 0x0F, 0xC0, 0x3C, 0x3B, 0x80, 0xE0, 0xEE, 0x03, 0x83,
  0xB8, 0x0E, 0x0E, 0xE0, 0x38, 0x3B, 0x80, 0xE1, 0xE7, 0x07, 0x87, 0x1C,
  0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x0E, 0x1C,
  0x3C, 0x38, 0xF0, 0xF0, 0xE3, 0xC3, 0x83, 0x8E, 0x0E, 0x06, 0x38, 0x38,
  0x1C, 0xE0, 0xE0, 0x73, 0x87, 0x81, 0xCE, 0x1E, 0x07, 0x78, 0x70, 0x0F,
  0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xFC, 0x1C, 0x03, 0xF0, 0x70, 0x0F, 0xC3,
  0xC0, 0x1F, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00, 0xF3, 0x80, 0x0F,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0,
  0x07, 0x87, 0x80, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x0F, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E,
  0x00, 0x1E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0,
  0x03, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0x7C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0x03, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70,
  0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00,
  0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xC7,
  0x80, 0x1C, 0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xC0, 0x7E,
  0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00,
  0x78, 0x70, 0x03, 0xC1, 0xC0, 0x3E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x38, 0x0E, 0x00, 0xE0,
  0x3C, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x81, 0xC0, 0x1E,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0, 0x07, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xF0, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0xC3, 0x80,
  0x0F, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3C,
  0x01, 0xC0, 0xF0, 0x1E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xE7,
  0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03,
  0x83, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xE0,
  0x0E, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x73,
  0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x1E, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70,
  0x3C, 0x0E, 0x70, 0x7C, 0x0E, 0x70, 0x6C, 0x1C, 0x70, 0x6C, 0x1C, 0x70,
  0xEC, 0x1C, 0x70, 0xCC, 0x38, 0x70, 0xCC, 0x38, 0x70, 0xCC, 0x38, 0x71,
  0xCC, 0x38, 0x71, 0x8C, 0x70, 0x71, 0x8C, 0x70, 0x73, 0x8C, 0x70, 0x73,
  0x0C, 0x70, 0x63, 0x0C, 0xE0, 0xE3, 0x0C, 0xE0, 0xE7, 0x0C, 0xE0, 0xE6,
  0x0C, 0xC0, 0xE6, 0x0D, 0xC0, 0xEE, 0x0D, 0xC0, 0xEC, 0x1D, 0xC0, 0xEC,
  0x1F, 0x80, 0xEC, 0x1F, 0x80, 0xFC, 0x1B, 0x80, 0xF8, 0x1B, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x1C, 0x00, 0x3C,
  0x70, 0x01, 0xE1, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x3C,
  0x00, 0x38, 0xE0, 0x00, 0xF7, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xEC, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x07, 0x03, 0xC1,
  0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x39,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x00, 0x20, 0x00, 0x3F, 0xC7,
  0x07, 0xFE, 0xF0, 0xFC, 0xFF, 0x1E, 0x03, 0xE1, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x0B, 0x87,
  0xFF, 0xF8, 0x3F, 0xF7, 0x81, 0xFC, 0x70, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x40, 0x0E, 0x3F, 0x80, 0xEF, 0xFE, 0x1F, 0xE7, 0xE1, 0xF0,
  0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x1C,
  0x78, 0x03, 0xC7, 0xC0, 0x78, 0x77, 0xFF, 0x0F, 0x7F, 0xE0, 0xF3, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1E,
  0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0x8F, 0x00, 0x78, 0x78, 0x0F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x04, 0x0E, 0x03, 0xFC,
  0x70, 0x3F, 0xF7, 0x83, 0xF3, 0xFC, 0x3C, 0x07, 0xC1, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE0,
  0xF0, 0x17, 0x07, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0x7F, 0x1C, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xE7, 0xE1, 0xE0, 0x1C, 0x38,
  0x03, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x3D, 0xC0,
  0x07, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0E, 0x78, 0x03, 0xC7, 0x80,
  0xF0, 0xFC, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xC7, 0x07, 0xFE, 0xF0, 0xFC, 0xFF, 0x1E,
  0x03, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x78, 0x78, 0x0F,
  0x87, 0xF7, 0xB8, 0x3F, 0xF3, 0x81, 0xFE, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x40, 0x0E, 0x7F, 0x80, 0xEF, 0xFE, 0x1F, 0xE7,
  0xE1, 0xF0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0x71, 0xC0,
  0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x1E,
  0x00, 0xF0, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x70, 0x03, 0xC1, 0xC0, 0x0F,
  0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x20, 0x20, 0x1D, 0xF1, 0xF0, 0x77, 0xF7, 0xF0, 0xE9,
  0xF9, 0xE1, 0xE1, 0xE1, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x07, 0x0E, 0x0E,
  0x0E, 0x3C, 0x1C, 0x1C, 0x70, 0x30, 0x38, 0xE0, 0xE0, 0xF1, 0xC1, 0xC1,
  0xC3, 0x83, 0x83, 0x87, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x3C, 0x1C, 0x1C,
  0x70, 0x30, 0x38, 0xE0, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x83, 0x83, 0x87,
  0x07, 0x07, 0x1E, 0x0E, 0x0E, 0x38, 0x18, 0x1C, 0x70, 0x70, 0x78, 0x00,
  0x04, 0x00, 0xE7, 0xF8, 0x0E, 0xFF, 0xE1, 0xFE, 0x7E, 0x1F, 0x01, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x07, 0x1C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xE0, 0x3C, 0x38,
  0x03, 0xCF, 0x00, 0x79, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xB8, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0xC7, 0x80,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x38,
  0xFE, 0x01, 0xDF, 0xFC, 0x1F, 0xE7, 0xE0, 0xFC, 0x0F, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x03,
  0xC3, 0xE0, 0x3C, 0x1D, 0xFF, 0xC1, 0xEF, 0xFC, 0x0F, 0x3F, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F,
  0xCF, 0x07, 0xFE, 0xF0, 0xFC, 0xFF, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x0B,
  0x87, 0xFF, 0xF8, 0x3F, 0xF7, 0x81, 0xFC, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0xE7, 0xF8, 0x1E, 0xFF, 0xC1,
  0xDE, 0x7E, 0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F,
  0xE7, 0xF1, 0xE0, 0x1E, 0x78, 0x01, 0xCF, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7B, 0x80,
  0x0F, 0x70, 0x01, 0xCF, 0x00, 0x79, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x1C, 0x00,
  0x71, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x70, 0x07, 0x07, 0x80, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF7, 0x00,
  0x0F, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x38,
  0x03, 0x83, 0x80, 0x78, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x01,
  0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80,
  0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x38, 0x1F, 0x81, 0xE0, 0x7E,
  0x07, 0x81, 0xF8, 0x1E, 0x0E, 0xE0, 0xD8, 0x3B, 0x83, 0x60, 0xEE, 0x0D,
  0x87, 0x38, 0x66, 0x1C, 0xE1, 0x98, 0x73, 0x86, 0x63, 0x8E, 0x31, 0x8E,
  0x38, 0xC6, 0x38, 0xE3, 0x18, 0xC3, 0x98, 0x67, 0x0E, 0x61, 0x9C, 0x19,
  0x86, 0x60, 0x6C, 0x1B, 0x81, 0xB0, 0x6E, 0x06, 0xC1, 0xB0, 0x1F, 0x07,
  0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x00,
  0x1E, 0x0E, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x78, 0xF0, 0x00, 0x73, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x80, 0x07, 0x87, 0x00, 0x1E,
  0x0F, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x80, 0xF8, 0x7F, 0xFB, 0x83, 0xFF, 0x78, 0x1F, 0xE7, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x73, 0xFC,
  0x07, 0x7F, 0xE0, 0x77, 0x0F, 0x07, 0xF0, 0xF0, 0xFE, 0x07, 0xDE, 0xE0,
  0x3F, 0xCE, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 31, 25, 8, -31 },
  { 40, 14, 13, 25, 8, -31 },
  { 63, 24, 31, 25, 1, -31 },
  { 156, 22, 43, 25, 2, -37 },
  { 275, 29, 31, 25, -1, -31 },
  { 388, 23, 31, 25, 1, -31 },
  { 478, 5, 13, 25, 12, -31 },
  { 487, 17, 40, 25, 7, -35 },
  { 572, 17, 40, 25, 2, -35 },
  { 657, 22, 22, 25, 2, -26 },
  { 718, 20, 20, 25, 3, -24 },
  { 768, 11, 13, 25, 4, -6 },
  { 786, 14, 3, 25, 6, -15 },
  { 792, 7, 6, 25, 8, -6 },
  { 798, 25, 40, 25, 1, -35 },
  { 923, 21, 31, 25, 3, -31 },
  { 1005, 19, 31, 25, 2, -31 },
  { 1079, 22, 31, 25, 2, -31 },
  { 1165, 21, 31, 25, 2, -31 },
  { 1247, 19, 31, 25, 3, -31 },
  { 1321, 20, 31, 25, 3, -31 },
  { 1399, 20, 31, 25, 2, -31 },
  { 1477, 20, 31, 25, 5, -31 },
  { 1555, 21, 31, 25, 2, -31 },
  { 1637, 20, 31, 25, 4, -31 },
  { 1715, 10, 24, 25, 8, -24 },
  { 1745, 14, 31, 25, 4, -24 },
  { 1800, 20, 22, 25, 4, -25 },
  { 1855, 20, 13, 25, 3, -20 },
  { 1888, 20, 22, 25, 2, -25 },
  { 1943, 17, 31, 25, 6, -31 },
  { 2009, 25, 39, 25, 0, -31 },
  { 2131, 21, 31, 25, 0, -31 },
  { 2213, 22, 31, 25, 2, -31 },
  { 2299, 21, 31, 25, 3, -31 },
  { 2381, 21, 31, 25, 2, -31 },
  { 2463, 22, 31, 25, 3, -31 },
  { 2549, 23, 31, 25, 2, -31 },
  { 2639, 21, 31, 25, 3, -31 },
  { 2721, 22, 31, 25, 2, -31 },
  { 2807, 21, 31, 25, 3, -31 },
  { 2889, 23, 31, 25, 1, -31 },
  { 2979, 24, 31, 25, 2, -31 },
  { 3072, 18, 31, 25, 3, -31 },
  { 3142, 23, 31, 25, 2, -31 },
  { 3232, 22, 31, 25, 2, -31 },
  { 3318, 20, 31, 25, 3, -31 },
  { 3396, 23, 31, 25, 2, -31 },
  { 3486, 21, 39, 25, 3, -31 },
  { 3589, 22, 31, 25, 2, -31 },
  { 3675, 22, 31, 25, 2, -31 },
  { 3761, 21, 31, 25, 5, -31 },
  { 3843, 21, 31, 25, 3, -31 },
  { 3925, 21, 31, 25, 5, -31 },
  { 4007, 24, 31, 25, 3, -31 },
  { 4100, 26, 31, 25, 0, -31 },
  { 4201, 22, 31, 25, 5, -31 },
  { 4287, 22, 31, 25, 2, -31 },
  { 4373, 17, 40, 25, 6, -35 },
  { 4458, 12, 40, 25, 7, -35 },
  { 4518, 16, 40, 25, 4, -35 },
  { 4598, 18, 17, 25, 4, -31 },
  { 4637, 21, 3, 25, 0, 1 },
  { 4645, 8, 6, 25, 11, -33 },
  { 4651, 20, 24, 25, 3, -24 },
  { 4711, 20, 31, 25, 2, -31 },
  { 4789, 20, 24, 25, 3, -24 },
  { 4849, 21, 31, 25, 3, -31 },
  { 4931, 19, 24, 25, 3, -24 },
  { 4988, 28, 39, 25, -2, -31 },
  { 5125, 20, 32, 25, 3, -24 },
  { 5205, 20, 31, 25, 2, -31 },
  { 5283, 20, 33, 25, 2, -33 },
  { 5366, 21, 41, 25, 1, -33 },
  { 5474, 22, 31, 25, 2, -31 },
  { 5560, 18, 31, 25, 4, -31 },
  { 5630, 23, 24, 25, 1, -24 },
  { 5699, 20, 24, 25, 2, -24 },
  { 5759, 19, 24, 25, 3, -24 },
  { 5816, 21, 32, 25, 1, -24 },
  { 5900, 20, 32, 25, 3, -24 },
  { 5980, 20, 24, 25, 3, -24 },
  { 6040, 19, 24, 25, 3, -24 },
  { 6097, 19, 29, 25, 4, -29 },
  { 6166, 20, 23, 25, 3, -23 },
  { 6224, 20, 23, 25, 4, -23 },
  { 6282, 22, 23, 25, 3, -23 },
  { 6346, 23, 23, 25, 1, -23 },
  { 6413, 20, 31, 25, 3, -23 },
  { 6491, 21, 23, 25, 2, -23 },
  { 6552, 21, 40, 25, 4, -35 },
  { 6657, 10, 40, 25, 8, -35 },
  { 6707, 21, 40, 25, 1, -35 },
  { 6812, 20, 8, 25, 3, -19 },
};

const GFXfont JetBrainsMono_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_LIGHTITALIC42PT7B_H_
