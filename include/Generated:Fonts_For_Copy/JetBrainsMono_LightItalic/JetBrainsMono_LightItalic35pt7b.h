#ifndef _JETBRAINSMONO_LIGHTITALIC35PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x00, 0x00, 0x00, 0x70,
  0xF8, 0xF8, 0xF0, 0x70, 0xEE, 0x1D, 0xC3, 0xF8, 0xFE, 0x1D, 0xC3, 0xB8,
  0x77, 0x0E, 0xE1, 0xD8, 0x33, 0x06, 0x00, 0x00, 0x70, 0x70, 0x06, 0x06,
  0x00, 0xE0, 0x60, 0x0E, 0x0E, 0x00, 0xC0, 0xC0, 0x1C, 0x1C, 0x01, 0x81,
  0xC0, 0x18, 0x18, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0x03, 0x00, 0x70,
  0x70, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x0E, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0x81, 0x80, 0x38, 0x38, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x07, 0x07, 0x00, 0x60, 0x60, 0x0E, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0xCE, 0x0C, 0x31, 0xC7, 0x18, 0x71, 0xC6,
  0x1C, 0x71, 0x80, 0x1C, 0x60, 0x07, 0x18, 0x01, 0xE6, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0x38, 0x00, 0xC7, 0x00,
  0x61, 0xC0, 0x18, 0x73, 0x86, 0x1C, 0xE1, 0x87, 0x38, 0x63, 0x8F, 0x18,
  0xE1, 0xE4, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x03, 0x07, 0xF0,
  0x06, 0x0F, 0x78, 0x0C, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x38, 0x1C, 0x18,
  0x70, 0x1C, 0x38, 0xE0, 0x18, 0x38, 0xC0, 0x18, 0x31, 0x80, 0x1C, 0x73,
  0x00, 0x0F, 0xE6, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x67, 0xF0, 0x00, 0xCF, 0xF8, 0x01, 0xCC,
  0x38, 0x03, 0x9C, 0x18, 0x07, 0x1C, 0x38, 0x06, 0x18, 0x38, 0x0C, 0x18,
  0x30, 0x18, 0x18, 0x30, 0x38, 0x1C, 0x70, 0x70, 0x1F, 0xE0, 0xE0, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0x83, 0xC0, 0x60,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x81, 0xCC, 0x38,
  0x73, 0x87, 0x0C, 0x70, 0x73, 0x8E, 0x0E, 0xE1, 0x80, 0xF8, 0x30, 0x1F,
  0x0E, 0x01, 0xC1, 0xC0, 0x7C, 0x38, 0x1F, 0x87, 0x87, 0xB8, 0x7F, 0xC7,
  0x07, 0xF0, 0x70, 0x77, 0x77, 0x77, 0xEE, 0xEE, 0xE0, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x04, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x38, 0x7F, 0xCC,
  0x7F, 0xFB, 0x7F, 0x1F, 0xFE, 0x00, 0x70, 0x00, 0x36, 0x00, 0x1D, 0xC0,
  0x0E, 0x70, 0x07, 0x8E, 0x03, 0xC3, 0x81, 0xE0, 0x70, 0x30, 0x1C, 0x04,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0,
  0xE0, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x3D, 0xF7, 0xFF, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x38, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x06, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xC3,
  0x0E, 0x71, 0xE3, 0x9C, 0x78, 0xE7, 0x1E, 0x31, 0xC0, 0x1C, 0x70, 0x07,
  0x18, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x87,
  0x01, 0xC1, 0xE1, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xB8, 0x0F, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x20,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x38, 0x0E, 0x1C, 0x03,
  0x86, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x02, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x03, 0x8F, 0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0xE0, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x06, 0x38,
  0x07, 0x1F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF8, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x3E, 0x01, 0xBF, 0xC0, 0xFF, 0xF8, 0x3C, 0x0F,
  0x0E, 0x01, 0xC3, 0x80, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x87, 0x01, 0xC1, 0xE1,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x9E, 0x03, 0xBF, 0x83, 0xFF, 0xE1, 0xE0, 0x79,
  0xE0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x71, 0xC0, 0x70, 0xF0, 0xF8, 0x3F, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEE, 0x00, 0x77, 0x00,
  0x73, 0x00, 0x33, 0x80, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0x61,
  0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC0, 0xE1, 0xE0, 0x1F,
  0xF0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xF3, 0xC0, 0xF0, 0x78, 0x38, 0x0E,
  0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0x03, 0x8F,
  0x01, 0xE1, 0xE0, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xE3, 0x80, 0x79, 0xC0, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0xE3, 0xE1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C,
  0x3E, 0x3F, 0x0F, 0x00, 0x01, 0x80, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x20, 0x00, 0x0C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0xE0, 0x7F,
  0x01, 0xF0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x78, 0x78, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x07,
  0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x79,
  0xC6, 0x0F, 0xEC, 0x70, 0x71, 0xE3, 0x87, 0x07, 0x1C, 0x30, 0x38, 0xE1,
  0x81, 0xC6, 0x0C, 0x0E, 0x30, 0xE0, 0x61, 0x87, 0x03, 0x1C, 0x38, 0x18,
  0xE1, 0x81, 0xC7, 0x0E, 0x0E, 0x30, 0x70, 0xF1, 0x83, 0xFF, 0x0C, 0x0F,
  0x98, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80,
  0x06, 0x60, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06,
  0x1C, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x70, 0x30, 0x1C, 0x0C, 0x0E, 0x03,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x39, 0xC0, 0x06, 0x70, 0x01, 0xBC, 0x00, 0x70, 0x0F, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x70, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0,
  0x18, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x70, 0xE0, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0x01, 0xE0, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x18, 0x03, 0x8E, 0x01,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3C, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x1C, 0x60, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1,
  0xE0, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x03,
  0xFF, 0xC3, 0x81, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0,
  0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x8E,
  0x01, 0xC7, 0x00, 0xE3, 0x00, 0xE3, 0x80, 0xF1, 0xC3, 0xF0, 0xFF, 0xF0,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x86, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3C, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x3F, 0xE3, 0x0F, 0xF1, 0xC3, 0xFC, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x60, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xE0,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x01, 0x87, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E,
  0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0x87, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30,
  0xE0, 0x1C, 0x38, 0x07, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x1C, 0x1C, 0x07, 0x03, 0xC3,
  0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0C,
  0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x01,
  0xC0, 0xE0, 0x18, 0x1C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x70, 0x38,
  0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8,
  0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0x61, 0xD8, 0x76, 0x1D, 0x86, 0xE1, 0xD8, 0xEE, 0x1D, 0x8C, 0xC1, 0x9C,
  0xCC, 0x18, 0xD9, 0xC1, 0x8D, 0x9C, 0x38, 0xF1, 0xC3, 0x8F, 0x1C, 0x38,
  0xE1, 0xC3, 0x80, 0x18, 0x30, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x70, 0x07, 0x06, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x1C,
  0x7C, 0x07, 0x1F, 0x01, 0xC7, 0xE0, 0x61, 0xB8, 0x18, 0x66, 0x0E, 0x19,
  0x83, 0x8E, 0x60, 0xE3, 0x9C, 0x38, 0xE7, 0x0C, 0x38, 0xC3, 0x0C, 0x31,
  0xC3, 0x0C, 0x71, 0xC3, 0x9C, 0x70, 0xE7, 0x1C, 0x19, 0xC7, 0x06, 0x61,
  0xC1, 0xD8, 0x60, 0x7E, 0x38, 0x1F, 0x8E, 0x03, 0xE3, 0x80, 0xF8, 0xE0,
  0x3C, 0x38, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3C,
  0x1E, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x01, 0xC3,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x61, 0xC0,
  0x38, 0x60, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0E, 0x01,
  0xE1, 0xC0, 0x1C, 0x38, 0x03, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x18, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3C, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x71,
  0x80, 0x18, 0xE0, 0x0E, 0x18, 0x03, 0x87, 0x01, 0xC1, 0xE1, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x70, 0x1E, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x1C, 0x3F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3C, 0x18, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x78, 0xE0,
  0x0E, 0x38, 0x03, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C,
  0x0E, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8F, 0x01, 0xE1, 0xE0, 0xF0, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0xE0, 0x01, 0xD8, 0x00, 0xE6, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07,
  0x01, 0x80, 0xC0, 0xE0, 0x30, 0x38, 0x0C, 0x1C, 0x03, 0x87, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x1B, 0x80,
  0x06, 0xE0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0x30, 0x38, 0x3B, 0x83, 0xC1, 0x9C, 0x1E, 0x1C, 0xE0, 0xA0, 0xE7, 0x0D,
  0x06, 0x38, 0x68, 0x31, 0xC3, 0x43, 0x8E, 0x12, 0x1C, 0x71, 0xB0, 0xC3,
  0x8D, 0x86, 0x1C, 0x4C, 0x70, 0xE6, 0x63, 0x07, 0x33, 0x18, 0x31, 0x99,
  0xC1, 0x98, 0xCE, 0x0C, 0xC6, 0x60, 0x66, 0x33, 0x03, 0x21, 0xB8, 0x1B,
  0x0D, 0xC0, 0xD8, 0x6C, 0x06, 0xC3, 0x60, 0x3C, 0x1F, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x70, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x3C,
  0x1C, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x06,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x37, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x38,
  0x0E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xF8,
  0x00, 0x66, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x0C, 0x03, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x18, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x33, 0x80,
  0x0E, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x80, 0x67, 0x01,
  0xC6, 0x07, 0x0C, 0x0C, 0x1C, 0x38, 0x18, 0x60, 0x31, 0xC0, 0x77, 0x00,
  0xFC, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xE3, 0x87, 0x00,
  0xC0, 0x03, 0xFD, 0xC3, 0xFE, 0xE3, 0xC1, 0xF1, 0xC0, 0x79, 0xC0, 0x38,
  0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xC7, 0x00, 0x63, 0x80, 0x71, 0x80, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x3C,
  0x36, 0x0F, 0xFB, 0x03, 0xF3, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xC0, 0x3B, 0xFC, 0x1B,
  0xFE, 0x1F, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x71, 0xF0, 0xF8, 0xEF, 0xF8, 0x73,
  0xF0, 0x00, 0x00, 0x70, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE1, 0xC0,
  0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x38, 0xE0, 0x1C,
  0x70, 0x1C, 0x3C, 0x1E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x0C,
  0x38, 0x1F, 0xEE, 0x0F, 0xFB, 0x87, 0x83, 0xE1, 0xC0, 0x78, 0xE0, 0x1C,
  0x38, 0x07, 0x0C, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0x87, 0x00, 0x61, 0xC0, 0x38, 0x60, 0x0E, 0x1C, 0x03, 0x87, 0x01,
  0xE1, 0xE1, 0xB8, 0x3F, 0xEC, 0x07, 0xE7, 0x00, 0x00, 0x60, 0x01, 0xFE,
  0x03, 0xFF, 0x83, 0xC1, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x0C, 0x60,
  0x0E, 0x70, 0x07, 0x3F, 0xFF, 0x9F, 0xFF, 0xCE, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x70, 0x1C, 0x3C, 0x1E, 0x0F, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0x80, 0x0F, 0xF7, 0x1F, 0xF7, 0x3C, 0x1F, 0x38, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x7C, 0x7F, 0xDC, 0x3F, 0x9C, 0x0E,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x80, 0x3B, 0xFC, 0x1B, 0xFE, 0x1F, 0x07,
  0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0x60,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x0F, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x0F, 0x1C, 0x03, 0x86, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x0E, 0x1E, 0x03, 0x8F, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1C, 0x38,
  0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x18, 0x0E, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0xFF, 0x83, 0xFE, 0x0F, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x81, 0x03, 0x7C, 0xF8, 0x7F, 0xBF,
  0x1E, 0x38, 0x63, 0x87, 0x0C, 0x70, 0xC1, 0x8E, 0x18, 0x31, 0x83, 0x0E,
  0x30, 0x61, 0xC6, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x60, 0xC7, 0x0C, 0x18,
  0xE1, 0x87, 0x18, 0x30, 0xE3, 0x0E, 0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x63,
  0x86, 0x0C, 0x70, 0xC3, 0x80, 0x00, 0x20, 0x0E, 0xFF, 0x06, 0xFF, 0x87,
  0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07,
  0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0xC0,
  0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE1, 0xC0, 0x71, 0xC0,
  0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0x80, 0x38, 0xE0, 0x1C, 0x70, 0x1C,
  0x3C, 0x3C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x18, 0x03, 0xBF, 0xC0,
  0xDF, 0xF0, 0x7C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x0E, 0x1F, 0x07, 0x87,
  0x7F, 0xC1, 0xCF, 0xC0, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFD, 0xC3, 0xFE,
  0xE3, 0xC1, 0xF1, 0xC0, 0x79, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x71,
  0x80, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x3C, 0x36, 0x0F, 0xFB, 0x03, 0xF3,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x10, 0x07, 0x3F, 0x81, 0xDF, 0xF0, 0x7C, 0x1E, 0x1E,
  0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xE1, 0xC0, 0x31, 0xC0, 0x04,
  0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x3C,
  0x1E, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07, 0xFF, 0xFD, 0xFF, 0xFE, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0,
  0x18, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x78, 0x78,
  0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0C, 0x60, 0x1C, 0x60, 0x18, 0x70, 0x38, 0x70, 0x30, 0x70, 0x70, 0x70,
  0x60, 0x30, 0xE0, 0x30, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x3B, 0x80, 0x3B,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xC1, 0xC1, 0xF0, 0x70, 0x7C,
  0x14, 0x1B, 0x0D, 0x06, 0xC3, 0x43, 0xB0, 0xD0, 0xCC, 0x64, 0x33, 0x19,
  0x1C, 0xC6, 0x46, 0x33, 0x11, 0x8C, 0xC4, 0xE3, 0x31, 0x30, 0xD8, 0x4C,
  0x36, 0x17, 0x0D, 0x85, 0x83, 0xC1, 0x60, 0xF0, 0x58, 0x3C, 0x1C, 0x0E,
  0x07, 0x00, 0x1E, 0x01, 0xE1, 0xC0, 0x78, 0x3C, 0x0E, 0x03, 0x83, 0x80,
  0x70, 0xE0, 0x07, 0x38, 0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x07,
  0x07, 0x01, 0xE0, 0xF0, 0x38, 0x0E, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x00,
  0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x7C, 0x7F, 0xDC, 0x3F, 0x98, 0x06, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x07,
  0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x01,
  0x9F, 0xC0, 0xDF, 0xF0, 0x6E, 0x38, 0x76, 0x0F, 0x7B, 0x03, 0xFB, 0x80,
  0xF8,
};

const GFXglyph JetBrainsMono_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 8, 26, 21, 7, -26 },
  { 27, 11, 11, 21, 7, -26 },
  { 43, 20, 26, 21, 1, -26 },
  { 108, 18, 35, 21, 2, -30 },
  { 187, 24, 26, 21, -1, -26 },
  { 265, 19, 26, 21, 1, -26 },
  { 327, 4, 11, 21, 10, -26 },
  { 333, 14, 34, 21, 6, -30 },
  { 393, 14, 34, 21, 2, -30 },
  { 453, 18, 18, 21, 2, -21 },
  { 494, 17, 17, 21, 2, -20 },
  { 531, 8, 11, 21, 4, -5 },
  { 542, 12, 3, 21, 5, -13 },
  { 547, 6, 5, 21, 6, -5 },
  { 551, 20, 33, 21, 1, -29 },
  { 634, 18, 26, 21, 2, -26 },
  { 693, 16, 26, 21, 2, -26 },
  { 745, 18, 26, 21, 2, -26 },
  { 804, 18, 26, 21, 2, -26 },
  { 863, 17, 26, 21, 2, -26 },
  { 919, 18, 26, 21, 2, -26 },
  { 978, 17, 26, 21, 2, -26 },
  { 1034, 17, 26, 21, 4, -26 },
  { 1090, 18, 26, 21, 2, -26 },
  { 1149, 17, 26, 21, 3, -26 },
  { 1205, 9, 20, 21, 6, -20 },
  { 1228, 11, 26, 21, 4, -20 },
  { 1264, 17, 19, 21, 3, -21 },
  { 1305, 16, 11, 21, 3, -17 },
  { 1327, 17, 19, 21, 2, -21 },
  { 1368, 14, 26, 21, 5, -26 },
  { 1414, 21, 32, 21, 0, -26 },
  { 1498, 18, 26, 21, 0, -26 },
  { 1557, 18, 26, 21, 2, -26 },
  { 1616, 18, 26, 21, 2, -26 },
  { 1675, 17, 26, 21, 2, -26 },
  { 1731, 19, 26, 21, 2, -26 },
  { 1793, 19, 26, 21, 2, -26 },
  { 1855, 18, 26, 21, 2, -26 },
  { 1914, 18, 26, 21, 2, -26 },
  { 1973, 18, 26, 21, 2, -26 },
  { 2032, 19, 26, 21, 1, -26 },
  { 2094, 20, 26, 21, 2, -26 },
  { 2159, 15, 26, 21, 3, -26 },
  { 2208, 20, 26, 21, 1, -26 },
  { 2273, 18, 26, 21, 2, -26 },
  { 2332, 18, 26, 21, 2, -26 },
  { 2391, 19, 26, 21, 2, -26 },
  { 2453, 18, 32, 21, 2, -26 },
  { 2525, 18, 26, 21, 2, -26 },
  { 2584, 18, 26, 21, 2, -26 },
  { 2643, 18, 26, 21, 4, -26 },
  { 2702, 18, 26, 21, 2, -26 },
  { 2761, 18, 26, 21, 4, -26 },
  { 2820, 21, 26, 21, 2, -26 },
  { 2889, 22, 26, 21, 0, -26 },
  { 2961, 18, 26, 21, 4, -26 },
  { 3020, 19, 26, 21, 1, -26 },
  { 3082, 14, 33, 21, 5, -29 },
  { 3140, 10, 33, 21, 6, -29 },
  { 3182, 14, 33, 21, 3, -29 },
  { 3240, 15, 14, 21, 3, -26 },
  { 3267, 17, 2, 21, 0, 1 },
  { 3272, 6, 4, 21, 9, -27 },
  { 3275, 17, 20, 21, 2, -20 },
  { 3318, 17, 26, 21, 2, -26 },
  { 3374, 17, 20, 21, 2, -20 },
  { 3417, 18, 26, 21, 2, -26 },
  { 3476, 17, 20, 21, 2, -20 },
  { 3519, 23, 32, 21, -1, -26 },
  { 3611, 16, 26, 21, 3, -20 },
  { 3663, 17, 26, 21, 2, -26 },
  { 3719, 17, 27, 21, 1, -27 },
  { 3777, 17, 33, 21, 1, -27 },
  { 3848, 18, 26, 21, 2, -26 },
  { 3907, 14, 26, 21, 4, -26 },
  { 3953, 19, 20, 21, 1, -20 },
  { 4001, 17, 20, 21, 2, -20 },
  { 4044, 17, 20, 21, 2, -20 },
  { 4087, 18, 26, 21, 1, -20 },
  { 4146, 17, 26, 21, 2, -20 },
  { 4202, 18, 20, 21, 2, -20 },
  { 4247, 17, 20, 21, 2, -20 },
  { 4290, 17, 25, 21, 3, -25 },
  { 4344, 17, 19, 21, 2, -19 },
  { 4385, 16, 19, 21, 4, -19 },
  { 4423, 18, 19, 21, 3, -19 },
  { 4466, 19, 19, 21, 1, -19 },
  { 4512, 16, 25, 21, 3, -19 },
  { 4562, 17, 19, 21, 2, -19 },
  { 4603, 18, 33, 21, 3, -29 },
  { 4678, 8, 33, 21, 7, -29 },
  { 4711, 18, 33, 21, 1, -29 },
  { 4786, 17, 7, 21, 2, -16 },
};

const GFXfont JetBrainsMono_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_LIGHTITALIC35PT7B_H_
