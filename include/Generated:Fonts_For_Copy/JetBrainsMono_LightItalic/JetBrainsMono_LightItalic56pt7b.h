#ifndef _JETBRAINSMONO_LIGHTITALIC56PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x3E,
  0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x8E, 0x3F, 0x01, 0xF8, 0x70, 0xF8, 0x0F,
  0x83, 0x87, 0xC0, 0xF8, 0x38, 0x1E, 0x07, 0xC1, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x07,
  0xF3, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xEF, 0xF0, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x78, 0x7C, 0x00,
  0x03, 0x81, 0xF0, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0xE0, 0x7C, 0x00, 0x07,
  0x03, 0xE3, 0xE0, 0x38, 0x1F, 0x1F, 0x01, 0xC0, 0xF0, 0xF8, 0x1E, 0x07,
  0x87, 0xC0, 0xE0, 0x7C, 0x3E, 0x07, 0x07, 0xC0, 0xF8, 0x38, 0x7E, 0x07,
  0xE1, 0xC7, 0xE0, 0x1F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xC0,
  0x01, 0xE0, 0x0F, 0xC7, 0xC0, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x07, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x3C, 0x00,
  0x0E, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x07,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x78, 0x00,
  0x01, 0xFF, 0xF1, 0xE0, 0x00, 0x01, 0xFF, 0xC7, 0x80, 0x00, 0x01, 0xFE,
  0x1E, 0x00, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xC7, 0xFF,
  0x80, 0x00, 0x0F, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x3C, 0x1F, 0x00, 0x00,
  0x78, 0xF0, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0x80,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x00,
  0xE0, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x00, 0x0F,
  0xFE, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC1, 0xF0, 0x1F,
  0x0F, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x7C, 0x07, 0xC3, 0xE0,
  0xF0, 0x07, 0xCF, 0x81, 0xE0, 0x0F, 0x9E, 0x03, 0xC0, 0x0F, 0xF8, 0x07,
  0x80, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xE0,
  0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xFB, 0xF8, 0xF8, 0x0F, 0xFF,
  0xE0, 0xF8, 0x0F, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3,
  0xCF, 0x9F, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x30, 0x07, 0x80, 0x19, 0xF0, 0x1E, 0x03, 0xE7,
  0xF8, 0x78, 0x7F, 0xBF, 0xF9, 0xC7, 0xFF, 0x7F, 0xF3, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x1F, 0x1F, 0xE7,
  0xF9, 0xFF, 0xFF, 0xBF, 0xE7, 0xF1, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x38,
  0x0F, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x3F, 0x87, 0xC3, 0xE1, 0xFC, 0x3E,
  0x1F, 0x07, 0xE1, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0x80, 0xE0, 0x78, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xE1,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF7, 0x80, 0x07, 0xE3, 0xC0,
  0x0F, 0xE3, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0x80, 0x78,
  0x01, 0x80, 0x3C, 0x01, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xC1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x78, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC1, 0xF8, 0x00, 0xF9, 0xFF, 0xC0, 0x1F, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7B, 0x81, 0xFC, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE7, 0xF8, 0x00, 0xFB, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x0F, 0x8F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0xCF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0x8F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0xC7, 0xFC,
  0x07, 0xFF, 0xEF, 0x80, 0x7F, 0xFB, 0xE0, 0x03, 0xFC, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x1F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFC, 0x01, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0xFE, 0x3C, 0x3C, 0x00, 0xFF, 0x9E, 0x1E, 0x01, 0xFF,
  0xEF, 0x0F, 0x00, 0xF8, 0x37, 0x07, 0x80, 0xF8, 0x0F, 0x83, 0xC0, 0x78,
  0x03, 0xC1, 0xE0, 0x7C, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0xF0, 0xF0, 0x1E,
  0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x07,
  0xC0, 0x1E, 0x0F, 0x03, 0xC0, 0x0F, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80,
  0xF0, 0x03, 0xC3, 0xC0, 0x78, 0x03, 0xE1, 0xE0, 0x3C, 0x01, 0xE0, 0xF0,
  0x1E, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xFC, 0x3C,
  0x03, 0xF9, 0xDE, 0x1E, 0x00, 0xFF, 0xEF, 0x0F, 0x00, 0x7F, 0xE7, 0x07,
  0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x7C,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xFE, 0x01,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x03, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x78, 0x00, 0xFE, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x3C, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x1F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0xC0, 0x78, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0xFF, 0xC3, 0xC0,
  0xFF, 0xFC, 0x3C, 0x0F, 0xFF, 0x87, 0xC0, 0xFF, 0xF8, 0x7C, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x80,
  0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x04, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x10, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xF0, 0x3B, 0x80, 0x1F, 0xC0, 0x77, 0x00, 0x7B, 0x81, 0xEE,
  0x00, 0xF7, 0x03, 0xDE, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0x78,
  0x0E, 0x78, 0x1E, 0x70, 0x3C, 0xF0, 0x3C, 0xE0, 0x73, 0xC0, 0x71, 0xE1,
  0xE7, 0x81, 0xE3, 0xC3, 0x8F, 0x03, 0xC7, 0x8F, 0x1E, 0x07, 0x87, 0x1C,
  0x3C, 0x0F, 0x0E, 0x78, 0xF8, 0x1E, 0x1C, 0xE1, 0xE0, 0x3C, 0x3B, 0xC3,
  0xC0, 0xF8, 0x7F, 0x07, 0x81, 0xF0, 0xFE, 0x0F, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0xC0, 0x03, 0xC0, 0xFE, 0x00,
  0x1E, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0x83, 0xFC, 0x00, 0x78,
  0x1E, 0xF0, 0x03, 0xC0, 0xF7, 0x80, 0x1E, 0x07, 0xBC, 0x00, 0xF0, 0x3D,
  0xE0, 0x07, 0x81, 0xE7, 0x00, 0x7C, 0x0F, 0x3C, 0x03, 0xE0, 0xF9, 0xE0,
  0x1E, 0x07, 0xCF, 0x00, 0xF0, 0x3C, 0x78, 0x07, 0x81, 0xE1, 0xC0, 0x3C,
  0x0F, 0x0F, 0x03, 0xE0, 0x78, 0x78, 0x1F, 0x07, 0xC3, 0xC0, 0xF0, 0x3E,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x1F, 0x03, 0xC0, 0xF0, 0xF8, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0x1E, 0x3C,
  0x0F, 0x00, 0xF1, 0xE0, 0x78, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x78, 0x1E,
  0x01, 0xE7, 0xC0, 0xF0, 0x07, 0xBC, 0x0F, 0x80, 0x3D, 0xE0, 0x7C, 0x01,
  0xEF, 0x03, 0xC0, 0x0F, 0x78, 0x1E, 0x00, 0x3F, 0xC0, 0xF0, 0x01, 0xFE,
  0x07, 0x80, 0x0F, 0xF0, 0x7C, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xF8, 0x1E,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0xBF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x07, 0xF8,
  0x0F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3E,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0A, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x03,
  0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x3C, 0x03, 0xE0, 0x0F, 0x3C,
  0x03, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x78,
  0x07, 0xE0, 0x3E, 0x78, 0x07, 0xE0, 0x3C, 0x78, 0x0E, 0xE0, 0x3C, 0x78,
  0x0E, 0xE0, 0x3C, 0x78, 0x0E, 0xE0, 0x78, 0x78, 0x1C, 0xE0, 0x78, 0x78,
  0x1C, 0xE0, 0x78, 0x78, 0x1C, 0xE0, 0x78, 0x78, 0x1C, 0xE0, 0xF0, 0x78,
  0x38, 0xE0, 0xF0, 0x78, 0x38, 0xE0, 0xF0, 0x78, 0x38, 0xE0, 0xE0, 0x78,
  0x70, 0xE1, 0xE0, 0x78, 0x70, 0xE1, 0xE0, 0x78, 0x70, 0xE1, 0xE0, 0x78,
  0x70, 0xE3, 0xC0, 0x78, 0xE0, 0xE3, 0xC0, 0x78, 0xE0, 0xC3, 0xC0, 0x78,
  0xE0, 0xC3, 0xC0, 0x79, 0xC0, 0xC7, 0x80, 0x71, 0xC0, 0xC7, 0x80, 0x71,
  0xC1, 0xC7, 0x80, 0x71, 0xC1, 0xC7, 0x00, 0xF3, 0x81, 0xCF, 0x00, 0xF3,
  0x81, 0xCF, 0x00, 0xF3, 0x81, 0xCF, 0x00, 0xF7, 0x01, 0xDE, 0x00, 0xF7,
  0x01, 0xDE, 0x00, 0xF7, 0x01, 0xDE, 0x00, 0xF7, 0x01, 0xDC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0,
  0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x01, 0xE0, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C,
  0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x7F, 0xC3,
  0xE0, 0x1F, 0xFC, 0x78, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0xFD, 0xE0, 0xFE,
  0x03, 0xBC, 0x1F, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0xC3, 0xDE, 0x03, 0xFF, 0xF3, 0xC0, 0x3F,
  0xFC, 0x78, 0x03, 0xFF, 0x1F, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xF0, 0x03, 0xC7,
  0xFF, 0x80, 0xFB, 0xFF, 0xF8, 0x1F, 0x7F, 0xFF, 0x03, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3F, 0x00, 0x1F, 0x07, 0xF0,
  0x0F, 0xC0, 0xF7, 0x87, 0xF8, 0x3E, 0xFF, 0xFE, 0x07, 0xCF, 0xFF, 0x00,
  0xF0, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0x83,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x78, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0x80, 0xFF,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xC3, 0xE0, 0x0F, 0xFE, 0x3C, 0x03, 0xFF, 0xF3,
  0xC0, 0x7F, 0xFF, 0xBC, 0x0F, 0xE0, 0x3B, 0xC0, 0xF8, 0x01, 0xFC, 0x1F,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x7B, 0xC0, 0x3F, 0xFF, 0x3C, 0x01, 0xFF, 0xE3, 0xC0, 0x0F,
  0xFC, 0x7C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC3, 0xE0, 0x1F, 0xFE, 0x78, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0xFD, 0xE0,
  0xFE, 0x03, 0xBC, 0x1F, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x06, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xFF,
  0xF7, 0xC0, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E, 0x00, 0x3F, 0x83, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xF0, 0x03, 0xC7, 0xFF, 0x80, 0xFB, 0xFF,
  0xF8, 0x1F, 0x7C, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x7A, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E,
  0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7E,
  0x07, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03,
  0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0,
  0x07, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0x8F, 0x83, 0xF0, 0x0F, 0x7F, 0x8F, 0xF0, 0x1E, 0xFF, 0xBF, 0xF0, 0x3F,
  0x1F, 0x43, 0xE0, 0x78, 0x1F, 0x03, 0xC1, 0xF0, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x03,
  0xC0, 0xF8, 0x3C, 0x07, 0x01, 0xE0, 0xF8, 0x0E, 0x03, 0xC1, 0xF0, 0x3C,
  0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0x3C, 0x1E, 0x03, 0xC0, 0xF8, 0x3C, 0x07, 0x01, 0xE0, 0xF8, 0x1E, 0x03,
  0xC1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0xF0, 0x7C, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0x1E, 0x0F, 0x01, 0xC0, 0x7C, 0x3E, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x87, 0xFC, 0x00, 0xF1, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x07, 0xDF,
  0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F,
  0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x3E,
  0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE1, 0xFF, 0x00, 0x0F, 0x1F, 0xFE,
  0x00, 0xFB, 0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0x01,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x80,
  0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x7D, 0xE1, 0xFE, 0x03, 0xEF,
  0xFF, 0xE0, 0x1F, 0x3F, 0xFC, 0x00, 0xF0, 0xFF, 0xC0, 0x07, 0x80, 0x40,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC3, 0xE0, 0x3F, 0xFC, 0x78, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0xFD, 0xE0,
  0xFC, 0x03, 0xFC, 0x1F, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0xC3, 0xDE, 0x03, 0xFF, 0xF3, 0xC0,
  0x3F, 0xFC, 0x78, 0x03, 0xFF, 0x1F, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xFC, 0x00, 0xF3, 0xFF, 0xE0,
  0x3E, 0xFF, 0xFE, 0x07, 0xFF, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x83, 0xE0,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x3F, 0xE1, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x1F, 0xC7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x0F,
  0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xB8, 0x07, 0xC0,
  0x3D, 0xC0, 0x3E, 0x01, 0xEE, 0x01, 0xB0, 0x0E, 0x70, 0x1D, 0x80, 0xF3,
  0x80, 0xEC, 0x07, 0x9C, 0x06, 0x60, 0x38, 0xE0, 0x73, 0x03, 0xC7, 0x03,
  0x98, 0x1E, 0x38, 0x18, 0xC0, 0xE1, 0xC1, 0xC6, 0x0F, 0x0E, 0x0E, 0x30,
  0x78, 0x70, 0x71, 0x83, 0x83, 0x87, 0x0C, 0x1C, 0x1C, 0x38, 0x61, 0xE0,
  0xE1, 0xC3, 0x0F, 0x07, 0x1C, 0x18, 0x70, 0x38, 0xE0, 0xC7, 0x81, 0xC7,
  0x06, 0x3C, 0x0E, 0x70, 0x31, 0xC0, 0x73, 0x81, 0x9E, 0x03, 0x9C, 0x0E,
  0xF0, 0x1D, 0xC0, 0x77, 0x00, 0xEE, 0x03, 0xF8, 0x07, 0x70, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C,
  0x3C, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x3F, 0x03, 0xFE, 0x07, 0xFF, 0xF7, 0xC0,
  0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xE3, 0xFF, 0x00, 0x3C,
  0xFF, 0xF0, 0x07, 0xBF, 0x3F, 0x01, 0xF7, 0x83, 0xF0, 0x3C, 0xF0, 0x3E,
  0x07, 0xBE, 0x03, 0xE1, 0xF7, 0x80, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E,
  0x00, 0x7F, 0xC3, 0xC0, 0x03, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 12, 41, 34, 11, -41 },
  { 63, 18, 17, 34, 11, -41 },
  { 102, 33, 41, 34, 1, -41 },
  { 272, 29, 57, 34, 3, -49 },
  { 479, 39, 41, 34, -2, -41 },
  { 679, 31, 42, 34, 1, -41 },
  { 842, 7, 17, 34, 16, -41 },
  { 857, 23, 54, 34, 9, -47 },
  { 1013, 22, 54, 34, 3, -47 },
  { 1162, 30, 29, 34, 3, -34 },
  { 1271, 27, 27, 34, 4, -32 },
  { 1363, 14, 17, 34, 6, -8 },
  { 1393, 19, 3, 34, 8, -20 },
  { 1401, 10, 9, 34, 10, -8 },
  { 1413, 33, 52, 34, 1, -46 },
  { 1628, 29, 42, 34, 3, -41 },
  { 1781, 25, 41, 34, 3, -41 },
  { 1910, 29, 41, 34, 3, -41 },
  { 2059, 28, 42, 34, 3, -41 },
  { 2206, 26, 41, 34, 4, -41 },
  { 2340, 27, 42, 34, 4, -41 },
  { 2482, 27, 42, 34, 3, -41 },
  { 2624, 27, 41, 34, 7, -41 },
  { 2763, 28, 43, 34, 3, -42 },
  { 2914, 27, 41, 34, 5, -41 },
  { 3053, 13, 32, 34, 10, -31 },
  { 3105, 18, 40, 34, 6, -31 },
  { 3195, 27, 29, 34, 5, -33 },
  { 3293, 27, 17, 34, 4, -27 },
  { 3351, 27, 29, 34, 3, -33 },
  { 3449, 23, 41, 34, 8, -41 },
  { 3567, 33, 51, 34, 1, -41 },
  { 3778, 27, 41, 34, 1, -41 },
  { 3917, 29, 41, 34, 3, -41 },
  { 4066, 28, 42, 34, 4, -41 },
  { 4213, 28, 41, 34, 3, -41 },
  { 4357, 30, 41, 34, 3, -41 },
  { 4511, 30, 41, 34, 3, -41 },
  { 4665, 28, 42, 34, 4, -41 },
  { 4812, 29, 41, 34, 3, -41 },
  { 4961, 28, 41, 34, 4, -41 },
  { 5105, 31, 42, 34, 1, -41 },
  { 5268, 32, 41, 34, 3, -41 },
  { 5432, 24, 41, 34, 4, -41 },
  { 5555, 31, 41, 34, 2, -41 },
  { 5714, 29, 41, 34, 3, -41 },
  { 5863, 27, 42, 34, 4, -41 },
  { 6005, 30, 41, 34, 3, -41 },
  { 6159, 28, 51, 34, 4, -41 },
  { 6338, 30, 41, 34, 3, -41 },
  { 6492, 29, 43, 34, 3, -42 },
  { 6648, 28, 41, 34, 7, -41 },
  { 6792, 28, 42, 34, 4, -41 },
  { 6939, 28, 41, 34, 7, -41 },
  { 7083, 32, 41, 34, 4, -41 },
  { 7247, 35, 41, 34, 0, -41 },
  { 7427, 29, 41, 34, 6, -41 },
  { 7576, 30, 41, 34, 2, -41 },
  { 7730, 22, 52, 34, 8, -46 },
  { 7873, 17, 52, 34, 9, -46 },
  { 7984, 22, 52, 34, 5, -46 },
  { 8127, 24, 22, 34, 5, -41 },
  { 8193, 28, 4, 34, 0, 1 },
  { 8207, 10, 8, 34, 15, -44 },
  { 8217, 27, 32, 34, 4, -31 },
  { 8325, 27, 42, 34, 3, -41 },
  { 8467, 26, 32, 34, 4, -31 },
  { 8571, 28, 42, 34, 4, -41 },
  { 8718, 26, 32, 34, 4, -31 },
  { 8822, 37, 51, 34, -2, -41 },
  { 9058, 27, 41, 34, 4, -31 },
  { 9197, 27, 41, 34, 3, -41 },
  { 9336, 27, 43, 34, 2, -43 },
  { 9482, 29, 53, 34, 1, -43 },
  { 9675, 30, 41, 34, 3, -41 },
  { 9829, 23, 41, 34, 6, -41 },
  { 9947, 31, 31, 34, 1, -31 },
  { 10068, 27, 31, 34, 3, -31 },
  { 10173, 26, 32, 34, 4, -31 },
  { 10277, 29, 41, 34, 1, -31 },
  { 10426, 27, 41, 34, 4, -31 },
  { 10565, 27, 31, 34, 4, -31 },
  { 10670, 27, 32, 34, 3, -31 },
  { 10778, 26, 39, 34, 5, -39 },
  { 10905, 27, 32, 34, 4, -31 },
  { 11013, 26, 31, 34, 6, -31 },
  { 11114, 29, 31, 34, 5, -31 },
  { 11227, 31, 31, 34, 1, -31 },
  { 11348, 27, 41, 34, 4, -31 },
  { 11487, 27, 31, 34, 3, -31 },
  { 11592, 28, 52, 34, 5, -46 },
  { 11774, 13, 52, 34, 11, -46 },
  { 11859, 28, 52, 34, 2, -46 },
  { 12041, 27, 11, 34, 4, -25 },
};

const GFXfont JetBrainsMono_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_LIGHTITALIC56PT7B_H_
