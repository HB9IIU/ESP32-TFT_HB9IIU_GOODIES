#ifndef _JETBRAINSMONO_LIGHTITALIC20PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x32, 0x22, 0x66, 0x40, 0x0E, 0xC0, 0x47, 0x3C, 0xF3,
  0xCE, 0x20, 0x02, 0x30, 0x62, 0x04, 0x20, 0x46, 0x3F, 0xF3, 0xFF, 0x08,
  0xC1, 0x88, 0x10, 0x81, 0x1A, 0xFF, 0xC2, 0x10, 0x23, 0x06, 0x20, 0x46,
  0x00, 0x03, 0x00, 0x80, 0x70, 0x7F, 0x32, 0xC9, 0x92, 0x40, 0xD0, 0x3C,
  0x07, 0xC0, 0x78, 0x16, 0x08, 0xB2, 0x2C, 0x99, 0xAC, 0x7E, 0x02, 0x01,
  0x80, 0x40, 0x0E, 0x04, 0x7C, 0x21, 0x11, 0x0C, 0xCC, 0x33, 0x60, 0xCB,
  0x01, 0xC8, 0x00, 0x40, 0x02, 0x60, 0x13, 0xC0, 0xD1, 0x06, 0x44, 0x11,
  0x10, 0x84, 0xCC, 0x1E, 0x00, 0x0F, 0x07, 0xE3, 0x18, 0xC2, 0x30, 0x0C,
  0x01, 0x81, 0xE0, 0xCC, 0xF3, 0x2C, 0x72, 0x0C, 0x87, 0x33, 0x6F, 0x98,
  0xFF, 0xE0, 0x01, 0x83, 0x83, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x1C, 0x07, 0x00,
  0x80, 0x10, 0x1C, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x0C, 0x18, 0x30, 0xE0, 0x80, 0x06, 0x00, 0xC0,
  0x10, 0x72, 0x77, 0xFC, 0x18, 0x07, 0x81, 0x90, 0x63, 0x08, 0x20, 0x06,
  0x01, 0x00, 0x40, 0x10, 0xFF, 0xC3, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x39,
  0x8C, 0xC4, 0x60, 0xFC, 0xFF, 0x80, 0x00, 0x30, 0x03, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x07,
  0x07, 0xF3, 0x0C, 0x81, 0x60, 0x58, 0x36, 0x4D, 0xB3, 0x4C, 0x90, 0x2C,
  0x0B, 0x06, 0xC1, 0x98, 0xC3, 0xE0, 0x03, 0x07, 0x86, 0xC4, 0x44, 0x20,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x63, 0xFE, 0x07,
  0x07, 0xF3, 0x0C, 0x81, 0x40, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x0F, 0xF8, 0x1F, 0xCF, 0xF0, 0x08, 0x0C, 0x06,
  0x03, 0x00, 0xF0, 0x06, 0x01, 0x80, 0x60, 0x1B, 0x06, 0xC1, 0x18, 0xC7,
  0xE0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC2, 0x61,
  0x90, 0x67, 0xFB, 0xFE, 0x01, 0x00, 0x40, 0x30, 0x1F, 0xCF, 0xF3, 0x00,
  0xC0, 0x20, 0x09, 0x83, 0xF9, 0xC6, 0x00, 0x80, 0x20, 0x18, 0x06, 0xC1,
  0x98, 0xC3, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0xF1,
  0xCE, 0x60, 0x90, 0x2C, 0x0B, 0x02, 0xC1, 0x98, 0xC3, 0xE0, 0x7F, 0xDF,
  0xF4, 0x0D, 0x06, 0x81, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x00, 0x07, 0x07, 0xF3, 0x0C, 0x83, 0x20, 0xCC,
  0x21, 0xB0, 0x38, 0x33, 0x18, 0x64, 0x1B, 0x06, 0xC1, 0x98, 0xC7, 0xE0,
  0x0E, 0x0F, 0xE6, 0x19, 0x02, 0xC0, 0xB0, 0x2C, 0x1B, 0x0C, 0x7F, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x00, 0x77, 0x60, 0x00, 0x00, 0x4E,
  0xE0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xC3, 0x18, 0x43, 0x00,
  0x00, 0x81, 0xC3, 0xC7, 0x0E, 0x04, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x40, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x40, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x20, 0x38, 0x38, 0x78, 0x30, 0x08, 0x00, 0x78,
  0x7E, 0x06, 0x03, 0x03, 0x02, 0x06, 0x3C, 0x30, 0x60, 0x60, 0x00, 0x00,
  0xE0, 0xE0, 0x03, 0xC0, 0xEE, 0x18, 0x33, 0x03, 0x20, 0x32, 0x1B, 0x63,
  0x76, 0x62, 0x64, 0x24, 0x42, 0x44, 0x24, 0x46, 0x46, 0xEC, 0x74, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x05, 0x83, 0x20, 0x88, 0x62, 0x18, 0x84, 0x23, 0xFC, 0x83, 0x60, 0xD0,
  0x3C, 0x0C, 0x3F, 0x0F, 0xE3, 0x0C, 0x83, 0x20, 0xC8, 0x36, 0x19, 0xFC,
  0x61, 0x98, 0x24, 0x09, 0x02, 0xC1, 0xB1, 0xCF, 0xE0, 0x07, 0x07, 0xF3,
  0x0C, 0x81, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x06,
  0x41, 0x98, 0xC3, 0xE0, 0x3E, 0x0F, 0xE3, 0x0C, 0x83, 0x20, 0xC8, 0x36,
  0x0D, 0x82, 0x60, 0x98, 0x24, 0x19, 0x06, 0xC1, 0x31, 0xCF, 0xC0, 0x1F,
  0xE7, 0xFC, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0xFC, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0xFC, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x00, 0x07, 0x07, 0xF3, 0x0C, 0x81, 0x20, 0x18,
  0x06, 0x01, 0x81, 0x67, 0x90, 0x24, 0x09, 0x06, 0x41, 0x98, 0xC3, 0xE0,
  0x30, 0x4C, 0x13, 0x04, 0x83, 0x20, 0xC8, 0x36, 0x0D, 0xFE, 0x60, 0x98,
  0x64, 0x19, 0x06, 0xC1, 0xB0, 0x4C, 0x10, 0x1F, 0xCF, 0xF0, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x0F, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x20, 0x46, 0x18, 0xC6, 0x0F, 0x80, 0x30,
  0x66, 0x0C, 0xC3, 0x10, 0xC2, 0x18, 0x46, 0x19, 0x83, 0xF0, 0x66, 0x0C,
  0x41, 0x0C, 0x21, 0x8C, 0x11, 0x83, 0x30, 0x60, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0xFE, 0x30, 0x66, 0x14, 0xE3, 0x9C, 0xA6, 0x94, 0xD6, 0x9A, 0xB2, 0x76,
  0x4C, 0xC8, 0x13, 0x02, 0x60, 0x4C, 0x19, 0x83, 0x20, 0x60, 0x30, 0x67,
  0x08, 0xE1, 0x14, 0x22, 0x8C, 0x59, 0x9B, 0x33, 0x24, 0x64, 0x88, 0x91,
  0x1E, 0x23, 0xCC, 0x39, 0x86, 0x30, 0xC0, 0x07, 0x07, 0xE3, 0x0C, 0x83,
  0x20, 0xD8, 0x36, 0x0D, 0x82, 0x60, 0x90, 0x24, 0x19, 0x06, 0x41, 0x18,
  0xC3, 0xE0, 0x3F, 0x07, 0xF8, 0xC1, 0x90, 0x32, 0x06, 0x40, 0x98, 0x33,
  0xFC, 0x7F, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x07,
  0x07, 0xF3, 0x0C, 0x81, 0x20, 0xD8, 0x36, 0x0D, 0x83, 0x40, 0x90, 0x24,
  0x0B, 0x06, 0xC1, 0x98, 0xC3, 0xE0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x3F,
  0x07, 0xF8, 0xC3, 0x10, 0x22, 0x04, 0x40, 0x98, 0x33, 0xFC, 0x7E, 0x0C,
  0xC1, 0x08, 0x21, 0x8C, 0x31, 0x82, 0x30, 0x60, 0x07, 0x07, 0xF3, 0x0C,
  0x81, 0x20, 0x0C, 0x03, 0x80, 0x78, 0x03, 0x80, 0x60, 0x0B, 0x02, 0xC1,
  0x98, 0xC7, 0xE0, 0x7F, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x30, 0x66,
  0x08, 0xC1, 0x10, 0x62, 0x0C, 0x41, 0x98, 0x33, 0x04, 0x60, 0x88, 0x11,
  0x06, 0x20, 0xC4, 0x10, 0xC6, 0x0F, 0x80, 0x80, 0xC0, 0xE0, 0x50, 0x6C,
  0x36, 0x13, 0x19, 0x88, 0xCC, 0x66, 0x12, 0x0B, 0x05, 0x03, 0x81, 0x80,
  0x42, 0x34, 0x63, 0x46, 0x24, 0x62, 0x4A, 0x64, 0xA4, 0x4A, 0x44, 0xAC,
  0x52, 0xC5, 0x28, 0x52, 0x86, 0x38, 0x63, 0x0E, 0x30, 0xE3, 0x00, 0x10,
  0x31, 0x83, 0x18, 0x60, 0x8C, 0x0C, 0x80, 0x58, 0x07, 0x00, 0x60, 0x07,
  0x00, 0xF0, 0x19, 0x01, 0x18, 0x30, 0x86, 0x0C, 0xC0, 0xC0, 0xC0, 0x68,
  0x19, 0x82, 0x30, 0xC2, 0x30, 0x44, 0x0D, 0x80, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x3F, 0xCF, 0xF0, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x2F, 0xF0, 0x1F, 0x1F, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xF8, 0xC1, 0x04, 0x18,
  0x61, 0x82, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x60, 0x82, 0x0C, 0x30, 0xC0,
  0x1F, 0x1E, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0xF8, 0x04, 0x07, 0x06, 0x82, 0x43,
  0x21, 0x19, 0x05, 0x83, 0xFF, 0xFF, 0xF0, 0xC6, 0x30, 0x1E, 0xCC, 0x76,
  0x0D, 0x82, 0x60, 0x90, 0x64, 0x19, 0x06, 0x41, 0x98, 0xC7, 0xD0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x2F, 0x8C, 0x66, 0x09, 0x82, 0x60, 0x98, 0x24,
  0x19, 0x06, 0xC1, 0xB8, 0xCD, 0xE0, 0x1F, 0x0C, 0x62, 0x0D, 0x83, 0x60,
  0x10, 0x04, 0x01, 0x06, 0x41, 0x98, 0xC3, 0xE0, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x61, 0xEC, 0x63, 0x98, 0x33, 0x04, 0x60, 0x88, 0x31, 0x06, 0x20,
  0xC4, 0x18, 0xC6, 0x1F, 0x40, 0x1F, 0x0C, 0x62, 0x09, 0x82, 0x60, 0x9F,
  0xE4, 0x01, 0x00, 0x41, 0x98, 0xC3, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0xCC, 0x76, 0x0D, 0x82, 0x60, 0x90,
  0x24, 0x19, 0x06, 0x63, 0x8F, 0x40, 0x10, 0x04, 0x03, 0x1F, 0x87, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x2F, 0x8C, 0x66, 0x09, 0x82, 0x60, 0x98,
  0x24, 0x19, 0x06, 0xC1, 0xB0, 0x4C, 0x10, 0x07, 0x03, 0x80, 0x00, 0x03,
  0xE0, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x63, 0xFE,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x1F,
  0x83, 0xC0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x0E, 0x43, 0x18,
  0x63, 0x18, 0x66, 0x0F, 0x81, 0x18, 0x23, 0x04, 0x31, 0x86, 0x30, 0x60,
  0xF8, 0xF8, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x30, 0x1F, 0x3E, 0xE6, 0x6C, 0x88, 0x91, 0x32, 0x66, 0xCC, 0xD9,
  0x13, 0x22, 0x44, 0x48, 0x9B, 0x33, 0x00, 0x2F, 0x8C, 0x66, 0x09, 0x82,
  0x60, 0x98, 0x24, 0x19, 0x06, 0xC1, 0xB0, 0x4C, 0x10, 0x1F, 0x0C, 0x62,
  0x09, 0x82, 0x60, 0x90, 0x24, 0x19, 0x06, 0x41, 0x18, 0xC3, 0xE0, 0x17,
  0xC3, 0x18, 0xC1, 0x18, 0x23, 0x04, 0x60, 0x88, 0x31, 0x06, 0x60, 0xCE,
  0x31, 0xBC, 0x30, 0x04, 0x00, 0x80, 0x30, 0x00, 0x1E, 0xCC, 0x76, 0x0D,
  0x82, 0x60, 0x90, 0x64, 0x19, 0x06, 0x41, 0x98, 0xC7, 0xD0, 0x04, 0x03,
  0x00, 0xC0, 0x30, 0x3F, 0x8A, 0x33, 0x0C, 0x83, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x00, 0x1F, 0x8C, 0x62, 0x0D, 0x80, 0x30, 0x07,
  0xC0, 0x18, 0x06, 0xC1, 0xB8, 0xC7, 0xE0, 0x08, 0x0C, 0x06, 0x1F, 0xF1,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x03, 0x00, 0xF0, 0x20,
  0xC8, 0x36, 0x0D, 0x82, 0x60, 0x90, 0x24, 0x19, 0x06, 0x41, 0x18, 0xC3,
  0xE0, 0xC0, 0xF0, 0x64, 0x11, 0x0C, 0x42, 0x19, 0x86, 0x41, 0xB0, 0x28,
  0x0E, 0x03, 0x00, 0x8C, 0x63, 0x39, 0x4A, 0x52, 0x95, 0xA9, 0x4A, 0x52,
  0x9C, 0xC6, 0x31, 0x8C, 0x60, 0x30, 0x63, 0x18, 0x22, 0x06, 0xC0, 0x70,
  0x0C, 0x03, 0xC0, 0xD8, 0x31, 0x84, 0x33, 0x83, 0x00, 0x20, 0xD8, 0x36,
  0x0D, 0x82, 0x60, 0x90, 0x64, 0x19, 0x06, 0x63, 0x8F, 0x40, 0x10, 0x0C,
  0x03, 0x1F, 0x87, 0x80, 0x3F, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x0F, 0xF0, 0x00, 0xC0, 0xF0, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x3E, 0x0F, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xE0, 0x18, 0x84, 0x63, 0x18, 0xC4, 0x21,
  0x18, 0xC6, 0x21, 0x08, 0xC6, 0x30, 0x10, 0x0F, 0x00, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xF0, 0xF8, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x0E, 0x00, 0x38, 0x5B, 0x34, 0x6F, 0x0E,
};

const GFXglyph JetBrainsMono_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 4, -15 },
  { 14, 12, 15, 12, 0, -15 },
  { 37, 10, 20, 12, 1, -17 },
  { 62, 14, 15, 12, -1, -15 },
  { 89, 10, 15, 12, 1, -15 },
  { 108, 2, 6, 12, 6, -15 },
  { 110, 9, 20, 12, 3, -17 },
  { 133, 8, 20, 12, 1, -17 },
  { 153, 11, 10, 12, 1, -12 },
  { 167, 10, 9, 12, 1, -11 },
  { 179, 5, 6, 12, 2, -3 },
  { 183, 6, 1, 12, 3, -7 },
  { 184, 3, 3, 12, 4, -3 },
  { 186, 12, 19, 12, 0, -17 },
  { 215, 10, 15, 12, 1, -15 },
  { 234, 9, 15, 12, 1, -15 },
  { 251, 10, 15, 12, 1, -15 },
  { 270, 10, 15, 12, 1, -15 },
  { 289, 10, 15, 12, 1, -15 },
  { 308, 10, 15, 12, 1, -15 },
  { 327, 10, 15, 12, 1, -15 },
  { 346, 10, 15, 12, 2, -15 },
  { 365, 10, 15, 12, 1, -15 },
  { 384, 10, 15, 12, 2, -15 },
  { 403, 4, 11, 12, 4, -11 },
  { 409, 6, 14, 12, 2, -11 },
  { 420, 9, 11, 12, 2, -12 },
  { 433, 10, 6, 12, 1, -10 },
  { 441, 10, 11, 12, 1, -12 },
  { 455, 8, 15, 12, 3, -15 },
  { 470, 12, 19, 12, 0, -15 },
  { 499, 10, 15, 12, 0, -15 },
  { 518, 10, 15, 12, 1, -15 },
  { 537, 10, 15, 12, 1, -15 },
  { 556, 10, 15, 12, 1, -15 },
  { 575, 11, 15, 12, 1, -15 },
  { 596, 11, 15, 12, 1, -15 },
  { 617, 10, 15, 12, 1, -15 },
  { 636, 10, 15, 12, 1, -15 },
  { 655, 10, 15, 12, 1, -15 },
  { 674, 11, 15, 12, 0, -15 },
  { 695, 11, 15, 12, 1, -15 },
  { 716, 9, 15, 12, 1, -15 },
  { 733, 11, 15, 12, 1, -15 },
  { 754, 11, 15, 12, 1, -15 },
  { 775, 10, 15, 12, 1, -15 },
  { 794, 11, 15, 12, 1, -15 },
  { 815, 10, 19, 12, 1, -15 },
  { 839, 11, 15, 12, 1, -15 },
  { 860, 10, 15, 12, 1, -15 },
  { 879, 10, 15, 12, 2, -15 },
  { 898, 11, 15, 12, 1, -15 },
  { 919, 9, 15, 12, 3, -15 },
  { 936, 12, 15, 12, 1, -15 },
  { 959, 12, 15, 12, 0, -15 },
  { 982, 11, 15, 12, 2, -15 },
  { 1003, 10, 15, 12, 1, -15 },
  { 1022, 8, 19, 12, 3, -17 },
  { 1041, 6, 19, 12, 3, -17 },
  { 1056, 8, 19, 12, 2, -17 },
  { 1075, 9, 8, 12, 2, -15 },
  { 1084, 10, 2, 12, 0, 0 },
  { 1087, 4, 3, 12, 5, -16 },
  { 1089, 10, 11, 12, 1, -11 },
  { 1103, 10, 15, 12, 1, -15 },
  { 1122, 10, 11, 12, 1, -11 },
  { 1136, 11, 15, 12, 1, -15 },
  { 1157, 10, 11, 12, 1, -11 },
  { 1171, 14, 19, 12, -1, -15 },
  { 1205, 10, 15, 12, 1, -11 },
  { 1224, 10, 15, 12, 1, -15 },
  { 1243, 9, 15, 12, 1, -15 },
  { 1260, 11, 19, 12, 0, -15 },
  { 1287, 11, 15, 12, 1, -15 },
  { 1308, 8, 15, 12, 2, -15 },
  { 1323, 11, 11, 12, 0, -11 },
  { 1339, 10, 11, 12, 1, -11 },
  { 1353, 10, 11, 12, 1, -11 },
  { 1367, 11, 15, 12, 0, -11 },
  { 1388, 10, 15, 12, 1, -11 },
  { 1407, 10, 11, 12, 1, -11 },
  { 1421, 10, 11, 12, 1, -11 },
  { 1435, 9, 14, 12, 2, -14 },
  { 1451, 10, 11, 12, 1, -11 },
  { 1465, 10, 11, 12, 2, -11 },
  { 1479, 10, 11, 12, 2, -11 },
  { 1493, 11, 11, 12, 0, -11 },
  { 1509, 10, 15, 12, 1, -11 },
  { 1528, 10, 11, 12, 1, -11 },
  { 1542, 10, 19, 12, 2, -17 },
  { 1566, 5, 19, 12, 4, -17 },
  { 1578, 10, 19, 12, 1, -17 },
  { 1602, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_LIGHTITALIC20PT7B_H_
