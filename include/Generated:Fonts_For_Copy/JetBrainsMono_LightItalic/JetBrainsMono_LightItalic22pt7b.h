#ifndef _JETBRAINSMONO_LIGHTITALIC22PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x08, 0x00, 0x03, 0x9C, 0x66,
  0xCD, 0x1E, 0x3C, 0x78, 0xB1, 0x00, 0x03, 0x18, 0x10, 0x80, 0x84, 0x0C,
  0x63, 0xFF, 0x9F, 0xFC, 0x31, 0x81, 0x08, 0x18, 0x40, 0xC6, 0x1F, 0xFD,
  0xFF, 0xC3, 0x18, 0x10, 0x81, 0x8C, 0x0C, 0x60, 0x01, 0x00, 0x10, 0x01,
  0x00, 0xFC, 0x1F, 0xE3, 0x26, 0x32, 0x23, 0x20, 0x32, 0x03, 0xA0, 0x1F,
  0x00, 0x78, 0x04, 0xC0, 0x4C, 0x04, 0x4C, 0x4C, 0xC4, 0xC7, 0xF8, 0x3F,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0x06, 0x33, 0x08, 0x46, 0x21, 0x88,
  0x83, 0x13, 0x06, 0x6C, 0x07, 0xB0, 0x00, 0x40, 0x01, 0x00, 0x04, 0xF0,
  0x1A, 0x20, 0x64, 0x61, 0x98, 0x86, 0x31, 0x08, 0x66, 0x60, 0x78, 0x0F,
  0x81, 0x8C, 0x30, 0xC3, 0x00, 0x30, 0x01, 0x00, 0x18, 0x03, 0xC0, 0x6C,
  0x7C, 0x66, 0xC6, 0xCC, 0x38, 0xC1, 0x0C, 0x38, 0xCE, 0xC7, 0xCC, 0x6D,
  0xAD, 0xB0, 0x00, 0x81, 0x83, 0x83, 0x81, 0x81, 0x81, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0E,
  0x01, 0xC0, 0x40, 0x10, 0x0E, 0x03, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x06, 0x07,
  0x07, 0x0E, 0x04, 0x00, 0x03, 0x00, 0x20, 0x06, 0x06, 0x67, 0xFD, 0xE1,
  0xF0, 0x0E, 0x01, 0xB0, 0x33, 0x06, 0x18, 0x21, 0x00, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0x80, 0x60, 0x18, 0x06, 0x00, 0x1C, 0xE3,
  0x1C, 0x61, 0x0C, 0x00, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0xC3, 0x9C, 0xC1, 0x98, 0x12, 0x06,
  0x40, 0xD8, 0x1B, 0x33, 0x66, 0x6C, 0x09, 0x01, 0x20, 0x6C, 0x0C, 0xC3,
  0x1C, 0xE1, 0xF0, 0x03, 0x83, 0xE1, 0x90, 0xCC, 0x23, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x8F, 0xFF, 0xFF, 0x0F,
  0xC3, 0x9C, 0xC1, 0x90, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x3F, 0xF7, 0xFE, 0x1F, 0xE3, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x6C, 0x0D, 0x83, 0x1C, 0xC1, 0xF0, 0x00, 0xE0, 0x10, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xC2, 0x30, 0xCC, 0x19, 0x83, 0x3F, 0xE8,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x1F, 0xE3, 0xFC, 0x40, 0x18, 0x03, 0x00,
  0x66, 0x0F, 0xF1, 0x86, 0x60, 0xC0, 0x08, 0x03, 0x00, 0x64, 0x0C, 0x83,
  0x1C, 0xE1, 0xF0, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x05,
  0xE1, 0xFE, 0x60, 0xCC, 0x0D, 0x01, 0x60, 0x2C, 0x0C, 0x81, 0x9C, 0xE1,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x0F, 0xC3, 0x9C,
  0xC1, 0x98, 0x33, 0x06, 0x61, 0x86, 0x60, 0x78, 0x1F, 0x86, 0x19, 0x83,
  0x20, 0x6C, 0x0D, 0x81, 0x9C, 0xE1, 0xF8, 0x1F, 0x87, 0x39, 0x83, 0x30,
  0x2C, 0x05, 0x80, 0xB0, 0x33, 0x0E, 0x7F, 0x87, 0xE0, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x80, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x3D,
  0xC0, 0x0E, 0x3C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04, 0x30, 0xE1, 0x83,
  0x0C, 0x10, 0x60, 0x00, 0x40, 0x70, 0x78, 0x70, 0x70, 0x30, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x20, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x70,
  0x3C, 0x1C, 0x0E, 0x03, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x1C, 0x3C, 0x18, 0x08, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x07, 0xE0, 0x61, 0x86, 0x06, 0x20, 0x33, 0x01, 0x90, 0x6C, 0x8F, 0xEC,
  0x63, 0x62, 0x13, 0x30, 0x99, 0x84, 0x8C, 0x64, 0x63, 0x23, 0xFB, 0x0E,
  0x98, 0x00, 0x40, 0x03, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0x80, 0x78,
  0x0F, 0x01, 0x60, 0x6C, 0x09, 0x83, 0x30, 0x66, 0x18, 0x43, 0x08, 0x7F,
  0x1F, 0xF3, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0x1F, 0xC7, 0xFC, 0xC1, 0x98,
  0x33, 0x06, 0x60, 0xC8, 0x31, 0xF8, 0x61, 0xCC, 0x19, 0x81, 0x30, 0x24,
  0x0C, 0x81, 0xBF, 0xE7, 0xF0, 0x1F, 0x8E, 0x76, 0x0D, 0x81, 0x60, 0x90,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x81, 0xB0, 0x4E, 0x71,
  0xF8, 0x1F, 0x87, 0xF8, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xC8, 0x19, 0x03,
  0x60, 0x4C, 0x19, 0x83, 0x30, 0x64, 0x0C, 0x83, 0x3F, 0xC7, 0xF0, 0x1F,
  0xF1, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFC, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF1, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0xFC, 0x7F,
  0xC6, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x1F,
  0x8E, 0x76, 0x0D, 0x81, 0x60, 0x90, 0x04, 0x03, 0x00, 0xCF, 0xF3, 0xEC,
  0x0B, 0x06, 0x81, 0xB0, 0x4E, 0x71, 0xF8, 0x10, 0x33, 0x02, 0x30, 0x63,
  0x06, 0x30, 0x63, 0x06, 0x20, 0x63, 0xFC, 0x7F, 0xC6, 0x0C, 0x60, 0xC6,
  0x0C, 0x40, 0xC4, 0x08, 0xC0, 0x8C, 0x18, 0x1F, 0xE3, 0xFC, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x1F, 0xE7, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x60, 0x6C, 0x09, 0x83,
  0x39, 0xC3, 0xF0, 0x10, 0x39, 0x81, 0x8C, 0x18, 0x61, 0x83, 0x0C, 0x18,
  0xC0, 0x8C, 0x07, 0xE0, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC3, 0x04, 0x18,
  0x20, 0xC3, 0x03, 0x18, 0x18, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0x38,
  0x72, 0x85, 0x28, 0xF2, 0x8A, 0x29, 0xA6, 0xD2, 0x6F, 0x66, 0x66, 0x66,
  0x66, 0x06, 0x40, 0x44, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0x18,
  0x33, 0x82, 0x3C, 0x23, 0xC6, 0x3C, 0x62, 0x46, 0x24, 0x66, 0x64, 0x66,
  0x46, 0x6C, 0x62, 0xC6, 0x2C, 0x43, 0xC4, 0x3C, 0xC1, 0x8C, 0x18, 0x1F,
  0x8E, 0x76, 0x0D, 0x83, 0x60, 0xD0, 0x34, 0x0F, 0x03, 0xC0, 0xB0, 0x6C,
  0x1B, 0x06, 0x81, 0xB0, 0xCE, 0x71, 0xF0, 0x1F, 0xC3, 0xFE, 0x30, 0x33,
  0x03, 0x30, 0x33, 0x03, 0x20, 0x62, 0x0E, 0x7F, 0x86, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC3, 0x9C, 0xC1, 0x98,
  0x33, 0x06, 0x40, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x09, 0x83, 0x20, 0x64,
  0x0C, 0xC3, 0x1C, 0xE1, 0xF0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1F,
  0xC3, 0xFE, 0x30, 0x63, 0x03, 0x30, 0x33, 0x06, 0x20, 0x63, 0xFC, 0x7F,
  0x86, 0x30, 0x63, 0x06, 0x10, 0x41, 0x84, 0x18, 0xC1, 0x8C, 0x0C, 0x0F,
  0xC1, 0xCE, 0x30, 0x63, 0x02, 0x30, 0x03, 0x00, 0x38, 0x01, 0xF0, 0x07,
  0x80, 0x0C, 0x00, 0xC0, 0x04, 0xC0, 0xCC, 0x0C, 0x73, 0x83, 0xF0, 0xFF,
  0xFF, 0xF8, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x33, 0x02,
  0x30, 0x23, 0x06, 0x30, 0x63, 0x06, 0x20, 0x66, 0x04, 0x60, 0x46, 0x0C,
  0x60, 0xC6, 0x0C, 0x40, 0xC6, 0x18, 0x73, 0x83, 0xE0, 0xC0, 0x78, 0x1B,
  0x02, 0x60, 0xCC, 0x19, 0x86, 0x30, 0xC2, 0x10, 0x46, 0x08, 0xC1, 0xB0,
  0x36, 0x06, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xC6, 0x3C, 0x63, 0xC6, 0x2C,
  0xA2, 0xCA, 0x6C, 0xA6, 0xDA, 0x49, 0x24, 0x92, 0xCB, 0x28, 0xA2, 0x8A,
  0x38, 0xA3, 0x8E, 0x30, 0xC7, 0x0C, 0x70, 0x18, 0x1C, 0x60, 0xC0, 0xC3,
  0x03, 0x18, 0x04, 0xC0, 0x1B, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0xD8, 0x06, 0x20, 0x10, 0xC0, 0xC3, 0x06, 0x06, 0x30, 0x18, 0xC0,
  0x36, 0x06, 0x60, 0xC2, 0x0C, 0x31, 0x83, 0x10, 0x13, 0x01, 0xE0, 0x1C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xFF, 0xCF, 0xF8, 0x1F,
  0x8C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x1F, 0x80, 0xC3, 0x0C,
  0x10, 0x61, 0x86, 0x18, 0x20, 0xC3, 0x0C, 0x10, 0x61, 0x86, 0x18, 0x20,
  0xC3, 0x1F, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0x00,
  0x06, 0x03, 0xC0, 0xB0, 0x64, 0x11, 0x0C, 0x66, 0x19, 0x02, 0xC0, 0xC0,
  0xFF, 0xE0, 0xC6, 0x30, 0x1F, 0x67, 0x1C, 0xC3, 0xB0, 0x26, 0x04, 0xC1,
  0x98, 0x33, 0x06, 0x40, 0xCC, 0x39, 0xCA, 0x1E, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x7C, 0x71, 0x8C, 0x11, 0x03, 0x60, 0x4C, 0x19, 0x83,
  0x30, 0x66, 0x0C, 0xC3, 0x3C, 0xE6, 0xF8, 0x1F, 0x1C, 0x66, 0x0F, 0x03,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x81, 0xB0, 0x4E, 0x71, 0xF8, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x1F, 0x63, 0x8E, 0x30, 0xE6, 0x04, 0x60, 0x46,
  0x0C, 0x60, 0xC6, 0x0C, 0x40, 0xC6, 0x1C, 0x72, 0x83, 0xD8, 0x1F, 0x1C,
  0x66, 0x0B, 0x03, 0xC0, 0xBF, 0xEC, 0x02, 0x00, 0x80, 0x30, 0x6E, 0x71,
  0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x03, 0xFF,
  0x07, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x3E, 0xDC, 0x76, 0x0F, 0x02, 0xC0, 0xB0, 0x6C, 0x1B,
  0x06, 0xC3, 0xB9, 0xE7, 0xD0, 0x0C, 0x03, 0x00, 0xCF, 0xE3, 0xF0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x7C, 0x71, 0x8C, 0x19, 0x02, 0x60, 0x4C,
  0x19, 0x83, 0x30, 0x64, 0x0C, 0x81, 0xB0, 0x26, 0x0C, 0x03, 0x80, 0xE0,
  0x30, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x43, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x07,
  0xE0, 0xFC, 0x00, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x73, 0x0C,
  0x20, 0xC2, 0x18, 0x63, 0x07, 0xE0, 0x7E, 0x06, 0x30, 0x63, 0x04, 0x18,
  0xC1, 0x8C, 0x0C, 0xFC, 0x7E, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x3F, 0x7F, 0xEC, 0xCD,
  0x98, 0xB3, 0x34, 0x66, 0x88, 0xF1, 0x1E, 0x22, 0xCC, 0x59, 0x9A, 0x33,
  0x44, 0x60, 0x37, 0xC7, 0x18, 0xC1, 0x90, 0x26, 0x04, 0xC1, 0x98, 0x33,
  0x06, 0x40, 0xC8, 0x1B, 0x02, 0x60, 0xC0, 0x1F, 0x1C, 0x66, 0x0B, 0x03,
  0xC0, 0xB0, 0x6C, 0x1B, 0x06, 0x81, 0xB0, 0xCE, 0x71, 0xF0, 0x37, 0xC7,
  0x18, 0xC1, 0x10, 0x36, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x33,
  0xCE, 0x6F, 0x8C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x1F, 0x67, 0x1C, 0xC3,
  0xB0, 0x26, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xCC, 0x31, 0xCA, 0x1E,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x6F, 0x9C, 0x76, 0x0D, 0x83, 0x40,
  0xD0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x1F, 0xC7, 0x18,
  0xC1, 0x90, 0x03, 0x00, 0x7E, 0x01, 0xF0, 0x06, 0x00, 0xD8, 0x19, 0x86,
  0x3F, 0x80, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xC1, 0xF0, 0x30, 0x66, 0x0C,
  0x81, 0xB0, 0x26, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xCC, 0x31, 0xCE,
  0x1F, 0x00, 0xC0, 0x68, 0x19, 0x82, 0x30, 0xC6, 0x10, 0xC6, 0x08, 0x81,
  0x30, 0x36, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x8C, 0x31, 0x8E, 0x31, 0x4E,
  0x29, 0x4D, 0x29, 0x25, 0x25, 0x2C, 0xA5, 0x14, 0xA3, 0x1C, 0x63, 0x00,
  0x18, 0x38, 0xC3, 0x03, 0x30, 0x19, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xB0, 0x19, 0x81, 0x86, 0x0C, 0x31, 0xC0, 0xC0, 0x60, 0xD8, 0x34, 0x0F,
  0x02, 0xC0, 0xB0, 0x6C, 0x1B, 0x06, 0xC3, 0xB9, 0x47, 0x90, 0x0C, 0x03,
  0x00, 0xCF, 0xE3, 0xF0, 0x3F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xE0, 0x70,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0x83, 0xF0,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x30, 0x07,
  0x80, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x8C, 0x62, 0x31, 0x8C, 0x63,
  0x11, 0x80, 0x1E, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0xFC, 0x1F, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x2F, 0x8D, 0x19, 0xE1, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 7, 13, 4, -16 },
  { 18, 13, 16, 13, 0, -16 },
  { 44, 12, 22, 13, 1, -19 },
  { 77, 15, 16, 13, -1, -16 },
  { 107, 12, 16, 13, 1, -16 },
  { 131, 3, 7, 13, 6, -16 },
  { 134, 9, 22, 13, 4, -19 },
  { 159, 9, 22, 13, 1, -19 },
  { 184, 12, 11, 13, 1, -13 },
  { 201, 10, 10, 13, 2, -12 },
  { 214, 6, 7, 13, 2, -3 },
  { 220, 7, 2, 13, 3, -8 },
  { 222, 4, 3, 13, 4, -3 },
  { 224, 13, 20, 13, 0, -18 },
  { 257, 11, 16, 13, 1, -16 },
  { 279, 10, 16, 13, 1, -16 },
  { 299, 11, 16, 13, 1, -16 },
  { 321, 11, 16, 13, 1, -16 },
  { 343, 11, 16, 13, 1, -16 },
  { 365, 11, 16, 13, 1, -16 },
  { 387, 11, 16, 13, 1, -16 },
  { 409, 10, 16, 13, 3, -16 },
  { 429, 11, 16, 13, 1, -16 },
  { 451, 11, 16, 13, 2, -16 },
  { 473, 5, 12, 13, 4, -12 },
  { 481, 7, 16, 13, 2, -12 },
  { 495, 10, 11, 13, 2, -13 },
  { 509, 10, 7, 13, 2, -11 },
  { 518, 11, 11, 13, 1, -13 },
  { 534, 9, 16, 13, 3, -16 },
  { 552, 13, 20, 13, 0, -16 },
  { 585, 11, 16, 13, 0, -16 },
  { 607, 11, 16, 13, 1, -16 },
  { 629, 10, 16, 13, 2, -16 },
  { 649, 11, 16, 13, 1, -16 },
  { 671, 12, 16, 13, 1, -16 },
  { 695, 12, 16, 13, 1, -16 },
  { 719, 10, 16, 13, 2, -16 },
  { 739, 12, 16, 13, 1, -16 },
  { 763, 11, 16, 13, 1, -16 },
  { 785, 11, 16, 13, 1, -16 },
  { 807, 13, 16, 13, 1, -16 },
  { 833, 9, 16, 13, 2, -16 },
  { 851, 12, 16, 13, 1, -16 },
  { 875, 12, 16, 13, 1, -16 },
  { 899, 10, 16, 13, 2, -16 },
  { 919, 12, 16, 13, 1, -16 },
  { 943, 11, 20, 13, 1, -16 },
  { 971, 12, 16, 13, 1, -16 },
  { 995, 12, 16, 13, 1, -16 },
  { 1019, 11, 16, 13, 3, -16 },
  { 1041, 12, 16, 13, 1, -16 },
  { 1065, 11, 16, 13, 3, -16 },
  { 1087, 12, 16, 13, 2, -16 },
  { 1111, 14, 16, 13, 0, -16 },
  { 1139, 12, 16, 13, 2, -16 },
  { 1163, 12, 16, 13, 1, -16 },
  { 1187, 9, 20, 13, 3, -18 },
  { 1210, 6, 20, 13, 4, -18 },
  { 1225, 9, 20, 13, 2, -18 },
  { 1248, 10, 9, 13, 2, -16 },
  { 1260, 11, 1, 13, 0, 1 },
  { 1262, 4, 3, 13, 6, -17 },
  { 1264, 11, 12, 13, 1, -12 },
  { 1281, 11, 16, 13, 1, -16 },
  { 1303, 10, 12, 13, 2, -12 },
  { 1318, 12, 16, 13, 1, -16 },
  { 1342, 10, 12, 13, 2, -12 },
  { 1357, 15, 20, 13, -1, -16 },
  { 1395, 10, 16, 13, 2, -12 },
  { 1415, 11, 16, 13, 1, -16 },
  { 1437, 10, 17, 13, 1, -17 },
  { 1459, 12, 21, 13, 0, -17 },
  { 1491, 12, 16, 13, 1, -16 },
  { 1515, 9, 16, 13, 2, -16 },
  { 1533, 11, 12, 13, 1, -12 },
  { 1550, 11, 12, 13, 1, -12 },
  { 1567, 10, 12, 13, 2, -12 },
  { 1582, 11, 16, 13, 1, -12 },
  { 1604, 11, 16, 13, 1, -12 },
  { 1626, 10, 12, 13, 2, -12 },
  { 1641, 11, 12, 13, 1, -12 },
  { 1658, 10, 15, 13, 2, -15 },
  { 1677, 11, 12, 13, 1, -12 },
  { 1694, 11, 12, 13, 2, -12 },
  { 1711, 11, 12, 13, 2, -12 },
  { 1728, 13, 12, 13, 0, -12 },
  { 1748, 10, 16, 13, 2, -12 },
  { 1768, 11, 12, 13, 1, -12 },
  { 1785, 11, 20, 13, 2, -18 },
  { 1813, 5, 20, 13, 4, -18 },
  { 1826, 11, 20, 13, 1, -18 },
  { 1854, 11, 4, 13, 1, -10 },
};

const GFXfont JetBrainsMono_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_LIGHTITALIC22PT7B_H_
