#ifndef _JETBRAINSMONO_LIGHTITALIC41PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x1F, 0x8F, 0xC7, 0xC0, 0x78,
  0x3B, 0xC3, 0xDE, 0x1E, 0xE0, 0xF7, 0x07, 0x78, 0x3B, 0xC1, 0xDE, 0x0E,
  0xE0, 0xF7, 0x07, 0x38, 0x39, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x38, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x80,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x03,
  0x80, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x1C, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0C,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3C, 0x67, 0x81, 0xC3, 0x1E, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0C, 0x1C, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x79, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x06, 0x78, 0x00, 0x71, 0xE0, 0x03, 0x0F, 0x00, 0x18, 0x38,
  0x00, 0xC1, 0xCF, 0x06, 0x0E, 0x78, 0x30, 0xF3, 0xC3, 0x87, 0x0E, 0x1C,
  0x78, 0x78, 0xC7, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x70, 0x3F, 0xC0, 0x0E, 0x07,
  0x9E, 0x01, 0xC0, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0xE0,
  0x60, 0x0E, 0x0E, 0x0C, 0x00, 0xC0, 0xE1, 0xC0, 0x1C, 0x0E, 0x38, 0x01,
  0xC0, 0xC7, 0x00, 0x0E, 0x1C, 0xE0, 0x00, 0xFF, 0x9C, 0x00, 0x07, 0xF1,
  0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x10, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0x31, 0xFF, 0x00, 0x07,
  0x38, 0x70, 0x00, 0xE7, 0x07, 0x00, 0x1C, 0x70, 0x30, 0x03, 0x87, 0x07,
  0x00, 0x70, 0x70, 0x70, 0x0E, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x70, 0x1C,
  0x07, 0x0E, 0x03, 0x80, 0x79, 0xE0, 0x70, 0x07, 0xFC, 0x0E, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xBC, 0x07, 0x38, 0x78, 0x3C,
  0xE0, 0xE1, 0xE7, 0x83, 0xC7, 0x1C, 0x07, 0x38, 0x70, 0x1F, 0xE1, 0xC0,
  0x3F, 0x07, 0x00, 0xF8, 0x1C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7F,
  0x07, 0x03, 0xDC, 0x1F, 0xFE, 0x78, 0x3F, 0xF0, 0xE0, 0x7F, 0x03, 0xC0,
  0x7B, 0xDE, 0xE7, 0x7B, 0xDE, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x02, 0x00, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x07, 0x03, 0x81, 0x9F, 0x0E, 0x3F, 0xFF, 0x33, 0xFC, 0xFE,
  0xDF, 0xC0, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x70,
  0x00, 0x39, 0xC0, 0x01, 0xE7, 0x80, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xE0, 0x18, 0x02, 0x00, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0xFD, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C,
  0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x3C, 0x38, 0xE1, 0xE1, 0xC7, 0x0F,
  0x1E, 0x38, 0x78, 0xF1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x03,
  0xC3, 0xC0, 0x1C, 0x1F, 0x01, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80,
  0x7C, 0xF0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0x40, 0x70, 0x10, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x01,
  0xE0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0x83, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x03, 0x87, 0x80, 0x70, 0xE0, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xC0,
  0x0E, 0x78, 0x01, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x38, 0x03, 0xDF, 0xF0, 0x3F, 0xFF,
  0x83, 0xF0, 0xF8, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x1F, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x7F, 0x00, 0xFF, 0xFC, 0x1F, 0xCF, 0xC3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x80, 0x3C,
  0x7C, 0x07, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xEF, 0x00,
  0x1C, 0xF0, 0x03, 0xCE, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x01, 0xE0,
  0x70, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0x70, 0x07, 0x83, 0xC0, 0x38, 0x0F, 0x07, 0x80, 0x3C, 0x78, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0x8F, 0x80, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF1, 0xC0,
  0x07, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1E, 0x01, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xE0, 0x3C, 0x3C, 0x01, 0xE3, 0x80, 0x0E, 0x78,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0x78, 0x07, 0x87, 0xE1, 0xF8,
  0x3F, 0xF7, 0x01, 0xFE, 0xE0, 0x01, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF8, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x7C, 0x0F,
  0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x87, 0x00, 0xF9, 0xC3, 0x80, 0xFE, 0xE1, 0xC0, 0xFF, 0xF0,
  0xE0, 0xF0, 0x78, 0x70, 0x70, 0x38, 0x38, 0x70, 0x1C, 0x38, 0x38, 0x0E,
  0x1C, 0x1C, 0x07, 0x0E, 0x0E, 0x03, 0x87, 0x07, 0x01, 0xC3, 0x83, 0x80,
  0xE1, 0xC3, 0x80, 0xE1, 0xC1, 0xC0, 0x70, 0xE0, 0xE0, 0x38, 0x70, 0x78,
  0x3C, 0x38, 0x1F, 0xFE, 0x1C, 0x0F, 0xF7, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x78, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0xF0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x78, 0x00, 0x3C, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x1E, 0x03, 0xE0, 0xE0, 0x07, 0x87,
  0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x03,
  0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x3C, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3C, 0x03, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00,
  0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x03, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xF8, 0x1E, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x03, 0xCE, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0x78, 0x0F,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x87,
  0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x70,
  0x03, 0x83, 0x80, 0x3C, 0x1C, 0x07, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1E, 0x0E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x87, 0xFE, 0x70, 0x7F, 0xC7, 0x07, 0xFC, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00,
  0x38, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0x78, 0x0F, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00,
  0x3C, 0x1C, 0x00, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03,
  0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83,
  0xC0, 0x0E, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70,
  0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0xF0, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1C,
  0x00, 0xE0, 0x78, 0x01, 0xC1, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x78, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x38,
  0x03, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x03, 0x80,
  0x1E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xD8, 0x36, 0x03, 0xF0, 0x6C, 0x06, 0xE1, 0xD8, 0x1D, 0x83, 0xB8, 0x33,
  0x07, 0x70, 0xEE, 0x0E, 0xE1, 0x9C, 0x1C, 0xC7, 0x38, 0x39, 0x8C, 0x70,
  0xE3, 0x39, 0xC1, 0xC7, 0x63, 0x83, 0x8F, 0xC7, 0x07, 0x1F, 0x8E, 0x0E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xE0, 0xFC, 0x03, 0x83, 0xF0, 0x0E, 0x0F, 0xC0, 0x38, 0x3F, 0x00, 0xE0,
  0xEE, 0x07, 0x83, 0xB8, 0x1C, 0x1E, 0xE0, 0x70, 0x73, 0x81, 0xC1, 0xCE,
  0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC3, 0xC1, 0xC7, 0x0E,
  0x0F, 0x0C, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x8E, 0x0E,
  0x0E, 0x78, 0x38, 0x19, 0xC1, 0xE0, 0x77, 0x07, 0x01, 0xDC, 0x1C, 0x07,
  0x70, 0x70, 0x1D, 0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0xE0, 0x0F, 0x83, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0xF0, 0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0x0F, 0x1C, 0x00, 0xF1,
  0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x78,
  0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xC0, 0x3E, 0x0E, 0x00, 0x3C, 0x38,
  0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x03, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0xF0, 0x1E, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C,
  0x00, 0x73, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1E,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x03,
  0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8F, 0x00,
  0x70, 0xF8, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xC0, 0x3E, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x87,
  0x00, 0x1E, 0x1C, 0x00, 0xF0, 0x70, 0x07, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0x01, 0xE0, 0x70, 0x07, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x73, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1E,
  0x1E, 0x01, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x3C,
  0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E,
  0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x78, 0x01, 0xC3,
  0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x80, 0x78, 0x1E, 0x07,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x70, 0x70, 0x07,
  0x07, 0x80, 0xE0, 0x78, 0x0E, 0x03, 0x81, 0xE0, 0x38, 0x1C, 0x03, 0x81,
  0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x38,
  0xF0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x01,
  0xDC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x70, 0x3C, 0x0E, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x3B, 0x81, 0xE0, 0xE7,
  0x06, 0xC1, 0xCE, 0x0D, 0x83, 0x9C, 0x1B, 0x07, 0x38, 0x76, 0x1C, 0x70,
  0xCC, 0x38, 0xE1, 0x98, 0x71, 0xC3, 0x30, 0xC3, 0x8C, 0x63, 0x87, 0x18,
  0xC7, 0x0C, 0x33, 0x8E, 0x18, 0xE7, 0x38, 0x71, 0x8E, 0x70, 0xE3, 0x18,
  0xE1, 0xCE, 0x31, 0xC3, 0x98, 0x67, 0x07, 0x30, 0xCE, 0x0E, 0x61, 0x9C,
  0x1D, 0xC3, 0x30, 0x3B, 0x06, 0xE0, 0x76, 0x0D, 0xC0, 0xFC, 0x1B, 0x81,
  0xF0, 0x36, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x03, 0x80, 0xF0, 0x03,
  0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x03, 0x81,
  0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x07, 0x80, 0x03,
  0xC0, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xBC, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x1C, 0x3C, 0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x00, 0xE0, 0x3C, 0x0F,
  0x00, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0x80, 0x07,
  0x38, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0xE3, 0x00, 0x38, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x38, 0x03, 0x1E,
  0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xE1, 0xE1, 0xC1, 0xC0, 0x01, 0xF8, 0xE0, 0xFF,
  0x9C, 0x3F, 0xFB, 0x8F, 0x83, 0x71, 0xC0, 0x3E, 0x78, 0x03, 0xCE, 0x00,
  0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01,
  0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F, 0x87, 0xEF, 0xF0, 0x7F, 0xEE,
  0x07, 0xF1, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE3, 0xF0, 0x0E,
  0x7F, 0xC1, 0xEF, 0xFC, 0x1D, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x78, 0x01,
  0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x7C, 0x07, 0x87, 0xFF,
  0xF0, 0xF7, 0xFE, 0x0F, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xFE, 0x0F, 0x83, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0xCE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x9E, 0x00,
  0xF3, 0xC0, 0x1C, 0x3C, 0x07, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F, 0x1C, 0x07, 0xFC,
  0xE0, 0x7F, 0xF7, 0x07, 0xC1, 0xB8, 0x38, 0x07, 0xC3, 0xC0, 0x1E, 0x1C,
  0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3E, 0x07, 0xC0,
  0xFD, 0xFE, 0x03, 0xFF, 0x70, 0x0F, 0xE3, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0x81, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00,
  0x73, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFD, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xF3, 0xC0, 0x1C, 0x38, 0x07, 0x87, 0xE7, 0xE0, 0x7F, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0xE0, 0xFF, 0x9C, 0x3F, 0xFB, 0x8F, 0x83, 0x71, 0xC0,
  0x3E, 0x78, 0x03, 0xCE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x3C, 0x00,
  0xE7, 0x80, 0x3C, 0x70, 0x07, 0x8F, 0x01, 0x71, 0xF9, 0xFE, 0x1F, 0xFB,
  0x81, 0xFE, 0x70, 0x04, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE3, 0xF0, 0x0E, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1D, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0,
  0x03, 0x8E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x0F, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0x70,
  0x1C, 0x03, 0xC0, 0x70, 0x1E, 0x01, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x3C,
  0x3C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x38, 0x3C,
  0x00, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x70, 0x0F, 0x01,
  0xC0, 0x3C, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x70, 0x03, 0xC3, 0xC0,
  0x0F, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0C, 0xF0, 0xF0, 0x77, 0xE7, 0xE1,
  0xDF, 0xFF, 0xC7, 0x87, 0x8F, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC1,
  0x81, 0xCF, 0x06, 0x0E, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83,
  0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0xE0, 0xC1, 0xC7, 0x07, 0x07, 0x1C,
  0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x18,
  0x3C, 0xE0, 0x60, 0xE3, 0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x00, 0x0E, 0x3F,
  0x00, 0xEF, 0xFC, 0x1F, 0xFF, 0xC1, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x78, 0x01, 0xC7,
  0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38,
  0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE1, 0xC0, 0x3C, 0x78, 0x03, 0x8E, 0x00,
  0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03,
  0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x3C, 0x0F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFC, 0x00, 0x07, 0x1F, 0x80, 0x39, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0x83, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x7C, 0x07, 0x83, 0xFF, 0xF8, 0x3D, 0xFF,
  0x81, 0xE7, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8,
  0xE0, 0xFF, 0x9C, 0x3F, 0xFB, 0x8F, 0x83, 0x71, 0xC0, 0x3E, 0x78, 0x03,
  0xCE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x01, 0xE7, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F, 0x87, 0xEF, 0x70,
  0x7F, 0xEE, 0x07, 0xF1, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x3F,
  0x01, 0xEF, 0xF8, 0x1D, 0xFF, 0xC1, 0xF8, 0x3E, 0x1E, 0x01, 0xE1, 0xE0,
  0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0xF0, 0x1E, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x80, 0x78, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x78, 0x01,
  0xCF, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x07,
  0x3C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0x9E, 0x00, 0xE3, 0xC0, 0x3C,
  0x3C, 0x0F, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xF0, 0x00,
  0xF7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00,
  0x38, 0x78, 0x07, 0x83, 0x80, 0x70, 0x38, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x78, 0x1F, 0x81,
  0xE0, 0x6E, 0x07, 0x83, 0xB8, 0x3E, 0x0E, 0xE0, 0xD8, 0x33, 0x83, 0x61,
  0xCE, 0x1D, 0x87, 0x38, 0x66, 0x18, 0xE1, 0x98, 0xE3, 0x8E, 0x63, 0x8E,
  0x31, 0x8C, 0x38, 0xC6, 0x30, 0xE7, 0x19, 0xC3, 0x98, 0x67, 0x0E, 0x61,
  0x98, 0x3B, 0x86, 0xE0, 0xEC, 0x1B, 0x83, 0xB0, 0x6C, 0x0F, 0xC1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x70, 0x07, 0x81, 0xE0, 0x3C, 0x03,
  0x81, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x79, 0xE0, 0x00, 0xEF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8F, 0x00, 0x3C,
  0x1C, 0x01, 0xE0, 0x78, 0x07, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x73, 0xC0, 0x0E, 0x78,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0,
  0x07, 0x3C, 0x00, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x8F, 0x01, 0xF1, 0xF9,
  0xFE, 0x1F, 0xFB, 0x81, 0xFE, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3E,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x07, 0x3F, 0xC0,
  0xF7, 0x9E, 0x0E, 0xF0, 0xF0, 0xEE, 0x07, 0x9E, 0xE0, 0x7F, 0xCE, 0x03,
  0xF8, 0xE0, 0x0C, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 30, 25, 8, -30 },
  { 35, 13, 12, 25, 8, -30 },
  { 55, 24, 30, 25, 1, -30 },
  { 145, 21, 42, 25, 2, -36 },
  { 256, 28, 30, 25, -1, -30 },
  { 361, 22, 30, 25, 1, -30 },
  { 444, 5, 12, 25, 12, -30 },
  { 452, 17, 40, 25, 7, -35 },
  { 537, 17, 40, 25, 2, -35 },
  { 622, 22, 21, 25, 2, -25 },
  { 680, 19, 19, 25, 3, -23 },
  { 726, 10, 13, 25, 4, -6 },
  { 743, 13, 3, 25, 6, -15 },
  { 748, 7, 6, 25, 7, -6 },
  { 754, 24, 39, 25, 1, -34 },
  { 871, 21, 30, 25, 2, -30 },
  { 950, 19, 30, 25, 2, -30 },
  { 1022, 21, 30, 25, 2, -30 },
  { 1101, 21, 30, 25, 2, -30 },
  { 1180, 19, 30, 25, 3, -30 },
  { 1252, 20, 30, 25, 3, -30 },
  { 1327, 20, 30, 25, 2, -30 },
  { 1402, 20, 30, 25, 5, -30 },
  { 1477, 21, 30, 25, 2, -30 },
  { 1556, 20, 30, 25, 4, -30 },
  { 1631, 10, 23, 25, 7, -23 },
  { 1660, 13, 30, 25, 4, -23 },
  { 1709, 19, 21, 25, 4, -24 },
  { 1759, 19, 13, 25, 3, -20 },
  { 1790, 20, 21, 25, 2, -24 },
  { 1843, 16, 30, 25, 6, -30 },
  { 1903, 25, 37, 25, 0, -30 },
  { 2019, 21, 30, 25, 0, -30 },
  { 2098, 21, 30, 25, 2, -30 },
  { 2177, 20, 30, 25, 3, -30 },
  { 2252, 21, 30, 25, 2, -30 },
  { 2331, 22, 30, 25, 2, -30 },
  { 2414, 22, 30, 25, 2, -30 },
  { 2497, 20, 30, 25, 3, -30 },
  { 2572, 22, 30, 25, 2, -30 },
  { 2655, 20, 30, 25, 3, -30 },
  { 2730, 22, 30, 25, 1, -30 },
  { 2813, 23, 30, 25, 2, -30 },
  { 2900, 18, 30, 25, 3, -30 },
  { 2968, 23, 30, 25, 1, -30 },
  { 3055, 22, 30, 25, 2, -30 },
  { 3138, 20, 30, 25, 3, -30 },
  { 3213, 22, 30, 25, 2, -30 },
  { 3296, 20, 37, 25, 3, -30 },
  { 3389, 22, 30, 25, 2, -30 },
  { 3472, 21, 30, 25, 2, -30 },
  { 3551, 20, 30, 25, 5, -30 },
  { 3626, 21, 30, 25, 3, -30 },
  { 3705, 20, 30, 25, 5, -30 },
  { 3780, 23, 30, 25, 3, -30 },
  { 3867, 25, 30, 25, 0, -30 },
  { 3961, 21, 30, 25, 5, -30 },
  { 4040, 22, 30, 25, 2, -30 },
  { 4123, 16, 39, 25, 6, -34 },
  { 4201, 12, 39, 25, 7, -34 },
  { 4260, 16, 39, 25, 4, -34 },
  { 4338, 18, 16, 25, 4, -30 },
  { 4374, 20, 3, 25, 0, 1 },
  { 4382, 7, 6, 25, 11, -32 },
  { 4388, 19, 23, 25, 3, -23 },
  { 4443, 20, 30, 25, 2, -30 },
  { 4518, 19, 23, 25, 3, -23 },
  { 4573, 21, 30, 25, 3, -30 },
  { 4652, 19, 23, 25, 3, -23 },
  { 4707, 28, 37, 25, -2, -30 },
  { 4837, 19, 30, 25, 3, -23 },
  { 4909, 20, 30, 25, 2, -30 },
  { 4984, 19, 32, 25, 2, -32 },
  { 5060, 21, 39, 25, 1, -32 },
  { 5163, 22, 30, 25, 2, -30 },
  { 5246, 17, 30, 25, 4, -30 },
  { 5310, 22, 23, 25, 1, -23 },
  { 5374, 20, 23, 25, 2, -23 },
  { 5432, 19, 23, 25, 3, -23 },
  { 5487, 21, 30, 25, 1, -23 },
  { 5566, 19, 30, 25, 3, -23 },
  { 5638, 20, 23, 25, 3, -23 },
  { 5696, 20, 23, 25, 2, -23 },
  { 5754, 19, 29, 25, 4, -29 },
  { 5823, 19, 23, 25, 3, -23 },
  { 5878, 20, 23, 25, 4, -23 },
  { 5936, 22, 23, 25, 3, -23 },
  { 6000, 22, 23, 25, 1, -23 },
  { 6064, 19, 30, 25, 3, -23 },
  { 6136, 20, 23, 25, 2, -23 },
  { 6194, 21, 39, 25, 4, -34 },
  { 6297, 10, 39, 25, 8, -34 },
  { 6346, 21, 39, 25, 1, -34 },
  { 6449, 20, 9, 25, 3, -19 },
};

const GFXfont JetBrainsMono_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_LIGHTITALIC41PT7B_H_
