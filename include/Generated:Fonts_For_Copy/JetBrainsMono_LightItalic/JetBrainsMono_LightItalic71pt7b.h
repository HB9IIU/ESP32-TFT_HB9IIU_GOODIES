#ifndef _JETBRAINSMONO_LIGHTITALIC71PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xF8, 0xF1, 0xFE, 0x00, 0x7F, 0x07, 0x87, 0xF0, 0x03, 0xF0,
  0x3C, 0x1F, 0x80, 0x3F, 0x03, 0xC0, 0x7E, 0x01, 0xF8, 0x1E, 0x03, 0xF0,
  0x1F, 0x80, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0xFC, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x00, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x70, 0x00, 0x00, 0x1F, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x7F, 0xE0, 0x00, 0x00, 0x78, 0xFF,
  0x00, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x01,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x83, 0xF0, 0x07, 0x00, 0xFC, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0xFC,
  0x03, 0xC0, 0x3F, 0x07, 0xE0, 0x1E, 0x03, 0xF0, 0x3F, 0x80, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0x81, 0xF8, 0x07, 0xF0, 0x38, 0x1F, 0xC0, 0x3F, 0xE3,
  0xC3, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC3,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC3,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC1,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x78, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xF0,
  0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x3F,
  0x00, 0x7C, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x00,
  0xFC, 0xFC, 0x03, 0xE0, 0x01, 0xFB, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xC0,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x9F,
  0x80, 0x7F, 0xE7, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x0C, 0x7C,
  0x00, 0xF8, 0x03, 0xF7, 0xFC, 0x07, 0x80, 0x7F, 0xBF, 0xF8, 0x3C, 0x1F,
  0xFF, 0xFF, 0xE1, 0xC3, 0xFF, 0xEF, 0xFF, 0xCE, 0x7F, 0xFE, 0x1F, 0xFF,
  0x77, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0x01, 0xFC,
  0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC,
  0x7F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xFC, 0x0F, 0xC1,
  0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0x83, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0xC0,
  0xFC, 0x1F, 0x01, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0xC0, 0xF8, 0x3F, 0x00,
  0xF8, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0x80, 0x00,
  0x7F, 0xCF, 0xC0, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0xFF, 0x83, 0xE0, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x1F, 0x01, 0xFC, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFE, 0x00,
  0x03, 0xE3, 0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0x1F, 0xBF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E,
  0x7F, 0xFC, 0x00, 0x3F, 0xBF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0x7E, 0x00, 0x0F,
  0xFF, 0xBF, 0x80, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xFC, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xCF,
  0x83, 0xF0, 0x03, 0xFF, 0xF3, 0xC0, 0xF8, 0x01, 0xFF, 0xFE, 0xF0, 0x3E,
  0x00, 0x7E, 0x03, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x7C, 0x00, 0xFE, 0x0E, 0xF8, 0x1F, 0x00, 0x3F, 0xFF, 0xBE, 0x0F,
  0xC0, 0x07, 0xFF, 0xCF, 0x03, 0xF0, 0x00, 0xFF, 0xE3, 0xC0, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0xF0, 0x7E, 0x01, 0xFF,
  0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0xF8, 0x3E, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x04, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xBF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x1E, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3D, 0xE0, 0x00, 0xFF, 0x80,
  0x7B, 0xC0, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x07, 0xDE, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x0F, 0x9E, 0x00, 0xF9, 0xE0,
  0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x80, 0x78, 0xF8,
  0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x07, 0xC3, 0xC1, 0xF1, 0xF0, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0x1F, 0x0F,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x3C, 0x3F,
  0x01, 0xF8, 0x3C, 0xF8, 0x7E, 0x03, 0xF0, 0x79, 0xE0, 0xFC, 0x07, 0xC0,
  0xF7, 0xC1, 0xF0, 0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x1F, 0x03, 0xFE, 0x07,
  0xC0, 0x3E, 0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0x7E, 0x03, 0xFE,
  0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x00, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x80,
  0x03, 0xF0, 0x1F, 0x7C, 0x00, 0x1F, 0x80, 0xF9, 0xE0, 0x00, 0xF8, 0x07,
  0xCF, 0x80, 0x07, 0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x03,
  0xF0, 0x0F, 0x9F, 0x00, 0x1F, 0x80, 0xFC, 0x7C, 0x00, 0xFC, 0x07, 0xE3,
  0xE0, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x0F, 0x83, 0xE0,
  0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x0F,
  0x8F, 0xC0, 0x7E, 0x00, 0x7C, 0x7C, 0x03, 0xF0, 0x03, 0xE3, 0xE0, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x03, 0xEF,
  0xC0, 0x7E, 0x00, 0x1F, 0x7E, 0x03, 0xF0, 0x00, 0xFB, 0xE0, 0x1F, 0x80,
  0x07, 0xDF, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xC0,
  0x3E, 0x00, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x01,
  0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x3E,
  0x00, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3E,
  0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0xC0, 0x0F, 0x8F,
  0x80, 0x0F, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xE0, 0x03, 0xE3, 0xE0, 0x07,
  0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xDC, 0x00,
  0xF8, 0x7C, 0x01, 0xEE, 0x00, 0xFC, 0x3E, 0x00, 0xF7, 0x00, 0x7C, 0x1F,
  0x00, 0x73, 0x80, 0x3E, 0x0F, 0x80, 0x79, 0xC0, 0x1F, 0x07, 0xC0, 0x3C,
  0xE0, 0x1F, 0x83, 0xE0, 0x1E, 0x70, 0x0F, 0x81, 0xF0, 0x0E, 0x78, 0x07,
  0xC0, 0xF8, 0x0F, 0x3C, 0x03, 0xE0, 0x7C, 0x07, 0x9E, 0x03, 0xE0, 0x7E,
  0x03, 0x8F, 0x01, 0xF0, 0x3F, 0x03, 0xC7, 0x80, 0xF8, 0x1F, 0x01, 0xE3,
  0xC0, 0x7C, 0x0F, 0x80, 0xF1, 0xE0, 0x7C, 0x07, 0xC0, 0x70, 0xF0, 0x3E,
  0x03, 0xE0, 0x78, 0x78, 0x1F, 0x01, 0xF0, 0x3C, 0x3C, 0x1F, 0x00, 0xF8,
  0x1C, 0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x07,
  0x83, 0xE0, 0x1F, 0x07, 0x83, 0xC3, 0xE0, 0x0F, 0x83, 0x81, 0xE1, 0xF0,
  0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x70, 0x7C, 0x01, 0xF0,
  0xE0, 0x38, 0x7C, 0x00, 0xF8, 0xF0, 0x1C, 0x3E, 0x00, 0x7C, 0x78, 0x0E,
  0x1F, 0x00, 0x3E, 0x3C, 0x07, 0x1F, 0x00, 0x1F, 0x3C, 0x03, 0x8F, 0x80,
  0x0F, 0x9E, 0x01, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0xE3, 0xE0, 0x03, 0xE7,
  0x00, 0x73, 0xE0, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x00, 0xF3, 0xC0, 0x3C,
  0xF8, 0x00, 0xF9, 0xE0, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00,
  0x3E, 0xF0, 0x07, 0xBE, 0x00, 0x1F, 0x78, 0x03, 0xDF, 0x00, 0x0F, 0xB8,
  0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x03,
  0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFF, 0xCF, 0x80, 0xFF, 0xC1, 0xFB, 0xE0,
  0x3F, 0x80, 0x1F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0x83, 0xF7, 0xC0, 0x3F, 0xFF, 0xF9, 0xF0, 0x07,
  0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x0F, 0xFE, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x3E, 0x1F, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF,
  0xF8, 0x07, 0xEF, 0xFF, 0xFE, 0x01, 0xFB, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x07, 0xF0, 0x1F, 0x60, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x60, 0x00, 0xFE, 0x07, 0xDC, 0x00, 0xFF,
  0x03, 0xF7, 0xE0, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF,
  0xE0, 0x0F, 0xC7, 0xFF, 0xF0, 0x03, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xFF, 0x8F,
  0xC0, 0x0F, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0xF0,
  0x7F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xDF, 0x00, 0x3F, 0xFF, 0xF9, 0xF0, 0x01, 0xFF, 0xFF,
  0x3F, 0x00, 0x0F, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xF8,
  0xFC, 0x03, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFF, 0xCF, 0x80, 0xFF, 0xC1,
  0xFB, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x6F, 0x80,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFD, 0xFD, 0xF8, 0x07, 0xFF, 0xFF, 0x7E,
  0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0x87, 0xC0, 0x01, 0xFF, 0x81,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x3E, 0x1F,
  0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFE, 0x01, 0xFB,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF0, 0x1F, 0x60, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x01, 0xFC, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x8F, 0xF0, 0x7F, 0x80, 0x3E, 0xFF,
  0xC3, 0xFF, 0x00, 0xFB, 0xFF, 0x9F, 0xFE, 0x07, 0xDF, 0xFE, 0xFF, 0xF8,
  0x1F, 0x40, 0xFB, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0x81, 0xF8, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x83,
  0xE0, 0x0F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x7C, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x80,
  0x3E, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x3E, 0x00, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x0F,
  0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3F, 0x00,
  0x78, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x3E, 0x1F, 0xFF, 0xC0, 0x0F,
  0x9F, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFE, 0x01, 0xFB, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC3, 0xFF, 0xC0, 0x00,
  0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0x9F, 0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0xFF,
  0x80, 0x1F, 0xBE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0x60,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF6, 0x00, 0x0F, 0xE0, 0x1F,
  0x70, 0x03, 0xFC, 0x03, 0xF7, 0xE0, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xF0,
  0x03, 0xF3, 0xFF, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0xFF,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xF0, 0x03, 0xFF,
  0xF8, 0xFC, 0x03, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFF, 0xCF, 0x80, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xDF, 0x00, 0xFF, 0x83, 0xF7, 0xC0, 0x3F, 0xFF,
  0xF9, 0xF0, 0x07, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x1F,
  0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x0F, 0xC7, 0xFF, 0xF0,
  0x01, 0xF3, 0xFF, 0xFF, 0x00, 0x3E, 0x7F, 0xFF, 0xF0, 0x0F, 0xDF, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7D, 0xF0, 0x07, 0xF0, 0x03, 0xEF,
  0x80, 0x3F, 0x80, 0x1E, 0x7C, 0x01, 0xDC, 0x01, 0xF3, 0xE0, 0x1E, 0xE0,
  0x0F, 0x9F, 0x00, 0xF7, 0x00, 0x78, 0xF8, 0x07, 0x38, 0x07, 0xC7, 0xC0,
  0x79, 0xC0, 0x3E, 0x3E, 0x03, 0xCE, 0x01, 0xE1, 0xF0, 0x1C, 0x70, 0x1F,
  0x0F, 0x81, 0xE3, 0x80, 0xF8, 0x7C, 0x0F, 0x1C, 0x07, 0x83, 0xE0, 0x70,
  0xE0, 0x7C, 0x1F, 0x07, 0x87, 0x03, 0xE0, 0xF8, 0x3C, 0x38, 0x1E, 0x07,
  0xC1, 0xC1, 0xC0, 0xF0, 0x3E, 0x1E, 0x0E, 0x0F, 0x81, 0xE0, 0xF0, 0x70,
  0x7C, 0x0F, 0x07, 0x03, 0x83, 0xC0, 0x78, 0x78, 0x1C, 0x3E, 0x03, 0xC3,
  0xC0, 0xE1, 0xF0, 0x1E, 0x1E, 0x07, 0x0F, 0x00, 0xF1, 0xE0, 0x38, 0xF8,
  0x07, 0x8F, 0x01, 0xC7, 0xC0, 0x3C, 0x78, 0x0E, 0x3C, 0x01, 0xE7, 0x80,
  0x73, 0xE0, 0x0F, 0x3C, 0x03, 0x9F, 0x00, 0x79, 0xE0, 0x1C, 0xF0, 0x03,
  0xDE, 0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x07, 0x7C, 0x00, 0xF7, 0x80, 0x3B,
  0xC0, 0x07, 0xB8, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xF7,
  0xE0, 0x1F, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFC, 0x7C, 0x00, 0x7F, 0xFE,
  0x1F, 0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC1, 0xFF, 0xC0, 0x01, 0xF0,
  0xFF, 0xF8, 0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x1F, 0x3F, 0xFF, 0xE0, 0x07,
  0xCF, 0xC1, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xE0,
  0x3E, 0x7C, 0x01, 0xFC, 0x1F, 0xBF, 0x00, 0x3F, 0xFF, 0xCF, 0xC0, 0x0F,
  0xFF, 0xF3, 0xE0, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xF8, 0x3E, 0x00,
  0x03, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 16, 52, 43, 14, -52 },
  { 105, 24, 21, 43, 13, -52 },
  { 168, 41, 52, 43, 2, -52 },
  { 435, 37, 72, 43, 3, -62 },
  { 768, 49, 52, 43, -2, -52 },
  { 1087, 39, 54, 43, 2, -53 },
  { 1351, 9, 21, 43, 20, -52 },
  { 1375, 29, 69, 43, 12, -60 },
  { 1626, 28, 69, 43, 4, -60 },
  { 1868, 37, 36, 43, 4, -43 },
  { 2035, 34, 33, 43, 5, -40 },
  { 2176, 18, 22, 43, 7, -11 },
  { 2226, 24, 5, 43, 10, -26 },
  { 2241, 12, 12, 43, 13, -11 },
  { 2259, 42, 67, 43, 1, -59 },
  { 2611, 36, 54, 43, 4, -53 },
  { 2854, 33, 52, 43, 3, -52 },
  { 3069, 37, 53, 43, 3, -53 },
  { 3315, 36, 53, 43, 4, -52 },
  { 3554, 33, 52, 43, 5, -52 },
  { 3769, 35, 53, 43, 5, -52 },
  { 4001, 34, 53, 43, 4, -52 },
  { 4227, 34, 52, 43, 9, -52 },
  { 4448, 36, 54, 43, 4, -53 },
  { 4691, 34, 53, 43, 7, -53 },
  { 4917, 17, 41, 43, 13, -40 },
  { 5005, 22, 51, 43, 8, -40 },
  { 5146, 34, 37, 43, 6, -42 },
  { 5304, 34, 21, 43, 5, -34 },
  { 5394, 34, 37, 43, 4, -42 },
  { 5552, 28, 52, 43, 11, -52 },
  { 5734, 42, 66, 43, 1, -53 },
  { 6081, 35, 52, 43, 1, -52 },
  { 6309, 36, 52, 43, 4, -52 },
  { 6543, 35, 54, 43, 5, -53 },
  { 6780, 35, 52, 43, 4, -52 },
  { 7008, 38, 52, 43, 4, -52 },
  { 7255, 38, 52, 43, 4, -52 },
  { 7502, 35, 54, 43, 5, -53 },
  { 7739, 37, 52, 43, 4, -52 },
  { 7980, 35, 52, 43, 5, -52 },
  { 8208, 38, 53, 43, 2, -52 },
  { 8460, 40, 52, 43, 4, -52 },
  { 8720, 31, 52, 43, 5, -52 },
  { 8922, 39, 52, 43, 3, -52 },
  { 9176, 37, 52, 43, 4, -52 },
  { 9417, 35, 54, 43, 5, -53 },
  { 9654, 38, 52, 43, 4, -52 },
  { 9901, 35, 66, 43, 5, -53 },
  { 10190, 37, 52, 43, 4, -52 },
  { 10431, 38, 54, 43, 3, -53 },
  { 10688, 36, 52, 43, 8, -52 },
  { 10922, 36, 53, 43, 5, -52 },
  { 11161, 35, 52, 43, 9, -52 },
  { 11389, 41, 52, 43, 5, -52 },
  { 11656, 44, 52, 43, 0, -52 },
  { 11942, 37, 52, 43, 8, -52 },
  { 12183, 38, 52, 43, 3, -52 },
  { 12430, 27, 67, 43, 11, -59 },
  { 12657, 21, 67, 43, 12, -59 },
  { 12833, 28, 67, 43, 6, -59 },
  { 13068, 30, 28, 43, 7, -52 },
  { 13173, 35, 5, 43, 0, 2 },
  { 13195, 12, 10, 43, 19, -56 },
  { 13210, 34, 41, 43, 5, -40 },
  { 13385, 34, 53, 43, 4, -52 },
  { 13611, 33, 41, 43, 5, -40 },
  { 13781, 36, 53, 43, 5, -52 },
  { 14020, 33, 41, 43, 5, -40 },
  { 14190, 48, 65, 43, -3, -52 },
  { 14580, 34, 53, 43, 5, -40 },
  { 14806, 34, 52, 43, 4, -52 },
  { 15027, 33, 55, 43, 3, -55 },
  { 15254, 36, 68, 43, 1, -55 },
  { 15560, 37, 52, 43, 4, -52 },
  { 15801, 30, 52, 43, 7, -52 },
  { 15996, 38, 40, 43, 2, -40 },
  { 16186, 34, 40, 43, 4, -40 },
  { 16356, 33, 41, 43, 5, -40 },
  { 16526, 36, 53, 43, 2, -40 },
  { 16765, 34, 53, 43, 5, -40 },
  { 16991, 35, 40, 43, 5, -40 },
  { 17166, 34, 41, 43, 4, -40 },
  { 17341, 34, 50, 43, 6, -50 },
  { 17554, 34, 40, 43, 5, -39 },
  { 17724, 33, 39, 43, 8, -39 },
  { 17885, 37, 39, 43, 6, -39 },
  { 18066, 40, 39, 43, 1, -39 },
  { 18261, 34, 52, 43, 5, -39 },
  { 18482, 35, 39, 43, 3, -39 },
  { 18653, 35, 67, 43, 7, -59 },
  { 18947, 16, 67, 43, 14, -59 },
  { 19081, 36, 67, 43, 2, -59 },
  { 19383, 34, 14, 43, 5, -32 },
};

const GFXfont JetBrainsMono_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_LIGHTITALIC71PT7B_H_
