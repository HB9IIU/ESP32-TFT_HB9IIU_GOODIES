#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/JetBrainsMono_LightItalic
// Headers: 67

#include "JetBrainsMono_LightItalic6pt7b.h"
#include "JetBrainsMono_LightItalic7pt7b.h"
#include "JetBrainsMono_LightItalic8pt7b.h"
#include "JetBrainsMono_LightItalic9pt7b.h"
#include "JetBrainsMono_LightItalic10pt7b.h"
#include "JetBrainsMono_LightItalic11pt7b.h"
#include "JetBrainsMono_LightItalic12pt7b.h"
#include "JetBrainsMono_LightItalic13pt7b.h"
#include "JetBrainsMono_LightItalic14pt7b.h"
#include "JetBrainsMono_LightItalic15pt7b.h"
#include "JetBrainsMono_LightItalic16pt7b.h"
#include "JetBrainsMono_LightItalic17pt7b.h"
#include "JetBrainsMono_LightItalic18pt7b.h"
#include "JetBrainsMono_LightItalic19pt7b.h"
#include "JetBrainsMono_LightItalic20pt7b.h"
#include "JetBrainsMono_LightItalic21pt7b.h"
#include "JetBrainsMono_LightItalic22pt7b.h"
#include "JetBrainsMono_LightItalic23pt7b.h"
#include "JetBrainsMono_LightItalic24pt7b.h"
#include "JetBrainsMono_LightItalic25pt7b.h"
#include "JetBrainsMono_LightItalic26pt7b.h"
#include "JetBrainsMono_LightItalic27pt7b.h"
#include "JetBrainsMono_LightItalic28pt7b.h"
#include "JetBrainsMono_LightItalic29pt7b.h"
#include "JetBrainsMono_LightItalic30pt7b.h"
#include "JetBrainsMono_LightItalic31pt7b.h"
#include "JetBrainsMono_LightItalic32pt7b.h"
#include "JetBrainsMono_LightItalic33pt7b.h"
#include "JetBrainsMono_LightItalic34pt7b.h"
#include "JetBrainsMono_LightItalic35pt7b.h"
#include "JetBrainsMono_LightItalic36pt7b.h"
#include "JetBrainsMono_LightItalic37pt7b.h"
#include "JetBrainsMono_LightItalic38pt7b.h"
#include "JetBrainsMono_LightItalic39pt7b.h"
#include "JetBrainsMono_LightItalic40pt7b.h"
#include "JetBrainsMono_LightItalic41pt7b.h"
#include "JetBrainsMono_LightItalic42pt7b.h"
#include "JetBrainsMono_LightItalic43pt7b.h"
#include "JetBrainsMono_LightItalic44pt7b.h"
#include "JetBrainsMono_LightItalic45pt7b.h"
#include "JetBrainsMono_LightItalic46pt7b.h"
#include "JetBrainsMono_LightItalic47pt7b.h"
#include "JetBrainsMono_LightItalic48pt7b.h"
#include "JetBrainsMono_LightItalic49pt7b.h"
#include "JetBrainsMono_LightItalic50pt7b.h"
#include "JetBrainsMono_LightItalic51pt7b.h"
#include "JetBrainsMono_LightItalic52pt7b.h"
#include "JetBrainsMono_LightItalic53pt7b.h"
#include "JetBrainsMono_LightItalic54pt7b.h"
#include "JetBrainsMono_LightItalic55pt7b.h"
#include "JetBrainsMono_LightItalic56pt7b.h"
#include "JetBrainsMono_LightItalic57pt7b.h"
#include "JetBrainsMono_LightItalic58pt7b.h"
#include "JetBrainsMono_LightItalic59pt7b.h"
#include "JetBrainsMono_LightItalic60pt7b.h"
#include "JetBrainsMono_LightItalic61pt7b.h"
#include "JetBrainsMono_LightItalic62pt7b.h"
#include "JetBrainsMono_LightItalic63pt7b.h"
#include "JetBrainsMono_LightItalic64pt7b.h"
#include "JetBrainsMono_LightItalic65pt7b.h"
#include "JetBrainsMono_LightItalic66pt7b.h"
#include "JetBrainsMono_LightItalic67pt7b.h"
#include "JetBrainsMono_LightItalic68pt7b.h"
#include "JetBrainsMono_LightItalic69pt7b.h"
#include "JetBrainsMono_LightItalic70pt7b.h"
#include "JetBrainsMono_LightItalic71pt7b.h"
#include "JetBrainsMono_LightItalic72pt7b.h"
