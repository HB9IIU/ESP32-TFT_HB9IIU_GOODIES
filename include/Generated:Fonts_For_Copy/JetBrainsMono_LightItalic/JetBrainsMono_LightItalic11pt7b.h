#ifndef _JETBRAINSMONO_LIGHTITALIC11PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x86, 0x9A, 0xA0, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94,
  0x48, 0x10, 0x9E, 0xDA, 0x30, 0xC5, 0xAF, 0x90, 0x80, 0x72, 0xA9, 0x63,
  0x81, 0xC6, 0x95, 0x4E, 0x38, 0x92, 0x08, 0x56, 0x68, 0x9F, 0xE8, 0x34,
  0x48, 0x88, 0x88, 0x86, 0x61, 0x11, 0x11, 0x22, 0x48, 0x21, 0x3E, 0x45,
  0x48, 0x21, 0x3E, 0x42, 0x00, 0x69, 0x40, 0xE0, 0x70, 0x06, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x41, 0x80, 0x7C, 0x63, 0x5A, 0xC6, 0x5E, 0x32,
  0xA4, 0x42, 0x10, 0x9F, 0x7C, 0x42, 0x11, 0x32, 0x1E, 0x78, 0x88, 0x60,
  0x86, 0x5C, 0x18, 0x88, 0x98, 0xF8, 0x42, 0x7A, 0x21, 0xE0, 0x86, 0x5E,
  0x11, 0x10, 0xE8, 0xC6, 0x5E, 0x7E, 0x20, 0x84, 0x10, 0x84, 0x10, 0x7A,
  0x52, 0xE5, 0x46, 0x5E, 0x7C, 0x63, 0x17, 0x08, 0x88, 0x60, 0x05, 0x80,
  0x30, 0x00, 0x24, 0x48, 0x08, 0xD9, 0x06, 0x08, 0xF8, 0x3E, 0x82, 0x0C,
  0x17, 0x40, 0xE1, 0x12, 0xC8, 0x08, 0x3C, 0x85, 0x2A, 0xA5, 0x54, 0xAF,
  0x40, 0x80, 0xE0, 0x18, 0x62, 0x8A, 0x29, 0xE4, 0xA1, 0x7A, 0x63, 0xE9,
  0xC6, 0x5E, 0x7A, 0x61, 0x08, 0x46, 0x5E, 0x72, 0x63, 0x18, 0xC6, 0x5C,
  0x7A, 0x21, 0xF8, 0x42, 0x1E, 0x7D, 0x08, 0x3E, 0x82, 0x08, 0x20, 0x7A,
  0x61, 0x0B, 0xC6, 0x5E, 0x4A, 0x63, 0xF8, 0xCA, 0x52, 0x79, 0x08, 0x42,
  0x10, 0x9E, 0x1C, 0x10, 0x41, 0x04, 0x28, 0x9C, 0x4D, 0x29, 0x38, 0xA2,
  0x49, 0x26, 0x42, 0x11, 0x08, 0x42, 0x1F, 0x26, 0xD9, 0xB2, 0xA4, 0x48,
  0x91, 0x44, 0x4E, 0x6B, 0x5A, 0xD6, 0xD2, 0x7A, 0x63, 0x18, 0xC6, 0x5E,
  0x79, 0x28, 0xA2, 0xF2, 0x08, 0x20, 0x7A, 0x63, 0x18, 0xC6, 0x5E, 0x20,
  0x80, 0x7A, 0x63, 0x3E, 0x4A, 0x52, 0x7A, 0x60, 0xC1, 0x06, 0x3E, 0xFC,
  0x82, 0x08, 0x20, 0x82, 0x10, 0x4A, 0x63, 0x18, 0xC6, 0x5E, 0x86, 0x24,
  0x94, 0x51, 0x46, 0x18, 0xB6, 0xDA, 0xB6, 0xDB, 0x69, 0x24, 0x66, 0x48,
  0xA0, 0x81, 0x05, 0x12, 0x46, 0x85, 0x25, 0x14, 0x20, 0x82, 0x10, 0x3C,
  0x10, 0x84, 0x10, 0x84, 0x3E, 0x74, 0x44, 0x88, 0x88, 0x8C, 0x92, 0x24,
  0x92, 0x24, 0x31, 0x11, 0x12, 0x22, 0x2E, 0x31, 0x95, 0x10, 0xF8, 0x90,
  0x7C, 0x63, 0x19, 0x78, 0x42, 0x3D, 0x18, 0xC6, 0x5E, 0x74, 0x61, 0x09,
  0x78, 0x08, 0x5F, 0x18, 0xC6, 0x5E, 0x74, 0x7F, 0x09, 0x78, 0x0E, 0x21,
  0xF0, 0x82, 0x04, 0x08, 0x10, 0x21, 0x80, 0x7C, 0x63, 0x19, 0x38, 0x5C,
  0x42, 0x3D, 0x18, 0xC6, 0x52, 0x08, 0x60, 0x0C, 0x10, 0x41, 0x04, 0xFC,
  0x04, 0x30, 0x0E, 0x08, 0x20, 0x82, 0x10, 0x4E, 0x00, 0x42, 0x23, 0x2E,
  0x52, 0x52, 0xE1, 0x08, 0x84, 0x21, 0x0F, 0x7D, 0x55, 0x55, 0x96, 0x90,
  0xF4, 0x63, 0x19, 0x48, 0x74, 0x63, 0x19, 0x78, 0x79, 0x14, 0x51, 0x49,
  0xE8, 0x20, 0x7C, 0x63, 0x29, 0x78, 0x42, 0x7C, 0x61, 0x08, 0x40, 0x7C,
  0x38, 0x21, 0x78, 0x21, 0x3E, 0x44, 0x21, 0x0E, 0x8C, 0x63, 0x19, 0x78,
  0x8C, 0x54, 0xA6, 0x30, 0xA6, 0xAE, 0xBA, 0x92, 0x40, 0x64, 0xA1, 0x0C,
  0x4B, 0x20, 0x8C, 0x63, 0x29, 0x38, 0x5C, 0xF8, 0x88, 0x88, 0x78, 0x1C,
  0x41, 0x04, 0x23, 0x82, 0x08, 0x20, 0xC0, 0x29, 0x24, 0x92, 0x90, 0x30,
  0x41, 0x04, 0x10, 0x72, 0x08, 0x23, 0x80, 0xED, 0xC0,
};

const GFXglyph JetBrainsMono_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 5, 12, 7, 1, -10 },
  { 21, 7, 8, 7, 0, -8 },
  { 28, 6, 8, 7, 0, -8 },
  { 34, 2, 3, 7, 3, -8 },
  { 35, 4, 10, 7, 2, -9 },
  { 40, 4, 10, 7, 1, -9 },
  { 45, 5, 6, 7, 1, -7 },
  { 49, 5, 5, 7, 1, -6 },
  { 53, 3, 4, 7, 1, -2 },
  { 55, 3, 1, 7, 2, -4 },
  { 56, 2, 2, 7, 2, -2 },
  { 57, 7, 10, 7, 0, -9 },
  { 66, 5, 8, 7, 1, -8 },
  { 71, 5, 8, 7, 1, -8 },
  { 76, 5, 8, 7, 1, -8 },
  { 81, 5, 8, 7, 1, -8 },
  { 86, 5, 8, 7, 1, -8 },
  { 91, 5, 8, 7, 1, -8 },
  { 96, 5, 8, 7, 1, -8 },
  { 101, 6, 8, 7, 1, -8 },
  { 107, 5, 8, 7, 1, -8 },
  { 112, 5, 8, 7, 1, -8 },
  { 117, 3, 6, 7, 2, -6 },
  { 120, 4, 8, 7, 1, -6 },
  { 124, 5, 6, 7, 1, -7 },
  { 128, 5, 3, 7, 1, -5 },
  { 130, 5, 6, 7, 1, -7 },
  { 134, 4, 8, 7, 2, -8 },
  { 138, 7, 10, 7, 0, -8 },
  { 147, 6, 8, 7, 0, -8 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 6, 8, 7, 1, -8 },
  { 179, 5, 8, 7, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 6, 8, 7, 0, -8 },
  { 200, 6, 8, 7, 1, -8 },
  { 206, 5, 8, 7, 1, -8 },
  { 211, 7, 8, 7, 0, -8 },
  { 218, 5, 8, 7, 1, -8 },
  { 223, 5, 8, 7, 1, -8 },
  { 228, 6, 8, 7, 1, -8 },
  { 234, 5, 10, 7, 1, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 5, 8, 7, 1, -8 },
  { 251, 6, 8, 7, 1, -8 },
  { 257, 5, 8, 7, 1, -8 },
  { 262, 6, 8, 7, 1, -8 },
  { 268, 6, 8, 7, 1, -8 },
  { 274, 7, 8, 7, 0, -8 },
  { 281, 6, 8, 7, 1, -8 },
  { 287, 6, 8, 7, 0, -8 },
  { 293, 4, 10, 7, 2, -9 },
  { 298, 3, 10, 7, 2, -9 },
  { 302, 4, 10, 7, 1, -9 },
  { 307, 5, 4, 7, 1, -8 },
  { 310, 5, 1, 7, 0, 0 },
  { 311, 2, 2, 7, 3, -9 },
  { 312, 5, 6, 7, 1, -6 },
  { 316, 5, 8, 7, 1, -8 },
  { 321, 5, 6, 7, 1, -6 },
  { 325, 5, 8, 7, 1, -8 },
  { 330, 5, 6, 7, 1, -6 },
  { 334, 7, 10, 7, 0, -8 },
  { 343, 5, 8, 7, 1, -6 },
  { 348, 5, 8, 7, 1, -8 },
  { 353, 6, 9, 7, 0, -9 },
  { 360, 6, 11, 7, 0, -9 },
  { 369, 5, 8, 7, 1, -8 },
  { 374, 5, 8, 7, 1, -8 },
  { 379, 6, 6, 7, 0, -6 },
  { 384, 5, 6, 7, 1, -6 },
  { 388, 5, 6, 7, 1, -6 },
  { 392, 6, 8, 7, 0, -6 },
  { 398, 5, 8, 7, 1, -6 },
  { 403, 5, 6, 7, 1, -6 },
  { 407, 5, 6, 7, 1, -6 },
  { 411, 5, 8, 7, 1, -8 },
  { 416, 5, 6, 7, 1, -6 },
  { 420, 5, 6, 7, 1, -6 },
  { 424, 6, 6, 7, 1, -6 },
  { 429, 6, 6, 7, 0, -6 },
  { 434, 5, 8, 7, 1, -6 },
  { 439, 5, 6, 7, 1, -6 },
  { 443, 6, 10, 7, 1, -9 },
  { 451, 3, 10, 7, 2, -9 },
  { 455, 6, 10, 7, 0, -9 },
  { 463, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_LIGHTITALIC11PT7B_H_
