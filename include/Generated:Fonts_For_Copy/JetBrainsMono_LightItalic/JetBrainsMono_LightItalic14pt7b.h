#ifndef _JETBRAINSMONO_LIGHTITALIC14PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x90, 0x98, 0x99, 0x9B, 0x09, 0x11, 0x12, 0x7F, 0x22,
  0x24, 0xFE, 0x44, 0x48, 0x48, 0x08, 0x10, 0xF2, 0x95, 0x0A, 0x0C, 0x0E,
  0x15, 0x2A, 0x93, 0xC2, 0x04, 0x00, 0x78, 0xA4, 0x92, 0x8E, 0x80, 0x80,
  0xB0, 0x64, 0x52, 0x49, 0x47, 0x00, 0x1E, 0x22, 0x20, 0x30, 0x30, 0x5B,
  0x4A, 0x44, 0xCC, 0x72, 0xFA, 0x04, 0x63, 0x08, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x30, 0x40, 0x21, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x4C,
  0x40, 0x10, 0x22, 0x4F, 0xF1, 0x07, 0x32, 0x26, 0x10, 0x20, 0x47, 0xF1,
  0x06, 0x08, 0x00, 0x32, 0x4C, 0xF8, 0xF0, 0x01, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x00, 0x3C,
  0x85, 0x0A, 0x1D, 0x52, 0xA1, 0x42, 0x8C, 0xF0, 0x19, 0xA4, 0x82, 0x10,
  0x41, 0x04, 0x13, 0xF0, 0x3C, 0x85, 0x08, 0x20, 0x41, 0x0C, 0x30, 0xC1,
  0xF8, 0x7E, 0x08, 0x20, 0x83, 0xC0, 0x81, 0x42, 0x88, 0xF0, 0x04, 0x21,
  0x08, 0x65, 0x18, 0x7F, 0x0C, 0x20, 0x7E, 0x81, 0x02, 0xC6, 0xC0, 0x81,
  0x02, 0x8C, 0xF0, 0x0C, 0x43, 0x08, 0x7F, 0x18, 0x61, 0x8D, 0xE0, 0xFE,
  0x10, 0x82, 0x10, 0x42, 0x18, 0x43, 0x00, 0x3C, 0x85, 0x0A, 0x23, 0x8D,
  0x21, 0x42, 0x8C, 0xF0, 0x3C, 0x85, 0x0E, 0x14, 0x4F, 0x82, 0x08, 0x20,
  0xC0, 0x6C, 0x00, 0x36, 0x19, 0xC0, 0x00, 0x00, 0xC4, 0x46, 0x00, 0x06,
  0x31, 0x84, 0x06, 0x03, 0x01, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x40,
  0xC0, 0xC1, 0x19, 0x88, 0x00, 0x78, 0x20, 0x82, 0x19, 0x84, 0x00, 0x43,
  0x00, 0x1F, 0x21, 0x41, 0x47, 0x49, 0x51, 0x51, 0x91, 0x9E, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x18, 0x50, 0xA3, 0x44, 0xCF, 0xA1, 0x43, 0x84, 0x7C,
  0x8D, 0x0A, 0x27, 0x98, 0xA1, 0x42, 0x8D, 0xF0, 0x3C, 0x85, 0x0A, 0x04,
  0x10, 0x20, 0x42, 0x8C, 0xF0, 0x7C, 0x8D, 0x0A, 0x34, 0x58, 0xA1, 0x42,
  0x89, 0xE0, 0x7E, 0x81, 0x02, 0x07, 0xC8, 0x30, 0x40, 0x81, 0xF8, 0x7E,
  0x81, 0x02, 0x07, 0xD8, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x85, 0x0A, 0x04,
  0x13, 0xA1, 0x42, 0x8C, 0xF0, 0x42, 0x85, 0x0A, 0x27, 0xD8, 0xA1, 0x42,
  0x85, 0x10, 0x7E, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x21, 0xF0, 0x0F,
  0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x42, 0x44, 0x78, 0x43, 0x44, 0x44,
  0x48, 0x70, 0xD8, 0x88, 0x88, 0x8C, 0x84, 0x21, 0x04, 0x10, 0x41, 0x04,
  0x30, 0x83, 0xF0, 0x33, 0x33, 0x35, 0x35, 0x5B, 0x4A, 0x42, 0x42, 0x42,
  0xC2, 0x62, 0xC5, 0x8A, 0xA5, 0x5A, 0xA5, 0x4A, 0x8D, 0x18, 0x3C, 0x85,
  0x0A, 0x34, 0x50, 0xA1, 0x42, 0x8C, 0xF0, 0x7E, 0x85, 0x0A, 0x14, 0x5F,
  0x20, 0x40, 0x81, 0x00, 0x3C, 0x85, 0x0A, 0x3C, 0x50, 0xA1, 0x42, 0x8C,
  0xF0, 0x40, 0x40, 0x80, 0x7C, 0x85, 0x0A, 0x14, 0xDE, 0x22, 0x44, 0x89,
  0x08, 0x3C, 0x85, 0x02, 0x03, 0x01, 0x81, 0x42, 0x8C, 0xF0, 0xFE, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x80, 0x42, 0x85, 0x0A, 0x24, 0x58,
  0xA1, 0x42, 0x88, 0xF0, 0x87, 0x0A, 0x24, 0x48, 0x92, 0x34, 0x30, 0x60,
  0xC0, 0x99, 0x99, 0x9A, 0xAA, 0xAA, 0xAC, 0xAC, 0xCC, 0xCC, 0xC8, 0x21,
  0x99, 0x05, 0x82, 0x80, 0x80, 0xC0, 0x50, 0x48, 0x46, 0x61, 0x00, 0x87,
  0x0B, 0x22, 0x85, 0x0C, 0x08, 0x30, 0x40, 0x80, 0x7E, 0x08, 0x30, 0x41,
  0x04, 0x08, 0x20, 0x81, 0xF8, 0x3C, 0x82, 0x08, 0x61, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x93, 0x80, 0x84, 0x44, 0x46, 0x22, 0x23, 0x11, 0x11, 0x3C,
  0x30, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x13, 0xC0, 0x18, 0x62,
  0x51, 0xC4, 0xFE, 0x90, 0x3A, 0x89, 0x16, 0x28, 0x50, 0xA3, 0x3E, 0x41,
  0x05, 0x99, 0x47, 0x18, 0x61, 0x8F, 0xE0, 0x38, 0x89, 0x16, 0x08, 0x10,
  0xA3, 0x3C, 0x02, 0x04, 0xEA, 0x24, 0x58, 0xA1, 0x42, 0x8C, 0xF8, 0x39,
  0x14, 0x7F, 0x82, 0x08, 0xDE, 0x07, 0xC1, 0x00, 0x40, 0xFE, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x00, 0x3A, 0x89,
  0x16, 0x28, 0x50, 0xB7, 0x16, 0x08, 0x33, 0x80, 0x41, 0x05, 0x99, 0x47,
  0x18, 0x61, 0x86, 0x30, 0x08, 0x60, 0x1E, 0x10, 0x41, 0x04, 0x10, 0x4F,
  0xC0, 0x02, 0x0C, 0x01, 0xF0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x4F,
  0x98, 0x00, 0x60, 0x81, 0x0A, 0x24, 0x9A, 0x3C, 0x4C, 0x89, 0x18, 0xF0,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x3E, 0x69, 0x49, 0x4B, 0x4A,
  0x52, 0x52, 0x92, 0x59, 0x94, 0x71, 0x86, 0x18, 0x63, 0x39, 0x14, 0x61,
  0x86, 0x18, 0xDE, 0x2E, 0x64, 0x8B, 0x14, 0x28, 0x51, 0xBE, 0x40, 0x82,
  0x00, 0x3E, 0x89, 0x14, 0x28, 0x50, 0xA3, 0x3C, 0x08, 0x10, 0x20, 0x5C,
  0xCD, 0x1A, 0x04, 0x18, 0x20, 0x40, 0x3D, 0x14, 0x18, 0x1C, 0x18, 0x7E,
  0x10, 0x23, 0xF9, 0x82, 0x04, 0x08, 0x10, 0x20, 0x78, 0x42, 0x89, 0x16,
  0x28, 0x50, 0xA2, 0x3C, 0xC2, 0x8D, 0x12, 0x64, 0x8B, 0x0C, 0x18, 0x93,
  0x26, 0xCD, 0xAA, 0xD9, 0xB2, 0x64, 0x21, 0x22, 0x14, 0x18, 0x18, 0x3C,
  0x64, 0xC6, 0x46, 0x89, 0x16, 0x28, 0x51, 0xBD, 0x04, 0x08, 0x33, 0x80,
  0x7E, 0x08, 0x20, 0x82, 0x08, 0x30, 0x7E, 0x02, 0x18, 0x20, 0x40, 0x81,
  0x3C, 0x18, 0x10, 0x20, 0x41, 0x81, 0x01, 0x00, 0x24, 0xA4, 0x92, 0x5A,
  0x49, 0x00, 0x30, 0x10, 0x20, 0x40, 0x81, 0x03, 0x84, 0x10, 0x20, 0x40,
  0x82, 0x18, 0x00, 0xF3, 0x38,
};

const GFXglyph JetBrainsMono_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 9, 10, 8, 0, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 8, 4, -10 },
  { 53, 6, 14, 8, 2, -12 },
  { 64, 5, 14, 8, 1, -12 },
  { 73, 7, 8, 8, 1, -9 },
  { 80, 7, 7, 8, 1, -8 },
  { 87, 4, 4, 8, 1, -2 },
  { 89, 5, 1, 8, 2, -5 },
  { 90, 2, 2, 8, 3, -2 },
  { 91, 9, 14, 8, 0, -12 },
  { 107, 7, 10, 8, 1, -10 },
  { 116, 6, 10, 8, 1, -10 },
  { 124, 7, 10, 8, 1, -10 },
  { 133, 7, 10, 8, 1, -10 },
  { 142, 6, 10, 8, 1, -10 },
  { 150, 7, 10, 8, 1, -10 },
  { 159, 6, 10, 8, 1, -10 },
  { 167, 6, 10, 8, 2, -10 },
  { 175, 7, 10, 8, 1, -10 },
  { 184, 7, 10, 8, 1, -10 },
  { 193, 3, 8, 8, 3, -8 },
  { 196, 5, 10, 8, 1, -8 },
  { 203, 7, 7, 8, 1, -8 },
  { 210, 7, 5, 8, 1, -7 },
  { 215, 6, 7, 8, 1, -8 },
  { 221, 6, 10, 8, 2, -10 },
  { 229, 8, 13, 8, 0, -10 },
  { 242, 7, 10, 8, 0, -10 },
  { 251, 7, 10, 8, 1, -10 },
  { 260, 7, 10, 8, 1, -10 },
  { 269, 7, 10, 8, 1, -10 },
  { 278, 7, 10, 8, 1, -10 },
  { 287, 7, 10, 8, 1, -10 },
  { 296, 7, 10, 8, 1, -10 },
  { 305, 7, 10, 8, 1, -10 },
  { 314, 7, 10, 8, 1, -10 },
  { 323, 8, 10, 8, 0, -10 },
  { 333, 8, 10, 8, 1, -10 },
  { 343, 6, 10, 8, 1, -10 },
  { 351, 8, 10, 8, 0, -10 },
  { 361, 7, 10, 8, 1, -10 },
  { 370, 7, 10, 8, 1, -10 },
  { 379, 7, 10, 8, 1, -10 },
  { 388, 7, 13, 8, 1, -10 },
  { 400, 7, 10, 8, 1, -10 },
  { 409, 7, 10, 8, 1, -10 },
  { 418, 7, 10, 8, 2, -10 },
  { 427, 7, 10, 8, 1, -10 },
  { 436, 7, 10, 8, 2, -10 },
  { 445, 8, 10, 8, 1, -10 },
  { 455, 9, 10, 8, 0, -10 },
  { 467, 7, 10, 8, 2, -10 },
  { 476, 7, 10, 8, 1, -10 },
  { 485, 6, 14, 8, 2, -12 },
  { 496, 4, 14, 8, 2, -12 },
  { 503, 6, 14, 8, 1, -12 },
  { 514, 6, 5, 8, 1, -10 },
  { 518, 7, 1, 8, 0, 0 },
  { 519, 2, 2, 8, 4, -11 },
  { 520, 7, 8, 8, 1, -8 },
  { 527, 6, 10, 8, 1, -10 },
  { 535, 7, 8, 8, 1, -8 },
  { 542, 7, 10, 8, 1, -10 },
  { 551, 6, 8, 8, 1, -8 },
  { 557, 10, 13, 8, -1, -10 },
  { 574, 7, 11, 8, 1, -8 },
  { 584, 6, 10, 8, 1, -10 },
  { 592, 6, 11, 8, 1, -11 },
  { 601, 7, 14, 8, 0, -11 },
  { 614, 7, 10, 8, 1, -10 },
  { 623, 6, 10, 8, 1, -10 },
  { 631, 8, 8, 8, 0, -8 },
  { 639, 6, 8, 8, 1, -8 },
  { 645, 6, 8, 8, 1, -8 },
  { 651, 7, 11, 8, 0, -8 },
  { 661, 7, 11, 8, 1, -8 },
  { 671, 7, 8, 8, 1, -8 },
  { 678, 6, 8, 8, 1, -8 },
  { 684, 7, 10, 8, 1, -10 },
  { 693, 7, 8, 8, 1, -8 },
  { 700, 7, 8, 8, 1, -8 },
  { 707, 7, 8, 8, 1, -8 },
  { 714, 8, 8, 8, 0, -8 },
  { 722, 7, 11, 8, 1, -8 },
  { 732, 7, 8, 8, 1, -8 },
  { 739, 7, 14, 8, 1, -12 },
  { 752, 3, 14, 8, 3, -12 },
  { 758, 7, 14, 8, 0, -12 },
  { 771, 7, 2, 8, 1, -6 },
};

const GFXfont JetBrainsMono_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_LIGHTITALIC14PT7B_H_
