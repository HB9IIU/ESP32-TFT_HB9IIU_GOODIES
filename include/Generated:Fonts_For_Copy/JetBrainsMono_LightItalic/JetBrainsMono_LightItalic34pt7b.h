#ifndef _JETBRAINSMONO_LIGHTITALIC34PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x38, 0x78,
  0x78, 0x78, 0x38, 0x77, 0x8E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xC6, 0x0C, 0x60, 0xCE, 0x1C, 0x00, 0x60, 0x60, 0x0E, 0x0E, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x01, 0xC1, 0xC0, 0x18, 0x18, 0x01, 0x81, 0x81, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x30, 0x70, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x0E, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x18, 0x38, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03, 0x07, 0x00,
  0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xDE, 0x0E, 0x63, 0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x0C, 0x01, 0x86, 0x00,
  0xE2, 0x00, 0x73, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x00, 0x13, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x06, 0x18, 0x03, 0x0C, 0xE1,
  0x8E, 0x70, 0xC7, 0x38, 0xC7, 0x0F, 0x67, 0x87, 0xFF, 0x80, 0xFF, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xE0, 0x06, 0x0F, 0xE0, 0x18, 0x38, 0xE0, 0x60, 0x61, 0xC1, 0xC1, 0xC3,
  0x87, 0x03, 0x87, 0x1C, 0x06, 0x0C, 0x30, 0x0C, 0x18, 0xC0, 0x1C, 0x73,
  0x00, 0x3F, 0xCC, 0x00, 0x3F, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x19, 0xF8, 0x00, 0x67, 0xF8, 0x01, 0xCC, 0x30,
  0x07, 0x30, 0x60, 0x0C, 0x60, 0xC0, 0x30, 0xC1, 0x80, 0xC1, 0x83, 0x03,
  0x03, 0x0E, 0x0C, 0x06, 0x18, 0x38, 0x0F, 0xF0, 0xE0, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x78, 0xF0, 0x1C, 0x1C, 0x0E, 0x03, 0x03, 0x80,
  0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x0E, 0x70, 0x77, 0x0E, 0x39, 0xC3, 0x8C, 0x70,
  0x77, 0x18, 0x1F, 0x8E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x1F,
  0x8F, 0x0E, 0xE1, 0xFF, 0x1C, 0x3F, 0x87, 0x80, 0x77, 0x7F, 0xEE, 0xEE,
  0xCC, 0x00, 0x04, 0x00, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0x00, 0x04,
  0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x0F, 0x03,
  0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x10, 0x30, 0x2F, 0x8C, 0x7F, 0xFB, 0x7F, 0x3F,
  0xBE, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1D, 0x80, 0x0E, 0x70, 0x07, 0x9C,
  0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x1C, 0x04, 0x04, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x02, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x87, 0x83, 0x83,
  0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x00, 0xFF, 0xFF, 0xFC, 0x39,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xE3, 0xC1, 0xC0, 0xF1, 0xC0, 0x38, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xCE, 0x38,
  0x67, 0x1E, 0x73, 0x8E, 0x39, 0xC2, 0x1C, 0xE0, 0x0E, 0x60, 0x06, 0x70,
  0x03, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xC3, 0x80, 0xE1, 0xE1, 0xE0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x79,
  0xC1, 0xE3, 0x03, 0x06, 0x04, 0x1C, 0x10, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0xC0,
  0xF1, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC7, 0x01, 0xE1, 0xE1, 0xE0, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x07, 0x1C, 0x06, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E,
  0x60, 0x0E, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0xFC, 0x0E, 0xFF, 0x87, 0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x9C, 0x01,
  0xCE, 0x01, 0xC3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1D, 0xF8, 0x1B, 0xFE,
  0x3C, 0x1E, 0x78, 0x0F, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x1C, 0x78, 0x78, 0x3F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCC, 0x00, 0xE6, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0xE3, 0xC1, 0xC0, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x38,
  0x0E, 0x1C, 0x07, 0x0F, 0x07, 0x03, 0xCF, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x7B, 0xC0, 0x70, 0x70, 0x70, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE1, 0xE1, 0xE0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xC7, 0x87, 0x80, 0xE3, 0x80,
  0x73, 0x80, 0x39, 0xC0, 0x0C, 0xC0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x9C,
  0x03, 0x8E, 0x01, 0xC7, 0x83, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x1F, 0x1F, 0x1F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7C,
  0xFC, 0xFC, 0x78, 0x03, 0xC1, 0xF0, 0xFC, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x04, 0x3F, 0xFF, 0x9F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x83, 0xFF,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x78, 0x1F, 0xC0, 0x7E, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xC1, 0xE0, 0x70,
  0x07, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18,
  0x00, 0x31, 0x81, 0xFB, 0x38, 0x3F, 0xB3, 0x87, 0x07, 0x38, 0x60, 0x63,
  0x06, 0x06, 0x30, 0xE0, 0x63, 0x0E, 0x0E, 0x30, 0xC0, 0xE7, 0x0C, 0x0E,
  0x70, 0xC0, 0xC7, 0x0C, 0x0C, 0x60, 0xE1, 0xC6, 0x0F, 0xEC, 0x60, 0x7C,
  0xC6, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x30, 0x03, 0x98,
  0x01, 0x8C, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0xC0, 0x70, 0xE0, 0x30,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0F, 0xFF, 0x07, 0xFF, 0x87,
  0x00, 0xC3, 0x00, 0x63, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0xE0, 0x03, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0x80, 0xF1,
  0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x07, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0x81, 0xF1, 0xC0, 0x38, 0xE0,
  0x0C, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xE7,
  0x00, 0xE3, 0x83, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0x83, 0xE3, 0xC1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x03, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0x80, 0xE1,
  0xC0, 0x70, 0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x18, 0xE0,
  0x0C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0x8E, 0x01, 0xC7,
  0x01, 0xC3, 0x87, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x83, 0xE3, 0xC1, 0xC0, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x0F, 0xF3, 0x87, 0xF9, 0xC3, 0xFC, 0xE0,
  0x0E, 0x70, 0x06, 0x38, 0x03, 0x18, 0x03, 0x8C, 0x01, 0xC6, 0x00, 0xC3,
  0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0C, 0x01, 0xC3,
  0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80,
  0x38, 0x60, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0C, 0x01, 0x87, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x87, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x0C, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE0, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x11, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3C,
  0x07, 0x07, 0x87, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0xE1,
  0x80, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x1C, 0x06,
  0x03, 0x80, 0xC0, 0xE0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x61, 0xC0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70,
  0x70, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x01, 0xC1, 0xC0,
  0x38, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xB1, 0xF0, 0x7C, 0x3B, 0x0D, 0x86, 0x63,
  0xB0, 0xCC, 0x66, 0x19, 0x9D, 0xC3, 0x33, 0x38, 0x66, 0xE7, 0x1C, 0x78,
  0xC3, 0x8F, 0x18, 0x71, 0xC7, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03,
  0x8E, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0E,
  0x18, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x06, 0x00, 0x0E, 0x01, 0xC7, 0xC0,
  0x61, 0xF0, 0x18, 0x7C, 0x0E, 0x1B, 0x03, 0x86, 0xC0, 0xE1, 0xB8, 0x38,
  0xEE, 0x0C, 0x39, 0x83, 0x0E, 0x60, 0xC3, 0x98, 0x70, 0xC7, 0x1C, 0x31,
  0xC7, 0x0C, 0x31, 0xC7, 0x0C, 0x61, 0xC3, 0x18, 0x70, 0xEE, 0x1C, 0x3B,
  0x86, 0x06, 0xE1, 0x81, 0xB8, 0xE0, 0x7C, 0x38, 0x1F, 0x0E, 0x03, 0xC3,
  0x80, 0xF0, 0xC0, 0x3C, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xE3, 0xC1,
  0xC0, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x1C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x18, 0xE0, 0x0C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x8C, 0x01, 0xC6,
  0x01, 0xC3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x70, 0x0F, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0x80, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x3C, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0xE3, 0xC1, 0xC0, 0xF1, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x1F,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x70, 0x0E, 0x1C,
  0x03, 0x87, 0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x70, 0xE0, 0x78, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0x0E, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x81, 0x80, 0xE0, 0xE0,
  0x38, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x83, 0xE3, 0xC1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE1, 0xE0, 0xF0,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x01, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0x80, 0x38, 0xE0, 0x0C, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x30, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x1C, 0x1C, 0x07,
  0x07, 0x87, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0x98, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xE0,
  0x38, 0x70, 0x18, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x03, 0x07, 0x01,
  0x83, 0x00, 0xC3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x60,
  0x07, 0x70, 0x03, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x70, 0x77, 0x07, 0x07, 0x70, 0x70, 0x67, 0x0F, 0x0E,
  0x70, 0xF0, 0xE7, 0x0B, 0x0C, 0x71, 0xB0, 0xC7, 0x1B, 0x1C, 0x71, 0xB1,
  0xC6, 0x13, 0x18, 0x63, 0x31, 0x86, 0x33, 0x38, 0x62, 0x33, 0x06, 0x63,
  0x30, 0x66, 0x33, 0x06, 0x63, 0x70, 0x6C, 0x36, 0x06, 0xC3, 0x60, 0x6C,
  0x2E, 0x06, 0x82, 0xC0, 0x78, 0x2C, 0x07, 0x82, 0xC0, 0xF8, 0x3C, 0x0F,
  0x03, 0x80, 0xF0, 0x78, 0x00, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x00, 0xCE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3B, 0x80, 0x03,
  0x9C, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xE0, 0x0C, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0xF8, 0x00, 0xE6, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x0E, 0x0C, 0x07,
  0x03, 0x81, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x0D, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC1,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0,
  0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0xE7, 0x01, 0x8E, 0x06, 0x0C, 0x1C,
  0x18, 0x30, 0x38, 0xE0, 0x33, 0x80, 0x6E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE1, 0xC3, 0x0E, 0x1C, 0x03, 0xE3, 0x87, 0xFD, 0x87, 0xCE,
  0xC3, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x0C, 0x70,
  0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x71,
  0x80, 0x70, 0xE0, 0x38, 0x78, 0x7C, 0x1F, 0xEE, 0x07, 0xE7, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0xF8, 0x1B, 0xFE, 0x3F, 0x3E, 0x3C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x30,
  0x07, 0x30, 0x07, 0x70, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x0E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF8, 0x78, 0xEF, 0xF0, 0xEF,
  0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xBE, 0x1C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x78, 0x78, 0x3F,
  0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x3E, 0x38, 0x3F, 0xEC, 0x1F, 0x3B, 0x07,
  0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x07, 0x0C, 0x01, 0x87, 0x00,
  0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x38,
  0x60, 0x1C, 0x1C, 0x07, 0x07, 0x87, 0xC0, 0xFF, 0x70, 0x1F, 0x9C, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x0E, 0x38, 0x07, 0x38, 0x07,
  0x30, 0x07, 0x70, 0x07, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x70, 0x1C, 0x78, 0x38, 0x3F, 0xF0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0x87, 0xFD, 0x87, 0xCE, 0xC3, 0x81,
  0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x06, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xE0, 0xF0,
  0x7F, 0xD8, 0x3F, 0xDC, 0x03, 0x8E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0xF8,
  0x1B, 0xFE, 0x3F, 0x1E, 0x3C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07,
  0x30, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3E, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x3C, 0x60, 0x0E, 0x18, 0x07, 0x0E, 0x03, 0x83, 0x81,
  0xC0, 0xE0, 0xE0, 0x38, 0x78, 0x0C, 0x3C, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x1C, 0x38, 0x07, 0x07, 0x01, 0x81, 0xC0, 0x60, 0x38, 0x38,
  0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x00, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0xC0, 0x87, 0xFE, 0x07, 0xFC, 0x19, 0xC7, 0x86, 0xFB,
  0xF3, 0xCF, 0x1C, 0xE1, 0x87, 0x38, 0x61, 0xCE, 0x18, 0x73, 0x06, 0x1C,
  0xC3, 0x86, 0x70, 0xE1, 0x9C, 0x30, 0x67, 0x0C, 0x39, 0xC3, 0x0E, 0x60,
  0xC3, 0x98, 0x70, 0xC6, 0x1C, 0x33, 0x86, 0x0C, 0xE1, 0x87, 0x38, 0x61,
  0xCC, 0x18, 0x70, 0x18, 0xF8, 0x1B, 0xFE, 0x3F, 0x1E, 0x3C, 0x0F, 0x38,
  0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x3E, 0x1C,
  0x0E, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x1C, 0x70,
  0x1C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xE0, 0x0C, 0x7C, 0x06, 0xFF, 0x87,
  0xE7, 0xC3, 0xC0, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x07,
  0x38, 0x03, 0x1C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80,
  0x39, 0xE0, 0x38, 0xF0, 0x1C, 0x7C, 0x3C, 0x3B, 0xFC, 0x1C, 0xFC, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xE3, 0x87, 0xFD, 0x87, 0xCF, 0xC3, 0x81, 0xE3, 0x80, 0x71,
  0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xE0, 0x38, 0x78,
  0x7C, 0x1F, 0xEE, 0x07, 0xE7, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0xFC, 0x0E, 0xFF, 0x07,
  0xE3, 0xC3, 0xC0, 0xE1, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0x1F, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x3C, 0x7F, 0xF8,
  0x3F, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x18, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x03, 0x1C,
  0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0xC0, 0x70, 0xE0, 0x38,
  0x78, 0x78, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0xC0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x60, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0x70, 0xE0, 0x30, 0xC0, 0x31, 0xC0, 0x39, 0x80, 0x3B,
  0x80, 0x3B, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xC1, 0xC1, 0xF0,
  0x70, 0x6C, 0x1C, 0x3B, 0x0F, 0x0E, 0xC3, 0xC3, 0x30, 0xB0, 0xCC, 0x6C,
  0x73, 0x1B, 0x18, 0xC4, 0xC6, 0x33, 0x33, 0x8C, 0xCC, 0xC3, 0x23, 0x30,
  0xD8, 0xDC, 0x36, 0x36, 0x0D, 0x0D, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x38,
  0x3C, 0x0E, 0x0F, 0x00, 0x1C, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x1C,
  0x1C, 0x07, 0x0E, 0x00, 0xC7, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x30, 0x03, 0x8E, 0x01,
  0xC1, 0xC0, 0xF0, 0x70, 0x38, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0x70, 0x18,
  0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xC0, 0x1C, 0x60, 0x0C, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xE0, 0xB0, 0x7F, 0xF8, 0x3F, 0xDC, 0x07,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0x9F, 0xC1, 0xDC,
  0x70, 0xCC, 0x3C, 0xE6, 0x0F, 0xF7, 0x03, 0xF0,
};

const GFXglyph JetBrainsMono_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 25, 20, 6, -25 },
  { 26, 12, 10, 20, 6, -25 },
  { 41, 20, 25, 20, 1, -25 },
  { 104, 17, 35, 20, 2, -30 },
  { 179, 23, 25, 20, -1, -25 },
  { 251, 18, 25, 20, 1, -25 },
  { 308, 4, 10, 20, 10, -25 },
  { 313, 14, 33, 20, 6, -29 },
  { 371, 13, 33, 20, 2, -29 },
  { 425, 18, 18, 20, 2, -21 },
  { 466, 17, 16, 20, 2, -19 },
  { 500, 9, 10, 20, 3, -5 },
  { 512, 11, 2, 20, 5, -12 },
  { 515, 6, 5, 20, 6, -5 },
  { 519, 20, 32, 20, 1, -28 },
  { 599, 17, 25, 20, 2, -25 },
  { 653, 15, 25, 20, 2, -25 },
  { 700, 17, 25, 20, 2, -25 },
  { 754, 17, 25, 20, 2, -25 },
  { 808, 16, 25, 20, 2, -25 },
  { 858, 17, 25, 20, 2, -25 },
  { 912, 16, 25, 20, 2, -25 },
  { 962, 17, 25, 20, 4, -25 },
  { 1016, 17, 25, 20, 2, -25 },
  { 1070, 17, 25, 20, 3, -25 },
  { 1124, 8, 19, 20, 6, -19 },
  { 1143, 10, 24, 20, 4, -19 },
  { 1173, 16, 18, 20, 3, -20 },
  { 1209, 17, 10, 20, 2, -16 },
  { 1231, 16, 18, 20, 2, -20 },
  { 1267, 14, 25, 20, 5, -25 },
  { 1311, 20, 31, 20, 0, -25 },
  { 1389, 17, 25, 20, 0, -25 },
  { 1443, 17, 25, 20, 2, -25 },
  { 1497, 17, 25, 20, 2, -25 },
  { 1551, 17, 25, 20, 2, -25 },
  { 1605, 18, 25, 20, 2, -25 },
  { 1662, 18, 25, 20, 2, -25 },
  { 1719, 17, 25, 20, 2, -25 },
  { 1773, 18, 25, 20, 2, -25 },
  { 1830, 17, 25, 20, 2, -25 },
  { 1884, 18, 25, 20, 1, -25 },
  { 1941, 19, 25, 20, 2, -25 },
  { 2001, 15, 25, 20, 2, -25 },
  { 2048, 19, 25, 20, 1, -25 },
  { 2108, 18, 25, 20, 2, -25 },
  { 2165, 17, 25, 20, 2, -25 },
  { 2219, 18, 25, 20, 2, -25 },
  { 2276, 17, 31, 20, 2, -25 },
  { 2342, 18, 25, 20, 2, -25 },
  { 2399, 17, 25, 20, 2, -25 },
  { 2453, 17, 25, 20, 4, -25 },
  { 2507, 18, 25, 20, 2, -25 },
  { 2564, 17, 25, 20, 4, -25 },
  { 2618, 20, 25, 20, 2, -25 },
  { 2681, 21, 25, 20, 0, -25 },
  { 2747, 18, 25, 20, 4, -25 },
  { 2804, 19, 25, 20, 1, -25 },
  { 2864, 13, 32, 20, 5, -28 },
  { 2916, 10, 32, 20, 6, -28 },
  { 2956, 13, 32, 20, 3, -28 },
  { 3008, 15, 13, 20, 3, -25 },
  { 3033, 17, 2, 20, 0, 1 },
  { 3038, 6, 5, 20, 9, -27 },
  { 3042, 17, 19, 20, 2, -19 },
  { 3083, 16, 25, 20, 2, -25 },
  { 3133, 16, 19, 20, 2, -19 },
  { 3171, 18, 25, 20, 2, -25 },
  { 3228, 16, 19, 20, 2, -19 },
  { 3266, 22, 31, 20, -1, -25 },
  { 3352, 17, 25, 20, 2, -19 },
  { 3406, 16, 25, 20, 2, -25 },
  { 3456, 16, 26, 20, 1, -26 },
  { 3508, 17, 32, 20, 1, -26 },
  { 3576, 18, 25, 20, 2, -25 },
  { 3633, 15, 25, 20, 3, -25 },
  { 3680, 18, 19, 20, 1, -19 },
  { 3723, 16, 19, 20, 2, -19 },
  { 3761, 16, 19, 20, 2, -19 },
  { 3799, 17, 25, 20, 1, -19 },
  { 3853, 17, 25, 20, 2, -19 },
  { 3907, 17, 19, 20, 2, -19 },
  { 3948, 16, 19, 20, 2, -19 },
  { 3986, 16, 24, 20, 3, -24 },
  { 4034, 17, 19, 20, 2, -19 },
  { 4075, 16, 19, 20, 4, -19 },
  { 4113, 18, 19, 20, 3, -19 },
  { 4156, 18, 19, 20, 1, -19 },
  { 4199, 17, 25, 20, 2, -19 },
  { 4253, 16, 19, 20, 2, -19 },
  { 4291, 17, 32, 20, 3, -28 },
  { 4359, 8, 32, 20, 7, -28 },
  { 4391, 17, 32, 20, 1, -28 },
  { 4459, 17, 6, 20, 2, -15 },
};

const GFXfont JetBrainsMono_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_LIGHTITALIC34PT7B_H_
