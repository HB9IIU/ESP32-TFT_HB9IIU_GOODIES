#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xC0, 0x00, 0x3F, 0xFF, 0xFB, 0xC0, 0xF9, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F,
  0xF0, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x01, 0xC3, 0x80,
  0x38, 0xF0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x3C, 0x78, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83,
  0x87, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x38,
  0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x8E, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xBE, 0xE7,
  0x79, 0xC0, 0xF3, 0x81, 0xE7, 0x03, 0xEE, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0x7C, 0x0E, 0x78, 0x1C,
  0xF8, 0x39, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x3C, 0x07, 0xF0, 0x07,
  0x01, 0xFF, 0x01, 0xE0, 0x3C, 0xE0, 0x38, 0x07, 0x1E, 0x0F, 0x01, 0xE1,
  0xC1, 0xC0, 0x3C, 0x38, 0x78, 0x07, 0x87, 0x0E, 0x00, 0xF0, 0xE3, 0xC0,
  0x1E, 0x1C, 0x70, 0x03, 0xC7, 0x9E, 0x3C, 0x38, 0xF3, 0x9F, 0xC7, 0x9C,
  0xF3, 0xFC, 0xFF, 0x9C, 0xF3, 0xCF, 0xE7, 0x9C, 0x78, 0xF8, 0xE3, 0x87,
  0x00, 0x3C, 0xF0, 0xE0, 0x07, 0x1E, 0x1C, 0x01, 0xE3, 0xC3, 0x80, 0x38,
  0x78, 0x70, 0x0F, 0x07, 0x0E, 0x01, 0xC0, 0xE3, 0xC0, 0x78, 0x1E, 0x78,
  0x0E, 0x03, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x70, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0x8F, 0xFC, 0x1E, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0xF9, 0xF0,
  0x7D, 0xE3, 0xE0, 0x7F, 0xC7, 0xC0, 0x7F, 0x0F, 0x80, 0x7E, 0x0F, 0x81,
  0xFC, 0x1F, 0xDF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xF0,
  0xFC, 0xFF, 0xFD, 0xEF, 0x39, 0xCE, 0x73, 0x80, 0x07, 0x0F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x07, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83,
  0xC3, 0xC1, 0xE1, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x63, 0xC6, 0x7D, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x7C, 0x1C, 0x38, 0x0C, 0x30, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3C,
  0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xE3,
  0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBE, 0x03,
  0xDF, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0,
  0xFD, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x7C,
  0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xFF, 0x7B, 0xCF, 0x21, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0x83, 0xE1, 0x80, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFE, 0x30, 0x3E, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80,
  0x1F, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0x78, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xC3,
  0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xFE, 0x7F,
  0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x20, 0x1E, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xF0, 0xFB,
  0xF0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x01,
  0xF7, 0xC0, 0xF1, 0xE0, 0xF8, 0xFC, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xCF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x7C, 0x1E, 0x1F, 0x1F, 0x07, 0xDF, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x7C, 0x7C, 0x7C, 0x1F, 0x3C, 0x07,
  0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB, 0xC0, 0x79, 0xF0, 0x7C, 0xFF,
  0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC7, 0xC3, 0xE3, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8,
  0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xCF, 0x03, 0xF7, 0xC1, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xDE, 0x07, 0x8F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x87, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xE0, 0x00, 0x77, 0xFF, 0xFF, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0xF0, 0x39, 0xF7, 0xDF, 0x3C, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF0, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x60,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0x79, 0xE0, 0x7F, 0x0E, 0x78, 0x7F, 0xE3, 0x9C, 0x3F, 0xF8, 0xFF, 0x1E,
  0x1E, 0x1F, 0x87, 0x87, 0x87, 0xE1, 0xC1, 0xE1, 0xF8, 0xF0, 0x78, 0x7E,
  0x3C, 0x1E, 0x1F, 0x8F, 0x07, 0x87, 0xE3, 0xC1, 0xE3, 0xF8, 0x70, 0x78,
  0xEE, 0x1E, 0x3E, 0x7B, 0xC7, 0xFF, 0xFC, 0xF0, 0xFE, 0x7E, 0x1C, 0x1F,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x1F, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87,
  0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x3C, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF1, 0xF0,
  0x03, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xF0, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x03, 0xF7,
  0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x0F,
  0x9F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xF3, 0xC3, 0xFD, 0xE0, 0x3E, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x01, 0x8F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x23, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x03, 0xF9, 0xE0, 0x1F, 0x3C, 0x01,
  0xF7, 0x80, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0xF9, 0xE0, 0x7F,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x0C,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x00, 0xF7,
  0xE0, 0x1E, 0x7E, 0x03, 0xCF, 0xFB, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xF8, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF3, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFF, 0xFF, 0xFD,
  0xFC, 0xFC, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7C,
  0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C,
  0xF8, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xF7, 0xC0, 0xF8, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC1, 0xF0,
  0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC,
  0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xEE, 0x00,
  0xEF, 0xF7, 0x80, 0xF7, 0xFB, 0xC0, 0x7B, 0xFC, 0xE0, 0x39, 0xFE, 0x78,
  0x3C, 0xFF, 0x3C, 0x1E, 0x7F, 0x8E, 0x0E, 0x3F, 0xC7, 0x8F, 0x1F, 0xE3,
  0xC7, 0x8F, 0xF1, 0xE3, 0x87, 0xF8, 0x7B, 0xC3, 0xFC, 0x3D, 0xE1, 0xFE,
  0x1E, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xF8, 0x1F,
  0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x1E, 0x03, 0xC0, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0x78, 0x0F, 0xF7, 0xC0, 0xFF, 0x3C, 0x0F, 0xF3,
  0xE0, 0xFF, 0x1F, 0x0F, 0xF1, 0xF0, 0xFF, 0x0F, 0x8F, 0xF0, 0xF8, 0xFF,
  0x07, 0xCF, 0xF0, 0x7C, 0xFF, 0x03, 0xEF, 0xF0, 0x1E, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9E, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7B, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0,
  0x7E, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFE,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7,
  0xC0, 0x0F, 0x9E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x7E, 0x3C, 0x07,
  0xCF, 0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF0,
  0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x3E, 0x3C, 0x07,
  0x8F, 0x01, 0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x01, 0xF0, 0x0F, 0xF0,
  0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0x81, 0x9F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF8, 0x0F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xDF, 0x03, 0xF7, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F,
  0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3E,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x3D, 0xE0,
  0x1F, 0x00, 0xFB, 0xC0, 0x3F, 0x01, 0xF7, 0x80, 0x7E, 0x03, 0xCF, 0x81,
  0xFC, 0x07, 0x9F, 0x03, 0xF8, 0x0F, 0x1E, 0x07, 0x78, 0x3E, 0x3C, 0x0E,
  0xF0, 0x78, 0x7C, 0x3D, 0xE0, 0xF0, 0xF8, 0x7B, 0xC1, 0xE0, 0xF0, 0xF3,
  0xC7, 0xC1, 0xE1, 0xC7, 0x8F, 0x83, 0xC7, 0x8F, 0x1E, 0x07, 0xCF, 0x1E,
  0x3C, 0x07, 0x9E, 0x1E, 0x78, 0x0F, 0x38, 0x3D, 0xF0, 0x1E, 0xF0, 0x7B,
  0xC0, 0x3D, 0xE0, 0xF7, 0x80, 0x3F, 0xC0, 0xEF, 0x00, 0x7F, 0x01, 0xDE,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF7, 0xC0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0xF8, 0x0F,
  0x8F, 0x00, 0x79, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00,
  0xF9, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01,
  0xDC, 0x00, 0xF7, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x01, 0xC1,
  0xE0, 0xF0, 0x38, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0x7E, 0x10, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x7F, 0x7F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0xF7, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xFE, 0x7E, 0xFF, 0xFC, 0xE7, 0xFC, 0xE3, 0xF0, 0x07,
  0xE0, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xC1, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x81, 0x7E, 0x39, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x8F,
  0x1F, 0xEF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xEF,
  0x1F, 0xC7, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x78, 0x3E,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x02, 0x7E, 0x0E,
  0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x01, 0xC0, 0x7F, 0xC7, 0xFC, 0x3F,
  0xE1, 0xE1, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x8F, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x60, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8,
  0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0xF8, 0xF7, 0xF9, 0xFF, 0xFB, 0xFF, 0xFF, 0xE1,
  0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0x7F, 0xFE, 0xF3, 0x00, 0x0F, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x07, 0x87,
  0xC3, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0xFF, 0x7F,
  0xBF, 0x8F, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0,
  0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1,
  0xF0, 0x3E, 0x39, 0xFE, 0x3F, 0xCE, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0,
  0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F,
  0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0xE1, 0xF1, 0xCF, 0xF3, 0xBF, 0xF7, 0xFF, 0xFF,
  0xC3, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xC1, 0xE7, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B,
  0xE0, 0x3C, 0xF0, 0x3E, 0x7E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFE,
  0x00, 0xE1, 0xE0, 0xE7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF,
  0xFC, 0xF7, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0x8F, 0x1F, 0xEF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE1, 0xFC, 0xFF,
  0x9F, 0xF7, 0xFF, 0xF3, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0x9F, 0xBE, 0x78, 0x13, 0xE0, 0x07,
  0x80, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x70, 0xF9, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0xE2, 0x7F, 0xC7, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xE7, 0x1F,
  0xC7, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x3E, 0x7C, 0x0F,
  0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81,
  0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xEF, 0x03, 0xE0, 0x3D, 0xE0, 0x7E, 0x0F, 0xBC, 0x0F, 0xC1, 0xE7,
  0xC3, 0xF8, 0x3C, 0x78, 0x77, 0x07, 0x8F, 0x0E, 0xF1, 0xF1, 0xE1, 0xDE,
  0x3C, 0x3E, 0x79, 0xC7, 0x83, 0xCF, 0x38, 0xF0, 0x79, 0xC7, 0xBE, 0x0F,
  0x38, 0xF7, 0x81, 0xEF, 0x0E, 0xF0, 0x1F, 0xE1, 0xDE, 0x03, 0xF8, 0x3B,
  0xC0, 0x7F, 0x07, 0x70, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0xDF, 0x03, 0xE3, 0xE0,
  0xF0, 0xF8, 0x7C, 0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xC7, 0xC0,
  0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x3E,
  0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07,
  0x87, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xF0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xFE, 0x0F, 0xC0,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0xFF, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0E, 0x00, 0x3F, 0x80, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xE8, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 10, 2, -26 },
  { 18, 12, 10, 16, 2, -26 },
  { 33, 19, 26, 21, 1, -26 },
  { 95, 15, 29, 19, 2, -27 },
  { 150, 27, 26, 30, 1, -26 },
  { 238, 23, 26, 24, 1, -26 },
  { 313, 5, 10, 9, 2, -26 },
  { 320, 8, 32, 11, 2, -26 },
  { 352, 9, 32, 11, 1, -26 },
  { 388, 16, 15, 18, 1, -27 },
  { 418, 17, 17, 19, 1, -21 },
  { 455, 6, 9, 10, 1, -4 },
  { 462, 9, 4, 11, 1, -12 },
  { 467, 5, 5, 10, 2, -5 },
  { 471, 14, 26, 14, 0, -26 },
  { 517, 17, 26, 19, 1, -26 },
  { 573, 11, 26, 19, 2, -26 },
  { 609, 17, 26, 19, 1, -26 },
  { 665, 16, 26, 19, 1, -26 },
  { 717, 17, 26, 19, 1, -26 },
  { 773, 15, 26, 19, 2, -26 },
  { 822, 17, 26, 19, 1, -26 },
  { 878, 17, 26, 19, 1, -26 },
  { 934, 17, 26, 19, 1, -26 },
  { 990, 17, 26, 19, 1, -26 },
  { 1046, 5, 20, 10, 2, -20 },
  { 1059, 6, 25, 10, 1, -20 },
  { 1078, 17, 18, 19, 1, -22 },
  { 1117, 17, 11, 19, 1, -18 },
  { 1141, 17, 18, 19, 1, -22 },
  { 1180, 14, 26, 15, 0, -26 },
  { 1226, 26, 29, 30, 2, -26 },
  { 1321, 22, 26, 22, 0, -26 },
  { 1393, 17, 26, 22, 3, -26 },
  { 1449, 18, 26, 21, 2, -26 },
  { 1508, 19, 26, 24, 3, -26 },
  { 1570, 13, 26, 18, 3, -26 },
  { 1613, 13, 26, 18, 3, -26 },
  { 1656, 19, 26, 24, 2, -26 },
  { 1718, 19, 26, 25, 3, -26 },
  { 1780, 10, 26, 12, 1, -26 },
  { 1813, 9, 33, 10, -2, -26 },
  { 1851, 18, 26, 21, 3, -26 },
  { 1910, 14, 26, 18, 3, -26 },
  { 1956, 25, 26, 31, 3, -26 },
  { 2038, 20, 26, 26, 3, -26 },
  { 2103, 22, 26, 26, 2, -26 },
  { 2175, 16, 26, 20, 3, -26 },
  { 2227, 22, 32, 26, 2, -26 },
  { 2315, 18, 26, 21, 3, -26 },
  { 2374, 15, 26, 18, 2, -26 },
  { 2423, 17, 26, 18, 1, -26 },
  { 2479, 18, 26, 24, 3, -26 },
  { 2538, 21, 26, 21, 0, -26 },
  { 2607, 31, 26, 31, 0, -26 },
  { 2708, 20, 26, 20, 0, -26 },
  { 2773, 20, 26, 20, 0, -26 },
  { 2838, 16, 26, 18, 1, -26 },
  { 2890, 8, 32, 12, 3, -26 },
  { 2922, 14, 26, 14, 0, -26 },
  { 2968, 8, 32, 12, 1, -26 },
  { 3000, 18, 16, 20, 1, -26 },
  { 3036, 15, 3, 15, 0, 3 },
  { 3042, 9, 6, 11, 1, -28 },
  { 3049, 16, 20, 19, 1, -20 },
  { 3089, 16, 27, 21, 3, -27 },
  { 3143, 13, 20, 16, 2, -20 },
  { 3176, 16, 27, 21, 2, -27 },
  { 3230, 16, 20, 19, 2, -20 },
  { 3270, 13, 28, 12, 1, -28 },
  { 3316, 16, 29, 21, 2, -20 },
  { 3374, 15, 27, 21, 3, -27 },
  { 3425, 5, 27, 10, 2, -27 },
  { 3442, 9, 36, 10, -2, -27 },
  { 3483, 16, 27, 19, 3, -27 },
  { 3537, 4, 27, 9, 3, -27 },
  { 3551, 26, 20, 31, 3, -20 },
  { 3616, 15, 20, 21, 3, -20 },
  { 3654, 17, 20, 20, 2, -20 },
  { 3697, 16, 29, 21, 3, -20 },
  { 3755, 16, 29, 21, 2, -20 },
  { 3813, 11, 20, 14, 3, -20 },
  { 3841, 14, 20, 16, 1, -20 },
  { 3876, 11, 24, 13, 1, -24 },
  { 3909, 16, 20, 21, 2, -20 },
  { 3949, 18, 20, 18, 0, -20 },
  { 3994, 27, 20, 28, 0, -20 },
  { 4062, 18, 20, 18, 0, -20 },
  { 4107, 18, 29, 18, 0, -20 },
  { 4173, 13, 20, 16, 1, -20 },
  { 4206, 11, 32, 14, 1, -26 },
  { 4250, 4, 35, 18, 7, -27 },
  { 4268, 12, 32, 14, 1, -26 },
  { 4316, 17, 5, 19, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD36PT7B_H_
