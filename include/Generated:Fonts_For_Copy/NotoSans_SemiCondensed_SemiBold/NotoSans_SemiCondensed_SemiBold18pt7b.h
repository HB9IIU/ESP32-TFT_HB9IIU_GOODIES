#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0x41, 0x7E, 0xCF, 0x3C, 0xF3, 0xCC, 0x09, 0x82,
  0x61, 0x90, 0x64, 0x7F, 0xC6, 0xC1, 0x30, 0x4C, 0xFF, 0xCC, 0x83, 0x20,
  0xD8, 0x26, 0x00, 0x10, 0x10, 0x7E, 0xFE, 0xD0, 0xD0, 0xF0, 0x3C, 0x1E,
  0x17, 0x13, 0xFE, 0xFC, 0x10, 0x10, 0x70, 0xC6, 0xC6, 0x36, 0x61, 0x33,
  0x09, 0x90, 0x6D, 0xBB, 0x6B, 0xEE, 0xDB, 0x04, 0x98, 0x64, 0xC2, 0x36,
  0x31, 0xB3, 0x07, 0x00, 0x3C, 0x0F, 0xC1, 0x98, 0x33, 0x06, 0xE0, 0x78,
  0x1E, 0x37, 0xE6, 0xCF, 0xD8, 0xF3, 0x0E, 0x7F, 0xE7, 0xCE, 0xFF, 0xC0,
  0x36, 0x66, 0xCC, 0xCC, 0xCC, 0xCC, 0xE6, 0x63, 0xE3, 0x0C, 0x63, 0x8C,
  0x63, 0x18, 0xC6, 0x73, 0x19, 0x9C, 0x38, 0x22, 0x4F, 0xF7, 0xC5, 0x1B,
  0x73, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0xFB, 0x60,
  0xFF, 0x5F, 0x80, 0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0x41,
  0x83, 0x0C, 0x00, 0x3C, 0x7E, 0xE6, 0xC6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7,
  0xC7, 0xC6, 0x7E, 0x3C, 0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x7C, 0xFE, 0xC6, 0x06, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0x70,
  0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0x86, 0x06, 0x06, 0x7C, 0x7C, 0x0E, 0x07,
  0x07, 0x07, 0xFE, 0xFC, 0x07, 0x03, 0x83, 0xC3, 0x61, 0xB1, 0x98, 0x8C,
  0xC6, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x30, 0x7E, 0x7E, 0xC0, 0xC0, 0xC0,
  0xFC, 0xFE, 0x06, 0x07, 0x07, 0x06, 0xFE, 0xFC, 0x1E, 0x7E, 0x60, 0xC0,
  0xC0, 0xFE, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0x7E, 0x3C, 0xFF, 0xFF, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x3C, 0xFE,
  0xC6, 0xC6, 0xE6, 0x7C, 0x3C, 0xEE, 0xC7, 0xC3, 0xC3, 0xFE, 0x7C, 0x3C,
  0xFE, 0xC6, 0xC7, 0xC3, 0xC7, 0xEF, 0x7B, 0x06, 0x06, 0x06, 0xFC, 0xF8,
  0xDF, 0x00, 0x02, 0xFC, 0xDF, 0x00, 0x00, 0xFB, 0x60, 0x01, 0x07, 0x1C,
  0x70, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x7D, 0xFE, 0x18, 0x30,
  0x61, 0x86, 0x18, 0x30, 0x00, 0x41, 0xC3, 0x00, 0x0F, 0x80, 0xFF, 0x0C,
  0x0C, 0xC6, 0x2C, 0xF9, 0xE4, 0x4F, 0x62, 0x7B, 0x13, 0xD9, 0x9E, 0x6F,
  0xB3, 0x98, 0xC0, 0x07, 0x04, 0x1F, 0xE0, 0x08, 0x00, 0x0E, 0x01, 0xC0,
  0x6C, 0x0D, 0x81, 0xB0, 0x77, 0x0C, 0x61, 0x8C, 0x7F, 0x8F, 0xF9, 0x83,
  0x70, 0x6E, 0x0E, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0xFB, 0xF9, 0xC7,
  0xE1, 0xF0, 0xF8, 0xFF, 0xEF, 0xE0, 0x1F, 0x1F, 0xDC, 0x3C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x1C, 0x0F, 0xE1, 0xF0, 0xFE, 0x3F, 0xCE,
  0x3B, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x6E, 0x3B, 0xFC,
  0xFE, 0x00, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x3F, 0xFC,
  0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xFF, 0xC3, 0x0C, 0x30, 0xC0, 0x1F, 0xCF,
  0xE7, 0x09, 0x80, 0xE0, 0x30, 0x0C, 0x7F, 0x1F, 0xC1, 0xF8, 0x77, 0x1D,
  0xFF, 0x1F, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF, 0x98, 0xC6, 0x31, 0x8C, 0x63,
  0x19, 0xEF, 0x80, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xDE, 0xC0, 0xC3, 0xE3, 0xB3, 0x99, 0x8D, 0x87, 0xC3, 0xE1, 0xF0, 0xDC,
  0x67, 0x31, 0x98, 0xEC, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xE0, 0x7E, 0x0F, 0xE0, 0xFB, 0x0F, 0xF0,
  0xBF, 0x1B, 0xD9, 0xBD, 0x93, 0xDB, 0x3C, 0xF3, 0xCE, 0x3C, 0xE3, 0xC6,
  0x30, 0xC1, 0xF8, 0x7F, 0x1E, 0xC7, 0xB9, 0xF6, 0x7D, 0xDF, 0x33, 0xCE,
  0xF1, 0xBC, 0x7F, 0x0F, 0xC1, 0xC0, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x6E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x19, 0x87, 0x3F, 0xC1, 0xF0,
  0xFC, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x19, 0x87, 0x3F, 0xC1, 0xF0, 0x07, 0x00, 0x60, 0x0F, 0xFC,
  0x3F, 0xCE, 0x33, 0x8C, 0xE3, 0x38, 0xCF, 0xE3, 0xF0, 0xE6, 0x39, 0x8E,
  0x33, 0x8E, 0xE1, 0xC0, 0x3F, 0xFF, 0x0E, 0x0C, 0x1E, 0x1F, 0x0F, 0x06,
  0x0E, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x76, 0x19, 0xFE, 0x3F, 0x00,
  0xC0, 0xF8, 0x36, 0x1D, 0x86, 0x61, 0x8C, 0x63, 0x30, 0xCC, 0x1B, 0x07,
  0x81, 0xE0, 0x78, 0x0E, 0x00, 0xC1, 0x87, 0xE3, 0x86, 0x63, 0x86, 0x63,
  0xC6, 0x63, 0xC6, 0x66, 0xCC, 0x36, 0x4C, 0x36, 0x6C, 0x36, 0x6C, 0x34,
  0x78, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xD8, 0x63, 0x38, 0xCC,
  0x1E, 0x07, 0x80, 0xC0, 0x78, 0x1F, 0x0C, 0xC7, 0x39, 0x86, 0xE1, 0xC0,
  0xE1, 0xD8, 0x66, 0x38, 0xCC, 0x37, 0x07, 0x81, 0xE0, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x70, 0x30, 0x38, 0x18, 0x18, 0x1F, 0xFF, 0xF8, 0xFF, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xFF, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8F, 0xFF, 0x0C, 0x06, 0x07, 0x82, 0xC3, 0x31, 0x19, 0x87, 0xC3, 0xFF,
  0xC6, 0x30, 0x7C, 0xFC, 0x18, 0x37, 0xFC, 0xF1, 0xE3, 0xFE, 0xF4, 0xC0,
  0x60, 0x30, 0x18, 0x0D, 0xE7, 0xFB, 0x8D, 0xC6, 0xC3, 0xE1, 0xF8, 0xDC,
  0x6F, 0xF6, 0xF0, 0x3E, 0xFB, 0x86, 0x0C, 0x18, 0x30, 0x70, 0x7E, 0x7C,
  0x03, 0x03, 0x03, 0x03, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7F, 0x7B, 0x3C, 0x7E, 0xE6, 0xC3, 0xFF, 0xFF, 0xC0, 0xE0, 0x7E, 0x3E,
  0x1E, 0x78, 0xC1, 0x87, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x00, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0x03,
  0x03, 0xEF, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x5F, 0x0D, 0xB6, 0xDB, 0x6D, 0x80, 0x11,
  0xCC, 0x03, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0xF7, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x36, 0x33, 0x39, 0xB8, 0xD8, 0x7E, 0x3B, 0x18,
  0xCC, 0x76, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0xDE, 0x77, 0xFF, 0xF9, 0xC7,
  0xC6, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18, 0xC0,
  0xDE, 0xFF, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E, 0x3C, 0xDE, 0x7F, 0xB8, 0xDC,
  0x6C, 0x3E, 0x1F, 0x8D, 0xC6, 0xFF, 0x6F, 0x30, 0x18, 0x0C, 0x06, 0x00,
  0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0x03, 0x03,
  0x03, 0x03, 0xCF, 0x7F, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7F, 0xFC,
  0x30, 0xF0, 0xF0, 0xC3, 0xFF, 0xE0, 0x30, 0xC7, 0xFF, 0x71, 0xC7, 0x1C,
  0x70, 0xC3, 0xCF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F,
  0x7B, 0xC1, 0xF1, 0xD8, 0xCC, 0x67, 0x71, 0xB0, 0xD8, 0x6C, 0x1C, 0x0E,
  0x00, 0xC3, 0x1F, 0x9C, 0x66, 0x79, 0x99, 0xE6, 0x65, 0xB0, 0xF2, 0xC3,
  0xCF, 0x0F, 0x3C, 0x38, 0xE0, 0x61, 0x80, 0xE3, 0xB1, 0x8D, 0x87, 0xC1,
  0xC0, 0xE0, 0xF8, 0x6C, 0x63, 0x71, 0xC0, 0xC1, 0xF1, 0xD8, 0xCC, 0x63,
  0x71, 0xB0, 0xD8, 0x2C, 0x1C, 0x0E, 0x07, 0x03, 0x0F, 0x87, 0x80, 0xFF,
  0xF1, 0xC6, 0x31, 0xC6, 0x38, 0xFF, 0xF0, 0x0C, 0x73, 0x8C, 0x30, 0xC3,
  0x3C, 0xF0, 0xC3, 0x0C, 0x30, 0xE1, 0xC3, 0xFF, 0xFF, 0xC0, 0xC7, 0x18,
  0xC6, 0x31, 0xC7, 0x3B, 0x98, 0xC6, 0x33, 0x98, 0x61, 0xFF, 0x8E,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 6, 5, 8, 1, -13 },
  { 10, 10, 13, 11, 0, -13 },
  { 27, 8, 15, 10, 1, -14 },
  { 42, 13, 13, 15, 1, -13 },
  { 64, 11, 13, 12, 1, -13 },
  { 82, 2, 5, 4, 1, -13 },
  { 84, 4, 16, 6, 1, -13 },
  { 92, 5, 16, 6, 0, -13 },
  { 102, 7, 8, 9, 1, -14 },
  { 109, 8, 9, 10, 1, -11 },
  { 118, 3, 4, 5, 1, -2 },
  { 120, 4, 2, 6, 1, -6 },
  { 121, 3, 3, 5, 1, -3 },
  { 123, 7, 13, 7, 0, -13 },
  { 135, 8, 13, 9, 1, -13 },
  { 148, 6, 13, 9, 1, -13 },
  { 158, 8, 13, 9, 1, -13 },
  { 171, 8, 13, 9, 1, -13 },
  { 184, 9, 13, 9, 0, -13 },
  { 199, 8, 13, 9, 1, -13 },
  { 212, 8, 13, 9, 1, -13 },
  { 225, 8, 13, 9, 1, -13 },
  { 238, 8, 13, 9, 1, -13 },
  { 251, 8, 13, 9, 1, -13 },
  { 264, 3, 10, 5, 1, -10 },
  { 268, 3, 12, 5, 1, -10 },
  { 273, 8, 9, 10, 1, -11 },
  { 282, 8, 5, 10, 1, -9 },
  { 287, 8, 9, 10, 1, -11 },
  { 296, 7, 13, 8, 0, -13 },
  { 308, 13, 15, 15, 1, -13 },
  { 333, 11, 13, 11, 0, -13 },
  { 351, 9, 13, 11, 1, -13 },
  { 366, 9, 13, 10, 1, -13 },
  { 381, 10, 13, 12, 1, -13 },
  { 398, 6, 13, 9, 2, -13 },
  { 408, 6, 13, 9, 2, -13 },
  { 418, 10, 13, 12, 1, -13 },
  { 435, 9, 13, 12, 2, -13 },
  { 450, 5, 13, 6, 1, -13 },
  { 459, 5, 17, 5, -1, -13 },
  { 470, 9, 13, 11, 2, -13 },
  { 485, 7, 13, 9, 1, -13 },
  { 497, 12, 13, 16, 2, -13 },
  { 517, 10, 13, 13, 2, -13 },
  { 534, 11, 13, 13, 1, -13 },
  { 552, 8, 13, 10, 1, -13 },
  { 565, 11, 16, 13, 1, -13 },
  { 587, 10, 13, 11, 1, -13 },
  { 604, 7, 13, 9, 1, -13 },
  { 616, 9, 13, 9, 0, -13 },
  { 631, 10, 13, 12, 1, -13 },
  { 648, 10, 13, 10, 0, -13 },
  { 665, 16, 13, 16, 0, -13 },
  { 691, 10, 13, 10, 0, -13 },
  { 708, 10, 13, 10, 0, -13 },
  { 725, 9, 13, 9, 0, -13 },
  { 740, 4, 16, 6, 1, -13 },
  { 748, 7, 13, 7, 0, -13 },
  { 760, 5, 16, 6, 0, -13 },
  { 770, 9, 8, 10, 0, -13 },
  { 779, 8, 1, 8, 0, 2 },
  { 780, 4, 3, 6, 1, -14 },
  { 782, 7, 10, 10, 1, -10 },
  { 791, 9, 14, 10, 1, -14 },
  { 807, 7, 10, 8, 1, -10 },
  { 816, 8, 14, 10, 1, -14 },
  { 830, 8, 10, 10, 1, -10 },
  { 840, 7, 14, 6, 0, -14 },
  { 853, 8, 14, 10, 1, -10 },
  { 867, 8, 14, 10, 1, -14 },
  { 881, 3, 14, 5, 1, -14 },
  { 887, 5, 18, 5, -1, -14 },
  { 899, 9, 14, 10, 1, -14 },
  { 915, 2, 14, 5, 1, -14 },
  { 919, 13, 10, 16, 1, -10 },
  { 936, 8, 10, 10, 1, -10 },
  { 946, 8, 10, 10, 1, -10 },
  { 956, 9, 14, 10, 1, -10 },
  { 972, 8, 14, 10, 1, -10 },
  { 986, 6, 10, 7, 1, -10 },
  { 994, 6, 10, 8, 1, -10 },
  { 1002, 6, 12, 7, 0, -12 },
  { 1011, 8, 10, 10, 1, -10 },
  { 1021, 9, 10, 9, 0, -10 },
  { 1033, 14, 10, 14, 0, -10 },
  { 1051, 9, 10, 9, 0, -10 },
  { 1063, 9, 14, 9, 0, -10 },
  { 1079, 6, 10, 8, 1, -10 },
  { 1087, 6, 16, 7, 0, -13 },
  { 1099, 1, 18, 9, 4, -14 },
  { 1102, 5, 16, 7, 1, -13 },
  { 1112, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD18PT7B_H_
