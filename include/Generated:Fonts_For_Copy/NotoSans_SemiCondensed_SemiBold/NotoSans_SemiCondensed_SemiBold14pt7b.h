#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xD9, 0x99, 0x12, 0x16, 0x14, 0x7F, 0x24, 0x24,
  0xFF, 0x2C, 0x28, 0x68, 0x20, 0xCF, 0xE8, 0xE3, 0xC3, 0x8B, 0xAF, 0xE2,
  0x08, 0x71, 0x8B, 0x23, 0x6C, 0x2D, 0x05, 0xFC, 0xEA, 0xC3, 0x48, 0x49,
  0x19, 0x62, 0x38, 0x78, 0xC8, 0xC8, 0x58, 0x70, 0xF3, 0x9A, 0x8E, 0xCE,
  0xFB, 0xEA, 0x6B, 0x49, 0x24, 0x99, 0x30, 0xC6, 0x23, 0x33, 0x33, 0x32,
  0x6C, 0x10, 0x21, 0x57, 0xF2, 0x8D, 0x80, 0x20, 0x8F, 0xFF, 0x20, 0x80,
  0x6D, 0x60, 0xFF, 0xF0, 0x08, 0xC4, 0x23, 0x11, 0x8C, 0x46, 0x00, 0x73,
  0x68, 0xE3, 0x8E, 0x38, 0xE3, 0xD9, 0xE0, 0x37, 0xF3, 0x33, 0x33, 0x33,
  0xFB, 0x60, 0xC2, 0x18, 0xC2, 0x10, 0xC3, 0xF0, 0xFA, 0x60, 0xC2, 0x71,
  0xE0, 0xC3, 0x9B, 0xE0, 0x0C, 0x38, 0x71, 0xE2, 0xC9, 0xBF, 0xFF, 0x0C,
  0x18, 0xFB, 0xEC, 0x30, 0xF8, 0x70, 0xC3, 0x9B, 0xC0, 0x39, 0x8C, 0x20,
  0xFB, 0x38, 0xE3, 0xCD, 0xE0, 0xFF, 0xFC, 0x10, 0x60, 0xC3, 0x06, 0x08,
  0x30, 0x60, 0x3C, 0xC9, 0x1B, 0x63, 0x8F, 0x91, 0xE3, 0x66, 0xF8, 0x38,
  0xD9, 0x1E, 0x34, 0x6F, 0xC1, 0x82, 0x0C, 0xF0, 0xF0, 0x0F, 0x6C, 0x00,
  0x1B, 0x58, 0x04, 0x33, 0xB8, 0xC0, 0xE0, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0x07, 0x07, 0x1D, 0xCC, 0x00, 0xFB, 0x60, 0xC2, 0x18, 0xC2, 0x00, 0x21,
  0xC0, 0x1E, 0x18, 0x64, 0x0A, 0x7B, 0xB2, 0x6C, 0x9B, 0x2E, 0x7E, 0xC0,
  0x18, 0x43, 0xF0, 0x18, 0x0E, 0x0D, 0x06, 0x82, 0x63, 0x31, 0xF8, 0xC6,
  0xC3, 0x60, 0xC0, 0xFD, 0x9B, 0x1E, 0x2F, 0x9B, 0xB1, 0xE3, 0xCD, 0xF8,
  0x3E, 0xCB, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x64, 0x78, 0xF8, 0xDE, 0xC6,
  0xC2, 0xC3, 0xC3, 0xC2, 0xC6, 0xDC, 0xF8, 0xFE, 0x31, 0x8F, 0xFF, 0x18,
  0xC7, 0xC0, 0xFE, 0x31, 0x8F, 0xFF, 0x18, 0xC6, 0x00, 0x3E, 0xE7, 0x06,
  0x0C, 0x19, 0xF0, 0xE1, 0x62, 0x7C, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0,
  0xE1, 0xC3, 0x84, 0xF2, 0x22, 0x22, 0x22, 0x2F, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3F, 0xE0, 0xC7, 0x9B, 0x66, 0xCF, 0x1F, 0x36, 0x66, 0xCD, 0x8C,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F,
  0xCF, 0xD2, 0xF4, 0xBD, 0xEF, 0x7B, 0xCC, 0xF3, 0x30, 0xE3, 0xE3, 0xF3,
  0xF3, 0xDB, 0xDB, 0xCF, 0xC7, 0xC7, 0xC3, 0x3C, 0x66, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xFB, 0x7C, 0xF1, 0xCF, 0xEC, 0x30, 0xC3,
  0x00, 0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x0C,
  0x07, 0xF9, 0xBB, 0x16, 0x2C, 0xDF, 0x36, 0x66, 0xCD, 0x8C, 0x7E, 0x61,
  0x8F, 0x1C, 0x61, 0x9F, 0x80, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x66, 0xF8, 0xC3,
  0xC3, 0x42, 0x66, 0x66, 0x24, 0x3C, 0x3C, 0x18, 0x18, 0xC6, 0x3C, 0x63,
  0x47, 0x36, 0xF2, 0x6D, 0x66, 0x96, 0x29, 0xE2, 0x9C, 0x38, 0xC3, 0x0C,
  0xC3, 0x66, 0x2C, 0x3C, 0x18, 0x18, 0x3C, 0x64, 0x66, 0xC3, 0xC3, 0x66,
  0x64, 0x2C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x08, 0x30, 0xC1,
  0x86, 0x0C, 0x30, 0x41, 0xFC, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC2, 0x18,
  0xC2, 0x18, 0x42, 0x18, 0x40, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10,
  0x30, 0xA1, 0x26, 0x58, 0xC0, 0xFC, 0xC8, 0x80, 0x73, 0xE0, 0x8F, 0xCE,
  0x39, 0xFB, 0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0x71, 0xC7, 0x3B, 0x80, 0x37,
  0xF1, 0x08, 0x63, 0x2F, 0x0C, 0x30, 0xDB, 0xFF, 0x38, 0xE3, 0xCF, 0x37,
  0x40, 0x33, 0xEC, 0xFF, 0xFE, 0x0C, 0x5E, 0x3B, 0xD8, 0xFF, 0xB1, 0x8C,
  0x63, 0x18, 0x67, 0xFC, 0xE3, 0x8F, 0x3C, 0xDF, 0x0E, 0x3F, 0x80, 0xC3,
  0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xB3, 0xFF, 0xFC, 0x23,
  0x03, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC1, 0x83, 0x06, 0x6C, 0x9B, 0x3C,
  0x78, 0xD9, 0x9B, 0x38, 0xFF, 0xFF, 0xFC, 0x99, 0xBF, 0xFC, 0xCF, 0x31,
  0xCC, 0x73, 0x1C, 0xC7, 0x31, 0x9B, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0x33,
  0xFC, 0xE3, 0x87, 0x3C, 0xDE, 0x9B, 0xFC, 0xF1, 0xC7, 0x1C, 0xFE, 0xC3,
  0x0C, 0x00, 0x67, 0xFC, 0xE3, 0x8F, 0x3C, 0xDF, 0x0C, 0x30, 0xC0, 0x9F,
  0xCC, 0xCC, 0xCC, 0x7F, 0xA1, 0xC7, 0x0E, 0x7E, 0x23, 0xFE, 0xC6, 0x31,
  0x8C, 0x38, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xDD, 0xC7, 0x8D, 0x13, 0x66,
  0xC5, 0x0E, 0x1C, 0xCC, 0x79, 0xC9, 0x3B, 0x35, 0x67, 0xA8, 0xF5, 0x0C,
  0xE1, 0x8C, 0xC6, 0xD9, 0xB1, 0xC3, 0x85, 0x1B, 0x63, 0xC7, 0x8D, 0x13,
  0x66, 0xC5, 0x0E, 0x0C, 0x10, 0x63, 0x80, 0x7D, 0xF1, 0x84, 0x31, 0x84,
  0x3F, 0x19, 0x88, 0x42, 0x73, 0x84, 0x21, 0x0C, 0x70, 0xFF, 0xFC, 0xCC,
  0x44, 0x47, 0x74, 0x44, 0x4C, 0xE6, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 12, 7, 1, -11 },
  { 25, 11, 10, 12, 0, -10 },
  { 39, 8, 10, 9, 1, -10 },
  { 49, 2, 4, 3, 1, -10 },
  { 50, 3, 12, 4, 1, -10 },
  { 55, 4, 12, 4, 0, -10 },
  { 61, 7, 6, 7, 0, -11 },
  { 67, 6, 6, 7, 1, -8 },
  { 72, 3, 4, 4, 0, -2 },
  { 74, 4, 2, 4, 0, -5 },
  { 75, 2, 2, 4, 1, -2 },
  { 76, 5, 10, 6, 0, -10 },
  { 83, 6, 10, 7, 1, -10 },
  { 91, 4, 10, 7, 1, -10 },
  { 96, 6, 10, 7, 1, -10 },
  { 104, 6, 10, 7, 1, -10 },
  { 112, 7, 10, 7, 0, -10 },
  { 121, 6, 10, 7, 1, -10 },
  { 129, 6, 10, 7, 1, -10 },
  { 137, 7, 10, 7, 0, -10 },
  { 146, 7, 10, 7, 0, -10 },
  { 155, 7, 10, 7, 0, -10 },
  { 164, 2, 8, 4, 1, -8 },
  { 166, 3, 10, 4, 0, -8 },
  { 170, 6, 7, 7, 1, -9 },
  { 176, 6, 4, 7, 1, -7 },
  { 179, 6, 7, 7, 1, -9 },
  { 185, 6, 10, 6, 0, -10 },
  { 193, 10, 11, 12, 1, -10 },
  { 207, 9, 10, 9, 0, -10 },
  { 219, 7, 10, 8, 1, -10 },
  { 228, 7, 10, 8, 1, -10 },
  { 237, 8, 10, 9, 1, -10 },
  { 247, 5, 10, 7, 1, -10 },
  { 254, 5, 10, 7, 1, -10 },
  { 261, 7, 10, 9, 1, -10 },
  { 270, 7, 10, 10, 1, -10 },
  { 279, 4, 10, 5, 0, -10 },
  { 284, 4, 13, 4, -1, -10 },
  { 291, 7, 10, 8, 1, -10 },
  { 300, 6, 10, 7, 1, -10 },
  { 308, 10, 10, 12, 1, -10 },
  { 321, 8, 10, 10, 1, -10 },
  { 331, 8, 10, 10, 1, -10 },
  { 341, 6, 10, 8, 1, -10 },
  { 349, 8, 12, 10, 1, -10 },
  { 361, 7, 10, 8, 1, -10 },
  { 370, 5, 10, 7, 1, -10 },
  { 377, 7, 10, 7, 0, -10 },
  { 386, 7, 10, 9, 1, -10 },
  { 395, 8, 10, 8, 0, -10 },
  { 405, 12, 10, 12, 0, -10 },
  { 420, 8, 10, 8, 0, -10 },
  { 430, 8, 10, 8, 0, -10 },
  { 440, 7, 10, 7, 0, -10 },
  { 449, 3, 12, 5, 1, -10 },
  { 454, 5, 10, 6, 0, -10 },
  { 461, 4, 12, 5, 0, -10 },
  { 467, 7, 6, 8, 0, -10 },
  { 473, 6, 1, 6, 0, 1 },
  { 474, 3, 3, 4, 1, -11 },
  { 476, 6, 8, 7, 1, -8 },
  { 482, 6, 11, 8, 1, -11 },
  { 491, 5, 8, 6, 1, -8 },
  { 496, 6, 11, 8, 1, -11 },
  { 505, 6, 8, 7, 1, -8 },
  { 511, 5, 11, 5, 0, -11 },
  { 518, 6, 11, 8, 1, -8 },
  { 527, 6, 11, 8, 1, -11 },
  { 536, 2, 11, 4, 1, -11 },
  { 539, 4, 14, 4, -1, -11 },
  { 546, 7, 11, 8, 1, -11 },
  { 556, 2, 11, 4, 1, -11 },
  { 559, 10, 8, 12, 1, -8 },
  { 569, 6, 8, 8, 1, -8 },
  { 575, 6, 8, 8, 1, -8 },
  { 581, 6, 11, 8, 1, -8 },
  { 590, 6, 11, 8, 1, -8 },
  { 599, 4, 8, 6, 1, -8 },
  { 603, 5, 8, 6, 1, -8 },
  { 608, 5, 9, 5, 0, -9 },
  { 614, 6, 8, 8, 1, -8 },
  { 620, 7, 8, 7, 0, -8 },
  { 627, 11, 8, 11, 0, -8 },
  { 638, 7, 8, 7, 0, -8 },
  { 645, 7, 11, 7, 0, -8 },
  { 655, 6, 8, 6, 0, -8 },
  { 661, 5, 12, 5, 0, -10 },
  { 669, 1, 14, 7, 3, -11 },
  { 671, 4, 12, 5, 1, -10 },
  { 677, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD14PT7B_H_
