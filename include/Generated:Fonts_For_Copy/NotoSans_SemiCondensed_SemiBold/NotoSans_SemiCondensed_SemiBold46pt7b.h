#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xEF, 0xDF, 0xBF, 0xFE, 0xFC, 0x20, 0xF8, 0x7F, 0xF0, 0xFB, 0xE1,
  0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF0, 0x7B, 0xE0, 0xF3, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x0F,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x77,
  0xEF, 0xC7, 0x04, 0xFC, 0x70, 0x0F, 0xC7, 0x00, 0xFC, 0x70, 0x0F, 0xC7,
  0x00, 0x7F, 0x70, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x77, 0xF0,
  0x07, 0x3F, 0x00, 0x71, 0xF0, 0x07, 0x1F, 0x80, 0x71, 0xFF, 0x07, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x07, 0xFF, 0x00,
  0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x80, 0x3E, 0x1E,
  0x03, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x7C, 0x00, 0xF0,
  0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC3, 0xC0, 0x03,
  0xC1, 0xE1, 0xF0, 0x00, 0xF0, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x3E, 0x3F,
  0x0F, 0x87, 0x8F, 0x1F, 0xE3, 0xE3, 0xE7, 0xCF, 0xFC, 0x7D, 0xF1, 0xE7,
  0xFF, 0x9F, 0xFC, 0xF9, 0xF1, 0xE3, 0xFE, 0x3C, 0x78, 0x7C, 0x7F, 0x1F,
  0x1E, 0x1F, 0x00, 0x07, 0x8F, 0x83, 0xC0, 0x03, 0xE3, 0xE0, 0xF0, 0x00,
  0xF0, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x83, 0xC0,
  0x0F, 0x83, 0xE0, 0xF0, 0x03, 0xC0, 0x78, 0x7C, 0x01, 0xF0, 0x1E, 0x1F,
  0x00, 0x78, 0x07, 0xC7, 0x80, 0x3E, 0x01, 0xFB, 0xE0, 0x0F, 0x00, 0x3F,
  0xF8, 0x07, 0xC0, 0x07, 0xFC, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xE1,
  0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0x81, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xE1,
  0xF8, 0xFC, 0x7E, 0x0F, 0xE7, 0xC3, 0xF0, 0x3F, 0xFE, 0x1F, 0x80, 0xFF,
  0xF0, 0xFC, 0x03, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x81,
  0xFC, 0x07, 0xFE, 0x07, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x20, 0x7C, 0x09, 0xE1, 0xC3, 0xCF, 0xEE, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xEF, 0x00, 0x1F, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3E,
  0x01, 0xC1, 0xC0, 0x02, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE3, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x3F, 0x9F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF3, 0xF7, 0xDF, 0xBF, 0xFC, 0xFD, 0xE3, 0xF3, 0x0F, 0xC8, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xC0, 0xFE, 0x30, 0x07, 0xE2, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x3F,
  0xE3, 0x80, 0x7E, 0x20, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7E, 0xF8, 0x3F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xE0,
  0x07, 0xDF, 0x80, 0x1E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xC7, 0xE0, 0x1F,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x78, 0x07, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE1, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xEC, 0x00, 0xFE, 0xFC, 0x3F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0x84, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x7C, 0xFF, 0xC3, 0xEF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xDF, 0xE7, 0xF0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xC0, 0x1F,
  0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x80, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xF0, 0xFE, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x7E,
  0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF9,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0xFE, 0x1F, 0xC7, 0xE0, 0x7E, 0x7E, 0x01,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xE0, 0x7F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xBF, 0xC7, 0xE0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x7F, 0x1F,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x20, 0x7F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7D, 0xFB, 0xF7, 0xFF, 0xDF, 0x8C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xDF,
  0xBF, 0xFE, 0xFC, 0x20, 0x1F, 0x1F, 0x8F, 0xC7, 0xF3, 0xF1, 0xF8, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0xC3, 0xC3, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0x7F, 0xCC, 0x03,
  0xF2, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0xFF, 0xC3, 0xE3, 0xC0,
  0xFF, 0xF8, 0x78, 0xF0, 0x7F, 0xFE, 0x1E, 0x7C, 0x3F, 0x0F, 0x87, 0x9E,
  0x0F, 0x83, 0xE1, 0xF7, 0x87, 0xC0, 0xF8, 0x3F, 0xE1, 0xF0, 0x3C, 0x0F,
  0xF8, 0x78, 0x0F, 0x03, 0xFC, 0x1E, 0x03, 0xC0, 0xFF, 0x07, 0x80, 0xF0,
  0x7F, 0xC1, 0xE0, 0x3C, 0x1E, 0xF0, 0x78, 0x0F, 0x07, 0xBC, 0x1E, 0x07,
  0xC1, 0xEF, 0x87, 0xC1, 0xF0, 0x7B, 0xE1, 0xF0, 0xFE, 0x3C, 0x78, 0x3F,
  0xFF, 0xFF, 0x1E, 0x07, 0xFC, 0xFF, 0x87, 0xC1, 0xFE, 0x1F, 0xC1, 0xF0,
  0x1F, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x1F, 0xCF, 0x80, 0x3F, 0xBE, 0x00, 0x7E,
  0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0xFC, 0xF8,
  0x03, 0xF3, 0xE0, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0x80, 0xFF, 0x3E, 0x00, 0xFE, 0xF8, 0x01, 0xFB,
  0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x03, 0x87, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x20, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8,
  0x0F, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFE, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xF8,
  0x01, 0xFC, 0xF8, 0x03, 0xFC, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xE0, 0x0E, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0xC0, 0x1F, 0x1F, 0xFD, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF,
  0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xDF, 0xFB, 0xC0, 0x07, 0xDF, 0xFB, 0xE0,
  0x07, 0xDF, 0xFB, 0xE0, 0x07, 0x9F, 0xFB, 0xE0, 0x0F, 0x9F, 0xF9, 0xF0,
  0x0F, 0xBF, 0xF9, 0xF0, 0x0F, 0x3F, 0xF9, 0xF0, 0x1F, 0x3F, 0xF8, 0xF8,
  0x1F, 0x3F, 0xF8, 0xF8, 0x1E, 0x3F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF8, 0x7C,
  0x3E, 0x3F, 0xF8, 0x7C, 0x3C, 0x3F, 0xF8, 0x7C, 0x7C, 0x3F, 0xF8, 0x3C,
  0x7C, 0x3F, 0xF8, 0x3E, 0x78, 0x3F, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFD, 0xF8, 0x07, 0xFE, 0xFC, 0x03, 0xFF, 0x3F, 0x01, 0xFF,
  0x9F, 0xC0, 0xFF, 0xC7, 0xE0, 0x7F, 0xE1, 0xF8, 0x3F, 0xF0, 0xFC, 0x1F,
  0xF8, 0x3F, 0x0F, 0xFC, 0x1F, 0x87, 0xFE, 0x07, 0xE3, 0xFF, 0x03, 0xF1,
  0xFF, 0x80, 0xFC, 0xFF, 0xC0, 0x7E, 0x7F, 0xE0, 0x1F, 0xBF, 0xF0, 0x0F,
  0xDF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0x81, 0xFE, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xEF, 0x81, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0x01, 0xFC, 0x3E, 0x01, 0xFC, 0x7C, 0x01, 0xF8,
  0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F,
  0x80, 0x3F, 0x1F, 0x00, 0xFE, 0x3E, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x83,
  0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x1F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFC, 0x03, 0xBF, 0x00, 0x17, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xFE,
  0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x00,
  0x3E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x3E,
  0x00, 0xFF, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0x80, 0x7C, 0x3F, 0x01, 0xFF,
  0x80, 0x7C, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xE7, 0x80, 0xFC,
  0x1F, 0x01, 0xE7, 0xC0, 0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x0F, 0x83, 0xC3, 0xC1,
  0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0x0F,
  0xC7, 0xC3, 0xE3, 0xF0, 0x07, 0xC7, 0xC1, 0xE3, 0xF0, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xEF, 0x81, 0xF3, 0xE0,
  0x03, 0xEF, 0x80, 0xF7, 0xE0, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x78, 0x00, 0xF1, 0xF0, 0x01,
  0xF7, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0xFE, 0x20, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x79, 0xFF, 0xCF, 0x1F, 0xE1, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x1F, 0xC1, 0xFB, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFE,
  0x3F, 0xDF, 0xE0, 0x7E, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFB, 0xFE, 0x1F, 0xDF, 0xFF, 0xFC, 0xFB, 0xFF,
  0xE7, 0xCF, 0xFE, 0x3E, 0x3F, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xF1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xC7, 0x9F, 0xC0, 0x27, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x02, 0x3F, 0xC7, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0xFE, 0x3E, 0x1F, 0xF9, 0xF1, 0xFF,
  0xEF, 0x9F, 0xFF, 0xFC, 0xFE, 0x3F, 0xEF, 0xE0, 0x7F, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x81, 0xFC, 0xFE, 0x3F,
  0xE7, 0xFF, 0xFF, 0x1F, 0xFE, 0xF8, 0x7F, 0xE7, 0xC1, 0xFE, 0x1E, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0,
  0x0F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x23, 0xF8, 0x0E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xEE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xF8, 0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F,
  0xFF, 0xF3, 0xF8, 0xFF, 0xBF, 0x81, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xFF,
  0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0x9F, 0x07, 0xF8, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0xC0, 0x1F,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0xE1, 0xFB, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0x7E, 0xFE, 0x01, 0xF7, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x33, 0xFF,
  0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFB, 0xFF,
  0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xBF,
  0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00,
  0xFD, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0x7E, 0x03, 0xF9, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xFF, 0x83,
  0xFE, 0x3E, 0x7F, 0xF1, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0x3F, 0xBF, 0xC1, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x7F, 0x87, 0xCF,
  0xFE, 0x3E, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0x7F, 0x81, 0xFB,
  0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E,
  0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xF8,
  0x7F, 0x07, 0xCF, 0xFE, 0x3E, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF8, 0xFF,
  0x7F, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xEF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xBF, 0xF8, 0xFC, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFF, 0xF3, 0xF8, 0xFF, 0xBF,
  0x81, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7E,
  0xFE, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF,
  0x9F, 0x07, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x7F, 0xF1,
  0xFF, 0xE7, 0xF7, 0xDF, 0xEF, 0xFF, 0xDF, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xC0, 0xE7, 0xC0, 0x13, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xFF, 0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F,
  0xF8, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x84, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0x7F, 0x1F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFE, 0xF3, 0xFF, 0xCF, 0x0F,
  0xF0, 0xF0, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0x00, 0xF9, 0xF8,
  0x0F, 0xE0, 0x1F, 0x3F, 0x01, 0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0xC0, 0xFC,
  0x7C, 0x0F, 0x78, 0x1F, 0x0F, 0xC1, 0xEF, 0x03, 0xE1, 0xF8, 0x3D, 0xE0,
  0xFC, 0x1F, 0x0F, 0xBE, 0x1F, 0x83, 0xE1, 0xF3, 0xC3, 0xE0, 0x7C, 0x3C,
  0x78, 0x7C, 0x0F, 0xC7, 0x8F, 0x1F, 0x80, 0xF9, 0xF1, 0xF3, 0xE0, 0x1F,
  0x3E, 0x1E, 0x7C, 0x03, 0xE7, 0x83, 0xCF, 0x80, 0x7C, 0xF0, 0x79, 0xF0,
  0x07, 0xDE, 0x0F, 0x7C, 0x00, 0xFB, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01,
  0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x3F, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0,
  0x7F, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00,
  0x1E, 0x00, 0x0B, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFA, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 34, 12, 3, -33 },
  { 31, 15, 12, 20, 3, -33 },
  { 54, 25, 33, 27, 1, -33 },
  { 158, 20, 38, 24, 2, -35 },
  { 253, 34, 33, 38, 2, -33 },
  { 394, 29, 33, 31, 2, -33 },
  { 514, 5, 12, 11, 3, -33 },
  { 522, 11, 40, 15, 2, -33 },
  { 577, 12, 40, 15, 1, -33 },
  { 637, 21, 20, 23, 1, -35 },
  { 690, 20, 22, 24, 2, -27 },
  { 745, 7, 11, 12, 2, -5 },
  { 755, 12, 5, 14, 1, -15 },
  { 763, 6, 7, 12, 3, -6 },
  { 769, 18, 33, 18, 0, -33 },
  { 844, 20, 33, 24, 2, -33 },
  { 927, 14, 33, 24, 3, -33 },
  { 985, 20, 33, 24, 2, -33 },
  { 1068, 20, 33, 24, 2, -33 },
  { 1151, 22, 33, 24, 1, -33 },
  { 1242, 20, 33, 24, 2, -33 },
  { 1325, 21, 33, 24, 2, -33 },
  { 1412, 22, 33, 24, 1, -33 },
  { 1503, 21, 33, 24, 2, -33 },
  { 1590, 20, 33, 24, 2, -33 },
  { 1673, 7, 26, 12, 3, -25 },
  { 1696, 9, 31, 12, 1, -25 },
  { 1731, 20, 23, 24, 2, -28 },
  { 1789, 20, 13, 24, 2, -23 },
  { 1822, 21, 23, 24, 2, -28 },
  { 1883, 18, 34, 19, 0, -33 },
  { 1960, 34, 37, 38, 2, -33 },
  { 2118, 28, 33, 28, 0, -33 },
  { 2234, 22, 33, 28, 4, -33 },
  { 2325, 23, 33, 27, 2, -33 },
  { 2420, 24, 33, 30, 4, -33 },
  { 2519, 17, 33, 23, 4, -33 },
  { 2590, 17, 33, 23, 4, -33 },
  { 2661, 24, 33, 31, 3, -33 },
  { 2760, 24, 33, 32, 4, -33 },
  { 2859, 13, 33, 16, 1, -33 },
  { 2913, 12, 42, 13, -3, -33 },
  { 2976, 23, 33, 27, 4, -33 },
  { 3071, 17, 33, 23, 4, -33 },
  { 3142, 32, 33, 40, 4, -33 },
  { 3274, 25, 33, 33, 4, -33 },
  { 3378, 28, 33, 33, 2, -33 },
  { 3494, 20, 33, 26, 4, -33 },
  { 3577, 28, 41, 33, 2, -33 },
  { 3721, 23, 33, 27, 4, -33 },
  { 3816, 19, 33, 23, 2, -33 },
  { 3895, 22, 33, 24, 1, -33 },
  { 3986, 23, 33, 31, 4, -33 },
  { 4081, 27, 33, 27, 0, -33 },
  { 4193, 40, 33, 40, 0, -33 },
  { 4358, 26, 33, 26, 0, -33 },
  { 4466, 25, 33, 25, 0, -33 },
  { 4570, 21, 33, 23, 1, -33 },
  { 4657, 11, 40, 15, 3, -33 },
  { 4712, 18, 33, 18, 0, -33 },
  { 4787, 11, 40, 15, 1, -33 },
  { 4842, 23, 20, 25, 1, -33 },
  { 4900, 20, 3, 19, 0, 4 },
  { 4908, 11, 7, 15, 2, -35 },
  { 4918, 19, 25, 25, 2, -25 },
  { 4978, 21, 35, 26, 3, -35 },
  { 5070, 18, 25, 21, 2, -25 },
  { 5127, 21, 35, 26, 2, -35 },
  { 5219, 21, 25, 24, 2, -25 },
  { 5285, 16, 35, 16, 1, -35 },
  { 5355, 21, 36, 26, 2, -25 },
  { 5450, 21, 35, 27, 3, -35 },
  { 5542, 6, 35, 12, 3, -35 },
  { 5569, 11, 46, 12, -2, -35 },
  { 5633, 22, 35, 25, 3, -35 },
  { 5730, 6, 35, 12, 3, -35 },
  { 5757, 34, 25, 40, 3, -25 },
  { 5864, 21, 25, 27, 3, -25 },
  { 5930, 22, 25, 26, 2, -25 },
  { 5999, 21, 36, 26, 3, -25 },
  { 6094, 21, 36, 26, 2, -25 },
  { 6189, 15, 25, 18, 3, -25 },
  { 6236, 17, 25, 20, 2, -25 },
  { 6290, 15, 30, 17, 1, -30 },
  { 6347, 20, 25, 27, 3, -25 },
  { 6410, 23, 25, 23, 0, -25 },
  { 6482, 35, 25, 35, 0, -25 },
  { 6592, 23, 25, 23, 0, -25 },
  { 6664, 23, 36, 23, 0, -25 },
  { 6768, 17, 25, 20, 1, -25 },
  { 6822, 15, 40, 17, 1, -33 },
  { 6897, 5, 46, 23, 9, -35 },
  { 6926, 14, 40, 17, 2, -33 },
  { 6996, 21, 7, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD46PT7B_H_
