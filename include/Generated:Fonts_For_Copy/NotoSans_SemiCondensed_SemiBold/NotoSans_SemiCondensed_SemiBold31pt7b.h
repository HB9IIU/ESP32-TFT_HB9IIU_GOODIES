#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x70, 0x00, 0xFF, 0xFF,
  0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xEE, 0x3B, 0x86, 0x03, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xC1, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x00,
  0xC7, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x1C, 0x60, 0x0C, 0x30,
  0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x03, 0xFC, 0x3F, 0xFD, 0xFF, 0xE7, 0xB1, 0xBC, 0xC0, 0xF3,
  0x01, 0xEC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xDF, 0x03, 0x3C, 0x0C, 0xFC, 0x33, 0xFE, 0xFE, 0xFF, 0xF9, 0xFF, 0x80,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x01, 0xE0, 0xFE, 0x03,
  0x81, 0xCE, 0x0E, 0x07, 0x1C, 0x1C, 0x0E, 0x38, 0x70, 0x1C, 0x70, 0xE0,
  0x38, 0xE3, 0x80, 0x71, 0xC7, 0x00, 0xE3, 0x9C, 0x21, 0xC7, 0x39, 0xF9,
  0xCE, 0xE7, 0xF3, 0xF9, 0xCE, 0x73, 0xF7, 0x38, 0xE0, 0x0E, 0x71, 0xC0,
  0x38, 0xE3, 0x80, 0x71, 0xC7, 0x01, 0xE3, 0x8E, 0x03, 0x87, 0x1C, 0x07,
  0x0E, 0x38, 0x1C, 0x0E, 0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x1F, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x38, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x23, 0xFC, 0x1C, 0x7D, 0xE3, 0xC7, 0x9F, 0x3C, 0xF0, 0xFF,
  0x8F, 0x07, 0xF8, 0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0x78, 0x3F, 0x07, 0xFF,
  0xF8, 0x3F, 0xFB, 0xC1, 0xFE, 0x3F, 0xFF, 0xEE, 0xEE, 0xEE, 0x0F, 0x0E,
  0x1C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E,
  0x0F, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xC7,
  0x0B, 0xEF, 0xEF, 0xFF, 0x9F, 0xFF, 0x0F, 0x80, 0x7F, 0x01, 0xDE, 0x0F,
  0x3C, 0x38, 0xE0, 0x21, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x7B, 0xDE, 0xF7, 0x3B,
  0xDC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1E, 0x1E, 0x78, 0x79,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x3D, 0xE1, 0xE7, 0xC7,
  0x8F, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x03, 0x87, 0xC7, 0xE7, 0xF7, 0xBF,
  0x9D, 0x8E, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x9C, 0x1E, 0x20, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3,
  0xFF, 0xC7, 0xFF, 0x98, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x37, 0x00, 0xEE,
  0x03, 0xDC, 0x07, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0xE3, 0xC3, 0xC7, 0x87,
  0x0F, 0x1C, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0x87, 0xFF, 0x3F,
  0xFC, 0xC3, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xA0, 0x7D, 0xFF, 0xCF, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE1, 0xFF,
  0x8F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x73, 0xE3, 0xDF,
  0xEF, 0xFF, 0xBE, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70,
  0x3D, 0xE0, 0xF7, 0xC7, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x70, 0x3D, 0xC0, 0xF7,
  0x83, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x07, 0xFC, 0x3C, 0xF9,
  0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xDF, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0xF0,
  0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0xDF,
  0xFF, 0x3F, 0xFC, 0x7E, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x1F, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0x60, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x7B, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3D, 0xEF, 0x7B, 0x9D, 0xCE, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x03, 0xE0, 0x0C, 0x00, 0x20, 0x00, 0x3F, 0xCF, 0xFE, 0x7F, 0xF6, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0,
  0x1F, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0x07, 0xC0,
  0x78, 0x03, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x1F, 0xE7, 0x38,
  0x7F, 0xC7, 0x71, 0xE3, 0x8E, 0xE3, 0x87, 0x1D, 0xCE, 0x0E, 0x3B, 0x1C,
  0x1C, 0x7E, 0x38, 0x38, 0xFC, 0x70, 0x71, 0xD8, 0xE1, 0xE3, 0xB8, 0xE3,
  0xCE, 0x71, 0xFD, 0xFC, 0xE1, 0xF9, 0xF1, 0xE0, 0xC0, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x18, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x07, 0x01, 0xE0, 0xF0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x0F,
  0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x03, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xB8, 0x3E, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x1E, 0xE0, 0xFB,
  0xFF, 0xCF, 0xFC, 0x3F, 0xFE, 0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xFC, 0xFF, 0xF1, 0xF0, 0x67, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x11, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0xFC, 0xE0, 0x3E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0,
  0x1E, 0xE0, 0x3E, 0xE0, 0x7C, 0xE1, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3E, 0x02, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78,
  0x07, 0x7C, 0x07, 0x3E, 0x07, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xDF, 0xC7, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0xEF, 0xFF, 0xFC, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFC,
  0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xE7, 0x07, 0xCE, 0x0F, 0x1C, 0x3C, 0x38,
  0xF0, 0x73, 0xE0, 0xE7, 0x81, 0xDE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x1E, 0x78, 0x38, 0x78, 0x70, 0xF8, 0xE0, 0xF1, 0xC1, 0xF3, 0x81, 0xE7,
  0x01, 0xEE, 0x03, 0xDC, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xDF, 0xB8, 0x0E, 0xFD, 0xC0, 0xF7, 0xEF, 0x07,
  0x3F, 0x38, 0x39, 0xF9, 0xC3, 0xCF, 0xCF, 0x1C, 0x7E, 0x38, 0xE3, 0xF1,
  0xCF, 0x1F, 0x8F, 0x70, 0xFC, 0x3B, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x03, 0xF0, 0x78, 0x1C, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xBC, 0x1F, 0xDE, 0x0F, 0xE7, 0x87, 0xF3, 0xE3, 0xF8, 0xF1, 0xFC, 0x3C,
  0xFE, 0x1E, 0x7F, 0x07, 0xBF, 0x83, 0xDF, 0xC0, 0xFF, 0xE0, 0x7B, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7C, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0xBE, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07,
  0x9E, 0x01, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xC3, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0xFD, 0xFF, 0xEF, 0xFC, 0x7F, 0x83, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0xBE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0x78, 0x07, 0xDE, 0x01, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x07, 0xCE, 0x07, 0x9C, 0x0F,
  0x38, 0x1E, 0x70, 0x3C, 0xE0, 0x79, 0xC1, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFC, 0x1C, 0x78, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0xF1, 0xC1, 0xF3, 0x81,
  0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x07, 0xC0, 0x1F, 0xF1, 0xFF, 0xDF, 0xFE,
  0xF0, 0x67, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03,
  0xF8, 0x3F, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x0F, 0x78,
  0x0F, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xF0, 0x03, 0xDC,
  0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x0E, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x1C, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x38, 0x70,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF0,
  0x0E, 0x01, 0xFE, 0x03, 0xE0, 0x3D, 0xC0, 0x7C, 0x07, 0x3C, 0x0F, 0x81,
  0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x77, 0x07, 0x8E, 0x0E, 0xE0, 0xE1, 0xE1,
  0xDC, 0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x8F, 0x78, 0xF0, 0x71, 0xC7, 0x1E,
  0x0E, 0x38, 0xE3, 0x81, 0xE7, 0x1C, 0xF0, 0x3D, 0xE3, 0xDE, 0x07, 0xB8,
  0x3B, 0xC0, 0x77, 0x07, 0x70, 0x0E, 0xE0, 0xEE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x00, 0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x07, 0xC3, 0xC3, 0xC1, 0xE3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3D, 0xE0, 0x1E, 0x78,
  0x1E, 0x3C, 0x0F, 0x0F, 0x0F, 0x07, 0x8F, 0x81, 0xE7, 0x80, 0xFF, 0xC0,
  0x3C, 0xF0, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xB8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xDC, 0x07,
  0x3C, 0x0E, 0x38, 0x38, 0x78, 0x70, 0x71, 0xC0, 0xF3, 0x80, 0xEE, 0x01,
  0xFC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0xE1, 0xFF, 0x8F, 0xFE, 0x20, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE3,
  0xFF, 0x3F, 0xFB, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3D, 0xFF,
  0xEF, 0xF7, 0x3F, 0x18, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xF7, 0xF3, 0xFF, 0xEF, 0xC7, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0x39, 0xF8, 0x07, 0xF1,
  0xFF, 0x3F, 0xF7, 0xC2, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0xC1, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x87, 0xCF, 0x1F, 0xDE, 0x7F, 0xFD, 0xF1, 0xFB, 0xC1, 0xF7, 0x81,
  0xEE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x7B,
  0xC1, 0xF7, 0xC3, 0xE7, 0xFF, 0xCF, 0xF7, 0x8F, 0xCF, 0x0F, 0xE0, 0x7F,
  0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0, 0xF7, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x23, 0xFF, 0x87,
  0xFE, 0x0F, 0xF8, 0x03, 0xC0, 0xFF, 0x0F, 0xE1, 0xF2, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xFC, 0xFF, 0xCF, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xE3, 0xF7, 0x83,
  0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B,
  0xC0, 0xF7, 0x83, 0xEF, 0x87, 0xCF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE4, 0x03, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0xF8, 0xF7, 0xFB, 0xFF, 0xEF, 0xC7, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF6, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0x60, 0x00, 0x07,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xDF, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1E,
  0xF0, 0x79, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC1, 0xF7, 0x83, 0xC7, 0x87, 0x87, 0x8F, 0x0F,
  0x1E, 0x0F, 0x3C, 0x1F, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xF9, 0xDF, 0xE7, 0xFB,
  0xFF, 0xFF, 0xF7, 0xE3, 0xF1, 0xFF, 0x87, 0xC1, 0xFE, 0x07, 0x83, 0xFC,
  0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0,
  0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E,
  0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1E, 0xE3, 0xE3, 0x9F, 0xEF, 0xFF,
  0xBF, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3C, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x83, 0xCF, 0x03,
  0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC0, 0xF7,
  0x81, 0xCF, 0x87, 0x8F, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0, 0xE3, 0xE3, 0xDF,
  0xCF, 0xFF, 0xBE, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xBF,
  0xFC, 0xF3, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xE3, 0xF7, 0x83,
  0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B,
  0xC0, 0xF7, 0x83, 0xEF, 0x87, 0xCF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xE3, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0xC7,
  0xFE, 0x7F, 0xEF, 0x04, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xE0, 0x0F, 0x00, 0xFC, 0x0E, 0xFF, 0xEF, 0xFE, 0x7F, 0x80,
  0x18, 0x0E, 0x03, 0x81, 0xFE, 0xFF, 0xBF, 0xE3, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xF3, 0xFC,
  0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xE1, 0xF7, 0xFF, 0xDF, 0xF7, 0x3F, 0x9C, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0,
  0x7B, 0xC1, 0xE7, 0x83, 0xC7, 0x87, 0x8F, 0x0E, 0x1E, 0x3C, 0x1C, 0x78,
  0x3C, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0xE0, 0xF8, 0x3D, 0xE1, 0xF8, 0x7B,
  0xC3, 0xF0, 0xF7, 0x87, 0xE1, 0xC7, 0x1D, 0xC7, 0x8F, 0x39, 0x8F, 0x1E,
  0x73, 0x9E, 0x3C, 0xE7, 0x38, 0x3B, 0x8E, 0xF0, 0x77, 0x1D, 0xE0, 0xFE,
  0x1B, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1,
  0xF0, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0xF0, 0x78, 0xF0, 0xF1, 0xF3, 0xC1,
  0xE7, 0x81, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x77, 0x81, 0xE7, 0x87, 0x8F, 0x0F, 0x0F, 0x3C, 0x1E, 0xF8, 0x1E,
  0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x8F,
  0x0E, 0x0E, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x87, 0xC7,
  0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x8F, 0x87,
  0x83, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x0F, 0x87, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3F, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x7C, 0x0F, 0xC0, 0xF0, 0xFC, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0xFC, 0x3E,
  0x0E, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 10, 8, 14, 2, -22 },
  { 22, 17, 22, 18, 1, -22 },
  { 69, 14, 26, 16, 1, -24 },
  { 115, 23, 22, 25, 1, -22 },
  { 179, 20, 22, 21, 1, -22 },
  { 234, 4, 8, 7, 2, -22 },
  { 238, 8, 27, 10, 1, -22 },
  { 265, 8, 27, 10, 1, -22 },
  { 292, 14, 14, 16, 1, -24 },
  { 317, 14, 15, 16, 1, -18 },
  { 344, 5, 8, 8, 1, -4 },
  { 349, 8, 3, 10, 1, -10 },
  { 352, 4, 4, 8, 2, -4 },
  { 354, 12, 22, 12, 0, -22 },
  { 387, 14, 22, 16, 1, -22 },
  { 426, 9, 22, 16, 2, -22 },
  { 451, 14, 22, 16, 1, -22 },
  { 490, 14, 22, 16, 1, -22 },
  { 529, 15, 22, 16, 1, -22 },
  { 571, 13, 22, 16, 2, -22 },
  { 607, 14, 22, 16, 1, -22 },
  { 646, 14, 22, 16, 1, -22 },
  { 685, 14, 22, 16, 1, -22 },
  { 724, 14, 22, 16, 1, -22 },
  { 763, 4, 17, 8, 2, -17 },
  { 772, 5, 21, 8, 1, -17 },
  { 786, 14, 16, 16, 1, -19 },
  { 814, 14, 9, 16, 1, -15 },
  { 830, 14, 16, 16, 1, -19 },
  { 858, 12, 22, 13, 0, -22 },
  { 891, 23, 25, 26, 1, -22 },
  { 963, 19, 22, 19, 0, -22 },
  { 1016, 14, 22, 19, 3, -22 },
  { 1055, 15, 22, 18, 2, -22 },
  { 1097, 16, 22, 21, 3, -22 },
  { 1141, 11, 22, 16, 3, -22 },
  { 1172, 11, 22, 15, 3, -22 },
  { 1203, 16, 22, 21, 2, -22 },
  { 1247, 16, 22, 21, 3, -22 },
  { 1291, 9, 22, 11, 1, -22 },
  { 1316, 8, 28, 9, -2, -22 },
  { 1344, 15, 22, 18, 3, -22 },
  { 1386, 11, 22, 15, 3, -22 },
  { 1417, 21, 22, 27, 3, -22 },
  { 1475, 17, 22, 22, 3, -22 },
  { 1522, 18, 22, 22, 2, -22 },
  { 1572, 13, 22, 17, 3, -22 },
  { 1608, 18, 27, 22, 2, -22 },
  { 1669, 15, 22, 18, 3, -22 },
  { 1711, 13, 22, 16, 1, -22 },
  { 1747, 15, 22, 16, 0, -22 },
  { 1789, 16, 22, 21, 2, -22 },
  { 1833, 18, 22, 18, 0, -22 },
  { 1883, 27, 22, 27, 0, -22 },
  { 1958, 17, 22, 18, 0, -22 },
  { 2005, 17, 22, 17, 0, -22 },
  { 2052, 14, 22, 16, 1, -22 },
  { 2091, 7, 27, 10, 2, -22 },
  { 2115, 12, 22, 12, 0, -22 },
  { 2148, 7, 27, 10, 1, -22 },
  { 2172, 15, 14, 17, 1, -22 },
  { 2199, 13, 2, 13, 0, 3 },
  { 2203, 8, 5, 10, 1, -24 },
  { 2208, 13, 17, 17, 1, -17 },
  { 2236, 14, 24, 18, 2, -24 },
  { 2278, 12, 17, 14, 1, -17 },
  { 2304, 15, 24, 18, 1, -24 },
  { 2349, 14, 17, 16, 1, -17 },
  { 2379, 12, 24, 10, 0, -24 },
  { 2415, 15, 24, 18, 1, -17 },
  { 2460, 14, 24, 18, 2, -24 },
  { 2502, 4, 23, 8, 2, -23 },
  { 2514, 7, 30, 8, -1, -23 },
  { 2541, 15, 24, 17, 2, -24 },
  { 2586, 4, 24, 8, 2, -24 },
  { 2598, 23, 17, 27, 2, -17 },
  { 2647, 14, 17, 18, 2, -17 },
  { 2677, 15, 17, 17, 1, -17 },
  { 2709, 14, 24, 18, 2, -17 },
  { 2751, 15, 24, 18, 1, -17 },
  { 2796, 10, 17, 12, 2, -17 },
  { 2818, 12, 17, 14, 1, -17 },
  { 2844, 10, 20, 11, 1, -20 },
  { 2869, 14, 17, 18, 2, -17 },
  { 2899, 15, 17, 15, 0, -17 },
  { 2931, 23, 17, 24, 0, -17 },
  { 2980, 15, 17, 16, 0, -17 },
  { 3012, 15, 24, 16, 0, -17 },
  { 3057, 11, 17, 13, 1, -17 },
  { 3081, 9, 27, 12, 1, -22 },
  { 3112, 3, 31, 16, 6, -24 },
  { 3124, 10, 27, 12, 1, -22 },
  { 3158, 14, 4, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD31PT7B_H_
