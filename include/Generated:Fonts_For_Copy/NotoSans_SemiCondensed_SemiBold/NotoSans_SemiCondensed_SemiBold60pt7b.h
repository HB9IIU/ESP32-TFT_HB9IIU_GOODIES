#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFF, 0x0F, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0,
  0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF,
  0x79, 0xFC, 0xFF, 0x1E, 0x06, 0x3F, 0x87, 0x80, 0x0F, 0xE1, 0xE0, 0x03,
  0xF8, 0x78, 0x00, 0xFE, 0x1E, 0x00, 0x3F, 0x87, 0x80, 0x0F, 0xF9, 0xE0,
  0x01, 0xFF, 0x78, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0x9F,
  0xF0, 0x01, 0xE3, 0xFC, 0x00, 0x78, 0x7F, 0x00, 0x1E, 0x1F, 0xC0, 0x07,
  0x87, 0xF8, 0x01, 0xE1, 0xFF, 0x00, 0x78, 0xFF, 0xF8, 0x1E, 0x7F, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x1F, 0x87, 0xF8, 0x1F, 0x03, 0xF1, 0xF8,
  0x7F, 0xE0, 0xFC, 0x1F, 0x0F, 0xC7, 0xFF, 0x87, 0xE1, 0xF8, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x7E, 0x3F, 0x0F,
  0xC3, 0xFF, 0xE3, 0xF1, 0xF8, 0x7E, 0x0F, 0xFE, 0x3F, 0x0F, 0x81, 0xF8,
  0x3F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x00, 0xFF,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0xEF, 0xF8, 0x0F, 0xE0, 0xFF, 0x1F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFC, 0x1F, 0xE0, 0x7F, 0xCF, 0xF0,
  0x7F, 0x00, 0xFF, 0xBF, 0xC3, 0xFC, 0x01, 0xFF, 0xFE, 0x0F, 0xF0, 0x03,
  0xFF, 0xF8, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x01, 0x00, 0xFC, 0x01, 0x70, 0x3F, 0x03, 0x9F, 0xC7,
  0x8F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x03,
  0xC0, 0x70, 0x00, 0x20, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xF3, 0xFC,
  0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C,
  0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E,
  0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x1F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0xF7, 0xFF, 0xF9, 0xFD, 0xFC, 0x7F,
  0x7E, 0x1F, 0xCE, 0x07, 0xF1, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xE1, 0xF0, 0x03,
  0xFC, 0x1C, 0x00, 0x3F, 0xC1, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0xE0,
  0xE0, 0x03, 0xFE, 0x10, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x60, 0x00,
  0x3F, 0xEF, 0x00, 0x0F, 0xFD, 0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x80, 0x01, 0xF9, 0xFE, 0x00, 0x07, 0xE7,
  0xF8, 0x00, 0x3F, 0x1F, 0xE0, 0x01, 0xF8, 0x7F, 0x80, 0x07, 0xE1, 0xFE,
  0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0x80,
  0x3F, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xF8, 0x1F, 0x80,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xE0,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFB, 0x00, 0x03, 0xFE, 0xF0, 0x01, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x04, 0x00, 0x7F, 0x0F, 0xF8, 0x0F, 0xE7, 0xFF, 0xC1, 0xF9,
  0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF,
  0xBF, 0xF8, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE1,
  0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xCF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F,
  0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFE, 0x01, 0xFF,
  0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0xC0,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x07, 0xFE, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xEF, 0xE1, 0xFF,
  0xF9, 0xFC, 0x0F, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x38, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x1F, 0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3E, 0x01, 0xFE, 0x18, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F,
  0xFF, 0xF0, 0x7C, 0x3F, 0x01, 0xFF, 0xFF, 0x07, 0xE7, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3E, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0x7E, 0x03, 0xF0,
  0x3E, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xEF, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x03, 0xE0, 0x3F, 0xF8,
  0x1F, 0x80, 0x3E, 0x03, 0xFF, 0x81, 0xF8, 0x03, 0xE0, 0x3E, 0xF8, 0x1F,
  0x80, 0x3E, 0x03, 0xEF, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xEF, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xEF, 0xC0, 0xF8, 0x0F, 0xE0, 0x7C, 0xFC, 0x0F, 0xC0, 0xFF, 0x0F,
  0xCF, 0xC0, 0xFF, 0x3F, 0xFB, 0xF8, 0x7C, 0x07, 0xFF, 0xEF, 0xFF, 0x87,
  0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFF,
  0xEF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFE, 0x00, 0x7F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0x03, 0xFF, 0x00,
  0x0C, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x04, 0x0F, 0xFE,
  0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xF0,
  0xFE, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x7F, 0xF0, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xF8, 0x1F,
  0xF8, 0x00, 0x18, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0xE0, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x83, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0x80,
  0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFF, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0x81,
  0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xE3,
  0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFC, 0xFE,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFD,
  0xFF, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0xFF,
  0xBF, 0x80, 0x07, 0xE7, 0xFF, 0xEF, 0xE0, 0x01, 0xF9, 0xFF, 0xF9, 0xF8,
  0x00, 0xFE, 0x7F, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0xFF, 0x9F, 0xC0, 0x0F,
  0xC7, 0xFF, 0xE3, 0xF0, 0x03, 0xF1, 0xFF, 0xF8, 0xFC, 0x01, 0xF8, 0x7F,
  0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xFF, 0x87, 0xE0, 0x1F, 0x87, 0xFF, 0xE1,
  0xF8, 0x0F, 0xC1, 0xFF, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7E, 0x07, 0xFF, 0xE0, 0xFE, 0x1F, 0x81,
  0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0xFF,
  0x81, 0xFC, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x3F, 0x01, 0xFF, 0xF8, 0x0F,
  0xDF, 0x80, 0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xBF,
  0xC0, 0x03, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0xF9,
  0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x3F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF,
  0x0F, 0xF0, 0x0F, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xC1, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFC, 0x07, 0xF8, 0x3F, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x0F,
  0xFF, 0x80, 0x7F, 0x87, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0xE0, 0x07, 0xF9,
  0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0xFC, 0x00, 0x7F,
  0xBF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xE1, 0xFF, 0xFB, 0xF8, 0x03, 0xFE,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xFE, 0xFE, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F,
  0x80, 0x3F, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0x01,
  0xF9, 0xFF, 0x00, 0x18, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xDC, 0x00, 0x1F, 0xEF, 0xC0, 0x3F, 0xF7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x3F, 0xC7, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFE, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x80, 0xFE,
  0x01, 0xF9, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x0F, 0xC0, 0x7F,
  0x00, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7E,
  0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x03, 0xF8,
  0xFE, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0xC0, 0x01,
  0xFC, 0xFC, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xBF,
  0x80, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xE0, 0x78, 0x07, 0xF8, 0x10, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFE, 0x01, 0xFD,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF8,
  0x0F, 0xFD, 0xFF, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xF3, 0xF3,
  0xFF, 0xFC, 0xFC, 0x7F, 0xFC, 0x3F, 0x07, 0xFE, 0x07, 0xC0, 0x18, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0xFE, 0x3F, 0xFC, 0x0F, 0xE7, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF,
  0x0F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xFC, 0xFF,
  0xC0, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8,
  0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0xF9, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFC, 0x0E, 0x1F, 0xE0, 0x04, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x08, 0xFF, 0x80, 0x31, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x7F, 0x1F, 0xFF, 0xEF, 0xE3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB,
  0xFE, 0x03, 0xFF, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xF3, 0xF0, 0x7F, 0xFC, 0x7E, 0x07, 0xFE, 0x0F, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xC3, 0xFC,
  0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x23, 0xFC, 0x00, 0x18, 0xFF, 0xE0, 0x7E, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xC3, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F,
  0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F,
  0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xDF, 0xC3, 0xFF, 0xFB, 0xF8, 0x3F, 0xFE,
  0x7F, 0x03, 0xFF, 0x0F, 0xE0, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF9, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xFF, 0x87, 0xF3, 0xFF, 0xF8, 0xFE, 0xFF,
  0xFF, 0x9F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xEF,
  0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE,
  0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xCF, 0xE0, 0x0F,
  0xF8, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x03, 0xFE,
  0x0F, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x0F, 0xF8,
  0x1F, 0x87, 0xFF, 0xC3, 0xF1, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x1F, 0xF7, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0xFC, 0x0F, 0xF0, 0x0F, 0xC3, 0xFF, 0xC0, 0xFE, 0x7F, 0xFE, 0x0F, 0xEF,
  0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F,
  0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF,
  0x0F, 0xE3, 0xFF, 0xC0, 0xFF, 0x1F, 0xF8, 0x0F, 0xF0, 0x18, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x7F, 0xF0, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xFF, 0xF3, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xF8, 0x1F, 0xFB, 0xFE, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x9F, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xDF, 0xC3, 0xFF, 0xFB, 0xF8, 0x3F, 0xFE, 0x7F, 0x03, 0xFF, 0x0F,
  0xE0, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x9F, 0xE7,
  0xF0, 0x07, 0x1F, 0xC0, 0x04, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF7, 0x00, 0x3F, 0xDF, 0x81, 0xFF,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x05, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFE, 0x3F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0C, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFD, 0xFE, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xC7, 0xFF, 0xF3, 0xF8, 0x7F, 0xFC, 0x3F,
  0x07, 0xFF, 0x07, 0xE0, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xE0,
  0x0F, 0xE7, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFB, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0x9F, 0x01, 0xFC, 0x3F, 0x81, 0xF9, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0x9F, 0x83, 0xF8, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x0F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xE0, 0x7C, 0x7F, 0x00, 0xFE, 0x7E, 0x07, 0xC7,
  0xE0, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x07, 0xEF, 0xE0,
  0x07, 0xF7, 0xC0, 0x7E, 0xFE, 0x00, 0x7F, 0x7C, 0x03, 0xEF, 0xC0, 0x03,
  0xF7, 0xC0, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0x81, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x08,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x23, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x80, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 44, 16, 4, -43 },
  { 45, 20, 16, 26, 3, -43 },
  { 85, 33, 43, 35, 1, -43 },
  { 263, 26, 49, 32, 3, -46 },
  { 423, 45, 44, 49, 2, -43 },
  { 671, 38, 44, 40, 2, -43 },
  { 880, 8, 16, 14, 3, -43 },
  { 896, 14, 52, 19, 3, -43 },
  { 987, 15, 52, 19, 2, -43 },
  { 1085, 26, 26, 30, 2, -46 },
  { 1170, 27, 29, 32, 2, -36 },
  { 1268, 10, 15, 16, 2, -7 },
  { 1287, 15, 6, 19, 2, -19 },
  { 1299, 9, 9, 16, 3, -8 },
  { 1310, 22, 43, 24, 1, -43 },
  { 1429, 27, 45, 32, 2, -44 },
  { 1581, 18, 43, 32, 4, -43 },
  { 1678, 27, 43, 32, 2, -43 },
  { 1824, 27, 44, 32, 2, -43 },
  { 1973, 30, 43, 32, 1, -43 },
  { 2135, 26, 44, 32, 3, -43 },
  { 2278, 27, 44, 32, 2, -43 },
  { 2427, 27, 43, 32, 2, -43 },
  { 2573, 27, 44, 32, 2, -43 },
  { 2722, 27, 44, 32, 2, -43 },
  { 2871, 8, 34, 16, 4, -33 },
  { 2905, 10, 41, 16, 2, -33 },
  { 2957, 27, 29, 32, 2, -36 },
  { 3055, 27, 18, 32, 2, -30 },
  { 3116, 27, 29, 32, 2, -36 },
  { 3214, 24, 44, 25, 0, -43 },
  { 3346, 44, 48, 49, 3, -43 },
  { 3610, 36, 43, 36, 0, -43 },
  { 3804, 28, 43, 36, 5, -43 },
  { 3955, 30, 44, 35, 3, -43 },
  { 4120, 32, 43, 40, 5, -43 },
  { 4292, 22, 43, 31, 5, -43 },
  { 4411, 22, 43, 30, 5, -43 },
  { 4530, 33, 44, 40, 3, -43 },
  { 4712, 31, 43, 41, 5, -43 },
  { 4879, 17, 43, 21, 2, -43 },
  { 4971, 16, 55, 17, -4, -43 },
  { 5081, 30, 43, 35, 5, -43 },
  { 5243, 23, 43, 29, 5, -43 },
  { 5367, 42, 43, 52, 5, -43 },
  { 5593, 33, 43, 44, 5, -43 },
  { 5771, 36, 45, 43, 3, -44 },
  { 5974, 26, 43, 34, 5, -43 },
  { 6114, 36, 54, 43, 3, -44 },
  { 6357, 30, 43, 35, 5, -43 },
  { 6519, 25, 44, 30, 3, -43 },
  { 6657, 29, 43, 31, 1, -43 },
  { 6813, 31, 44, 41, 5, -43 },
  { 6984, 35, 43, 35, 0, -43 },
  { 7173, 52, 43, 52, 0, -43 },
  { 7453, 34, 43, 34, 0, -43 },
  { 7636, 33, 43, 33, 0, -43 },
  { 7814, 28, 43, 31, 1, -43 },
  { 7965, 14, 53, 19, 4, -43 },
  { 8058, 22, 43, 24, 1, -43 },
  { 8177, 13, 53, 19, 2, -43 },
  { 8264, 30, 27, 33, 1, -43 },
  { 8366, 25, 4, 25, 0, 5 },
  { 8379, 15, 10, 19, 2, -46 },
  { 8398, 26, 34, 32, 2, -33 },
  { 8509, 28, 47, 34, 4, -46 },
  { 8674, 23, 34, 27, 3, -33 },
  { 8772, 27, 47, 34, 3, -46 },
  { 8931, 26, 34, 32, 3, -33 },
  { 9042, 22, 46, 20, 1, -46 },
  { 9169, 27, 47, 34, 3, -33 },
  { 9328, 27, 46, 35, 4, -46 },
  { 9484, 8, 45, 16, 4, -45 },
  { 9529, 15, 59, 16, -3, -45 },
  { 9640, 28, 46, 32, 4, -46 },
  { 9801, 8, 46, 16, 4, -46 },
  { 9847, 44, 33, 52, 4, -33 },
  { 10029, 27, 33, 35, 4, -33 },
  { 10141, 28, 34, 34, 3, -33 },
  { 10260, 28, 47, 34, 4, -33 },
  { 10425, 27, 47, 34, 3, -33 },
  { 10584, 19, 33, 24, 4, -33 },
  { 10663, 22, 34, 27, 2, -33 },
  { 10757, 20, 41, 22, 1, -40 },
  { 10860, 27, 34, 35, 4, -33 },
  { 10975, 30, 33, 30, 0, -33 },
  { 11099, 44, 33, 46, 1, -33 },
  { 11281, 29, 33, 30, 1, -33 },
  { 11401, 30, 47, 30, 0, -33 },
  { 11578, 22, 33, 26, 2, -33 },
  { 11669, 19, 53, 23, 1, -43 },
  { 11795, 6, 60, 30, 12, -46 },
  { 11840, 19, 53, 23, 2, -43 },
  { 11966, 27, 9, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD60PT7B_H_
