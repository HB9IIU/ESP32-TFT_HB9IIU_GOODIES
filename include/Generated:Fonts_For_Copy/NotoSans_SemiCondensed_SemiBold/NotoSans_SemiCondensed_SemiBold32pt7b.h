#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x09, 0xEF, 0xFF, 0xC0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x0E, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x01, 0x00, 0x04, 0x00, 0x7E, 0x07, 0xFF, 0x3F, 0xFD,
  0xF5, 0xE7, 0x90, 0x9C, 0x40, 0x71, 0x01, 0xE4, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x4F, 0x01, 0x1C, 0x04, 0x7C, 0x13,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0x70, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x3E, 0x00, 0xE0, 0x7F, 0x01, 0xE0, 0x7F, 0x81, 0xC0, 0x73, 0x81,
  0xC0, 0xE1, 0xC3, 0x80, 0xE1, 0xC3, 0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xC7,
  0x00, 0xE1, 0xCE, 0x00, 0xE3, 0xCE, 0x78, 0x73, 0x9C, 0xFE, 0x7F, 0x9D,
  0xFE, 0x3F, 0x39, 0xCF, 0x1E, 0x39, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0x73,
  0xC7, 0x00, 0xE3, 0xC7, 0x00, 0xE1, 0xC7, 0x01, 0xC1, 0xC7, 0x01, 0xC1,
  0xC7, 0x03, 0x81, 0xEE, 0x03, 0x80, 0xFE, 0x07, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x38, 0x03, 0xC3,
  0x80, 0x3C, 0x78, 0x01, 0xC7, 0x80, 0x1E, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x1E, 0x3F, 0xE1, 0xE7, 0xDF, 0x1E, 0x78, 0xFB, 0xCF,
  0x07, 0xBC, 0xF0, 0x3F, 0x8F, 0x01, 0xF8, 0xF8, 0x1F, 0x07, 0xC3, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xBE, 0x1F, 0xE1, 0xF0, 0xFF, 0xFF, 0xFE, 0xEE,
  0x07, 0x0E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E,
  0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x20, 0xC1, 0xF3, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0,
  0x7F, 0x83, 0xCF, 0x0F, 0x3C, 0x18, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x3D, 0xE7, 0x9E, 0x71, 0xCF, 0x38, 0xFF, 0xFF, 0xFF, 0x27, 0xBF, 0xFF,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x78, 0x1E, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0x78, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF1,
  0xE3, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0xFC,
  0x7F, 0x3F, 0xFE, 0xF7, 0x3C, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xE0, 0x7F, 0xE3, 0xFF, 0xE3, 0xC7, 0xC2, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFF,
  0xCF, 0xFF, 0x9C, 0x1F, 0x20, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x0F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x1F, 0xFF, 0xFB, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xDE, 0x07, 0x3C, 0x0E, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xC3,
  0xC7, 0x07, 0x8E, 0x0F, 0x38, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xFE, 0x3F, 0xFD, 0xFF, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x83, 0xEF, 0xFF, 0x7F, 0xF3, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0xC1, 0xEF, 0xE3, 0xFF, 0xE7, 0xF7, 0xEF, 0x83,
  0xDF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x70, 0x1E, 0xF0, 0x3D, 0xE0, 0xF1,
  0xE3, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xC3, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x3C, 0x78, 0x7F, 0xE0, 0x3F,
  0x80, 0x7F, 0x03, 0xFF, 0x0F, 0x9F, 0x1E, 0x0F, 0x78, 0x1E, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE3, 0xE7, 0xC7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x7F, 0xE0, 0xFB, 0xE7, 0xF7, 0xFF,
  0xC7, 0xFB, 0x83, 0xC7, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x0F, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x67, 0xBF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x13, 0xDF, 0xFF, 0x80, 0x31, 0xE7, 0xDF, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x79, 0xE7, 0x1C, 0xF3,
  0x80, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x1E,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0xC7, 0xFF, 0x1F, 0xFC, 0xE1, 0xE4, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xF8, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x9C,
  0x1F, 0xC7, 0x38, 0x7F, 0xCE, 0xE1, 0xFF, 0x8F, 0xC7, 0x8E, 0x1F, 0x8E,
  0x1C, 0x3F, 0x1C, 0x38, 0x7E, 0x78, 0x70, 0xF8, 0xF0, 0xE1, 0xF0, 0xE1,
  0xC3, 0x71, 0xC3, 0x8E, 0xE3, 0x8F, 0x9D, 0xC7, 0xFF, 0xF3, 0x87, 0xE7,
  0xC3, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x60,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x01,
  0xEF, 0x00, 0x3C, 0xE0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x38, 0x07,
  0x87, 0x81, 0xE0, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x78, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x8F, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE3, 0xF3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x9E, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xEF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x1E, 0x7C, 0x02, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0,
  0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F,
  0x3C, 0x0F, 0x9E, 0x3F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0xC7, 0xFF, 0xC7, 0xF0, 0xE7, 0xE0, 0x13, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDF,
  0x01, 0xE7, 0xE0, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x87, 0xF7, 0xFF, 0xFE, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0xBF, 0xDF, 0xCF, 0xC1, 0x00, 0xF0, 0x1F, 0xF0, 0x3E,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0,
  0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xC0,
  0xF3, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C,
  0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0xE0, 0x3F,
  0xFB, 0x80, 0xEF, 0xEF, 0x03, 0xBF, 0x9C, 0x1E, 0xFE, 0x70, 0x73, 0xF9,
  0xE1, 0xCF, 0xE3, 0x8F, 0x3F, 0x8E, 0x38, 0xFE, 0x3C, 0xE3, 0xF8, 0x77,
  0x8F, 0xE1, 0xDC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F,
  0xE0, 0xF8, 0x3F, 0x83, 0xE0, 0xFE, 0x07, 0x03, 0xC0, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xBC, 0x0F,
  0xDF, 0x07, 0xE7, 0x83, 0xF3, 0xE1, 0xF8, 0xF0, 0xFC, 0x7C, 0x7E, 0x1E,
  0x3F, 0x07, 0x9F, 0x83, 0xCF, 0xC0, 0xF7, 0xE0, 0x7B, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3E, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x07,
  0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF8, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1F, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE,
  0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x0F,
  0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xE0, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x07,
  0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF8, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1F, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xF3,
  0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0,
  0x78, 0xF1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xF1, 0xE0, 0xF1,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0,
  0x3E, 0xF0, 0x1F, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0x9F, 0x9E, 0x78, 0x09,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x07,
  0xFC, 0x3E, 0xFF, 0xFB, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x1C, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00,
  0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0x70, 0x0F, 0x01, 0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F,
  0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x38, 0x1F, 0x81, 0xC3, 0xC3, 0xFC, 0x3C,
  0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0x81, 0xC7,
  0x9E, 0x78, 0x1E, 0x71, 0xE7, 0x81, 0xE7, 0x0E, 0x78, 0x1E, 0x70, 0xE7,
  0x80, 0xEF, 0x0F, 0x70, 0x0E, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF0,
  0xF8, 0x7C, 0x1E, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0xF0, 0x3C, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7C, 0xF0, 0x07, 0xBC,
  0x03, 0xDE, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0,
  0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x1C, 0x70, 0x3C,
  0x78, 0x38, 0x38, 0x38, 0x3C, 0x70, 0x1C, 0x70, 0x1E, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x01, 0x80, 0xFF,
  0xC3, 0xFF, 0x87, 0x3E, 0x10, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0x1F,
  0xFD, 0xFF, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF,
  0xFF, 0x7F, 0xDC, 0xFC, 0x70, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x70, 0x7B, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB,
  0xE0, 0xF7, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xEF, 0xC7, 0xDF, 0xFF, 0xBD, 0xFE,
  0x71, 0xF8, 0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x47, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC1, 0xC7, 0x8F, 0xEF, 0x3F,
  0xFE, 0x7F, 0xFD, 0xF0, 0xFB, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0xC3, 0xE7,
  0xFF, 0xCF, 0xFB, 0x87, 0xE7, 0x01, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xF3,
  0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x01, 0x1F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0x1F, 0xE1, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0x9C, 0xFF, 0xB9, 0xFF, 0xF7, 0xC3,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B,
  0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDF, 0x0F, 0x9F, 0xFF, 0x3F, 0xFE, 0x1F,
  0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE8, 0x07, 0xDF, 0xFF, 0x3F, 0xFC,
  0x7F, 0xF0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x0C, 0x3D, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x3C,
  0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF,
  0xBF, 0x78, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x1E, 0xF0, 0x79, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F,
  0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF3, 0xC3,
  0xC7, 0xC7, 0x87, 0x8F, 0x07, 0x9E, 0x0F, 0xBC, 0x0F, 0x78, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x70, 0xF7, 0xF1, 0xFC, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8,
  0x7E, 0x1F, 0xF8, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x00, 0xC3, 0xDF, 0xEF, 0xFF, 0xBF, 0xFF,
  0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x70, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0xC1, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x83, 0xDF, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFF, 0x07, 0xBF, 0x1F, 0x7F, 0xFE, 0xF7, 0xF9, 0xE7, 0xE3, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x3F, 0x9C, 0xFF, 0xB9, 0xFF, 0xF7, 0xC3, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC0,
  0xF7, 0x81, 0xEF, 0x03, 0xDF, 0x0F, 0x9F, 0xFF, 0x3F, 0xFE, 0x1F, 0xBC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0xFF, 0x7F, 0xFF, 0xFE, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x07, 0x03, 0xFF, 0x7F, 0xE7, 0xCE, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFC, 0xFF, 0x1F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0xDF, 0xF7,
  0x3F, 0x9C, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0xF0, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x7E, 0x0E, 0x78, 0x7E, 0x1E,
  0x38, 0x77, 0x1E, 0x3C, 0x77, 0x1E, 0x3C, 0xE7, 0x1C, 0x3C, 0xE7, 0x3C,
  0x1C, 0xE7, 0xBC, 0x1C, 0xE3, 0xBC, 0x1E, 0xE3, 0xB8, 0x1F, 0xC3, 0xB8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0x81, 0xF0, 0x78, 0x1F, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1F,
  0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0xF8,
  0x1F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC3, 0xF0, 0xFC, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xFC, 0x3E, 0x0F, 0x83,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F,
  0x03, 0xF0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0xC1, 0xF0, 0x7C, 0x3F,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x3F,
  0x0F, 0xC3, 0xC0, 0x1C, 0x02, 0xFE, 0x0F, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 10, 8, 14, 2, -23 },
  { 26, 17, 23, 19, 1, -23 },
  { 75, 14, 26, 17, 1, -24 },
  { 121, 24, 23, 26, 1, -23 },
  { 190, 20, 23, 21, 1, -23 },
  { 248, 4, 8, 8, 2, -23 },
  { 252, 8, 28, 10, 1, -23 },
  { 280, 8, 28, 10, 1, -23 },
  { 308, 14, 13, 16, 1, -24 },
  { 331, 15, 15, 17, 1, -19 },
  { 360, 6, 8, 8, 1, -4 },
  { 366, 8, 3, 10, 1, -10 },
  { 369, 5, 5, 8, 2, -5 },
  { 373, 12, 23, 13, 0, -23 },
  { 408, 15, 23, 17, 1, -23 },
  { 452, 10, 23, 17, 2, -23 },
  { 481, 15, 23, 17, 1, -23 },
  { 525, 14, 23, 17, 1, -23 },
  { 566, 15, 23, 17, 1, -23 },
  { 610, 13, 23, 17, 2, -23 },
  { 648, 15, 23, 17, 1, -23 },
  { 692, 15, 23, 17, 1, -23 },
  { 736, 15, 23, 17, 1, -23 },
  { 780, 15, 23, 17, 1, -23 },
  { 824, 5, 18, 9, 2, -18 },
  { 836, 6, 22, 9, 1, -18 },
  { 853, 15, 15, 17, 1, -19 },
  { 882, 15, 9, 17, 1, -16 },
  { 899, 15, 15, 17, 1, -19 },
  { 928, 13, 23, 13, 0, -23 },
  { 966, 23, 26, 26, 2, -23 },
  { 1041, 19, 23, 19, 0, -23 },
  { 1096, 15, 23, 19, 3, -23 },
  { 1140, 16, 23, 18, 2, -23 },
  { 1186, 17, 23, 21, 3, -23 },
  { 1235, 12, 23, 16, 3, -23 },
  { 1270, 12, 23, 16, 3, -23 },
  { 1305, 17, 23, 21, 2, -23 },
  { 1354, 16, 23, 22, 3, -23 },
  { 1400, 9, 23, 11, 1, -23 },
  { 1426, 9, 30, 9, -2, -23 },
  { 1460, 16, 23, 19, 3, -23 },
  { 1506, 12, 23, 16, 3, -23 },
  { 1541, 22, 23, 28, 3, -23 },
  { 1605, 17, 23, 23, 3, -23 },
  { 1654, 19, 23, 23, 2, -23 },
  { 1709, 14, 23, 18, 3, -23 },
  { 1750, 19, 28, 23, 2, -23 },
  { 1817, 16, 23, 19, 3, -23 },
  { 1863, 14, 23, 16, 1, -23 },
  { 1904, 16, 23, 16, 0, -23 },
  { 1950, 16, 23, 22, 3, -23 },
  { 1996, 18, 23, 18, 0, -23 },
  { 2048, 28, 23, 28, 0, -23 },
  { 2129, 18, 23, 18, 0, -23 },
  { 2181, 17, 23, 17, 0, -23 },
  { 2230, 14, 23, 16, 1, -23 },
  { 2271, 8, 28, 10, 2, -23 },
  { 2299, 12, 23, 13, 0, -23 },
  { 2334, 7, 28, 10, 1, -23 },
  { 2359, 16, 14, 17, 1, -23 },
  { 2387, 14, 2, 14, 0, 3 },
  { 2391, 8, 6, 10, 1, -25 },
  { 2397, 14, 18, 17, 1, -18 },
  { 2429, 15, 24, 18, 2, -24 },
  { 2474, 13, 18, 15, 1, -18 },
  { 2504, 15, 24, 18, 1, -24 },
  { 2549, 15, 18, 17, 1, -18 },
  { 2583, 12, 24, 11, 0, -24 },
  { 2619, 15, 26, 18, 1, -18 },
  { 2668, 14, 24, 19, 2, -24 },
  { 2710, 4, 24, 8, 2, -24 },
  { 2722, 7, 32, 8, -1, -24 },
  { 2750, 15, 24, 17, 2, -24 },
  { 2795, 4, 24, 8, 2, -24 },
  { 2807, 24, 18, 28, 2, -18 },
  { 2861, 14, 18, 19, 2, -18 },
  { 2893, 16, 18, 18, 1, -18 },
  { 2929, 15, 26, 18, 2, -18 },
  { 2978, 15, 26, 18, 1, -18 },
  { 3027, 10, 18, 13, 2, -18 },
  { 3050, 12, 18, 14, 1, -18 },
  { 3077, 10, 21, 12, 1, -21 },
  { 3104, 14, 17, 19, 2, -17 },
  { 3134, 16, 17, 16, 0, -17 },
  { 3168, 24, 17, 24, 0, -17 },
  { 3219, 16, 17, 16, 0, -17 },
  { 3253, 16, 25, 16, 0, -17 },
  { 3303, 12, 17, 14, 1, -17 },
  { 3329, 10, 28, 12, 1, -23 },
  { 3364, 3, 31, 16, 7, -24 },
  { 3376, 10, 28, 12, 1, -23 },
  { 3411, 15, 5, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD32PT7B_H_
