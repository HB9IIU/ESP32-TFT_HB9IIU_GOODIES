#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x48, 0x2F, 0xC0, 0xCF, 0x3C, 0xF3, 0xCC, 0x0C,
  0x81, 0x90, 0x26, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0xD8, 0xFF, 0xDF,
  0xF8, 0xCC, 0x19, 0x03, 0x20, 0x6C, 0x00, 0x18, 0x3E, 0xFF, 0xD9, 0xD8,
  0xF8, 0x78, 0x3E, 0x1F, 0x1B, 0x9B, 0xFF, 0xFE, 0x18, 0x18, 0x70, 0x63,
  0xE1, 0x8D, 0x8C, 0x32, 0x30, 0xC9, 0x83, 0x26, 0x0D, 0xB7, 0xBE, 0xD3,
  0x76, 0xCC, 0x1B, 0x30, 0xCC, 0xC3, 0x33, 0x18, 0x78, 0x61, 0xE0, 0x1C,
  0x07, 0xE0, 0x67, 0x06, 0x70, 0x66, 0x07, 0xE0, 0x3C, 0x07, 0xC6, 0xEE,
  0xEC, 0x7C, 0xC3, 0xCE, 0x38, 0xFF, 0xC7, 0xEF, 0xFF, 0xC0, 0x19, 0x98,
  0xCE, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x31, 0x86, 0x38, 0xE3, 0x0C, 0x63,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x98, 0xCE, 0x60, 0x18, 0x18, 0xDF, 0xFF,
  0x38, 0x6C, 0x66, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0xFB, 0x60, 0xFF, 0x5F, 0x80, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x06,
  0x0C, 0x30, 0x60, 0xC3, 0x06, 0x1C, 0x00, 0x3C, 0x7E, 0xE6, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0x0C, 0x73, 0xFB,
  0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x3C, 0xFE, 0xC7, 0x87,
  0x03, 0x07, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x3C, 0xFE,
  0xC7, 0x07, 0x07, 0x06, 0x3C, 0x3E, 0x07, 0x03, 0x03, 0x87, 0xFE, 0xFC,
  0x03, 0x01, 0xC0, 0x70, 0x3C, 0x1B, 0x06, 0xC3, 0x31, 0x8C, 0x63, 0x3F,
  0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7E, 0x7E, 0x60, 0xE0, 0xE0, 0xC8,
  0xFE, 0x4F, 0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0x0E, 0x3E, 0x70, 0x60,
  0xC0, 0xCC, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3E, 0xFF, 0xFF,
  0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x70,
  0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0x66, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3,
  0xFF, 0x7E, 0x38, 0x7E, 0xE6, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x03,
  0x07, 0x06, 0x7E, 0x78, 0xFC, 0x00, 0x02, 0xFC, 0xFC, 0x00, 0x00, 0xFB,
  0x60, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x1E, 0x78,
  0xE0, 0x80, 0x3C, 0xFE, 0x46, 0x07, 0x06, 0x06, 0x1C, 0x18, 0x30, 0x30,
  0x00, 0x10, 0x38, 0x38, 0x03, 0x80, 0x7F, 0x83, 0x83, 0x18, 0x06, 0x67,
  0xCB, 0x3B, 0x3C, 0xCC, 0xF6, 0x33, 0xD8, 0xCF, 0x23, 0x2C, 0xFF, 0xB1,
  0xDC, 0x60, 0x00, 0xC0, 0x81, 0xFE, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1B, 0x01, 0x98, 0x39, 0x83, 0x18, 0x3F, 0xC7, 0xFC, 0x70,
  0xC6, 0x0E, 0xE0, 0x6E, 0x07, 0xF8, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x3B,
  0xF9, 0xFC, 0xC3, 0x61, 0xF0, 0xF8, 0x6F, 0xF7, 0xF0, 0x0F, 0x1F, 0xDE,
  0x6C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0xF8,
  0xFC, 0xF8, 0x3F, 0x8C, 0xF3, 0x0E, 0xC1, 0xB0, 0x6C, 0x1F, 0x07, 0xC1,
  0xF0, 0x6C, 0x3B, 0x1C, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x18,
  0x3F, 0x7E, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x3F, 0x7E, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x0F, 0x8F, 0xF7,
  0x8D, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x0F, 0xE3, 0xF8, 0x36, 0x0D, 0xC3,
  0x3F, 0xC7, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xFF, 0xD8, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xCF, 0xFC, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0xE7, 0xF7, 0x00, 0xC3, 0xE1, 0xB1, 0xD9, 0xCC, 0xC6, 0xC3, 0xE1,
  0xF0, 0xFC, 0x67, 0x31, 0x98, 0xEC, 0x36, 0x1C, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xE0, 0x3F, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0D, 0xF8, 0x6F, 0x63, 0x7B, 0x33, 0xD9, 0x9E,
  0x6C, 0xF3, 0xC7, 0x9E, 0x3C, 0x71, 0xE3, 0x0C, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF8, 0xF6, 0x3D, 0xCF, 0x33, 0xCE, 0xF1, 0xBC, 0x7F, 0x0F, 0xC3,
  0xF0, 0x70, 0x0F, 0x07, 0xF1, 0xC7, 0x30, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB8, 0x73, 0xFC, 0x3F, 0x00, 0xF0, 0xFE,
  0xCF, 0xC7, 0xC3, 0xC7, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x0F, 0x07, 0xF9, 0xC7, 0x30, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xB8, 0x73, 0xFC, 0x3F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xF0, 0x7F, 0x33, 0xD8, 0xEC, 0x36, 0x3B, 0x39, 0xF8, 0xFC, 0x67, 0x31,
  0x98, 0xEC, 0x36, 0x1C, 0x3C, 0x7F, 0xE6, 0xC0, 0xC0, 0xE0, 0x78, 0x3E,
  0x0E, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xD8, 0x36, 0x0D,
  0xC7, 0x7F, 0x8F, 0xC0, 0xC0, 0x7C, 0x1D, 0x83, 0x30, 0x67, 0x1C, 0x63,
  0x0C, 0x61, 0x8C, 0x3B, 0x03, 0x60, 0x6C, 0x0D, 0x80, 0xE0, 0x1C, 0x00,
  0xC1, 0x83, 0xF0, 0xE1, 0x98, 0x70, 0xCC, 0x78, 0x66, 0x3C, 0x73, 0x1B,
  0x31, 0xCD, 0x98, 0x6C, 0xCC, 0x36, 0x6E, 0x1B, 0x1E, 0x0F, 0x8F, 0x03,
  0x87, 0x81, 0xC3, 0xC0, 0xE0, 0xC0, 0xE0, 0xCC, 0x39, 0xC6, 0x1D, 0xC1,
  0xB0, 0x3E, 0x03, 0x80, 0x70, 0x1F, 0x03, 0x60, 0xEE, 0x38, 0xC6, 0x1D,
  0xC1, 0xC0, 0xE0, 0xD8, 0x76, 0x19, 0xCE, 0x33, 0x0E, 0xC1, 0xE0, 0x78,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0xBF, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0F, 0xFF, 0xFC,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xC0,
  0xC1, 0x83, 0x03, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x0C,
  0x03, 0x01, 0xE0, 0x78, 0x33, 0x0C, 0xC2, 0x19, 0x86, 0xE0, 0xC0, 0xFF,
  0xC6, 0x30, 0x7E, 0x67, 0x03, 0x03, 0x7F, 0xE3, 0xC3, 0xC7, 0xFF, 0x7B,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xF7, 0xBB, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x7F, 0xF6, 0xF0, 0x08, 0xFD, 0xDF, 0x0C, 0x18, 0x30, 0x60, 0xE0,
  0xFC, 0xF8, 0x03, 0x81, 0xC0, 0xE2, 0x77, 0xFB, 0xBF, 0x8F, 0x87, 0xC3,
  0xE1, 0xF0, 0xFC, 0x77, 0xFB, 0xEC, 0x7E, 0x67, 0xC3, 0xC3, 0xFF, 0xC0,
  0xC0, 0xE0, 0x7F, 0x3F, 0x0C, 0x7C, 0xE9, 0x83, 0x1F, 0x8C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x10, 0x3F, 0xDD, 0xFC, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xE3, 0xBF, 0xDF, 0xE0, 0x70, 0x36, 0x3B, 0xF8, 0x30,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xF7, 0xBF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1C, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xC0,
  0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xBF, 0x90, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x37, 0x33, 0xB9, 0xF8, 0xFC, 0x7E, 0x3B, 0x9C, 0xEE,
  0x37, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x13, 0x7D, 0xFF,
  0x7D, 0xF8, 0xE3, 0xE3, 0x8F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0F,
  0x8C, 0x3E, 0x30, 0xC0, 0x04, 0x6F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x08, 0x3F, 0x1D, 0xDC, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xE3, 0x3F, 0x8F, 0x80, 0x04, 0x6F, 0xBD, 0xDC, 0x7E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE3, 0xFF, 0xBF, 0x9C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x10, 0x3F, 0xDD, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xBF, 0xDF,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x7F, 0xF8, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x00, 0x11, 0xFF, 0x16, 0x0E, 0x0F, 0x0F, 0x07, 0x0F, 0xFB,
  0xF0, 0x30, 0x60, 0xC7, 0xE3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xF3,
  0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0xBE,
  0xC0, 0xE1, 0xB0, 0xD8, 0xEE, 0x63, 0x31, 0xB0, 0xD8, 0x3C, 0x1C, 0x0E,
  0x00, 0xE3, 0x8D, 0x8E, 0x36, 0x79, 0xD9, 0xA6, 0x76, 0xD8, 0xD3, 0x63,
  0xCD, 0x8F, 0x1C, 0x3C, 0x70, 0x61, 0xC0, 0xE3, 0xB9, 0x8D, 0xC3, 0xC1,
  0xC0, 0xF0, 0xF8, 0x6E, 0x73, 0x70, 0xC0, 0xE1, 0xB0, 0xD8, 0xEE, 0x63,
  0x31, 0xB8, 0xF8, 0x3C, 0x1E, 0x06, 0x07, 0x03, 0x83, 0x83, 0x81, 0x80,
  0xFD, 0xF8, 0x70, 0xC3, 0x0E, 0x18, 0x70, 0xFF, 0xFC, 0x04, 0x71, 0x86,
  0x18, 0x61, 0x8E, 0xE3, 0xC3, 0x86, 0x18, 0x61, 0x87, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x83, 0x86, 0x1C, 0x71, 0xC7, 0x0C, 0x1C, 0xF7, 0x1C,
  0x71, 0xC7, 0x38, 0xC0, 0xF1, 0xFF, 0x86,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 11, 14, 11, 0, -14 },
  { 31, 8, 15, 10, 1, -14 },
  { 46, 14, 14, 16, 1, -14 },
  { 71, 12, 14, 13, 1, -14 },
  { 92, 2, 5, 5, 1, -14 },
  { 94, 5, 17, 6, 1, -14 },
  { 105, 5, 17, 6, 0, -14 },
  { 116, 8, 8, 10, 1, -14 },
  { 124, 8, 9, 10, 1, -11 },
  { 133, 3, 4, 5, 1, -2 },
  { 135, 4, 2, 6, 1, -6 },
  { 136, 3, 3, 5, 1, -3 },
  { 138, 7, 14, 8, 0, -14 },
  { 151, 8, 14, 10, 1, -14 },
  { 165, 6, 14, 10, 1, -14 },
  { 176, 8, 14, 10, 1, -14 },
  { 190, 8, 14, 10, 1, -14 },
  { 204, 10, 14, 10, 0, -14 },
  { 222, 8, 14, 10, 1, -14 },
  { 236, 8, 14, 10, 1, -14 },
  { 250, 8, 14, 10, 1, -14 },
  { 264, 8, 14, 10, 1, -14 },
  { 278, 8, 14, 10, 1, -14 },
  { 292, 3, 10, 5, 1, -10 },
  { 296, 3, 12, 5, 1, -10 },
  { 301, 8, 10, 10, 1, -12 },
  { 311, 8, 5, 10, 1, -9 },
  { 316, 8, 10, 10, 1, -12 },
  { 326, 8, 14, 8, 0, -14 },
  { 340, 14, 16, 16, 1, -14 },
  { 368, 12, 14, 12, 0, -14 },
  { 389, 9, 14, 11, 2, -14 },
  { 405, 9, 14, 11, 1, -14 },
  { 421, 10, 14, 13, 2, -14 },
  { 439, 7, 14, 10, 2, -14 },
  { 452, 7, 14, 9, 2, -14 },
  { 465, 10, 14, 13, 1, -14 },
  { 483, 9, 14, 13, 2, -14 },
  { 499, 5, 14, 7, 1, -14 },
  { 508, 5, 18, 5, -1, -14 },
  { 520, 9, 14, 11, 2, -14 },
  { 536, 7, 14, 9, 2, -14 },
  { 549, 13, 14, 16, 2, -14 },
  { 572, 10, 14, 14, 2, -14 },
  { 590, 11, 14, 13, 1, -14 },
  { 610, 8, 14, 11, 2, -14 },
  { 624, 11, 17, 13, 1, -14 },
  { 648, 9, 14, 11, 2, -14 },
  { 664, 8, 14, 10, 1, -14 },
  { 678, 9, 14, 10, 0, -14 },
  { 694, 10, 14, 13, 1, -14 },
  { 712, 11, 14, 11, 0, -14 },
  { 732, 17, 14, 17, 0, -14 },
  { 762, 11, 14, 11, 0, -14 },
  { 782, 10, 14, 10, 0, -14 },
  { 800, 9, 14, 10, 0, -14 },
  { 816, 5, 17, 6, 1, -14 },
  { 827, 7, 14, 8, 0, -14 },
  { 840, 5, 17, 6, 0, -14 },
  { 851, 10, 9, 10, 0, -14 },
  { 863, 8, 1, 8, 0, 2 },
  { 864, 4, 3, 6, 1, -15 },
  { 866, 8, 10, 10, 1, -10 },
  { 876, 9, 14, 11, 1, -14 },
  { 892, 7, 11, 9, 1, -11 },
  { 902, 9, 14, 11, 1, -14 },
  { 918, 8, 10, 10, 1, -10 },
  { 928, 7, 15, 6, 0, -15 },
  { 942, 9, 16, 11, 1, -11 },
  { 960, 9, 14, 11, 1, -14 },
  { 976, 3, 14, 5, 1, -14 },
  { 982, 5, 19, 5, -1, -14 },
  { 994, 9, 14, 10, 1, -14 },
  { 1010, 3, 14, 5, 1, -14 },
  { 1016, 14, 11, 17, 1, -11 },
  { 1036, 9, 11, 11, 1, -11 },
  { 1049, 9, 11, 11, 1, -11 },
  { 1062, 9, 16, 11, 1, -11 },
  { 1080, 9, 16, 11, 1, -11 },
  { 1098, 6, 11, 8, 1, -11 },
  { 1107, 7, 11, 8, 1, -11 },
  { 1117, 7, 13, 7, 0, -13 },
  { 1129, 9, 10, 11, 1, -10 },
  { 1141, 9, 10, 9, 0, -10 },
  { 1153, 14, 10, 15, 0, -10 },
  { 1171, 9, 10, 10, 0, -10 },
  { 1183, 9, 15, 10, 0, -10 },
  { 1200, 7, 10, 8, 1, -10 },
  { 1209, 6, 17, 7, 0, -14 },
  { 1222, 2, 18, 10, 4, -14 },
  { 1227, 6, 17, 7, 1, -14 },
  { 1240, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD19PT7B_H_
