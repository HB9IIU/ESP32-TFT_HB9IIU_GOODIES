#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF0, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x1E,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8,
  0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xF9, 0x84, 0xF1, 0x80, 0xF1, 0x80,
  0xF9, 0x80, 0xFD, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xFE, 0x01, 0xBE, 0x01, 0x9F, 0x01, 0x8F, 0x01, 0x8F, 0x81, 0x9F,
  0xF9, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xC0, 0x3F,
  0xC0, 0x38, 0x07, 0x9E, 0x07, 0x80, 0x71, 0xE0, 0x78, 0x07, 0x0E, 0x0F,
  0x00, 0xF0, 0xE0, 0xF0, 0x0F, 0x0E, 0x1E, 0x00, 0xF0, 0xF1, 0xE0, 0x0F,
  0x0E, 0x3C, 0x00, 0xF0, 0xE3, 0xC0, 0x07, 0x0E, 0x78, 0xF8, 0x71, 0xE7,
  0x9F, 0xC7, 0x9E, 0x73, 0xFE, 0x3F, 0xCF, 0x38, 0xE1, 0xF8, 0xE7, 0x8F,
  0x0F, 0x1E, 0x78, 0xF0, 0x01, 0xC7, 0x8F, 0x00, 0x3C, 0x78, 0xF0, 0x03,
  0x87, 0x8F, 0x00, 0x78, 0x78, 0xF0, 0x07, 0x07, 0x8F, 0x00, 0xF0, 0x78,
  0xF0, 0x0E, 0x03, 0x8E, 0x01, 0xE0, 0x3F, 0xE0, 0x1C, 0x01, 0xFC, 0x03,
  0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3C, 0x3F, 0xF0, 0x3C,
  0x3E, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0x78, 0xF8, 0x3F, 0xF8,
  0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xF0, 0x78, 0x07, 0xE0, 0x7C, 0x0F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0x7C, 0x0F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE7, 0x39, 0xCE, 0x70, 0x0F, 0x87, 0x87, 0x87, 0x83, 0xC3,
  0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x41, 0xC1, 0x79, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x1C, 0x38,
  0x04, 0x10, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFF, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE3, 0xE1, 0xE0, 0xF9, 0xF0,
  0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07,
  0xDE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x7F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x07,
  0xF1, 0xFF, 0x3F, 0xF7, 0xDF, 0xF9, 0xF3, 0x1F, 0x21, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0xC7, 0xC3, 0xF1, 0x80, 0xF8,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0x83, 0xF1, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7D, 0xF9, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1E,
  0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x80, 0xE3, 0xE0, 0x78, 0xF8, 0x3C, 0x3E,
  0x0F, 0x0F, 0x87, 0x83, 0xE1, 0xC0, 0xF8, 0xF0, 0x3E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7B, 0x80, 0x7F, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0x20, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x80, 0x3E, 0xFD, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7E,
  0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x3E, 0x0F, 0x7F, 0xC7,
  0xFF, 0xE3, 0xFF, 0xFB, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0xBC, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x3C, 0x7E,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x7C, 0x0F, 0x1F,
  0x0F, 0x8F, 0xCF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xF0,
  0x7E, 0xFC, 0x7C, 0x1F, 0x3C, 0x07, 0xDE, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3D, 0xE0, 0x3E, 0xFC, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3,
  0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xF7, 0xC1, 0xFB, 0xF1, 0xFC, 0xFF, 0xFE, 0x7F, 0xEF,
  0x1F, 0xE7, 0x81, 0xC7, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x43, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0xDE, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x78,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x7F,
  0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0x07, 0xC8, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x30, 0x1E, 0x78, 0x3F, 0xF3, 0xCE, 0x0F, 0xFC, 0x39, 0xC3, 0xE3,
  0x87, 0x78, 0xF0, 0x70, 0xFF, 0x1E, 0x0E, 0x1F, 0xC3, 0x81, 0xC3, 0xF8,
  0x70, 0x38, 0x7F, 0x0E, 0x07, 0x0F, 0xE1, 0xC1, 0xE1, 0xDC, 0x38, 0x3C,
  0x3B, 0x87, 0x87, 0x87, 0x70, 0xF1, 0xF9, 0xEF, 0x0F, 0xF7, 0xF9, 0xE0,
  0xFE, 0x7E, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFC, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xE1, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0x83, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x83, 0x8F, 0xC0, 0x27, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x08,
  0x7F, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x8F, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8,
  0x0F, 0xCF, 0x83, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xC1, 0xE3, 0xF0,
  0x02, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x3F, 0x01, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFD, 0xFF,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0xAF, 0xEF, 0xF3, 0xFC,
  0xFE, 0x18, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F,
  0x8F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x07, 0xDF, 0x00, 0xFC, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0xFF, 0x78,
  0x07, 0xBF, 0xDE, 0x01, 0xEF, 0xF7, 0x80, 0x73, 0xFC, 0xF0, 0x3C, 0xFF,
  0x3C, 0x0F, 0x7F, 0xCF, 0x03, 0x9F, 0xF1, 0xE1, 0xE7, 0xFC, 0x78, 0x79,
  0xFF, 0x1E, 0x1C, 0x7F, 0xC3, 0x8F, 0x1F, 0xF0, 0xF3, 0xC7, 0xFC, 0x3C,
  0xE1, 0xFF, 0x0F, 0x78, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x07, 0xFC,
  0x1F, 0xC1, 0xFF, 0x03, 0xF0, 0x7F, 0xC0, 0xFC, 0x1F, 0xF0, 0x3E, 0x07,
  0xFC, 0x07, 0x81, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xDE, 0x03, 0xFE, 0xF8,
  0x1F, 0xF3, 0xE0, 0xFF, 0x9F, 0x07, 0xFC, 0x7C, 0x3F, 0xE3, 0xE1, 0xFF,
  0x0F, 0x8F, 0xF8, 0x7C, 0x7F, 0xC1, 0xF1, 0xFE, 0x0F, 0x8F, 0xF0, 0x3E,
  0x7F, 0x80, 0xF3, 0xFC, 0x07, 0xDF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x87, 0xF0, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x78,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF8,
  0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF9, 0xFE,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xF8, 0x07,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x7F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x0F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF,
  0xEF, 0xE3, 0xDF, 0x00, 0xBE, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xF0, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x0F, 0x9F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE,
  0x00, 0x3C, 0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x07,
  0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x0F, 0x80, 0xF0, 0x78, 0x07, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0,
  0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0x78,
  0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C,
  0x07, 0xF0, 0x3E, 0x3C, 0x0F, 0xF0, 0x3E, 0x3C, 0x0F, 0xF0, 0x3C, 0x3E,
  0x0F, 0x70, 0x3C, 0x3E, 0x0E, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x7C, 0x1E,
  0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x38, 0x78, 0x1F, 0x1C, 0x3C, 0x78, 0x0F,
  0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F,
  0x3C, 0x1E, 0xF0, 0x07, 0xF8, 0x1E, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x87,
  0x80, 0x7C, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x78, 0x1F,
  0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x0E, 0x3C, 0x07, 0x87, 0x01,
  0xE1, 0xE0, 0xF0, 0x38, 0x3C, 0x0F, 0x1E, 0x01, 0xC7, 0x80, 0x79, 0xC0,
  0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFE, 0x1C,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF3, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xCF, 0xCF, 0x81,
  0xF7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x7D, 0xF0, 0x3E,
  0xFE, 0x7E, 0x7F, 0xFF, 0x3D, 0xFF, 0x1C, 0x7F, 0x00, 0x0F, 0xF8, 0x7F,
  0xF3, 0xFF, 0x9F, 0x8E, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x01, 0x7F, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x1F, 0xCF, 0x9F, 0xF7, 0xDF, 0xFF, 0xEF, 0xCF, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7E,
  0x7F, 0xBF, 0xFF, 0xCF, 0xF9, 0xE3, 0xF8, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x02, 0x7E, 0x0E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0x61, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7F, 0xE7, 0xFF, 0x3F, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0xC7,
  0x9F, 0xF3, 0xDF, 0xFF, 0xEF, 0xCF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7E, 0x7F, 0xBF, 0xFF,
  0xCF, 0xFB, 0xE3, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x60, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFE, 0x7F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x33, 0xFF, 0xF7, 0x80,
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF0, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x1F, 0x0F, 0xFF, 0xFF, 0xDF, 0xC7, 0xC0, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x0F, 0x87,
  0x8F, 0x83, 0xCF, 0x81, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xBC, 0x0F, 0x9F, 0x07, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF8, 0xF0,
  0x3E, 0x78, 0x1F, 0x3C, 0x07, 0xDE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8,
  0x7F, 0x1E, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0xE7, 0xEF,
  0x83, 0xF8, 0x3F, 0xF0, 0x3E, 0x07, 0xFC, 0x07, 0xC0, 0xFF, 0x80, 0xF8,
  0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8,
  0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x07, 0x80,
  0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0xC0,
  0x78, 0x0F, 0xF8, 0x0F, 0x01, 0xF0, 0xE3, 0xF8, 0xE7, 0xFC, 0xFF, 0xFE,
  0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x3E, 0x7E, 0x3F, 0x1F, 0xFF,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0xE3, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F,
  0xCF, 0xCF, 0x81, 0xF7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xE0,
  0x7D, 0xF0, 0x3E, 0xFE, 0x7E, 0x7F, 0xFF, 0x3D, 0xFF, 0x1E, 0x7F, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC7, 0x9F, 0xF3, 0xDF,
  0xFF, 0xEF, 0xCF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7E, 0x3F, 0xBF, 0xFF, 0xCF, 0xFB, 0xE3,
  0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xE3, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x00, 0x3F, 0xF3, 0xFF, 0xFF, 0xFD, 0xF0, 0xEF, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0x80, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x31, 0xFF, 0x1F, 0xF0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFE, 0xFF, 0xFF, 0xEF, 0x7F, 0xEF,
  0x3F, 0x8F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x1E, 0x3C,
  0x0F, 0x8F, 0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF7, 0x81, 0xF8, 0x1F, 0x78, 0x1F, 0x81, 0xE7, 0xC1, 0xFC,
  0x1E, 0x3C, 0x1F, 0xC3, 0xE3, 0xC3, 0xDC, 0x3C, 0x3C, 0x3D, 0xC3, 0xC3,
  0xE3, 0x9C, 0x3C, 0x1E, 0x39, 0xE7, 0xC1, 0xE7, 0x9E, 0x78, 0x1E, 0x78,
  0xE7, 0x81, 0xE7, 0x0E, 0x78, 0x0F, 0x70, 0xF7, 0x80, 0xF7, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xCF,
  0x03, 0xE3, 0xE0, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F,
  0x83, 0xE7, 0xC0, 0xFB, 0xF0, 0x1F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0x78, 0x7C,
  0x1E, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x7F, 0x0F, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xF0, 0xFE, 0x0F, 0x80, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xF0,
  0x1F, 0x03, 0xF0, 0xFF, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F,
  0x00, 0x1E, 0x00, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF4,
  0x00, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 12, 9, 16, 2, -26 },
  { 35, 20, 26, 22, 1, -26 },
  { 100, 16, 30, 20, 2, -28 },
  { 160, 28, 27, 30, 1, -27 },
  { 255, 24, 27, 25, 1, -27 },
  { 336, 5, 9, 9, 2, -26 },
  { 342, 9, 32, 12, 2, -26 },
  { 378, 9, 32, 12, 1, -26 },
  { 414, 16, 16, 19, 1, -28 },
  { 446, 17, 18, 20, 1, -22 },
  { 485, 7, 9, 10, 1, -4 },
  { 493, 9, 4, 12, 1, -12 },
  { 498, 6, 5, 10, 2, -5 },
  { 502, 14, 27, 15, 0, -27 },
  { 550, 17, 27, 20, 1, -27 },
  { 608, 12, 26, 20, 2, -26 },
  { 647, 17, 27, 20, 1, -27 },
  { 705, 17, 27, 20, 1, -27 },
  { 763, 18, 26, 20, 1, -26 },
  { 822, 16, 26, 20, 2, -26 },
  { 874, 17, 27, 20, 1, -27 },
  { 932, 17, 26, 20, 1, -26 },
  { 988, 17, 27, 20, 1, -27 },
  { 1046, 17, 27, 20, 1, -27 },
  { 1104, 6, 20, 10, 2, -20 },
  { 1119, 7, 25, 10, 1, -20 },
  { 1141, 17, 19, 20, 1, -23 },
  { 1182, 17, 10, 20, 1, -18 },
  { 1204, 17, 19, 20, 1, -23 },
  { 1245, 15, 27, 16, 0, -27 },
  { 1296, 27, 30, 30, 2, -27 },
  { 1398, 23, 26, 23, 0, -26 },
  { 1473, 18, 26, 22, 3, -26 },
  { 1532, 18, 27, 21, 2, -27 },
  { 1593, 20, 26, 25, 3, -26 },
  { 1658, 14, 26, 19, 3, -26 },
  { 1704, 14, 26, 18, 3, -26 },
  { 1750, 20, 27, 25, 2, -27 },
  { 1818, 19, 26, 25, 3, -26 },
  { 1880, 11, 26, 13, 1, -26 },
  { 1916, 10, 34, 11, -2, -26 },
  { 1959, 19, 26, 22, 3, -26 },
  { 2021, 14, 26, 18, 3, -26 },
  { 2067, 26, 26, 32, 3, -26 },
  { 2152, 21, 26, 27, 3, -26 },
  { 2221, 22, 27, 26, 2, -27 },
  { 2296, 16, 26, 21, 3, -26 },
  { 2348, 22, 33, 26, 2, -27 },
  { 2439, 19, 26, 22, 3, -26 },
  { 2501, 15, 27, 19, 2, -27 },
  { 2552, 17, 26, 19, 1, -26 },
  { 2608, 19, 26, 25, 3, -26 },
  { 2670, 21, 26, 21, 0, -26 },
  { 2739, 32, 26, 32, 0, -26 },
  { 2843, 21, 26, 21, 0, -26 },
  { 2912, 20, 26, 20, 0, -26 },
  { 2977, 17, 26, 19, 1, -26 },
  { 3033, 8, 32, 12, 3, -26 },
  { 3065, 14, 27, 15, 0, -27 },
  { 3113, 8, 32, 12, 1, -26 },
  { 3145, 18, 17, 20, 1, -27 },
  { 3184, 16, 3, 16, 0, 3 },
  { 3190, 9, 6, 12, 1, -28 },
  { 3197, 16, 20, 20, 1, -20 },
  { 3237, 17, 28, 21, 3, -28 },
  { 3297, 14, 20, 17, 2, -20 },
  { 3332, 17, 28, 21, 2, -28 },
  { 3392, 16, 20, 20, 2, -20 },
  { 3432, 13, 28, 13, 1, -28 },
  { 3478, 17, 29, 21, 2, -20 },
  { 3540, 16, 28, 22, 3, -28 },
  { 3596, 5, 28, 10, 2, -28 },
  { 3614, 9, 37, 10, -2, -28 },
  { 3656, 17, 28, 20, 3, -28 },
  { 3716, 4, 28, 10, 3, -28 },
  { 3730, 27, 20, 32, 3, -20 },
  { 3798, 16, 20, 22, 3, -20 },
  { 3838, 17, 20, 21, 2, -20 },
  { 3881, 17, 29, 21, 3, -20 },
  { 3943, 17, 29, 21, 2, -20 },
  { 4005, 11, 20, 15, 3, -20 },
  { 4033, 13, 20, 16, 2, -20 },
  { 4066, 12, 24, 14, 1, -24 },
  { 4102, 16, 20, 22, 3, -20 },
  { 4142, 18, 20, 18, 0, -20 },
  { 4187, 28, 20, 28, 0, -20 },
  { 4257, 18, 20, 19, 0, -20 },
  { 4302, 18, 29, 19, 0, -20 },
  { 4368, 14, 20, 16, 1, -20 },
  { 4403, 12, 32, 14, 1, -26 },
  { 4451, 3, 37, 19, 8, -28 },
  { 4465, 12, 32, 14, 1, -26 },
  { 4513, 17, 6, 20, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD37PT7B_H_
