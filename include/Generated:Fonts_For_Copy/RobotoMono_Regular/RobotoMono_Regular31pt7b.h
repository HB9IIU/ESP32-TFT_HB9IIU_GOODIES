#ifndef _ROBOTOMONO_REGULAR31PT7B_H_
#define _ROBOTOMONO_REGULAR31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x07, 0xF7,
  0xE3, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0x01, 0x86, 0x01, 0x87, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x61, 0xFF, 0xFE, 0xFF, 0xFF,
  0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61,
  0x83, 0xFF, 0xFD, 0xFF, 0xFE, 0x1C, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x86, 0x01, 0xC7, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0x1E, 0x1C, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0x31, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x77, 0x00, 0x7E, 0x00, 0xEE, 0x03, 0x9C,
  0x07, 0x3E, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x31, 0xC0, 0x18, 0x63, 0x8C, 0x31, 0x86,
  0x19, 0x83, 0x1C, 0xC1, 0xFC, 0xC0, 0x7C, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x19, 0xF0, 0x1D, 0xFC, 0x0C, 0xC7, 0x0C,
  0x61, 0x86, 0x30, 0xC6, 0x18, 0x60, 0x0C, 0x70, 0x07, 0xF0, 0x01, 0xF0,
  0x0F, 0xC0, 0x1F, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x30, 0x70, 0x30, 0x70,
  0x38, 0xE0, 0x39, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x7B, 0x86, 0xF3, 0xC6, 0xE1, 0xC6, 0xE0, 0xEE, 0xC0, 0x7C, 0xE0, 0x7C,
  0xE0, 0x38, 0xF0, 0x7C, 0x7F, 0xEE, 0x1F, 0xCF, 0xFF, 0xFF, 0xF8, 0x01,
  0x03, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x30, 0x38,
  0x38, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0x60, 0xE0, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x04, 0x18,
  0x4F, 0x33, 0xFF, 0xFF, 0x87, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x80,
  0xE3, 0x81, 0xC7, 0x87, 0x07, 0x02, 0x08, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x39, 0xCE, 0x77, 0x39, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xEF, 0xFE, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0x83, 0x9C, 0x07, 0x60, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xBE, 0x3C, 0xF9, 0xE3, 0xEE,
  0x0F, 0xF0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x01, 0xCE,
  0x0E, 0x3F, 0xF0, 0x3F, 0x80, 0x01, 0x87, 0xCF, 0xFF, 0xFE, 0x3C, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xE0, 0x7F, 0xE1, 0xE1, 0xE3,
  0x80, 0xE6, 0x01, 0xDC, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xC0,
  0x0F, 0xE0, 0xFF, 0xC3, 0x83, 0x9C, 0x07, 0x70, 0x1D, 0x80, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x01, 0xFC, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0xE0, 0x0D, 0x80, 0x77, 0x01, 0xDE, 0x0E, 0x3F,
  0xF8, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xB8, 0x03, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C,
  0x38, 0x18, 0x38, 0x38, 0x38, 0x70, 0x38, 0x60, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x3F,
  0xF8, 0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x6F, 0xE1, 0xFF, 0xC7, 0x0F, 0x88, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0x9E, 0x1E, 0x3F, 0xF0,
  0x7F, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xEF, 0xE3, 0xFF, 0xCF, 0x87, 0xBC, 0x0E, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x03, 0x8E,
  0x1E, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1F,
  0xC0, 0xFF, 0xC7, 0x87, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0x70, 0x70, 0xFF, 0xC1, 0xFC, 0x0F, 0xF8, 0x70, 0x73, 0x80, 0xEE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0x9C, 0x1E, 0x3F, 0xF0,
  0x7F, 0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0x87, 0x9C, 0x0E, 0x60, 0x1B, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDE, 0x1F, 0x3F,
  0xFC, 0x7F, 0x70, 0x71, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x03,
  0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3B, 0xFF, 0x70, 0x39, 0xE7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x8E, 0x38, 0xE7, 0x1C, 0x63, 0x80, 0x00, 0x10, 0x03,
  0x00, 0xF0, 0x7F, 0x1F, 0x87, 0xE0, 0xF0, 0x0E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x3E, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x7E, 0x1F,
  0xC1, 0xF8, 0x0E, 0x00, 0x40, 0x00, 0x1F, 0xC3, 0xFF, 0x9C, 0x3D, 0xC0,
  0x7E, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03,
  0x83, 0x00, 0xC3, 0x04, 0x33, 0x0F, 0x99, 0x8E, 0xC4, 0xCC, 0x62, 0xC6,
  0x31, 0xE3, 0x18, 0xF3, 0x0C, 0x79, 0x86, 0x2C, 0xC3, 0x16, 0x61, 0x9B,
  0x39, 0xCD, 0x8F, 0xFC, 0x67, 0x9C, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x02,
  0x01, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x06, 0x30,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0x83, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFC, 0x38, 0x0E, 0x18, 0x03, 0x1C, 0x01, 0xCE, 0x00, 0xE6,
  0x00, 0x77, 0x00, 0x1C, 0xFF, 0x83, 0xFF, 0x8C, 0x1F, 0x30, 0x0E, 0xC0,
  0x3B, 0x00, 0xEC, 0x03, 0xB0, 0x0E, 0xC0, 0x73, 0xFF, 0xCF, 0xFC, 0x3F,
  0xFC, 0xC0, 0x3B, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xB0, 0x7E, 0xFF, 0xF3, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xE0,
  0xE3, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x07, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0xC3, 0x87, 0xC7, 0x01, 0xCE, 0x01, 0xDC, 0x03,
  0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0xE7, 0x0F, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F,
  0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xF0,
  0xE3, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x39, 0xE0, 0xF1, 0xFF, 0x81, 0xFE,
  0x00, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x0E,
  0xE0, 0x39, 0xC0, 0x71, 0xE1, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xC0, 0x1D,
  0x80, 0x73, 0x01, 0xC6, 0x07, 0x8C, 0x1E, 0x18, 0x38, 0x30, 0xE0, 0x63,
  0x80, 0xCF, 0x01, 0xBC, 0x03, 0x78, 0x07, 0xF8, 0x0F, 0x78, 0x1C, 0x70,
  0x38, 0x70, 0x60, 0xF0, 0xC0, 0xE1, 0x80, 0xE3, 0x01, 0xE6, 0x01, 0xCC,
  0x01, 0xD8, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x1B, 0xF6, 0x37, 0xEE, 0xEF,
  0xDD, 0x9F, 0x9F, 0x3F, 0x3E, 0x7E, 0x78, 0xFC, 0x71, 0xF8, 0xE3, 0xF1,
  0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xC0, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3E,
  0xC0, 0xFB, 0x83, 0xE6, 0x0F, 0x9C, 0x3E, 0x38, 0xF8, 0xE3, 0xE1, 0xCF,
  0x87, 0x3E, 0x0E, 0xF8, 0x3B, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xE0, 0x3F, 0xE0, 0xF1, 0xE3, 0x81, 0xC7,
  0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0C,
  0xE0, 0x39, 0xC0, 0xE1, 0xE3, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0xCE, 0x0F, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x03, 0xC7, 0x00, 0xE3,
  0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x39, 0x80, 0x1C, 0xE0, 0x0E, 0x70,
  0x06, 0x38, 0x07, 0x0E, 0x07, 0x83, 0xC7, 0x80, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x00, 0xFF, 0x83, 0xFF,
  0x8E, 0x0F, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3B, 0x80, 0xEE, 0x1F, 0x3F, 0xF8, 0xFF, 0xC3, 0x87, 0x0E, 0x0E, 0x38,
  0x38, 0xE0, 0x73, 0x81, 0xCE, 0x03, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x70,
  0x0F, 0xE0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xE7, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x7B,
  0xE1, 0xE3, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x37, 0x00,
  0x6E, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x06, 0xE0,
  0x1C, 0xC0, 0x39, 0xC0, 0xF1, 0xC3, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xE0,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x0E, 0x38,
  0x0C, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x0C, 0x38, 0x0E,
  0x30, 0x0E, 0x70, 0x06, 0x70, 0x07, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xEC, 0x38, 0x66, 0x3E, 0x33, 0x1F, 0x19, 0x8D, 0x8C, 0xE6, 0xCE,
  0x73, 0x67, 0x39, 0xB3, 0x9D, 0xDD, 0xCE, 0xC6, 0xC3, 0x63, 0x61, 0xB1,
  0xB0, 0xD8, 0xD8, 0x6C, 0x6C, 0x3E, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0x87,
  0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0x07, 0xBC, 0x07, 0x8E, 0x03,
  0x83, 0x83, 0x81, 0xC1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0xE0, 0x07,
  0x70, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x0E, 0x0F, 0x07, 0x87, 0x01,
  0xC7, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x38,
  0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x06,
  0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x3F, 0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x1D, 0x81, 0xDC, 0x19,
  0xC3, 0x8C, 0x30, 0xE7, 0x06, 0x70, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xE1, 0xC3, 0x03, 0x80, 0x7F, 0xC3, 0xFF, 0x9C, 0x0E, 0x70, 0x1C,
  0x00, 0x70, 0x01, 0xC3, 0xFF, 0x3F, 0xFD, 0xE0, 0x77, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0xF7, 0x8F, 0xDF, 0xFF, 0x1F, 0x9C, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x70, 0x37, 0xF8, 0xFF,
  0xF3, 0xC1, 0xCE, 0x03, 0xB0, 0x0E, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xF0,
  0x07, 0xC0, 0x1B, 0x00, 0xEE, 0x03, 0xB8, 0x1E, 0xF0, 0xF3, 0x7F, 0x8C,
  0xFC, 0x00, 0x03, 0x80, 0x7F, 0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x1D, 0x80,
  0x3E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x0D, 0xC0, 0x73, 0x83, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x71, 0xC7, 0xF7, 0x3F, 0xFD,
  0xE0, 0xF7, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x07, 0x3C, 0x7C, 0xFF, 0xF0, 0xFD,
  0xC0, 0x03, 0x80, 0x1F, 0xE0, 0xFF, 0xE1, 0xC1, 0xC7, 0x01, 0xCC, 0x03,
  0xB8, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x01, 0x8F, 0x0F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7C, 0x03,
  0xFC, 0x0F, 0xB8, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0xFF, 0xFD, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0x73, 0xFF, 0xDE,
  0x0F, 0x70, 0x1D, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0x70, 0x1D, 0xC0, 0xF3, 0xC7, 0xCF, 0xFF, 0x0F, 0xDC,
  0x00, 0x70, 0x01, 0xC8, 0x0E, 0x70, 0x78, 0xFF, 0xC1, 0xFE, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0E, 0x19, 0xFC,
  0xDF, 0xF7, 0x83, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xEF, 0xF3, 0xF8, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0xB0, 0x1C, 0xC0, 0xE3, 0x07, 0x0C, 0x38,
  0x31, 0xC0, 0xCE, 0x03, 0x78, 0x0F, 0xE0, 0x3D, 0xC0, 0xE7, 0x83, 0x0F,
  0x0C, 0x1E, 0x30, 0x38, 0xC0, 0x73, 0x01, 0xEC, 0x03, 0xC0, 0xFF, 0x03,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x1C, 0xFF, 0xBE, 0xFF, 0xFF, 0xE1, 0xC7, 0xE1,
  0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1,
  0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1,
  0xC3, 0x03, 0x86, 0x7F, 0x37, 0xFD, 0xE0, 0xFE, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xE3, 0xC1,
  0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x6E, 0x01, 0xCE, 0x03, 0x9E, 0x1E, 0x1F, 0xF8, 0x0F,
  0xE0, 0x07, 0x86, 0xFF, 0x3F, 0xFD, 0xE0, 0xEE, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3F,
  0xC3, 0xDF, 0xFC, 0xCF, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x7F, 0x73, 0xFF, 0xDE, 0x0F, 0x70, 0x1D,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0x70, 0x1D, 0xC0, 0x73, 0x87, 0xCF, 0xFF, 0x0F, 0xDC, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xDC, 0xFF, 0xFF,
  0xFE, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xFF, 0x1F,
  0xFC, 0xE0, 0xFE, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x1E, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xEF, 0xFE, 0x1F, 0xE0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x10, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xB8, 0x7D, 0xFF, 0xE7,
  0xE7, 0xF0, 0x07, 0x70, 0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0x70, 0x07,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xC1, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xCC, 0x38, 0x66, 0x36, 0x33, 0x1B, 0x19, 0x8D, 0x9C,
  0xE6, 0xCC, 0x36, 0x76, 0x1B, 0x1B, 0x0D, 0x8D, 0x86, 0xC6, 0xC3, 0xC3,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0xF0, 0x1E, 0xE0, 0x78, 0xE0,
  0xE0, 0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x3B, 0x80, 0xE3, 0x83, 0x87, 0x87, 0x07, 0x1C, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x01, 0xDC,
  0x00, 0xEC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x3E, 0x0F,
  0x03, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xF0, 0x3C, 0x1F, 0x0E,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x20, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0xF9, 0xF0, 0xF8,
  0x3F, 0xEC, 0x0F, 0xE0, 0x01, 0xE0,
};

const GFXglyph RobotoMono_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 4, 22, 19, 7, -22 },
  { 12, 8, 7, 19, 5, -23 },
  { 19, 17, 22, 19, 1, -22 },
  { 66, 15, 29, 19, 2, -26 },
  { 121, 17, 22, 19, 1, -22 },
  { 168, 16, 22, 19, 2, -22 },
  { 212, 3, 7, 19, 7, -23 },
  { 215, 8, 32, 19, 5, -25 },
  { 247, 8, 32, 19, 5, -25 },
  { 279, 15, 15, 19, 2, -22 },
  { 308, 15, 16, 19, 2, -18 },
  { 338, 5, 8, 19, 5, -3 },
  { 343, 12, 3, 19, 3, -11 },
  { 348, 4, 4, 19, 8, -4 },
  { 350, 12, 24, 19, 4, -22 },
  { 386, 14, 22, 19, 2, -22 },
  { 425, 9, 22, 19, 3, -22 },
  { 450, 15, 22, 19, 1, -22 },
  { 492, 14, 22, 19, 1, -22 },
  { 531, 16, 22, 19, 1, -22 },
  { 575, 14, 22, 19, 3, -22 },
  { 614, 14, 22, 19, 2, -22 },
  { 653, 15, 22, 19, 2, -22 },
  { 695, 14, 22, 19, 3, -22 },
  { 734, 14, 22, 19, 2, -22 },
  { 773, 5, 17, 19, 8, -17 },
  { 784, 6, 22, 19, 7, -17 },
  { 801, 12, 14, 19, 3, -17 },
  { 822, 13, 8, 19, 3, -14 },
  { 835, 13, 14, 19, 3, -17 },
  { 858, 13, 22, 19, 3, -22 },
  { 894, 17, 22, 19, 1, -22 },
  { 941, 17, 22, 19, 1, -22 },
  { 988, 14, 22, 19, 3, -22 },
  { 1027, 15, 22, 19, 2, -22 },
  { 1069, 15, 22, 19, 2, -22 },
  { 1111, 13, 22, 19, 3, -22 },
  { 1147, 13, 22, 19, 3, -22 },
  { 1183, 15, 22, 19, 2, -22 },
  { 1225, 14, 22, 19, 2, -22 },
  { 1264, 13, 22, 19, 3, -22 },
  { 1300, 15, 22, 19, 1, -22 },
  { 1342, 15, 22, 19, 3, -22 },
  { 1384, 14, 22, 19, 3, -22 },
  { 1423, 15, 22, 19, 2, -22 },
  { 1465, 14, 22, 19, 2, -22 },
  { 1504, 15, 22, 19, 2, -22 },
  { 1546, 14, 22, 19, 3, -22 },
  { 1585, 17, 26, 19, 1, -22 },
  { 1641, 14, 22, 19, 3, -22 },
  { 1680, 15, 22, 19, 2, -22 },
  { 1722, 17, 22, 19, 1, -22 },
  { 1769, 15, 22, 19, 2, -22 },
  { 1811, 16, 22, 19, 1, -22 },
  { 1855, 17, 22, 19, 1, -22 },
  { 1902, 17, 22, 19, 1, -22 },
  { 1949, 16, 22, 19, 1, -22 },
  { 1993, 14, 22, 19, 2, -22 },
  { 2032, 6, 30, 19, 6, -25 },
  { 2055, 12, 24, 19, 3, -22 },
  { 2091, 6, 30, 19, 6, -25 },
  { 2114, 12, 12, 19, 3, -22 },
  { 2132, 14, 2, 19, 2, 0 },
  { 2136, 6, 4, 19, 6, -22 },
  { 2139, 14, 17, 19, 2, -17 },
  { 2169, 14, 23, 19, 3, -23 },
  { 2210, 14, 17, 19, 2, -17 },
  { 2240, 14, 23, 19, 2, -23 },
  { 2281, 15, 17, 19, 2, -17 },
  { 2313, 15, 24, 19, 2, -24 },
  { 2358, 14, 23, 19, 2, -17 },
  { 2399, 13, 23, 19, 3, -23 },
  { 2437, 14, 22, 19, 3, -22 },
  { 2476, 10, 29, 19, 3, -22 },
  { 2513, 14, 23, 19, 3, -23 },
  { 2554, 14, 23, 19, 3, -23 },
  { 2595, 16, 17, 19, 1, -17 },
  { 2629, 13, 17, 19, 3, -17 },
  { 2657, 15, 17, 19, 2, -17 },
  { 2689, 13, 23, 19, 3, -17 },
  { 2727, 14, 23, 19, 2, -17 },
  { 2768, 11, 17, 19, 5, -17 },
  { 2792, 13, 17, 19, 3, -17 },
  { 2820, 14, 20, 19, 2, -20 },
  { 2855, 13, 16, 19, 3, -16 },
  { 2881, 16, 16, 19, 1, -16 },
  { 2913, 17, 16, 19, 1, -16 },
  { 2947, 15, 16, 19, 2, -16 },
  { 2977, 17, 23, 19, 1, -16 },
  { 3026, 14, 16, 19, 2, -16 },
  { 3054, 10, 30, 19, 5, -24 },
  { 3092, 2, 28, 19, 8, -22 },
  { 3099, 10, 30, 19, 5, -24 },
  { 3137, 17, 6, 19, 1, -12 },
};

const GFXfont RobotoMono_Regular31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular31pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_REGULAR31PT7B_H_
