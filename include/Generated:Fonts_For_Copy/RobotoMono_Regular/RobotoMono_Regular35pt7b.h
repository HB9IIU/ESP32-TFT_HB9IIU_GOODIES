#ifndef _ROBOTOMONO_REGULAR35PT7B_H_
#define _ROBOTOMONO_REGULAR35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x02,
  0xFF, 0x70, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0D, 0x86, 0x00,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0xE1, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x0C,
  0x18, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x60, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0E, 0x70, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0x8E, 0x00,
  0x61, 0xC2, 0x0C, 0x18, 0x61, 0x83, 0x1C, 0x30, 0x63, 0x06, 0x1C, 0xE0,
  0xF7, 0x18, 0x0F, 0xE7, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0xC0, 0x0C, 0x7E, 0x03, 0x9D, 0xE0, 0x67, 0x1C,
  0x1C, 0xC1, 0x83, 0x18, 0x30, 0xE3, 0x06, 0x08, 0x60, 0xC0, 0x0E, 0x38,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xE7, 0x80,
  0xF0, 0xE0, 0x38, 0x38, 0x0E, 0x06, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x1C,
  0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x07, 0x9C, 0x1D, 0xC7, 0x87, 0xF0, 0xF3, 0xB8, 0x1E, 0xEE, 0x03, 0xBB,
  0x80, 0xFC, 0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0xC7, 0xF8, 0xFF, 0xFE, 0x1F,
  0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x81, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x10, 0x40, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x01, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xE1, 0x82, 0xF9, 0x9F, 0xFF, 0xFF, 0x1F,
  0xFC, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x78, 0x3C,
  0x3C, 0x38, 0x18, 0x08, 0x10, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39, 0xCE,
  0x77, 0xBD, 0xCE, 0xE2, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x23, 0xFE, 0xF7,
  0x80, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xDF, 0x87, 0x01, 0xC7, 0x80, 0xF3,
  0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x1E, 0xFF, 0x1E, 0x7F, 0xBC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC,
  0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x70,
  0xF8, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x83, 0xC7, 0xFF, 0xFF,
  0xBF, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xDF, 0x8F, 0x01, 0xC7, 0x00, 0xF3, 0x80,
  0x3B, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xF1, 0xFB, 0xF3,
  0x80, 0xEE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDF,
  0x1F, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x77, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x78, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x7C,
  0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x73, 0xF0,
  0x7F, 0xFC, 0x7E, 0x7E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x3C, 0x1E,
  0x1E, 0x3C, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xF8, 0x3E, 0x7C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8,
  0x0F, 0xF0, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFB, 0xE3, 0x81, 0xEF, 0x01, 0xDC,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x01, 0xEF, 0x0F, 0xCF, 0xFF, 0x8F, 0xF7, 0x07, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0x00, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x7F,
  0xFE, 0xF0, 0x10, 0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x9C, 0xE0, 0x80, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x3C, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0x00, 0x3E, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x1F, 0x00, 0x38,
  0x00, 0x40, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC0, 0xEF, 0x01,
  0xFC, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3C, 0x3C, 0x0E, 0x01, 0xC1,
  0x80, 0x18, 0x60, 0xE1, 0x8C, 0x3F, 0x33, 0x0E, 0x62, 0x63, 0x8C, 0x6C,
  0x61, 0x8F, 0x9C, 0x31, 0xE3, 0x04, 0x3C, 0x61, 0x87, 0x8C, 0x30, 0xF1,
  0x86, 0x16, 0x30, 0xC6, 0xC6, 0x38, 0xDC, 0xFF, 0xB1, 0x8F, 0xBE, 0x30,
  0x81, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x83, 0x00, 0x7F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03,
  0x81, 0xC0, 0xF0, 0x38, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1C,
  0x01, 0xC3, 0x80, 0x3C, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0F, 0xF0,
  0x00, 0xE0, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C,
  0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xDF, 0x87, 0x01,
  0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xEE, 0x00, 0xF7, 0x00,
  0x71, 0xC0, 0x78, 0xF8, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x73,
  0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x80, 0x39, 0xE0, 0x3C,
  0x7C, 0x7C, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x7E, 0x7C, 0x3F, 0xF8,
  0x0F, 0xF0, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x07, 0x8E, 0x07,
  0x87, 0x03, 0x83, 0x83, 0xC1, 0xC3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x39,
  0xC0, 0x1D, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0x01, 0xE3, 0xC0,
  0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x8E, 0x01, 0xC7, 0x00,
  0xF3, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xDC, 0x37,
  0xDC, 0x77, 0xDC, 0x77, 0xCE, 0x67, 0xEE, 0xE7, 0xEE, 0xE7, 0xE6, 0xC7,
  0xE7, 0xC7, 0xE7, 0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xF7, 0x07, 0xFB, 0xC3, 0xFC, 0xE1, 0xFE,
  0x78, 0xFF, 0x1C, 0x7F, 0x8F, 0x3F, 0xC3, 0x9F, 0xE1, 0xEF, 0xF0, 0x77,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xEE, 0x00,
  0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0xFD, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9C, 0x03, 0xCE, 0x00, 0xF7, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDC,
  0x03, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xE0, 0xF0, 0x78, 0x78, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00,
  0x39, 0xC0, 0x1C, 0x78, 0x07, 0x0E, 0x03, 0x83, 0xF7, 0xE0, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x3E,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x78,
  0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x07, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0x81, 0xE7, 0x80,
  0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0xC0,
  0x3C, 0xFC, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xCE, 0x00, 0xE7, 0x80, 0xF1, 0xC0, 0x70, 0xFD, 0xF8, 0x3F, 0xF8, 0x07,
  0xF0, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x01, 0xE3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x78, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1E, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x3C, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1D, 0xC3, 0xC3, 0xB8, 0x78, 0x77,
  0x0F, 0x0E, 0xE3, 0xE1, 0xDC, 0x7C, 0x33, 0x8F, 0x8E, 0x71, 0xB9, 0xCE,
  0x37, 0x39, 0xC6, 0xE7, 0x19, 0xCC, 0xE3, 0xB9, 0x9C, 0x77, 0x33, 0x8E,
  0xC7, 0x61, 0xD8, 0xEC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x00, 0x78, 0x01, 0xEF, 0x00, 0x78, 0xF0, 0x0E, 0x0E, 0x03, 0xC1,
  0xE0, 0x70, 0x1C, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0xBC, 0x00,
  0x77, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0x9C, 0x00, 0xE3, 0xC0, 0x3C, 0x38, 0x07,
  0x07, 0x81, 0xE0, 0x70, 0x38, 0x0F, 0x0F, 0x00, 0xE3, 0xC0, 0x1E, 0xF8,
  0x01, 0xE0, 0xF0, 0x01, 0xEE, 0x00, 0x79, 0xE0, 0x0E, 0x1C, 0x03, 0xC3,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFE, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xFE, 0x07, 0x00,
  0x38, 0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x0E, 0xE0, 0x77, 0x07, 0x1C, 0x38,
  0xE1, 0x87, 0x1C, 0x1C, 0xE0, 0xEE, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x70, 0x70, 0x70, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xE3,
  0x81, 0xEF, 0x01, 0xFC, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0xFE, 0x7F,
  0xFD, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x1F,
  0xFD, 0xFE, 0xFF, 0xDC, 0xFF, 0x38, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xEF, 0xF8,
  0xFF, 0xFC, 0xF8, 0x3C, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xFC, 0x7C, 0xEF, 0xF8, 0xE7, 0xF0, 0x03, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFE, 0x3C, 0x1E, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x07, 0x78, 0x07, 0x38, 0x0F, 0x3E, 0x1E, 0x1F, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x03, 0xC7, 0x0F, 0xF7, 0x1F, 0xFF, 0x3C, 0x1F, 0x78, 0x0F,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x07, 0x38, 0x0F, 0x3E, 0x3F,
  0x1F, 0xFF, 0x0F, 0xE7, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83,
  0xC3, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x08,
  0x78, 0x0E, 0x3F, 0x1F, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0xF7, 0x1F, 0xFF, 0x3C, 0x1F, 0x78,
  0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x07, 0x38, 0x0F, 0x3E,
  0x3F, 0x1F, 0xFF, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x20, 0x0F, 0x30,
  0x1E, 0x7C, 0x7C, 0x1F, 0xFC, 0x0F, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0xF0, 0xE7, 0xF9,
  0xDF, 0xFB, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x0F, 0x3F, 0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x02, 0xE0, 0x3C,
  0xE0, 0x78, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xEF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0xF3, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0,
  0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x0E, 0x6F, 0xDF, 0xBF, 0xFF, 0xFC, 0x3C, 0x7E, 0x1C,
  0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87,
  0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xE0, 0x01, 0xE1, 0xCF, 0xF3, 0xBF,
  0xF7, 0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7B, 0x80,
  0x39, 0xC0, 0x1C, 0xF0, 0x1C, 0x3E, 0x3E, 0x0F, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xC0, 0xEF, 0xF0, 0xFF, 0xF8, 0xF8, 0x3C, 0xF0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C, 0xFC, 0x7C, 0xFF, 0xF8,
  0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xF7, 0x1F, 0xFF, 0x3C, 0x1F,
  0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x07, 0x38, 0x0F,
  0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xFE, 0x7F, 0xEF,
  0xFF, 0xE1, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC0, 0xF7, 0x00, 0xEE, 0x01,
  0xDC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0x7C, 0x3E, 0x7F, 0xF8, 0x3F,
  0xC0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xE3, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x03, 0xDC, 0x07, 0xBE, 0x7F, 0x3F, 0xEE, 0x3F, 0x9C, 0xE0, 0x03, 0xF8,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xB0, 0x78, 0x77, 0x1B, 0x0C,
  0xE3, 0x61, 0x9C, 0x6C, 0x71, 0x8D, 0xCE, 0x33, 0xB9, 0x86, 0x63, 0x30,
  0xEC, 0x66, 0x1D, 0x8F, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x1E, 0x07, 0x01, 0x80, 0xE0, 0xF0, 0x07, 0x9C, 0x07, 0x8F,
  0x07, 0x83, 0xC3, 0x80, 0xE3, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xEF, 0x00, 0xF3, 0x80, 0xF0,
  0xE0, 0x70, 0x78, 0x70, 0x1E, 0x78, 0x07, 0x78, 0x03, 0xC0, 0xF0, 0x01,
  0xEF, 0x00, 0x79, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x38, 0x0E,
  0x07, 0x83, 0xC0, 0x70, 0x70, 0x0F, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x7C, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x07, 0xC0, 0xF0, 0x1F, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3F, 0x01, 0xE0, 0xFC, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x1E, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x0D, 0xFF,
  0x01, 0xF8, 0xF8, 0x7E, 0x0F, 0xFD, 0x80, 0xFF, 0x80, 0x07, 0xC0,
};

const GFXglyph RobotoMono_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 4, 25, 21, 8, -25 },
  { 14, 9, 8, 21, 6, -26 },
  { 23, 19, 25, 21, 1, -25 },
  { 83, 16, 33, 21, 3, -29 },
  { 149, 19, 25, 21, 1, -25 },
  { 209, 18, 25, 21, 2, -25 },
  { 266, 3, 8, 21, 8, -26 },
  { 269, 9, 36, 21, 6, -28 },
  { 310, 10, 36, 21, 5, -28 },
  { 355, 16, 17, 21, 3, -25 },
  { 389, 17, 19, 21, 2, -21 },
  { 430, 5, 10, 21, 6, -4 },
  { 437, 13, 2, 21, 4, -12 },
  { 441, 5, 5, 21, 8, -5 },
  { 445, 14, 27, 21, 4, -25 },
  { 493, 17, 25, 21, 2, -25 },
  { 547, 9, 25, 21, 4, -25 },
  { 576, 17, 25, 21, 1, -25 },
  { 630, 15, 25, 21, 2, -25 },
  { 677, 18, 25, 21, 1, -25 },
  { 734, 16, 25, 21, 3, -25 },
  { 784, 16, 25, 21, 2, -25 },
  { 834, 17, 25, 21, 2, -25 },
  { 888, 16, 25, 21, 3, -25 },
  { 938, 15, 25, 21, 3, -25 },
  { 985, 5, 20, 21, 9, -20 },
  { 998, 6, 26, 21, 8, -20 },
  { 1018, 14, 16, 21, 3, -19 },
  { 1046, 15, 10, 21, 3, -16 },
  { 1065, 15, 16, 21, 3, -19 },
  { 1095, 15, 25, 21, 3, -25 },
  { 1142, 19, 25, 21, 1, -25 },
  { 1202, 19, 25, 21, 1, -25 },
  { 1262, 16, 25, 21, 3, -25 },
  { 1312, 17, 25, 21, 2, -25 },
  { 1366, 16, 25, 21, 3, -25 },
  { 1416, 15, 25, 21, 3, -25 },
  { 1463, 16, 25, 21, 3, -25 },
  { 1513, 17, 25, 21, 2, -25 },
  { 1567, 17, 25, 21, 2, -25 },
  { 1621, 15, 25, 21, 3, -25 },
  { 1668, 16, 25, 21, 2, -25 },
  { 1718, 17, 25, 21, 3, -25 },
  { 1772, 16, 25, 21, 3, -25 },
  { 1822, 16, 25, 21, 3, -25 },
  { 1872, 17, 25, 21, 2, -25 },
  { 1926, 17, 25, 21, 2, -25 },
  { 1980, 17, 25, 21, 3, -25 },
  { 2034, 18, 29, 21, 2, -25 },
  { 2100, 16, 25, 21, 3, -25 },
  { 2150, 17, 25, 21, 2, -25 },
  { 2204, 19, 25, 21, 1, -25 },
  { 2264, 17, 25, 21, 2, -25 },
  { 2318, 19, 25, 21, 1, -25 },
  { 2378, 19, 25, 21, 1, -25 },
  { 2438, 19, 25, 21, 1, -25 },
  { 2498, 19, 25, 21, 1, -25 },
  { 2558, 16, 25, 21, 2, -25 },
  { 2608, 7, 33, 21, 7, -28 },
  { 2637, 13, 27, 21, 4, -25 },
  { 2681, 7, 33, 21, 7, -28 },
  { 2710, 13, 13, 21, 4, -25 },
  { 2732, 15, 3, 21, 3, 0 },
  { 2738, 7, 4, 21, 7, -25 },
  { 2742, 15, 19, 21, 3, -19 },
  { 2778, 16, 26, 21, 3, -26 },
  { 2830, 16, 19, 21, 2, -19 },
  { 2868, 16, 26, 21, 2, -26 },
  { 2920, 17, 19, 21, 2, -19 },
  { 2961, 16, 27, 21, 3, -27 },
  { 3015, 16, 26, 21, 2, -19 },
  { 3067, 15, 26, 21, 3, -26 },
  { 3116, 16, 25, 21, 3, -25 },
  { 3166, 11, 32, 21, 4, -25 },
  { 3210, 16, 26, 21, 3, -26 },
  { 3262, 16, 26, 21, 3, -26 },
  { 3314, 17, 19, 21, 2, -19 },
  { 3355, 15, 19, 21, 3, -19 },
  { 3391, 17, 19, 21, 2, -19 },
  { 3432, 16, 26, 21, 3, -19 },
  { 3484, 16, 26, 21, 2, -19 },
  { 3536, 12, 19, 21, 6, -19 },
  { 3565, 15, 19, 21, 3, -19 },
  { 3601, 16, 23, 21, 2, -23 },
  { 3647, 15, 18, 21, 3, -18 },
  { 3681, 17, 18, 21, 2, -18 },
  { 3720, 19, 18, 21, 1, -18 },
  { 3763, 17, 18, 21, 2, -18 },
  { 3802, 19, 25, 21, 1, -18 },
  { 3862, 16, 18, 21, 3, -18 },
  { 3898, 11, 33, 21, 6, -27 },
  { 3944, 3, 32, 21, 9, -25 },
  { 3956, 11, 33, 21, 6, -27 },
  { 4002, 19, 7, 21, 1, -14 },
};

const GFXfont RobotoMono_Regular35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular35pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_REGULAR35PT7B_H_
