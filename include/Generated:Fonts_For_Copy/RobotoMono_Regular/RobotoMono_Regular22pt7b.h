#ifndef _ROBOTOMONO_REGULAR22PT7B_H_
#define _ROBOTOMONO_REGULAR22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x3F, 0x8C, 0x63, 0x18, 0xC4, 0x0C,
  0x40, 0xC4, 0x0C, 0xC0, 0x8C, 0x08, 0xCF, 0xFF, 0x18, 0x81, 0x98, 0x11,
  0x81, 0x18, 0xFF, 0xEF, 0xFE, 0x33, 0x02, 0x30, 0x23, 0x06, 0x20, 0x0C,
  0x03, 0x01, 0xE1, 0xFC, 0x61, 0xB0, 0x6C, 0x0F, 0x80, 0x70, 0x0F, 0x01,
  0xF0, 0x0E, 0x01, 0xF0, 0x3C, 0x0F, 0x06, 0x7F, 0x8F, 0xC0, 0xC0, 0x30,
  0x38, 0x03, 0x60, 0x11, 0x11, 0x89, 0x84, 0x48, 0x36, 0xC0, 0xE4, 0x00,
  0x60, 0x02, 0x00, 0x33, 0x01, 0x7C, 0x1B, 0x30, 0x91, 0x8C, 0x8C, 0x06,
  0x40, 0x1E, 0x1E, 0x03, 0xF0, 0x31, 0x83, 0x18, 0x31, 0x83, 0x30, 0x3E,
  0x01, 0xC0, 0x3C, 0x06, 0x62, 0xE7, 0x6C, 0x36, 0xC1, 0xEE, 0x0C, 0x73,
  0xE3, 0xF7, 0xFF, 0xF0, 0x08, 0x31, 0x8C, 0x61, 0x86, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x70, 0x80, 0x83, 0x06,
  0x0C, 0x10, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x61,
  0x8C, 0x33, 0x84, 0x00, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xED, 0xDF, 0xE0,
  0xC0, 0x78, 0x33, 0x18, 0xE2, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x6D, 0xED,
  0x00, 0xFF, 0xFF, 0xC0, 0x7D, 0x80, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x60, 0xC0, 0xC0, 0x1E,
  0x1F, 0xCE, 0x1B, 0x06, 0xC0, 0xF0, 0x7C, 0x3F, 0x3B, 0xDC, 0xFC, 0x3E,
  0x0F, 0x03, 0xC1, 0xB0, 0x67, 0x30, 0xF8, 0x04, 0x77, 0xFB, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1E, 0x1F, 0xE6, 0x1B, 0x03,
  0xC0, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0F, 0xFF, 0xFF, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x7C, 0x1F, 0x00, 0x60, 0x0C, 0x03, 0xC0, 0xF0, 0x77, 0x38, 0xFC, 0x01,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0xD8, 0x33, 0x06, 0x61, 0x8C, 0x21, 0x8C,
  0x33, 0x06, 0x7F, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x7F, 0x9F, 0xE6,
  0x01, 0x80, 0x60, 0x18, 0x07, 0xF1, 0xFE, 0x21, 0x80, 0x30, 0x0C, 0x03,
  0xC0, 0xF8, 0x67, 0x38, 0xFC, 0x06, 0x0F, 0x0E, 0x0C, 0x0C, 0x06, 0x03,
  0xF9, 0xEE, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xDC, 0x7C, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x1E, 0x1F, 0xC6,
  0x1B, 0x06, 0xC1, 0xF0, 0x66, 0x18, 0xFC, 0x3F, 0x18, 0x6C, 0x0F, 0x03,
  0xC0, 0xF0, 0x77, 0x38, 0xFC, 0x1C, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE3, 0xBF, 0xCF, 0x60, 0x30, 0x30, 0x38, 0xF8, 0x70, 0xDF,
  0x80, 0x00, 0x1B, 0xF0, 0x67, 0x70, 0x00, 0x00, 0x00, 0x66, 0x66, 0xC4,
  0x00, 0x81, 0xC3, 0xC7, 0x8E, 0x07, 0x01, 0xF0, 0x1E, 0x03, 0x80, 0x40,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x1E, 0x03, 0xE0,
  0x38, 0x1C, 0x7C, 0xF0, 0xE0, 0x40, 0x00, 0x1E, 0x3F, 0xB8, 0x78, 0x30,
  0x18, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x38, 0x06, 0x01, 0xF8, 0x30, 0x46, 0x06, 0x4F, 0x2C, 0x92, 0x99, 0x29,
  0x12, 0x91, 0x29, 0x12, 0x93, 0x29, 0xFC, 0xC8, 0x84, 0x00, 0x71, 0x01,
  0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xF0, 0x0B, 0x01, 0xB0, 0x19, 0x81,
  0x18, 0x31, 0x83, 0x08, 0x3F, 0xC7, 0xFC, 0x60, 0xC6, 0x06, 0xC0, 0x6C,
  0x07, 0xFC, 0x3F, 0xCC, 0x3B, 0x06, 0xC0, 0xF0, 0x6C, 0x3B, 0xFC, 0xFF,
  0xB0, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x7F, 0xFB, 0xF8, 0x0F, 0x07, 0xF1,
  0xC3, 0x30, 0x36, 0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x36, 0x06, 0xC1, 0x8E, 0x70, 0xF8, 0xF8, 0x3F, 0x8C, 0x33, 0x06,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB0,
  0xEF, 0xF3, 0xF0, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFC, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0x07, 0xF1, 0xC3, 0x30,
  0x3C, 0x07, 0x80, 0x30, 0x06, 0x00, 0xC3, 0xF8, 0x7F, 0x01, 0xE0, 0x36,
  0x06, 0xE0, 0xCF, 0x70, 0xFC, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x63, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x03, 0xC0, 0xD8,
  0x77, 0xB8, 0xFC, 0xC0, 0xD8, 0x33, 0x0E, 0x63, 0x8C, 0x61, 0x98, 0x36,
  0x07, 0xC0, 0xFC, 0x1D, 0x83, 0x18, 0x63, 0x8C, 0x31, 0x83, 0x30, 0x76,
  0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x7E,
  0x1F, 0x8F, 0xA3, 0xEC, 0xBB, 0x6E, 0x5B, 0x9C, 0xF7, 0x3C, 0xCF, 0x23,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0xFC,
  0x3D, 0x8F, 0x63, 0xCC, 0xF3, 0x3C, 0x6F, 0x1B, 0xC3, 0xF0, 0xFC, 0x1F,
  0x07, 0x0E, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x36, 0x0C, 0xC1, 0x8F, 0xE0, 0xF8, 0xFC,
  0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0x8C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0x03, 0xF8, 0x71, 0xC6,
  0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x06, 0x60, 0x66, 0x0C, 0x3F, 0x81, 0xF8, 0x00, 0xC0, 0x07, 0x00, 0x20,
  0xFC, 0x3F, 0xCC, 0x1B, 0x07, 0xC0, 0xF0, 0x3C, 0x1F, 0x0E, 0xFF, 0x3F,
  0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0x6C, 0x1F, 0x03, 0x0F, 0x07, 0xF9, 0xC3,
  0x30, 0x36, 0x06, 0xC0, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0xE0,
  0x3E, 0x06, 0xC0, 0xCE, 0xF0, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34, 0x06, 0x80,
  0xD0, 0x1A, 0x03, 0x40, 0x68, 0x0F, 0x01, 0xA0, 0x36, 0x0C, 0xC1, 0x8E,
  0xE0, 0xF8, 0xC0, 0x78, 0x0F, 0x81, 0xB0, 0x66, 0x0C, 0xC1, 0x8C, 0x61,
  0x8C, 0x31, 0x83, 0x20, 0x6C, 0x0D, 0x80, 0xB0, 0x1C, 0x03, 0x80, 0x30,
  0xC6, 0x3C, 0x63, 0xCE, 0x2C, 0xE6, 0xCE, 0x6C, 0xF6, 0x4B, 0x64, 0xB6,
  0x7B, 0x67, 0x96, 0x79, 0x47, 0x9C, 0x71, 0xC7, 0x1C, 0x30, 0xC3, 0x0C,
  0xC0, 0x66, 0x0E, 0x70, 0xC3, 0x1C, 0x39, 0x81, 0xB0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x1B, 0x01, 0x98, 0x31, 0x87, 0x0C, 0x60, 0xEE, 0x07,
  0xC0, 0x78, 0x0D, 0x83, 0x30, 0x63, 0x18, 0x63, 0x06, 0xC0, 0xD8, 0x0E,
  0x01, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0xDF,
  0xF8, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0, 0x30, 0x18, 0x04, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C,
  0x06, 0x01, 0x80, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x3F, 0x80, 0x08, 0x0E, 0x07, 0x02, 0xC3, 0x61, 0x91,
  0x8C, 0xC6, 0xC1, 0x80, 0xFF, 0xFF, 0xF0, 0xE1, 0x86, 0x3E, 0x1F, 0xCC,
  0x1B, 0x06, 0x01, 0x8F, 0xEF, 0x1B, 0x06, 0xC1, 0xB0, 0x6F, 0xF9, 0xF7,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8F, 0xF3, 0x86, 0xC1, 0xB0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x6C, 0x1B, 0xDE, 0xDF, 0x00, 0x1E, 0x1F,
  0xCE, 0x1B, 0x06, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x67, 0x38,
  0xF8, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC7, 0xB3, 0xFD, 0xC3, 0x60,
  0xD8, 0x36, 0x0F, 0x03, 0x60, 0xD8, 0x36, 0x0C, 0xEF, 0x1F, 0xC0, 0x0F,
  0x07, 0xF1, 0xC3, 0x30, 0x66, 0x07, 0xFF, 0xFF, 0xFB, 0x00, 0x60, 0x0E,
  0x08, 0xE7, 0x8F, 0xC0, 0x07, 0xC3, 0xF1, 0x80, 0x60, 0x18, 0x3F, 0xEF,
  0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x1E, 0xCF, 0xF7, 0x0D, 0x83, 0x60, 0xD8, 0x3C, 0x0D, 0x83,
  0x60, 0xD8, 0x33, 0xBC, 0x7F, 0x00, 0xC8, 0x36, 0x1C, 0xFE, 0x0C, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x73, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0x80, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x0F, 0xFF, 0xFF, 0x06, 0x0C, 0x00, 0x07, 0xEF, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x3F, 0xEF, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x6C, 0x33, 0x18, 0xCC, 0x36, 0x0F,
  0x83, 0xF0, 0xCE, 0x31, 0x8C, 0x33, 0x0E, 0xC1, 0xC0, 0xFC, 0x3F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0xDD, 0xDF, 0xFF, 0x19, 0xE3,
  0x3C, 0x67, 0x8C, 0xF1, 0x9E, 0x33, 0xC6, 0x78, 0xCF, 0x19, 0xE3, 0x30,
  0xCE, 0x7F, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x30, 0x0F, 0x07, 0xF1, 0xC3, 0x30, 0x6C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x60, 0x6C, 0x18, 0xEE, 0x0F, 0x80, 0xDE, 0x3F, 0xCE, 0x3B, 0x06,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB0, 0x6F, 0x7B, 0x7C, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x1E, 0xCF, 0xF7, 0x0D, 0x83, 0x60, 0xD8, 0x3C, 0x0D,
  0x83, 0x60, 0xD8, 0x33, 0xBC, 0x7F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x8F,
  0xBE, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1E,
  0x1F, 0xEE, 0x1B, 0x06, 0xE0, 0x1F, 0x01, 0xF0, 0x06, 0xC0, 0xF0, 0x67,
  0x38, 0xFC, 0x18, 0x0C, 0x3F, 0xFF, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xD8, 0x7C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xDD, 0xE7, 0xB0, 0xC0, 0x6C, 0x0D, 0x83,
  0x30, 0x63, 0x08, 0x63, 0x04, 0x60, 0xD8, 0x1B, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x84, 0x38, 0x63, 0xCE, 0x2C, 0xE6, 0xCA, 0x64, 0xB6, 0x5B, 0x47,
  0x94, 0x71, 0x47, 0x1C, 0x31, 0xC3, 0x08, 0xE0, 0x6C, 0x18, 0xC7, 0x0C,
  0xC1, 0xF0, 0x1C, 0x03, 0x80, 0x78, 0x1B, 0x86, 0x31, 0xC3, 0x70, 0x30,
  0xC0, 0x78, 0x0D, 0x83, 0x30, 0x63, 0x0C, 0x63, 0x0E, 0x60, 0xD8, 0x1B,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x03, 0x80, 0x60, 0x00,
  0xFF, 0xBF, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18,
  0x0F, 0xFF, 0xFF, 0x07, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x30, 0xE0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0xFF, 0xFF, 0xF0, 0x60, 0xB0, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0E, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0x40,
  0x30, 0x0F, 0xC3, 0xCE, 0x28, 0x7E, 0x01, 0x80,
};

const GFXglyph RobotoMono_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 5, 6, 13, 4, -17 },
  { 11, 12, 16, 13, 1, -16 },
  { 35, 10, 20, 13, 2, -18 },
  { 60, 13, 16, 13, 0, -16 },
  { 86, 12, 16, 13, 1, -16 },
  { 110, 2, 6, 13, 5, -17 },
  { 112, 6, 23, 13, 4, -18 },
  { 130, 6, 23, 13, 3, -18 },
  { 148, 10, 11, 13, 2, -16 },
  { 162, 11, 11, 13, 1, -13 },
  { 178, 3, 6, 13, 4, -2 },
  { 181, 9, 2, 13, 2, -8 },
  { 184, 3, 3, 13, 5, -3 },
  { 186, 8, 17, 13, 3, -16 },
  { 203, 10, 16, 13, 2, -16 },
  { 223, 6, 16, 13, 2, -16 },
  { 235, 10, 16, 13, 1, -16 },
  { 255, 10, 16, 13, 1, -16 },
  { 275, 11, 16, 13, 1, -16 },
  { 297, 10, 16, 13, 2, -16 },
  { 317, 9, 16, 13, 2, -16 },
  { 335, 11, 16, 13, 1, -16 },
  { 357, 10, 16, 13, 2, -16 },
  { 377, 9, 16, 13, 2, -16 },
  { 395, 3, 12, 13, 6, -12 },
  { 400, 4, 16, 13, 5, -12 },
  { 408, 9, 10, 13, 2, -12 },
  { 420, 9, 6, 13, 2, -10 },
  { 427, 9, 10, 13, 2, -12 },
  { 439, 9, 16, 13, 2, -16 },
  { 457, 12, 16, 13, 1, -16 },
  { 481, 12, 16, 13, 1, -16 },
  { 505, 10, 16, 13, 2, -16 },
  { 525, 11, 16, 13, 1, -16 },
  { 547, 10, 16, 13, 2, -16 },
  { 567, 10, 16, 13, 2, -16 },
  { 587, 10, 16, 13, 2, -16 },
  { 607, 11, 16, 13, 1, -16 },
  { 629, 10, 16, 13, 2, -16 },
  { 649, 9, 16, 13, 2, -16 },
  { 667, 10, 16, 13, 1, -16 },
  { 687, 11, 16, 13, 2, -16 },
  { 709, 10, 16, 13, 2, -16 },
  { 729, 10, 16, 13, 2, -16 },
  { 749, 10, 16, 13, 2, -16 },
  { 769, 11, 16, 13, 1, -16 },
  { 791, 10, 16, 13, 2, -16 },
  { 811, 12, 19, 13, 1, -16 },
  { 840, 10, 16, 13, 2, -16 },
  { 860, 11, 16, 13, 1, -16 },
  { 882, 11, 16, 13, 1, -16 },
  { 904, 11, 16, 13, 1, -16 },
  { 926, 11, 16, 13, 1, -16 },
  { 948, 12, 16, 13, 1, -16 },
  { 972, 12, 16, 13, 1, -16 },
  { 996, 11, 16, 13, 1, -16 },
  { 1018, 11, 16, 13, 1, -16 },
  { 1040, 4, 21, 13, 5, -18 },
  { 1051, 9, 17, 13, 2, -16 },
  { 1071, 5, 21, 13, 4, -18 },
  { 1085, 9, 9, 13, 2, -16 },
  { 1096, 10, 2, 13, 2, 0 },
  { 1099, 5, 3, 13, 4, -16 },
  { 1101, 10, 12, 13, 2, -12 },
  { 1116, 10, 17, 13, 2, -17 },
  { 1138, 10, 12, 13, 2, -12 },
  { 1153, 10, 17, 13, 1, -17 },
  { 1175, 11, 12, 13, 1, -12 },
  { 1192, 10, 17, 13, 2, -17 },
  { 1214, 10, 17, 13, 1, -12 },
  { 1236, 9, 17, 13, 2, -17 },
  { 1256, 10, 16, 13, 2, -16 },
  { 1276, 7, 21, 13, 2, -16 },
  { 1295, 10, 17, 13, 2, -17 },
  { 1317, 10, 17, 13, 2, -17 },
  { 1339, 11, 12, 13, 1, -12 },
  { 1356, 9, 12, 13, 2, -12 },
  { 1370, 11, 12, 13, 1, -12 },
  { 1387, 10, 16, 13, 2, -12 },
  { 1407, 10, 16, 13, 1, -12 },
  { 1427, 8, 12, 13, 4, -12 },
  { 1439, 10, 12, 13, 2, -12 },
  { 1454, 9, 14, 13, 2, -14 },
  { 1470, 9, 12, 13, 2, -12 },
  { 1484, 11, 12, 13, 1, -12 },
  { 1501, 12, 12, 13, 1, -12 },
  { 1519, 11, 12, 13, 1, -12 },
  { 1536, 11, 17, 13, 1, -12 },
  { 1560, 10, 12, 13, 2, -12 },
  { 1575, 8, 21, 13, 3, -17 },
  { 1596, 1, 20, 13, 6, -16 },
  { 1599, 8, 21, 13, 3, -17 },
  { 1620, 12, 5, 13, 1, -9 },
};

const GFXfont RobotoMono_Regular22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular22pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_REGULAR22PT7B_H_
