#ifndef _ROBOTOMONO_REGULAR27PT7B_H_
#define _ROBOTOMONO_REGULAR27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x00, 0x7D, 0x80, 0xCF, 0x3C, 0xF3,
  0x8E, 0x30, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x0F,
  0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80, 0xC3,
  0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x00,
  0xC6, 0x00, 0x03, 0x00, 0x30, 0x03, 0x01, 0xFC, 0x3F, 0xE7, 0x07, 0x70,
  0x76, 0x03, 0x60, 0x37, 0x00, 0x38, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x37, 0x07, 0x3F, 0xE1, 0xFC, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x7C, 0x01, 0x98, 0x02, 0x18, 0xC4, 0x33, 0x08,
  0x66, 0x18, 0x98, 0x3F, 0x30, 0x3C, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x33, 0xC0, 0x4F, 0xC1, 0x90, 0x86, 0x61, 0x8C, 0xC3, 0x08, 0x84,
  0x01, 0x98, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xE3, 0x81, 0xC3, 0x03,
  0x86, 0x07, 0x18, 0x06, 0x70, 0x0F, 0xC0, 0x0E, 0x00, 0x3E, 0x00, 0xFC,
  0x33, 0x9C, 0x66, 0x1C, 0xDC, 0x1F, 0xB8, 0x3E, 0x30, 0x3C, 0x70, 0x78,
  0x7F, 0xF8, 0x7E, 0x78, 0xFE, 0xA0, 0x02, 0x0C, 0x30, 0xC3, 0x06, 0x18,
  0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x06,
  0x0C, 0x1C, 0x18, 0x18, 0x30, 0x38, 0x20, 0x81, 0x81, 0x81, 0x83, 0x83,
  0x07, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x38,
  0x70, 0xC1, 0x86, 0x0C, 0x30, 0xE3, 0x86, 0x00, 0x07, 0x00, 0x38, 0x01,
  0x81, 0x04, 0x2F, 0x23, 0x7F, 0xFC, 0x7F, 0x00, 0xE0, 0x0D, 0x80, 0xCE,
  0x0E, 0x30, 0x61, 0xC1, 0x04, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x6D, 0xB7, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0x80, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x1F, 0xC3, 0xFE, 0x70, 0x6E, 0x07,
  0xE0, 0x3C, 0x03, 0xC0, 0xFC, 0x1F, 0xC3, 0xBC, 0x73, 0xDC, 0x3F, 0x83,
  0xF0, 0x3C, 0x03, 0xE0, 0x36, 0x07, 0x70, 0xE3, 0xFE, 0x1F, 0x80, 0x06,
  0x3F, 0xFF, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x1F, 0xC1, 0xFF, 0x1C, 0x1D, 0xC0, 0xEE, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x1F,
  0xC3, 0xFE, 0x70, 0x76, 0x07, 0xE0, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x0F,
  0xC0, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0xE0, 0x3E, 0x03, 0x70,
  0x73, 0xFE, 0x1F, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0x60, 0x19, 0x80, 0xE6, 0x03, 0x18, 0x18, 0x60, 0xE1, 0x83, 0x06, 0x18,
  0x18, 0xE0, 0x63, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x3F, 0xF1, 0xFF, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC8, 0x0F, 0xF8, 0x7F, 0xE1, 0x83, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x1F, 0x80, 0xCC, 0x06, 0x70, 0x71, 0xFF, 0x07, 0xF0, 0x07, 0x81, 0xF8,
  0x3C, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE7, 0x0D, 0xFC, 0xFF, 0xEE, 0x0E,
  0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x76, 0x07, 0x70, 0xE3, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x1F, 0xC1, 0xFF,
  0x1C, 0x1C, 0xC0, 0xE6, 0x03, 0x30, 0x19, 0xC1, 0xC6, 0x1C, 0x1F, 0xC0,
  0xFE, 0x0E, 0x38, 0xC0, 0xEE, 0x03, 0x70, 0x1F, 0x80, 0xEC, 0x06, 0x70,
  0x71, 0xFF, 0x07, 0xF0, 0x1F, 0x87, 0xFC, 0x70, 0xEE, 0x06, 0xE0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x77, 0x0F, 0x7F, 0xF3, 0xFF, 0x04, 0x70,
  0x06, 0x00, 0xE0, 0x0C, 0x07, 0xC1, 0xF8, 0x1E, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x7B, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x18, 0xCE, 0x73, 0x38, 0x00, 0x60, 0x3C, 0x1F, 0x1F, 0x8F, 0x81,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x70, 0x1F, 0x0F, 0x87, 0xE0, 0xF8,
  0x0E, 0x00, 0x3F, 0x9F, 0xFB, 0x83, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0xC0, 0x30, 0x00, 0x07, 0xE0, 0x7B, 0xC3, 0x81, 0x8C, 0x02,
  0x63, 0xCD, 0x1D, 0x1C, 0xC4, 0x73, 0x11, 0xC8, 0x47, 0x21, 0x1C, 0x84,
  0x72, 0x33, 0xCC, 0xCB, 0x3D, 0xEC, 0x67, 0x18, 0x00, 0x70, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x06, 0xC0,
  0x3B, 0x00, 0xCC, 0x03, 0x38, 0x1C, 0x60, 0x61, 0x81, 0x87, 0x0E, 0x0C,
  0x3F, 0xF0, 0xFF, 0xE3, 0x01, 0x9C, 0x06, 0x60, 0x1D, 0x80, 0x7E, 0x00,
  0xC0, 0xFF, 0x87, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x81,
  0xDC, 0x1C, 0xFF, 0xC7, 0xFF, 0x38, 0x1D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x06, 0xE0, 0xF7, 0xFF, 0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC3,
  0x83, 0x9C, 0x06, 0x60, 0x1D, 0x80, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x77, 0x01, 0x9C, 0x06,
  0x38, 0x38, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x38, 0x79, 0xC0,
  0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1B, 0x81, 0xDC, 0x0E, 0xE1, 0xE7, 0xFE, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0xC3, 0x83, 0x9C, 0x06, 0x60, 0x1D, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x1D, 0x80, 0x77, 0x01, 0xCC,
  0x07, 0x38, 0x1C, 0x7F, 0xE0, 0xFE, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xF0, 0x1F, 0x80, 0xEC, 0x06, 0x70, 0x71, 0xFF, 0x07, 0xF0,
  0xE0, 0x3B, 0x81, 0xCE, 0x0E, 0x38, 0x70, 0xE3, 0x83, 0x8E, 0x0E, 0x70,
  0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3C, 0xE0, 0xE3, 0x83, 0x87,
  0x0E, 0x0E, 0x38, 0x38, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x8F, 0xEC, 0xFF, 0x66,
  0xFB, 0x37, 0xCF, 0xBE, 0x79, 0xF3, 0xCF, 0x8E, 0x7C, 0x63, 0xE3, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0E, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x03, 0xF8, 0x3D, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C, 0x63, 0xC7,
  0x3C, 0x33, 0xC3, 0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x30, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x1C, 0x0E, 0x60, 0x19, 0x80, 0x66,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x1D,
  0x80, 0x67, 0x01, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0xFF,
  0x8F, 0xFC, 0xC0, 0xEC, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0xEF, 0xFE, 0xFF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x1C, 0x0E, 0x60,
  0x19, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1D, 0x80, 0x76, 0x01, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0x80,
  0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0x87, 0xFF, 0x38, 0x1D,
  0xC0, 0x6E, 0x03, 0x70, 0x1F, 0x80, 0xDC, 0x0E, 0xE0, 0xF7, 0xFF, 0x3F,
  0xE1, 0xC3, 0x0E, 0x1C, 0x70, 0x63, 0x83, 0x9C, 0x0C, 0xE0, 0x77, 0x01,
  0xB8, 0x0E, 0x1F, 0xC3, 0xFF, 0x1C, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x03,
  0x80, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0x70, 0x71, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0xE3, 0xFC, 0x1F, 0x80,
  0xE0, 0x1F, 0x80, 0x76, 0x01, 0x9C, 0x0E, 0x70, 0x38, 0xC0, 0xC3, 0x83,
  0x0E, 0x1C, 0x18, 0x60, 0x61, 0x81, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x3B,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC3, 0x0F,
  0x87, 0x1B, 0x8E, 0x37, 0x1C, 0x66, 0x78, 0xCC, 0xF1, 0x99, 0xB3, 0x33,
  0x6E, 0x66, 0xDC, 0xC9, 0xB1, 0xB3, 0x63, 0xE6, 0xC7, 0xC7, 0x87, 0x8F,
  0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0xE0, 0xC0, 0xF0, 0x1D,
  0xC0, 0xE3, 0x83, 0x8E, 0x1C, 0x1C, 0x70, 0x33, 0x80, 0xEC, 0x01, 0xF0,
  0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x0E, 0xE0, 0x73, 0x81, 0xC7,
  0x0E, 0x0C, 0x30, 0x39, 0xC0, 0x7E, 0x01, 0xC0, 0xE0, 0x1D, 0x80, 0x67,
  0x03, 0x8C, 0x0C, 0x38, 0x70, 0x61, 0x81, 0xCE, 0x03, 0x30, 0x0F, 0xC0,
  0x1E, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0xFF, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0xFF, 0xF0, 0x0C, 0x03, 0x81, 0xE0, 0x78, 0x3B, 0x0C,
  0xC3, 0x39, 0x86, 0x61, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xE1, 0xC3, 0x87,
  0x02, 0x03, 0xFC, 0x7B, 0xE6, 0x06, 0xE0, 0x70, 0x07, 0x07, 0xF3, 0xFF,
  0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xF7, 0xFF, 0x3F, 0x70, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x20, 0xFF, 0xCF, 0xFE, 0xF0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7F, 0x0E, 0xFF, 0xEE, 0xFC, 0x02, 0x01, 0xFC, 0x3D, 0xE7, 0x07, 0xE0,
  0x3E, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x36, 0x03, 0x70,
  0x73, 0xFE, 0x1F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x47, 0x3F, 0xF7, 0xFF, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x3F, 0xF1, 0xF3, 0x02, 0x01,
  0xFC, 0x3F, 0xE7, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xE0, 0x0E, 0x02, 0x70, 0x73, 0xFE, 0x1F, 0xC0, 0x00, 0xF0, 0x1F,
  0xC1, 0xC2, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x1F, 0xFE, 0xFF, 0xF0,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x04, 0x03, 0xFB, 0x7F,
  0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x76, 0x06, 0x7B,
  0xE3, 0xFC, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x10, 0xEF, 0xCF, 0xFE, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x0E, 0xFC, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x83, 0xDC, 0x38, 0xE3, 0x87, 0x38, 0x3B, 0x81, 0xF8, 0x0F,
  0xE0, 0x7B, 0x83, 0x9C, 0x1C, 0x70, 0xE1, 0xC7, 0x07, 0x38, 0x1D, 0xC0,
  0xF0, 0xFE, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x04, 0x23, 0x7F, 0xEF, 0xFF,
  0xF8, 0xC3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0F, 0x8C,
  0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xC0, 0x01, 0x0E,
  0xFC, 0xFF, 0xEF, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0x06, 0x00, 0xFE,
  0x1F, 0xF8, 0xE0, 0xEE, 0x07, 0x60, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x3E,
  0x01, 0xB0, 0x0D, 0xC0, 0xE7, 0x0E, 0x1F, 0xF0, 0x7E, 0x00, 0x02, 0x0F,
  0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xF0, 0xEF, 0xFE, 0xEF, 0xCE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x04, 0x03, 0xFB, 0x7F, 0xF7, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xF3,
  0xFF, 0x1F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x01, 0x3B,
  0xFF, 0xFF, 0xE0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x02, 0x01, 0xFC, 0x3D, 0xE7, 0x07, 0x60,
  0x37, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x3E, 0x03, 0x70,
  0x73, 0xFE, 0x1F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77,
  0x0F, 0x7F, 0xB3, 0xF3, 0xE0, 0x1D, 0x80, 0x67, 0x03, 0x8C, 0x0C, 0x38,
  0x30, 0x61, 0x81, 0x86, 0x07, 0x38, 0x0C, 0xC0, 0x3B, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0xC3, 0x0F, 0x86, 0x1B, 0x0E, 0x36, 0x3C,
  0x66, 0x78, 0xCC, 0xD1, 0x19, 0x36, 0x36, 0x6C, 0x6C, 0xD8, 0x78, 0xB0,
  0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x03, 0x06, 0x00, 0x70, 0x3C, 0xE0, 0xE1,
  0x87, 0x07, 0x38, 0x0E, 0xC0, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xC0,
  0x3B, 0x81, 0xC6, 0x0E, 0x1C, 0x30, 0x3B, 0xC0, 0x70, 0xE0, 0x1D, 0x80,
  0x67, 0x03, 0x8C, 0x0E, 0x38, 0x30, 0xE1, 0xC1, 0xC6, 0x07, 0x38, 0x0C,
  0xC0, 0x3B, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0x83, 0xC1, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x07, 0x0F, 0x07, 0x80, 0x60, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x03, 0x80, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x78, 0x3C, 0x38, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x60, 0xF0, 0x60, 0x00, 0x10,
  0x00, 0xFC, 0x0F, 0xFC, 0x36, 0x1E, 0xE8, 0x1F, 0x80, 0x0C, 0x00,
};

const GFXglyph RobotoMono_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 19, 16, 6, -19 },
  { 9, 6, 6, 16, 5, -20 },
  { 14, 15, 19, 16, 1, -19 },
  { 50, 12, 25, 16, 2, -22 },
  { 88, 15, 19, 16, 1, -19 },
  { 124, 15, 19, 16, 1, -19 },
  { 160, 2, 6, 16, 7, -20 },
  { 162, 7, 28, 16, 5, -22 },
  { 187, 7, 28, 16, 4, -22 },
  { 212, 13, 13, 16, 2, -19 },
  { 234, 13, 14, 16, 2, -16 },
  { 257, 3, 7, 16, 5, -3 },
  { 260, 10, 2, 16, 3, -9 },
  { 263, 3, 3, 16, 7, -3 },
  { 265, 11, 21, 16, 3, -19 },
  { 294, 12, 19, 16, 2, -19 },
  { 323, 7, 19, 16, 3, -19 },
  { 340, 13, 19, 16, 1, -19 },
  { 371, 12, 19, 16, 1, -19 },
  { 400, 14, 19, 16, 1, -19 },
  { 434, 13, 19, 16, 2, -19 },
  { 465, 12, 19, 16, 2, -19 },
  { 494, 13, 19, 16, 1, -19 },
  { 525, 13, 19, 16, 2, -19 },
  { 556, 12, 19, 16, 2, -19 },
  { 585, 4, 15, 16, 7, -15 },
  { 593, 5, 19, 16, 6, -15 },
  { 605, 11, 11, 16, 2, -14 },
  { 621, 12, 7, 16, 2, -12 },
  { 632, 12, 12, 16, 2, -15 },
  { 650, 11, 19, 16, 3, -19 },
  { 677, 14, 19, 16, 1, -19 },
  { 711, 14, 19, 16, 1, -19 },
  { 745, 13, 19, 16, 2, -19 },
  { 776, 14, 19, 16, 1, -19 },
  { 810, 13, 19, 16, 2, -19 },
  { 841, 12, 19, 16, 2, -19 },
  { 870, 11, 19, 16, 3, -19 },
  { 897, 14, 19, 16, 1, -19 },
  { 931, 12, 19, 16, 2, -19 },
  { 960, 12, 19, 16, 2, -19 },
  { 989, 13, 19, 16, 1, -19 },
  { 1020, 14, 19, 16, 2, -19 },
  { 1054, 11, 19, 16, 3, -19 },
  { 1081, 13, 19, 16, 2, -19 },
  { 1112, 12, 19, 16, 2, -19 },
  { 1141, 14, 19, 16, 1, -19 },
  { 1175, 12, 19, 16, 3, -19 },
  { 1204, 14, 22, 16, 1, -19 },
  { 1243, 13, 19, 16, 2, -19 },
  { 1274, 13, 19, 16, 2, -19 },
  { 1305, 14, 19, 16, 1, -19 },
  { 1339, 12, 19, 16, 2, -19 },
  { 1368, 14, 19, 16, 1, -19 },
  { 1402, 15, 19, 16, 1, -19 },
  { 1438, 14, 19, 16, 1, -19 },
  { 1472, 14, 19, 16, 1, -19 },
  { 1506, 13, 19, 16, 1, -19 },
  { 1537, 5, 26, 16, 6, -22 },
  { 1554, 10, 21, 16, 3, -19 },
  { 1581, 6, 26, 16, 5, -22 },
  { 1601, 10, 10, 16, 3, -19 },
  { 1614, 12, 2, 16, 2, 0 },
  { 1617, 6, 4, 16, 5, -20 },
  { 1620, 12, 15, 16, 2, -15 },
  { 1643, 12, 20, 16, 2, -20 },
  { 1673, 12, 15, 16, 2, -15 },
  { 1696, 12, 20, 16, 2, -20 },
  { 1726, 12, 15, 16, 2, -15 },
  { 1749, 13, 21, 16, 2, -21 },
  { 1784, 12, 21, 16, 2, -15 },
  { 1816, 12, 20, 16, 2, -20 },
  { 1846, 12, 19, 16, 3, -19 },
  { 1875, 8, 25, 16, 3, -19 },
  { 1900, 13, 20, 16, 2, -20 },
  { 1933, 12, 20, 16, 3, -20 },
  { 1963, 14, 15, 16, 1, -15 },
  { 1990, 12, 15, 16, 2, -15 },
  { 2013, 13, 15, 16, 2, -15 },
  { 2038, 12, 20, 16, 2, -15 },
  { 2068, 12, 20, 16, 2, -15 },
  { 2098, 10, 15, 16, 4, -15 },
  { 2117, 12, 15, 16, 2, -15 },
  { 2140, 12, 18, 16, 2, -18 },
  { 2167, 12, 14, 16, 2, -14 },
  { 2188, 14, 14, 16, 1, -14 },
  { 2213, 15, 14, 16, 1, -14 },
  { 2240, 14, 14, 16, 1, -14 },
  { 2265, 14, 20, 16, 1, -14 },
  { 2300, 12, 14, 16, 2, -14 },
  { 2321, 9, 26, 16, 4, -21 },
  { 2351, 2, 24, 16, 7, -19 },
  { 2357, 9, 26, 16, 4, -21 },
  { 2387, 15, 6, 16, 1, -11 },
};

const GFXfont RobotoMono_Regular27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular27pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_REGULAR27PT7B_H_
