#ifndef _ROBOTOMONO_REGULAR68PT7B_H_
#define _ROBOTOMONO_REGULAR68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x01, 0x00, 0x1E, 0x01, 0xF0, 0x07, 0x00,
  0xF8, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x3C,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x01,
  0xE0, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0xF8, 0x00, 0x7E, 0x0F, 0x83, 0xE0, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x01,
  0xFF, 0xF0, 0x78, 0x00, 0x03, 0xFF, 0x83, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x0C, 0x00, 0x00, 0x07, 0x81, 0xFF, 0x00, 0x00, 0x3E, 0x1F,
  0xFE, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0x07, 0xC3, 0xFB, 0xF8, 0x00,
  0x3E, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x07, 0xC1, 0xE0,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x80,
  0x3C, 0x00, 0xE0, 0x3E, 0x00, 0xF0, 0x00, 0x80, 0x78, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x7C, 0x3F, 0xC7, 0xF0, 0x07, 0xC3, 0xF8, 0x3F, 0x80, 0x7C, 0x7F,
  0x03, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0xC0, 0xFC, 0xFE, 0x00, 0xFE, 0x0F,
  0xCF, 0xC0, 0x07, 0xF0, 0xF8, 0xFC, 0x00, 0x7F, 0x9F, 0x8F, 0xC0, 0x03,
  0xF9, 0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0xFC,
  0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x01,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFB, 0xF8, 0x0F,
  0xFF, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0xE8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x02,
  0x80, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x03, 0xE0, 0x06, 0x3E,
  0x03, 0xE0, 0x3E, 0x7F, 0x83, 0xC0, 0xFE, 0x7F, 0xE3, 0xC3, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0x78, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x83, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xFF, 0x00, 0x7F,
  0x9F, 0xFE, 0x03, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xDF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x01, 0x80, 0x00, 0x3E, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xC0, 0x07,
  0xFC, 0x07, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF0, 0x7F, 0xF0, 0x0F, 0xC7, 0xFF,
  0xF0, 0x3F, 0x3F, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x87, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x01,
  0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFB,
  0xF0, 0x3F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0x3E, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1C, 0x1F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x07, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC1,
  0xC0, 0x07, 0x01, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3,
  0xFE, 0x1F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x07,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x1F, 0xE0, 0x78, 0x3E, 0x03, 0xFF, 0x83,
  0xC1, 0xE0, 0x3F, 0xFE, 0x0F, 0x0F, 0x03, 0xFF, 0xF0, 0x78, 0xF0, 0x1F,
  0x07, 0x83, 0xC7, 0x81, 0xF0, 0x3C, 0x1E, 0x3C, 0x0F, 0x01, 0xE0, 0x73,
  0xC0, 0xF8, 0x0E, 0x03, 0x9E, 0x07, 0x80, 0x70, 0x1C, 0xF0, 0x3C, 0x03,
  0x80, 0xE7, 0x83, 0xC0, 0x1C, 0x07, 0x3C, 0x1E, 0x01, 0xE0, 0x3B, 0xC0,
  0xF0, 0x0F, 0x01, 0xDE, 0x07, 0x80, 0x78, 0x0E, 0xF0, 0x3C, 0x03, 0xC0,
  0x77, 0x81, 0xE0, 0x1E, 0x03, 0xBC, 0x1F, 0x00, 0xF0, 0x3D, 0xE0, 0xF8,
  0x07, 0x81, 0xEF, 0x07, 0xC0, 0x3C, 0x0F, 0x78, 0x3E, 0x03, 0xC0, 0x73,
  0xE0, 0xF0, 0x1E, 0x07, 0x8F, 0x07, 0x81, 0xF8, 0x3C, 0x78, 0x3F, 0x3F,
  0xC3, 0xC3, 0xC1, 0xFF, 0xFF, 0x3E, 0x1E, 0x07, 0xFE, 0xFF, 0xE0, 0xF8,
  0x3F, 0xE3, 0xFE, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x10, 0x00,
  0x07, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x07, 0xFE, 0x3F, 0x00,
  0x03, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F,
  0xC7, 0xE0, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xF8, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x03, 0xFD, 0xF8, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80,
  0x03, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x07, 0xFF, 0x03, 0xF0, 0x00, 0x7F,
  0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x1F,
  0xF0, 0x3F, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0x3F,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0xC0,
  0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x03, 0xF7, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x07,
  0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFF,
  0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07,
  0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xE0, 0x0F, 0xBF, 0xFB,
  0xE0, 0x0F, 0xBF, 0xFB, 0xF0, 0x1F, 0xBF, 0xFD, 0xF0, 0x1F, 0x3F, 0xFD,
  0xF0, 0x1F, 0x3F, 0xFD, 0xF8, 0x3F, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F, 0xFC,
  0xF8, 0x3E, 0x3F, 0xFC, 0xFC, 0x7E, 0x3F, 0xFC, 0x7C, 0x7C, 0x3F, 0xFC,
  0x7C, 0x7C, 0x3F, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3E, 0xF8, 0x3F, 0xFC,
  0x3E, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC,
  0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x3F, 0xFC,
  0x07, 0xC0, 0x3F, 0xFC, 0x07, 0x80, 0x3F, 0xFC, 0x03, 0x80, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0x00, 0x0F, 0xFF, 0x7F, 0x00,
  0x1F, 0xFE, 0x7E, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x7F, 0xF8, 0xFC, 0x00,
  0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC1, 0xF8, 0x07,
  0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF,
  0xE0, 0x1F, 0x83, 0xFF, 0xC0, 0x1F, 0x87, 0xFF, 0x80, 0x3F, 0x8F, 0xFF,
  0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x7E, 0x7F, 0xF8,
  0x00, 0xFE, 0xFF, 0xF0, 0x00, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF8,
  0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x7F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x00, 0x7E, 0xFC, 0x03, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x1F, 0xBF,
  0x00, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0xC0,
  0x3E, 0x7E, 0x01, 0xFE, 0x01, 0xF1, 0xF0, 0x1F, 0xF0, 0x1F, 0x8F, 0x80,
  0xFF, 0x80, 0xFC, 0x7E, 0x07, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xF0, 0x3F,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0x7C, 0x0F, 0x87, 0xE0, 0xF9,
  0xE0, 0x7C, 0x3F, 0x07, 0xCF, 0x83, 0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07,
  0xC1, 0xF3, 0xE1, 0xF8, 0x3E, 0x0F, 0x9F, 0x0F, 0xC1, 0xF0, 0x78, 0xF8,
  0x7E, 0x0F, 0xC7, 0xC3, 0xC3, 0xF0, 0x7E, 0x3E, 0x1F, 0x1F, 0x03, 0xF1,
  0xF0, 0xF8, 0xF8, 0x1F, 0x8F, 0x87, 0xC7, 0xC0, 0x7C, 0x78, 0x3E, 0x3E,
  0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0x80, 0xF9, 0xF0,
  0x3E, 0xFC, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x3F, 0x7C, 0x0F, 0xBF, 0x01,
  0xFB, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0,
  0x01, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F,
  0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x9F, 0xC0,
  0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFD, 0xF8, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0x87, 0xE0, 0x1F, 0xFE,
  0x0F, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x1C, 0x00, 0x3F, 0x0F, 0xFF, 0x00, 0xFC, 0x7F, 0xFE, 0x03, 0xF7, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F,
  0xE3, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE,
  0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFF, 0x00, 0x7F, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x83, 0xF3, 0xFF,
  0xF8, 0x0F, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x60, 0x0F, 0xC0, 0x1F, 0xFC,
  0x3F, 0x01, 0xFF, 0xF8, 0xFC, 0x1F, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xF3,
  0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x18,
  0x1F, 0xC0, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF8, 0x01, 0xFE,
  0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x18, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0x8F, 0xC1, 0xFF,
  0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFE, 0x00,
  0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0xC0, 0x7F,
  0xFF, 0x3F, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x3A, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x20, 0x00, 0x07,
  0xE0, 0xC0, 0x00, 0x3F, 0x87, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0x00, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x3F, 0xFF,
  0x87, 0xE3, 0xFF, 0xFE, 0x3F, 0x7F, 0xFF, 0xF9, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xF0, 0x00,
  0xFC, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xFC, 0x7F, 0x80, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xC0, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x30,
  0x1F, 0x8F, 0xF0, 0x7F, 0xC3, 0xF7, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x81,
  0xFF, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0x80, 0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x7E,
  0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0xF0, 0x3E, 0x0F, 0xFF,
  0xE1, 0xF1, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0xFF,
  0xE0, 0x0F, 0x8F, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xDF, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0x80, 0xFC, 0x3F, 0xFC,
  0x03, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xC3, 0xF0, 0x1F, 0xFF, 0xCF, 0xC1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFB, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0xFF,
  0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0x3F, 0x00, 0xFF, 0xF0,
  0xFC, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x7E, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xDF, 0x8F, 0xFF, 0xEF, 0xCF, 0xFF, 0xF7, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xF0,
  0x01, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xCF, 0xC1, 0xFF, 0xFC,
  0x7E, 0x03, 0xFF, 0x83, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x80, 0x0F, 0xBF, 0x00, 0x3E, 0x00,
  0x7E, 0x7C, 0x01, 0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0xC0, 0x1F, 0x1F, 0x00, 0x7F, 0x00, 0x7C, 0x7E, 0x03, 0xFE, 0x01,
  0xF0, 0xF8, 0x0F, 0x78, 0x0F, 0xC3, 0xE0, 0x3D, 0xE0, 0x3E, 0x0F, 0x80,
  0xF7, 0x80, 0xF8, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0xFC, 0x1F, 0x7C, 0x0F,
  0x81, 0xF0, 0x78, 0xF0, 0x3C, 0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x1F, 0x0F,
  0x8F, 0x87, 0xC0, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0xF0, 0xF0, 0x78, 0x7C,
  0x03, 0xE3, 0xC1, 0xE1, 0xE0, 0x0F, 0x9F, 0x07, 0xC7, 0x80, 0x3E, 0x7C,
  0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0xF3, 0xE0,
  0x07, 0x9E, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x0F, 0xBC, 0x00, 0x7F, 0xC0,
  0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1E, 0x7F, 0xFF, 0x80, 0x00, 0xF3,
  0xFF, 0xFF, 0x00, 0x0F, 0xBF, 0xFF, 0xFC, 0x00, 0x7D, 0xF8, 0x1F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x7E, 0xF8, 0x00, 0xFF, 0xFF, 0xF7, 0x80,
  0x03, 0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
};

const GFXglyph RobotoMono_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 8, 48, 41, 16, -48 },
  { 49, 17, 16, 41, 12, -51 },
  { 83, 37, 48, 41, 2, -48 },
  { 305, 31, 63, 41, 5, -56 },
  { 550, 38, 50, 41, 1, -49 },
  { 788, 36, 50, 41, 4, -49 },
  { 1013, 6, 16, 41, 16, -51 },
  { 1025, 17, 71, 41, 12, -55 },
  { 1176, 17, 71, 41, 11, -55 },
  { 1327, 32, 32, 41, 5, -48 },
  { 1455, 33, 35, 41, 4, -40 },
  { 1600, 9, 18, 41, 12, -7 },
  { 1621, 26, 5, 41, 7, -24 },
  { 1638, 10, 10, 41, 16, -9 },
  { 1651, 26, 52, 41, 8, -48 },
  { 1820, 31, 50, 41, 5, -49 },
  { 2014, 19, 48, 41, 7, -48 },
  { 2128, 32, 49, 41, 3, -49 },
  { 2324, 31, 50, 41, 3, -49 },
  { 2518, 35, 48, 41, 2, -48 },
  { 2728, 31, 49, 41, 6, -48 },
  { 2918, 30, 49, 41, 5, -48 },
  { 3102, 32, 48, 41, 4, -48 },
  { 3294, 31, 50, 41, 6, -49 },
  { 3488, 30, 49, 41, 5, -49 },
  { 3672, 10, 39, 41, 18, -38 },
  { 3721, 12, 49, 41, 16, -38 },
  { 3795, 28, 29, 41, 6, -36 },
  { 3897, 29, 19, 41, 6, -31 },
  { 3966, 29, 30, 41, 6, -37 },
  { 4075, 29, 49, 41, 6, -49 },
  { 4253, 37, 48, 41, 2, -48 },
  { 4475, 36, 48, 41, 3, -48 },
  { 4691, 31, 48, 41, 6, -48 },
  { 4877, 33, 50, 41, 4, -49 },
  { 5084, 33, 48, 41, 5, -48 },
  { 5282, 30, 48, 41, 6, -48 },
  { 5462, 30, 48, 41, 6, -48 },
  { 5642, 34, 50, 41, 3, -49 },
  { 5855, 31, 48, 41, 5, -48 },
  { 6041, 29, 48, 41, 6, -48 },
  { 6215, 32, 49, 41, 3, -48 },
  { 6411, 33, 48, 41, 6, -48 },
  { 6609, 29, 48, 41, 7, -48 },
  { 6783, 32, 48, 41, 5, -48 },
  { 6975, 31, 48, 41, 5, -48 },
  { 7161, 33, 50, 41, 4, -49 },
  { 7368, 32, 48, 41, 6, -48 },
  { 7560, 36, 57, 41, 3, -49 },
  { 7817, 32, 48, 41, 6, -48 },
  { 8009, 33, 50, 41, 4, -49 },
  { 8216, 35, 48, 41, 3, -48 },
  { 8426, 31, 49, 41, 5, -48 },
  { 8616, 36, 48, 41, 2, -48 },
  { 8832, 37, 48, 41, 2, -48 },
  { 9054, 36, 48, 41, 3, -48 },
  { 9270, 36, 48, 41, 2, -48 },
  { 9486, 32, 48, 41, 4, -48 },
  { 9678, 13, 65, 41, 14, -55 },
  { 9784, 25, 52, 41, 8, -48 },
  { 9947, 14, 65, 41, 13, -55 },
  { 10061, 25, 26, 41, 8, -48 },
  { 10143, 31, 5, 41, 5, 0 },
  { 10163, 13, 9, 41, 14, -49 },
  { 10178, 31, 38, 41, 5, -37 },
  { 10326, 30, 52, 41, 6, -51 },
  { 10521, 31, 38, 41, 5, -37 },
  { 10669, 30, 52, 41, 5, -51 },
  { 10864, 32, 38, 41, 4, -37 },
  { 11016, 33, 52, 41, 5, -52 },
  { 11231, 30, 51, 41, 5, -37 },
  { 11423, 29, 51, 41, 6, -51 },
  { 11608, 30, 49, 41, 7, -49 },
  { 11792, 21, 64, 41, 7, -49 },
  { 11960, 32, 51, 41, 6, -51 },
  { 12164, 30, 51, 41, 7, -51 },
  { 12356, 35, 37, 41, 3, -37 },
  { 12518, 29, 37, 41, 6, -37 },
  { 12653, 33, 38, 41, 4, -37 },
  { 12810, 30, 51, 41, 6, -37 },
  { 13002, 30, 51, 41, 5, -37 },
  { 13194, 25, 37, 41, 11, -37 },
  { 13310, 30, 38, 41, 6, -37 },
  { 13453, 30, 46, 41, 5, -45 },
  { 13626, 29, 37, 41, 6, -36 },
  { 13761, 34, 36, 41, 3, -36 },
  { 13914, 38, 36, 41, 2, -36 },
  { 14085, 34, 36, 41, 4, -36 },
  { 14238, 36, 51, 41, 2, -36 },
  { 14468, 31, 36, 41, 5, -36 },
  { 14608, 22, 65, 41, 11, -53 },
  { 14787, 5, 61, 41, 18, -48 },
  { 14826, 22, 65, 41, 11, -53 },
  { 15005, 37, 14, 41, 2, -27 },
};

const GFXfont RobotoMono_Regular68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular68pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_REGULAR68PT7B_H_
