#ifndef _ROBOTOMONO_REGULAR25PT7B_H_
#define _ROBOTOMONO_REGULAR25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x02, 0xFC, 0xC7, 0x8F, 0x16, 0x2C,
  0x58, 0x80, 0x06, 0x30, 0x31, 0x81, 0x08, 0x08, 0xC0, 0xC6, 0x3F, 0xFD,
  0xFF, 0xE1, 0x08, 0x08, 0x40, 0xC6, 0x06, 0x31, 0xFF, 0xEF, 0xFF, 0x08,
  0x40, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x00, 0x06, 0x00, 0xC0, 0x18,
  0x0F, 0x83, 0xFC, 0xE1, 0x98, 0x3B, 0x03, 0x60, 0x6E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x7C, 0x0D, 0x83, 0xBF, 0xE3,
  0xF8, 0x0C, 0x01, 0x80, 0x30, 0x78, 0x07, 0xE0, 0x23, 0x11, 0x18, 0xC8,
  0xCC, 0x46, 0x43, 0xE6, 0x0E, 0x20, 0x03, 0x00, 0x30, 0x01, 0x98, 0x19,
  0xF0, 0xD9, 0x8C, 0xC4, 0xE6, 0x22, 0x31, 0x01, 0x98, 0x07, 0x80, 0x0F,
  0x00, 0x7E, 0x03, 0x8C, 0x0C, 0x30, 0x30, 0xC0, 0xC7, 0x03, 0xB8, 0x07,
  0xC0, 0x0E, 0x00, 0xF8, 0x07, 0x71, 0x98, 0xE6, 0xE1, 0x9B, 0x87, 0xCE,
  0x0F, 0x18, 0x3C, 0x7F, 0xF0, 0x7E, 0xF0, 0xFF, 0xF0, 0x06, 0x1C, 0x30,
  0xC3, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60,
  0xC1, 0x81, 0x83, 0x07, 0x06, 0x06, 0x06, 0x04, 0x83, 0x06, 0x0C, 0x30,
  0x61, 0x87, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18,
  0xC3, 0x18, 0xC2, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE6, 0x6F,
  0xFF, 0x1F, 0x80, 0xE0, 0x1B, 0x03, 0x98, 0x71, 0xC3, 0x08, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x77, 0x77, 0x66, 0xC0,
  0xFF, 0xFF, 0xC0, 0xEF, 0xE0, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0x1F, 0x07, 0xF1, 0x83, 0x70, 0x7C,
  0x07, 0x80, 0xF0, 0x3E, 0x1F, 0xC7, 0x79, 0xCF, 0xE1, 0xF8, 0x3E, 0x07,
  0x80, 0xF8, 0x1B, 0x06, 0x7F, 0xC3, 0xF0, 0x04, 0x7F, 0xFB, 0x8C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x1F, 0x03, 0xFC,
  0x70, 0xEE, 0x06, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0x1F, 0x07, 0xF9, 0xC3, 0xF0, 0x3E, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x0F,
  0x81, 0xF8, 0x03, 0x80, 0x30, 0x07, 0x80, 0xF8, 0x1B, 0x07, 0x7F, 0xC3,
  0xF0, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x07, 0x60, 0x33,
  0x03, 0x18, 0x18, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x8F, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x19, 0x83, 0xFC, 0x7B, 0xC4, 0x1C, 0x01, 0x80, 0x30,
  0x07, 0x80, 0xF8, 0x1B, 0x07, 0x3F, 0xC3, 0xF0, 0x03, 0x03, 0xE0, 0xF8,
  0x38, 0x06, 0x01, 0xC0, 0x31, 0x86, 0xFC, 0xF1, 0xDC, 0x1B, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x3B, 0x06, 0x7F, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x1F, 0x07, 0xF9, 0xC3, 0xB0, 0x76, 0x06, 0xC0, 0xD8, 0x3B, 0x8E, 0x1F,
  0x87, 0xF9, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x1B, 0x07, 0x7F, 0xC3,
  0xF0, 0x1F, 0x0F, 0xF1, 0x87, 0x70, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0xEC, 0x3D, 0xFF, 0x8F, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x3F,
  0x07, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x77, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x66, 0x66, 0xEC, 0x00, 0xC0, 0xF0, 0xF8, 0xF8, 0xF0, 0x38,
  0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x30, 0x04, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x03, 0xC1, 0xF1, 0xF0, 0xF8, 0x1C, 0x02, 0x00, 0x00, 0x1F, 0x0F, 0xF9,
  0xC3, 0x70, 0x70, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x01, 0xC0, 0x07, 0x80,
  0xFF, 0x0C, 0x0C, 0x40, 0x26, 0x39, 0xA3, 0x67, 0x32, 0x39, 0x11, 0x98,
  0x8C, 0xC4, 0x66, 0x23, 0x33, 0x3D, 0xFB, 0x67, 0x71, 0x00, 0x0C, 0x00,
  0x3D, 0xC0, 0xFC, 0x00, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0xD8,
  0x06, 0xC0, 0x37, 0x03, 0x98, 0x18, 0xC0, 0xC7, 0x0E, 0x18, 0x7F, 0xC3,
  0xFF, 0x38, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x1E, 0x00, 0xC0, 0xFE, 0x0F,
  0xFC, 0xC1, 0xEC, 0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x1C, 0xFF, 0x8F,
  0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF,
  0xF0, 0x0F, 0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0x30, 0x1F, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0xB0, 0x19,
  0x80, 0xC6, 0x0E, 0x3F, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xF8, 0xC3, 0xCC,
  0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x1C, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF,
  0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0x0F, 0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0x30, 0x07, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x0F, 0xF0, 0x7F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0xC0,
  0xE7, 0x07, 0x1F, 0xF0, 0x7E, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0xFF, 0xFF, 0xFC, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7E, 0x07, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0xC0,
  0x76, 0x07, 0x30, 0x31, 0x83, 0x0C, 0x38, 0x63, 0x83, 0x38, 0x19, 0x80,
  0xDC, 0x07, 0xF0, 0x3D, 0xC1, 0xC6, 0x0C, 0x38, 0x60, 0xE3, 0x07, 0x18,
  0x1C, 0xC0, 0x76, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xE0, 0x7C, 0x1F, 0x83, 0xF8, 0xFF,
  0x1F, 0xE3, 0xF6, 0xDE, 0xDB, 0xDB, 0x79, 0xCF, 0x39, 0xE7, 0x3C, 0x47,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0xC0, 0x7C, 0x0F, 0x81, 0xF8,
  0x3F, 0x07, 0xF0, 0xF6, 0x1E, 0xE3, 0xCC, 0x78, 0xCF, 0x19, 0xE1, 0xBC,
  0x37, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0C, 0x0F, 0x80, 0xFE, 0x0E,
  0x38, 0xE0, 0xE6, 0x03, 0x30, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x76, 0x03, 0x30, 0x19, 0xC1, 0xC6, 0x0C, 0x3F, 0xE0,
  0x7C, 0x00, 0xFF, 0x0F, 0xFC, 0xE0, 0xEE, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0xFE, 0x0E, 0x38, 0xE0, 0xE6,
  0x03, 0x70, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x7E, 0x03, 0xB0, 0x19, 0x80, 0xC6, 0x0C, 0x3F, 0xE0, 0x7F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x00, 0xFE, 0x0F, 0xFC, 0xC1, 0xEC, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x06, 0xC1, 0xCF, 0xF8, 0xFF, 0x0C, 0x38, 0xC1, 0x8C,
  0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x6C, 0x07, 0x0F, 0x81, 0xFF, 0x0E, 0x1C,
  0xE0, 0x66, 0x03, 0xB0, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3E, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0xF0, 0x1D, 0x80, 0xEE, 0x0E, 0x3F, 0xF0, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3B, 0x06, 0x7F, 0xC3, 0xE0, 0xC0, 0x1F, 0x01, 0xD8,
  0x0C, 0xC0, 0x67, 0x07, 0x18, 0x30, 0xC1, 0x86, 0x1C, 0x38, 0xC0, 0xC6,
  0x06, 0x30, 0x3B, 0x80, 0xD8, 0x06, 0xC0, 0x3E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC3, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x3E, 0x71, 0xB3, 0xCD,
  0x96, 0x6D, 0xB3, 0x6D, 0xB3, 0x6D, 0x9B, 0x2C, 0xD1, 0xE6, 0x8F, 0x3C,
  0x78, 0xE3, 0xC7, 0x0E, 0x38, 0x61, 0x83, 0x00, 0xE0, 0x3B, 0x81, 0x8C,
  0x1C, 0x70, 0xC1, 0x8E, 0x0E, 0x60, 0x36, 0x01, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xE0, 0x1B, 0x01, 0xCC, 0x0C, 0x70, 0xE1, 0x86, 0x0E, 0x70, 0x37,
  0x01, 0xC0, 0xC0, 0x3F, 0x01, 0x98, 0x1C, 0xE0, 0xC3, 0x0E, 0x1C, 0x60,
  0x63, 0x03, 0xB0, 0x0D, 0x80, 0x78, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0xFF, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8F, 0xFF, 0x08, 0x0E, 0x07, 0x06, 0xC3, 0x61, 0xB1, 0x8C,
  0xC6, 0xC1, 0xE0, 0xC0, 0xFF, 0xFF, 0xFC, 0xE1, 0x8E, 0x3F, 0x8E, 0x7B,
  0x83, 0x00, 0x70, 0x0E, 0x3F, 0xDF, 0xFF, 0x07, 0xC0, 0xF8, 0x1F, 0x87,
  0xBF, 0xF3, 0xE6, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x37,
  0xE7, 0xDE, 0xE0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x07, 0xE0, 0xDF, 0xFB, 0x7E, 0x00, 0x3F, 0x8F, 0x79, 0x83, 0xF0, 0x3C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x0D, 0x83, 0xBF, 0xE1, 0xF8,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xCF, 0xDB, 0xDF, 0xE0,
  0xFC, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x60, 0xEF,
  0xFC, 0xFD, 0x80, 0x1F, 0x8F, 0x79, 0x83, 0xE0, 0x3C, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xC0, 0x1C, 0x01, 0xC1, 0xBF, 0xE1, 0xF8, 0x03, 0xF0, 0xFF,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0x3F, 0x6F, 0x7F, 0x83, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0D, 0x83, 0xBF, 0xF3, 0xF6, 0x00, 0xC0, 0x3F, 0x06,
  0x7F, 0xC7, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33,
  0xE6, 0xFE, 0xE0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x06, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x08,
  0x00, 0x0F, 0xDF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0xFF, 0xBE, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0xEC, 0x18, 0xC3, 0x0C, 0x60, 0xCC, 0x0D, 0xC0,
  0xFE, 0x0E, 0x60, 0xC7, 0x0C, 0x38, 0xC1, 0xCC, 0x0E, 0xC0, 0x70, 0xFE,
  0x0F, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x0F, 0xFF, 0xFF, 0xF0, 0xDE, 0xF7, 0xFF, 0xF1, 0xC7, 0x8E, 0x3C, 0x71,
  0xE3, 0x8F, 0x1C, 0x78, 0xE3, 0xC7, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x3C,
  0x71, 0x80, 0xCF, 0x9F, 0xFB, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x1F, 0xC1, 0xEF, 0x1C,
  0x1C, 0xC0, 0x66, 0x03, 0x30, 0x1B, 0x80, 0xEC, 0x06, 0x60, 0x33, 0x01,
  0x9C, 0x18, 0x7F, 0xC1, 0xFC, 0x00, 0xDF, 0x9F, 0xFB, 0x83, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0x7F, 0xED, 0xF9,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x3F, 0x6F, 0x7F, 0x83, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0D, 0x83, 0xBF, 0xF3,
  0xF6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0xCF, 0xEF, 0xFC, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3F,
  0x8F, 0x79, 0x83, 0xB0, 0x36, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x78,
  0x0F, 0x81, 0xBF, 0xE3, 0xF8, 0x18, 0x03, 0x00, 0x60, 0x7F, 0xFF, 0xFE,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0xF8, 0x3F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x1D, 0x83, 0xBF, 0xB3, 0xE6, 0xE0, 0x3B, 0x01,
  0x9C, 0x1C, 0x60, 0xC3, 0x06, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x0D, 0x80,
  0x6C, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x00, 0xC2, 0x1F, 0x1C, 0x6C, 0x71,
  0xB1, 0x46, 0x45, 0x19, 0xB6, 0x46, 0xDB, 0x1B, 0x2C, 0x68, 0xB0, 0xE3,
  0x83, 0x8E, 0x0E, 0x18, 0x30, 0x60, 0xF0, 0x39, 0x83, 0x06, 0x38, 0x3B,
  0x80, 0xD8, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0D, 0xC0, 0xE6, 0x0E, 0x38,
  0xE0, 0xEE, 0x03, 0x80, 0xE0, 0x3B, 0x01, 0x9C, 0x0C, 0xE0, 0xE3, 0x06,
  0x1C, 0x70, 0x63, 0x03, 0x98, 0x0D, 0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0x07, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x70, 0xE0, 0x70, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C,
  0x0C, 0x0C, 0x0E, 0x07, 0xFF, 0xFF, 0xFE, 0x80, 0xE0, 0x30, 0x30, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0F, 0x07, 0x0E, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x38, 0x03, 0xF0, 0x73, 0xC7,
  0x07, 0xF0, 0x1F, 0x00,
};

const GFXglyph RobotoMono_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 7, 6, 15, 4, -19 },
  { 14, 13, 18, 15, 1, -18 },
  { 44, 11, 24, 15, 2, -21 },
  { 77, 13, 18, 15, 1, -18 },
  { 107, 14, 18, 15, 1, -18 },
  { 139, 2, 6, 15, 6, -19 },
  { 141, 7, 26, 15, 4, -20 },
  { 164, 6, 26, 15, 4, -20 },
  { 184, 12, 12, 15, 2, -18 },
  { 202, 13, 13, 15, 1, -15 },
  { 224, 4, 7, 15, 4, -3 },
  { 228, 9, 2, 15, 3, -9 },
  { 231, 4, 3, 15, 6, -3 },
  { 233, 10, 20, 15, 3, -18 },
  { 258, 11, 18, 15, 2, -18 },
  { 283, 6, 18, 15, 3, -18 },
  { 297, 12, 18, 15, 1, -18 },
  { 324, 11, 18, 15, 1, -18 },
  { 349, 13, 18, 15, 1, -18 },
  { 379, 11, 18, 15, 2, -18 },
  { 404, 11, 18, 15, 2, -18 },
  { 429, 12, 18, 15, 1, -18 },
  { 456, 11, 18, 15, 2, -18 },
  { 481, 11, 18, 15, 2, -18 },
  { 506, 3, 14, 15, 7, -14 },
  { 512, 4, 18, 15, 6, -14 },
  { 521, 10, 11, 15, 2, -13 },
  { 535, 11, 7, 15, 2, -11 },
  { 545, 11, 11, 15, 2, -13 },
  { 561, 11, 18, 15, 2, -18 },
  { 586, 13, 18, 15, 1, -18 },
  { 616, 13, 18, 15, 1, -18 },
  { 646, 12, 18, 15, 2, -18 },
  { 673, 13, 18, 15, 1, -18 },
  { 703, 12, 18, 15, 2, -18 },
  { 730, 11, 18, 15, 2, -18 },
  { 755, 11, 18, 15, 2, -18 },
  { 780, 13, 18, 15, 1, -18 },
  { 810, 11, 18, 15, 2, -18 },
  { 835, 11, 18, 15, 2, -18 },
  { 860, 12, 18, 15, 1, -18 },
  { 887, 13, 18, 15, 2, -18 },
  { 917, 11, 18, 15, 2, -18 },
  { 942, 11, 18, 15, 2, -18 },
  { 967, 11, 18, 15, 2, -18 },
  { 992, 13, 18, 15, 1, -18 },
  { 1022, 12, 18, 15, 2, -18 },
  { 1049, 13, 21, 15, 1, -18 },
  { 1084, 12, 18, 15, 2, -18 },
  { 1111, 13, 18, 15, 1, -18 },
  { 1141, 13, 18, 15, 1, -18 },
  { 1171, 11, 18, 15, 2, -18 },
  { 1196, 13, 18, 15, 1, -18 },
  { 1226, 13, 18, 15, 1, -18 },
  { 1256, 13, 18, 15, 1, -18 },
  { 1286, 13, 18, 15, 1, -18 },
  { 1316, 12, 18, 15, 1, -18 },
  { 1343, 5, 24, 15, 5, -20 },
  { 1358, 9, 20, 15, 3, -18 },
  { 1381, 5, 24, 15, 5, -20 },
  { 1396, 9, 10, 15, 3, -18 },
  { 1408, 11, 2, 15, 2, 0 },
  { 1411, 5, 3, 15, 5, -18 },
  { 1413, 11, 13, 15, 2, -13 },
  { 1431, 11, 19, 15, 2, -19 },
  { 1458, 11, 13, 15, 2, -13 },
  { 1476, 11, 19, 15, 2, -19 },
  { 1503, 11, 13, 15, 2, -13 },
  { 1521, 12, 19, 15, 2, -19 },
  { 1550, 11, 18, 15, 2, -13 },
  { 1575, 11, 19, 15, 2, -19 },
  { 1602, 12, 18, 15, 2, -18 },
  { 1629, 7, 23, 15, 3, -18 },
  { 1650, 12, 19, 15, 2, -19 },
  { 1679, 12, 19, 15, 2, -19 },
  { 1708, 13, 13, 15, 1, -13 },
  { 1730, 11, 13, 15, 2, -13 },
  { 1748, 13, 13, 15, 1, -13 },
  { 1770, 11, 18, 15, 2, -13 },
  { 1795, 11, 18, 15, 2, -13 },
  { 1820, 9, 13, 15, 4, -13 },
  { 1835, 11, 13, 15, 2, -13 },
  { 1853, 11, 16, 15, 2, -16 },
  { 1875, 11, 13, 15, 2, -13 },
  { 1893, 13, 13, 15, 1, -13 },
  { 1915, 14, 13, 15, 1, -13 },
  { 1938, 13, 13, 15, 1, -13 },
  { 1960, 13, 18, 15, 1, -13 },
  { 1990, 11, 13, 15, 2, -13 },
  { 2008, 8, 24, 15, 4, -20 },
  { 2032, 1, 23, 15, 7, -18 },
  { 2035, 8, 24, 15, 4, -20 },
  { 2059, 13, 5, 15, 1, -10 },
};

const GFXfont RobotoMono_Regular25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular25pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_REGULAR25PT7B_H_
