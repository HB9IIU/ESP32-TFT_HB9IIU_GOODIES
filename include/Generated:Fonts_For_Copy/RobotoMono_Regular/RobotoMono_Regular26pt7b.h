#ifndef _ROBOTOMONO_REGULAR26PT7B_H_
#define _ROBOTOMONO_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x21,
  0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x08, 0x60, 0x61, 0x01, 0x8C, 0x3F, 0xFE,
  0xFF, 0xF8, 0x43, 0x03, 0x08, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x00, 0x06,
  0x00, 0x60, 0x0F, 0x03, 0xFC, 0x39, 0xE7, 0x06, 0x60, 0x76, 0x07, 0x60,
  0x07, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0xC0,
  0x3E, 0x07, 0x70, 0xE7, 0xFE, 0x1F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x30,
  0x03, 0xF0, 0x0C, 0xC0, 0x21, 0x18, 0x84, 0x62, 0x13, 0x0C, 0xCC, 0x1E,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x9C, 0x0C, 0xF8, 0x36, 0x31,
  0x98, 0xC6, 0x63, 0x11, 0x8C, 0x03, 0x70, 0x0F, 0x80, 0x07, 0x00, 0x7E,
  0x03, 0x9C, 0x0E, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x9C, 0x06, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xF0, 0xDC, 0xC7, 0x63, 0x9B, 0x87, 0x6E, 0x0F, 0xB8,
  0x1C, 0x70, 0x71, 0xFF, 0xE1, 0xF9, 0xC0, 0xFF, 0xFC, 0x04, 0x31, 0x8E,
  0x31, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38,
  0x61, 0x83, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x81, 0x81, 0x83, 0x83, 0x07,
  0x06, 0x0C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61,
  0xC3, 0x0E, 0x18, 0x61, 0x82, 0x00, 0x06, 0x00, 0x60, 0x06, 0x04, 0x63,
  0xF6, 0xF7, 0xFE, 0x06, 0x00, 0xF0, 0x19, 0x83, 0x9C, 0x70, 0xE1, 0x08,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x33, 0x33, 0x76, 0xE0,
  0xFF, 0xFF, 0xC0, 0x7F, 0x70, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0x06, 0x03, 0xFC, 0x71, 0xC6, 0x06,
  0xE0, 0x6C, 0x07, 0xC0, 0x7C, 0x1F, 0xC3, 0xFC, 0x77, 0xDC, 0x7F, 0x87,
  0xF0, 0x7E, 0x07, 0xC0, 0x7E, 0x06, 0x60, 0xE3, 0xFC, 0x1F, 0x80, 0x0E,
  0xFF, 0xFE, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x06, 0x01, 0xFE, 0x1C, 0x38, 0xC0, 0xCE, 0x07, 0x60,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0x03,
  0xFC, 0x78, 0xE6, 0x06, 0xE0, 0x70, 0x07, 0x00, 0x60, 0x06, 0x03, 0xC0,
  0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x70, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0x67,
  0xFE, 0x1F, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x6E, 0x07,
  0x70, 0x33, 0x83, 0x1C, 0x38, 0xE1, 0x87, 0x18, 0x39, 0xC1, 0xCF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE3, 0xFE,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x6F, 0x87, 0xFC, 0x70, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x3E, 0x03, 0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8,
  0x00, 0x81, 0xF0, 0x7E, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x7C, 0xFF,
  0xDE, 0x1F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0x70, 0xE7,
  0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x03, 0xFC,
  0x79, 0xE7, 0x06, 0x60, 0x76, 0x07, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8,
  0x3F, 0xC6, 0x06, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0x63, 0xFE,
  0x1F, 0x80, 0x0E, 0x03, 0xF8, 0x71, 0xCE, 0x0E, 0xE0, 0x6C, 0x06, 0xC0,
  0x6C, 0x07, 0xE0, 0x7E, 0x0E, 0x71, 0xE3, 0xFE, 0x1E, 0x60, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x83, 0xF0, 0x3C, 0x00, 0xEF, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0xFE, 0x73, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCC,
  0x66, 0x00, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0x87, 0xC1, 0xC0, 0x3C, 0x01,
  0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x1E, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xC0, 0x78, 0x7E, 0x3E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x0F,
  0x07, 0xF9, 0xE7, 0xB0, 0x3E, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0x00, 0x3F, 0x81, 0x87, 0x0C, 0x06, 0x61, 0x19, 0x1F,
  0x24, 0xC4, 0xF3, 0x33, 0xC8, 0xCE, 0x23, 0x39, 0x8C, 0xE6, 0x32, 0xD8,
  0xCB, 0x3F, 0xEC, 0xE7, 0x18, 0x00, 0x70, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x33, 0x00, 0xCC,
  0x07, 0x38, 0x18, 0x60, 0x61, 0x83, 0x86, 0x0F, 0xFC, 0x3F, 0xF1, 0xC0,
  0xC6, 0x03, 0x98, 0x06, 0x60, 0x1B, 0x80, 0x70, 0xFF, 0xCF, 0xFE, 0xE0,
  0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0x8E, 0x1E, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x0E, 0xFF, 0xEF, 0xF8, 0x07,
  0x00, 0xFF, 0x0E, 0x1C, 0x60, 0x66, 0x03, 0xB0, 0x0D, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x0D, 0x80, 0x6E,
  0x07, 0x38, 0x70, 0xFF, 0x03, 0xF0, 0xFF, 0x0C, 0x7C, 0xC0, 0xEC, 0x06,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0xEC, 0x1C, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFC, 0xFF, 0xCE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0x0F, 0x3C, 0x60, 0x67, 0x03, 0xB0,
  0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xC3, 0xFE, 0x01,
  0xB0, 0x0D, 0x80, 0x6E, 0x03, 0x38, 0x38, 0xFF, 0x83, 0xF8, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3E, 0x03, 0x60,
  0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0xE0, 0x7F, 0x07, 0x38, 0x71, 0xC3, 0x0E,
  0x38, 0x73, 0x83, 0xB8, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3D, 0xC1, 0xC7,
  0x0E, 0x18, 0x70, 0xE3, 0x83, 0x9C, 0x0C, 0xE0, 0x77, 0x01, 0xC0, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFC,
  0xE0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xBD, 0x9B, 0xD9, 0xBD, 0xB3,
  0xCF, 0x3C, 0xF3, 0xCE, 0x3C, 0x63, 0xC6, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7D, 0x87,
  0xDC, 0x7C, 0xC7, 0xCE, 0x7C, 0x67, 0xC7, 0x7C, 0x37, 0xC1, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0x07, 0x00, 0xFE, 0x0F, 0x78, 0x60,
  0xE7, 0x03, 0x30, 0x1D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xB0, 0x0D, 0x80, 0xEE, 0x06, 0x38, 0x70, 0xFF, 0x03,
  0xF0, 0xFF, 0xC7, 0x0F, 0x38, 0x1D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80,
  0xDC, 0x0E, 0xE1, 0xE7, 0xFE, 0x3F, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x7F, 0x03, 0xCE,
  0x1C, 0x1C, 0x60, 0x39, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x1B, 0x80,
  0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x19, 0x80, 0x66, 0x03, 0x9C, 0x0C, 0x38,
  0x70, 0x7F, 0x80, 0xFE, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x60, 0xFF, 0xCE,
  0x3E, 0xE0, 0x6E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x06, 0xE3, 0xEF,
  0xF8, 0xE3, 0x8E, 0x18, 0xE1, 0xCE, 0x0C, 0xE0, 0xEE, 0x06, 0xE0, 0x7E,
  0x03, 0x03, 0x00, 0xFF, 0x0F, 0x3C, 0xE0, 0x77, 0x03, 0xB8, 0x0D, 0xC0,
  0x07, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0D,
  0x80, 0x6E, 0x03, 0x78, 0x39, 0xFF, 0x83, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xE0, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0xE0, 0x1D, 0x80, 0x66, 0x03,
  0x9C, 0x0C, 0x70, 0x30, 0xC1, 0xC3, 0x06, 0x0E, 0x18, 0x18, 0xE0, 0x63,
  0x01, 0xCC, 0x03, 0x30, 0x0D, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x0C, 0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x79, 0xF9, 0xE7, 0x67, 0x99,
  0x9E, 0x66, 0x79, 0x99, 0x26, 0x6C, 0xD9, 0xB3, 0x66, 0xCD, 0x9B, 0x36,
  0x7C, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0xF0,
  0x3D, 0xC0, 0xE3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x33, 0x00, 0xFC, 0x01,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x1C, 0xE0, 0x61, 0x83,
  0x87, 0x0C, 0x0C, 0x70, 0x3B, 0x80, 0x70, 0xE0, 0x3D, 0x80, 0xE7, 0x03,
  0x0C, 0x1C, 0x38, 0x60, 0x63, 0x81, 0xCC, 0x03, 0x70, 0x0F, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F,
  0xF8, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x60,
  0x18, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x0C, 0x07, 0x01, 0xE0, 0xD8, 0x37,
  0x0C, 0xC6, 0x31, 0x86, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xE3, 0x8E, 0x30,
  0x1F, 0x07, 0xFC, 0x70, 0xEE, 0x06, 0x00, 0x60, 0x06, 0x3F, 0xE7, 0x86,
  0xE0, 0x6C, 0x06, 0xC0, 0x6E, 0x0E, 0x7F, 0xE3, 0xF7, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x8F, 0xFC, 0xF0, 0xEE, 0x06,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6F, 0x0E,
  0xFF, 0xCC, 0xF8, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xE0, 0x7C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x77, 0x0E, 0x3F, 0xC1, 0xF8,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC7, 0xD9, 0xFF, 0x70,
  0xFC, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x6E,
  0x1D, 0xFF, 0x8F, 0xB0, 0x0F, 0x03, 0xFC, 0x70, 0xE6, 0x06, 0xC0, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x27, 0x07, 0x3F, 0xE1,
  0xFC, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xEF,
  0xFE, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1F, 0x67, 0xFD, 0xC3, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xB8, 0x77,
  0xFE, 0x3E, 0xC0, 0x18, 0x03, 0x60, 0xFF, 0xF8, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8F, 0xFC, 0xF0, 0xEE,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x04, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0x80, 0x02, 0x07, 0x07, 0x00, 0x00,
  0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x06, 0x9E, 0xFC, 0x60, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x1C, 0xE3, 0x8E, 0x70, 0xEE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xE7, 0x0E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0,
  0xEE, 0x07, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC3, 0xFF, 0xFF, 0xF0, 0xDE, 0x77, 0xFF, 0xF9, 0xC7, 0x86,
  0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18, 0xF0, 0xC7,
  0x86, 0x3C, 0x31, 0xE1, 0x8C, 0xC7, 0x8D, 0xFC, 0xF0, 0xEE, 0x06, 0xE0,
  0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x1F, 0x03, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x66, 0x0E, 0x7F, 0xC1, 0xF8, 0xCF,
  0x8D, 0xFC, 0xF1, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x67, 0xFD, 0xC3, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xB8, 0x77, 0xFE, 0x3E, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xC7, 0xF7, 0xEF, 0xCB, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x17, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x76, 0x06, 0x7F, 0xE1, 0xFC, 0x1C, 0x01,
  0xC0, 0x1C, 0x0F, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xFE, 0x07, 0xF0,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xB0, 0x77, 0xFE, 0x7E, 0xC0, 0xE0, 0x1B, 0x01, 0xDC,
  0x0C, 0x60, 0x63, 0x07, 0x1C, 0x30, 0x61, 0x83, 0x18, 0x0C, 0xC0, 0x6E,
  0x03, 0xE0, 0x0F, 0x00, 0x70, 0x01, 0x80, 0xC3, 0x0F, 0x0C, 0x3C, 0x30,
  0xF1, 0xC6, 0xC7, 0x99, 0x9E, 0x66, 0x59, 0x9B, 0x26, 0x6C, 0xD0, 0xB3,
  0xC3, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x80, 0x60, 0x3B, 0x81, 0x8E,
  0x1C, 0x39, 0xC0, 0xDC, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x6E,
  0x07, 0x38, 0x70, 0xE3, 0x03, 0x78, 0x1C, 0xE0, 0x1F, 0x80, 0x66, 0x03,
  0x9C, 0x0C, 0x30, 0x70, 0xE1, 0x81, 0x86, 0x07, 0x38, 0x0C, 0xC0, 0x37,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x01, 0xF0, 0x07, 0x80, 0x08, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0x03, 0x83, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x1E, 0x0F, 0x01, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x0F, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0xF0, 0x78, 0x70, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xC1, 0xC0, 0xC0, 0x00, 0x7C, 0x0B, 0xF8, 0x3C, 0x79,
  0xE0, 0x7E, 0x00, 0xF0,
};

const GFXglyph RobotoMono_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 18, 16, 6, -18 },
  { 8, 7, 7, 16, 4, -20 },
  { 15, 14, 18, 16, 1, -18 },
  { 47, 12, 24, 16, 2, -21 },
  { 83, 14, 19, 16, 1, -19 },
  { 117, 14, 19, 16, 1, -19 },
  { 151, 2, 7, 16, 6, -20 },
  { 153, 6, 27, 16, 5, -21 },
  { 174, 7, 27, 16, 4, -21 },
  { 198, 12, 12, 16, 2, -18 },
  { 216, 12, 13, 16, 2, -15 },
  { 236, 4, 7, 16, 4, -3 },
  { 240, 9, 2, 16, 3, -9 },
  { 243, 4, 3, 16, 6, -3 },
  { 245, 10, 20, 16, 3, -18 },
  { 270, 12, 19, 16, 2, -19 },
  { 299, 7, 18, 16, 3, -18 },
  { 315, 13, 19, 16, 1, -19 },
  { 346, 12, 19, 16, 1, -19 },
  { 375, 13, 18, 16, 1, -18 },
  { 405, 12, 18, 16, 2, -18 },
  { 432, 11, 19, 16, 2, -19 },
  { 459, 13, 18, 16, 1, -18 },
  { 489, 12, 19, 16, 2, -19 },
  { 518, 12, 19, 16, 2, -19 },
  { 547, 4, 14, 16, 7, -14 },
  { 554, 5, 18, 16, 6, -14 },
  { 566, 11, 12, 16, 2, -14 },
  { 583, 12, 7, 16, 2, -12 },
  { 594, 11, 12, 16, 2, -14 },
  { 611, 11, 19, 16, 2, -19 },
  { 638, 14, 19, 16, 1, -19 },
  { 672, 14, 18, 16, 1, -18 },
  { 704, 12, 18, 16, 2, -18 },
  { 731, 13, 19, 16, 1, -19 },
  { 762, 12, 18, 16, 2, -18 },
  { 789, 12, 18, 16, 2, -18 },
  { 816, 12, 18, 16, 2, -18 },
  { 843, 13, 19, 16, 1, -19 },
  { 874, 12, 18, 16, 2, -18 },
  { 901, 11, 18, 16, 2, -18 },
  { 926, 12, 18, 16, 1, -18 },
  { 953, 13, 18, 16, 2, -18 },
  { 983, 11, 18, 16, 3, -18 },
  { 1008, 12, 18, 16, 2, -18 },
  { 1035, 12, 18, 16, 2, -18 },
  { 1062, 13, 19, 16, 1, -19 },
  { 1093, 13, 18, 16, 2, -18 },
  { 1123, 14, 22, 16, 1, -19 },
  { 1162, 12, 18, 16, 2, -18 },
  { 1189, 13, 19, 16, 1, -19 },
  { 1220, 14, 18, 16, 1, -18 },
  { 1252, 12, 18, 16, 2, -18 },
  { 1279, 14, 18, 16, 1, -18 },
  { 1311, 14, 18, 16, 1, -18 },
  { 1343, 14, 18, 16, 1, -18 },
  { 1375, 14, 18, 16, 1, -18 },
  { 1407, 13, 18, 16, 1, -18 },
  { 1437, 5, 25, 16, 5, -21 },
  { 1453, 10, 20, 16, 3, -18 },
  { 1478, 5, 25, 16, 5, -21 },
  { 1494, 10, 9, 16, 3, -18 },
  { 1506, 12, 2, 16, 2, 0 },
  { 1509, 5, 4, 16, 5, -19 },
  { 1512, 12, 14, 16, 2, -14 },
  { 1533, 12, 20, 16, 2, -20 },
  { 1563, 12, 14, 16, 2, -14 },
  { 1584, 11, 20, 16, 2, -20 },
  { 1612, 12, 14, 16, 2, -14 },
  { 1633, 12, 20, 16, 2, -20 },
  { 1663, 11, 19, 16, 2, -14 },
  { 1690, 12, 20, 16, 2, -20 },
  { 1720, 11, 19, 16, 3, -19 },
  { 1747, 8, 25, 16, 3, -19 },
  { 1772, 12, 20, 16, 2, -20 },
  { 1802, 11, 20, 16, 3, -20 },
  { 1830, 13, 14, 16, 1, -14 },
  { 1853, 12, 14, 16, 2, -14 },
  { 1874, 12, 14, 16, 2, -14 },
  { 1895, 12, 19, 16, 2, -14 },
  { 1924, 11, 19, 16, 2, -14 },
  { 1951, 10, 14, 16, 4, -14 },
  { 1969, 12, 14, 16, 2, -14 },
  { 1990, 12, 17, 16, 2, -17 },
  { 2016, 11, 14, 16, 2, -14 },
  { 2036, 13, 14, 16, 1, -14 },
  { 2059, 14, 14, 16, 1, -14 },
  { 2084, 13, 14, 16, 1, -14 },
  { 2107, 14, 20, 16, 1, -14 },
  { 2142, 12, 14, 16, 2, -14 },
  { 2163, 9, 25, 16, 4, -20 },
  { 2192, 2, 23, 16, 7, -18 },
  { 2198, 9, 25, 16, 4, -20 },
  { 2227, 14, 5, 16, 1, -10 },
};

const GFXfont RobotoMono_Regular26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular26pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_REGULAR26PT7B_H_
