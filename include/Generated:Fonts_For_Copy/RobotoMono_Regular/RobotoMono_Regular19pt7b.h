#ifndef _ROBOTOMONO_REGULAR19PT7B_H_
#define _ROBOTOMONO_REGULAR19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0xB0, 0xCE, 0x73, 0x90, 0x09, 0x86, 0x61, 0x90,
  0x44, 0xFF, 0xFF, 0xF1, 0x30, 0xC8, 0x22, 0x3F, 0xE2, 0x20, 0x98, 0x64,
  0x11, 0x00, 0x0C, 0x06, 0x03, 0x07, 0xE6, 0x1B, 0x0D, 0x86, 0xC0, 0x38,
  0x0F, 0x80, 0xE0, 0x3C, 0x1B, 0x0D, 0xCE, 0x7E, 0x0C, 0x06, 0x00, 0x30,
  0x0B, 0x03, 0x22, 0x64, 0x84, 0x90, 0xF4, 0x01, 0x80, 0x20, 0x0D, 0xC1,
  0x6C, 0x68, 0x89, 0x10, 0x26, 0x03, 0x80, 0x1C, 0x0F, 0x86, 0x21, 0x88,
  0x66, 0x0F, 0x03, 0x80, 0xE0, 0x6C, 0xF1, 0xBC, 0x6B, 0x0E, 0x67, 0x8F,
  0xB0, 0xF0, 0x08, 0xCC, 0x46, 0x31, 0x18, 0xC6, 0x31, 0x84, 0x21, 0x84,
  0x30, 0x82, 0x82, 0x18, 0x63, 0x08, 0x63, 0x18, 0xC6, 0x31, 0x88, 0xC6,
  0x22, 0x20, 0x0C, 0x06, 0x03, 0x09, 0x9F, 0xF8, 0x60, 0x78, 0x64, 0x33,
  0x11, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xF8, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x6D, 0xBC, 0xFF, 0xFC, 0xF0, 0x03, 0x02, 0x06, 0x04, 0x0C,
  0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0x60, 0xC0, 0x1C, 0x1F,
  0x98, 0x48, 0x3C, 0x1E, 0x1F, 0x1F, 0xBB, 0xF1, 0xF0, 0xF0, 0x6C, 0x36,
  0x31, 0xF0, 0x09, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x1C,
  0x3F, 0x30, 0xD8, 0x60, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x07, 0xFC, 0x1C, 0x7E, 0xC3, 0xC3, 0x03, 0x03, 0x1E, 0x1E, 0x03,
  0x01, 0xC1, 0xC3, 0xE3, 0x3E, 0x03, 0x03, 0x83, 0xC1, 0x61, 0xB0, 0x98,
  0xCC, 0xC6, 0x43, 0x7F, 0xFF, 0xE0, 0x60, 0x30, 0x18, 0x7F, 0x7F, 0x40,
  0x40, 0x40, 0xDC, 0xFE, 0x43, 0x03, 0x01, 0x83, 0xC3, 0xE7, 0x7E, 0x02,
  0x0F, 0x0C, 0x0C, 0x06, 0x02, 0xF3, 0xFD, 0xC2, 0xC1, 0xE0, 0xF0, 0x6C,
  0x37, 0x31, 0xF0, 0xFF, 0xFF, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0x18, 0x7E, 0xC3, 0xC3, 0xC3,
  0xC3, 0x7E, 0x7E, 0xC3, 0x83, 0x81, 0xC3, 0xE7, 0x7E, 0x1C, 0x1F, 0x18,
  0xC8, 0x3C, 0x1E, 0x0D, 0x06, 0xC7, 0x3F, 0x80, 0xC0, 0x40, 0x63, 0xE1,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x77, 0x00, 0x00, 0x00, 0x66, 0x66, 0xC0,
  0x02, 0x1D, 0xE7, 0x0E, 0x0F, 0x03, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xF0, 0x3C, 0x07, 0x07, 0x3C, 0xF0, 0x80, 0x38, 0x7E, 0xC3,
  0x83, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x10, 0x00, 0x00, 0x18, 0x18, 0x04,
  0x0F, 0xC6, 0x19, 0x32, 0x9A, 0x64, 0x9B, 0x26, 0x89, 0xA2, 0x6D, 0xA9,
  0xB3, 0x00, 0x62, 0x0F, 0x80, 0x0C, 0x03, 0x01, 0xC0, 0x78, 0x16, 0x0C,
  0x83, 0x20, 0x8C, 0x23, 0x1F, 0xC7, 0xF9, 0x06, 0xC0, 0xB0, 0x30, 0xF0,
  0xFE, 0x83, 0x83, 0x83, 0x83, 0xFE, 0xFE, 0x83, 0x81, 0x81, 0x83, 0x8F,
  0xFC, 0x1C, 0x1F, 0x98, 0x78, 0x3C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x28, 0x37, 0x31, 0xF0, 0xF0, 0x3F, 0x8C, 0x33, 0x06, 0xC1, 0xB0,
  0x2C, 0x0F, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0x06, 0xC7, 0x3F, 0x00, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0xFE, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x1C, 0x1F, 0x98, 0x78, 0x3C, 0x06, 0x03, 0x01, 0x8F,
  0xC7, 0xE0, 0x70, 0x2C, 0x17, 0x18, 0xF8, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xF0, 0x78, 0x26, 0x71, 0xF0, 0x81, 0xC1, 0xA1, 0x91, 0x89, 0xC4, 0xC2,
  0xC1, 0xF0, 0xD8, 0x46, 0x21, 0x90, 0xC8, 0x34, 0x0C, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xE1,
  0xF0, 0xF8, 0xFC, 0x5F, 0x2E, 0xB7, 0x53, 0xB9, 0xCC, 0xE4, 0x70, 0x38,
  0x1C, 0x0E, 0x04, 0xC1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1E, 0xCF, 0x67, 0x9B,
  0xCD, 0xE3, 0xF0, 0xF8, 0x7C, 0x1E, 0x0C, 0x1C, 0x1F, 0x98, 0xC8, 0x3C,
  0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x6C, 0x37, 0x31, 0xF0, 0xF0,
  0x7F, 0x20, 0xD0, 0x38, 0x1C, 0x0E, 0x0D, 0xFC, 0xF8, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x1C, 0x0F, 0xC6, 0x13, 0x06, 0xC0, 0xB0, 0x2C, 0x0F,
  0x03, 0xC0, 0xB0, 0x2C, 0x19, 0x06, 0x73, 0x0F, 0xC0, 0x18, 0x03, 0xF0,
  0x7F, 0x20, 0xD0, 0x68, 0x34, 0x1A, 0x0D, 0xFC, 0x8C, 0x42, 0x21, 0x90,
  0x48, 0x34, 0x1C, 0x1C, 0x1F, 0x98, 0x78, 0x34, 0x03, 0x00, 0xE0, 0x3E,
  0x03, 0x80, 0xF0, 0x38, 0x37, 0x39, 0xF8, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x68, 0x37, 0x31, 0xF0, 0xC0, 0xF0, 0x2C, 0x19, 0x06, 0x61, 0x18,
  0xC2, 0x30, 0xC8, 0x36, 0x05, 0x81, 0x60, 0x70, 0x1C, 0x03, 0x00, 0x8C,
  0xE3, 0x3C, 0xCF, 0x33, 0xDC, 0xB7, 0x2D, 0x69, 0x5A, 0x52, 0x9C, 0xE7,
  0x39, 0xCE, 0x63, 0x98, 0xC0, 0xC0, 0xD0, 0x66, 0x18, 0xCC, 0x32, 0x07,
  0x81, 0xC0, 0x30, 0x1E, 0x0D, 0x83, 0x31, 0x8C, 0x61, 0xB0, 0x30, 0xC0,
  0xF0, 0x64, 0x19, 0x8C, 0x23, 0x0D, 0x81, 0x60, 0x70, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x20,
  0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x07, 0xFC, 0xFC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC0, 0x81, 0x03, 0x02, 0x06, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0, 0x80, 0xE4, 0x92, 0x49, 0x24,
  0x92, 0x49, 0xFC, 0x10, 0x30, 0xE1, 0x66, 0xCC, 0x91, 0xE1, 0xFF, 0x80,
  0xC6, 0x30, 0x3E, 0x31, 0x90, 0x60, 0x33, 0xFB, 0x0D, 0x07, 0x83, 0x67,
  0x9E, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xE6, 0x83, 0x83, 0x83, 0x83,
  0x83, 0xC3, 0xE6, 0xBC, 0x3E, 0x39, 0x98, 0x78, 0x0C, 0x06, 0x03, 0x00,
  0xC3, 0x73, 0x1F, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xFB, 0x9D, 0x87,
  0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0x37, 0x39, 0xFC, 0x3E, 0x39, 0x98, 0x78,
  0x3F, 0xFE, 0x03, 0x00, 0xC2, 0x71, 0x9F, 0x80, 0x03, 0xC3, 0xE1, 0x80,
  0x60, 0x18, 0x3F, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x3F, 0xB9, 0xD8, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xC3,
  0x73, 0x9F, 0xC0, 0x68, 0x27, 0x71, 0xF0, 0x80, 0x80, 0x80, 0x80, 0xBE,
  0xE6, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x18, 0x18, 0x00,
  0x00, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x0C,
  0x30, 0x00, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x9B,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x87, 0x8C, 0x98, 0xB0, 0xF0, 0xD8, 0x8C,
  0x8C, 0x86, 0x83, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xBB, 0xB3, 0x2C, 0xCF, 0x33, 0xCC, 0xF3,
  0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x30, 0xBE, 0xE6, 0xC3, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x3E, 0x31, 0x90, 0x78, 0x3C, 0x0E, 0x07, 0x06,
  0x83, 0x63, 0x1F, 0x00, 0xBC, 0xC6, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xC6, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3F, 0xB9, 0xD8, 0x78, 0x3C, 0x1E,
  0x0F, 0x06, 0xC3, 0x73, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xDF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x7E, 0xC7, 0xC3, 0xC0, 0x78,
  0x1E, 0x03, 0x83, 0xC7, 0x7E, 0x18, 0x0C, 0x3F, 0xE3, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x21, 0xF0, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0xC3, 0xC7, 0x7B, 0xC1, 0xA0, 0xD8, 0x4C, 0x62, 0x31, 0x90,
  0x58, 0x38, 0x1C, 0x06, 0x00, 0xC4, 0x68, 0xCD, 0x19, 0xB7, 0x26, 0xA4,
  0x56, 0x8A, 0x71, 0xCC, 0x31, 0x86, 0x30, 0xC1, 0x98, 0xC3, 0x30, 0x78,
  0x0C, 0x07, 0x01, 0xE0, 0xCC, 0x63, 0x30, 0x70, 0xC0, 0xF0, 0x66, 0x19,
  0x8C, 0x23, 0x0C, 0x81, 0x60, 0x70, 0x1C, 0x03, 0x01, 0x80, 0x60, 0xB0,
  0x38, 0x00, 0x7F, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60,
  0x7F, 0xC0, 0x04, 0x61, 0x84, 0x10, 0x41, 0x0C, 0x63, 0x83, 0x0C, 0x10,
  0x41, 0x04, 0x18, 0x30, 0xFF, 0xFF, 0xC0, 0xC1, 0x82, 0x0C, 0x30, 0xC3,
  0x0C, 0x18, 0x31, 0x0C, 0x30, 0xC3, 0x0C, 0x63, 0x00, 0x7C, 0x28, 0xCF,
  0x0F, 0x00,
};

const GFXglyph RobotoMono_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 14, 11, 5, -14 },
  { 5, 5, 4, 11, 3, -14 },
  { 8, 10, 14, 11, 1, -14 },
  { 26, 9, 18, 11, 1, -16 },
  { 47, 11, 14, 11, 0, -14 },
  { 67, 10, 14, 11, 1, -14 },
  { 85, 1, 4, 11, 5, -14 },
  { 86, 5, 19, 11, 3, -15 },
  { 98, 5, 19, 11, 3, -15 },
  { 110, 9, 10, 11, 1, -14 },
  { 122, 9, 10, 11, 1, -11 },
  { 134, 3, 5, 11, 3, -2 },
  { 136, 7, 2, 11, 2, -7 },
  { 138, 2, 2, 11, 5, -2 },
  { 139, 8, 15, 11, 2, -14 },
  { 154, 9, 14, 11, 1, -14 },
  { 170, 5, 14, 11, 2, -14 },
  { 179, 9, 14, 11, 1, -14 },
  { 195, 8, 14, 11, 1, -14 },
  { 209, 9, 14, 11, 1, -14 },
  { 225, 8, 14, 11, 2, -14 },
  { 239, 9, 14, 11, 1, -14 },
  { 255, 9, 14, 11, 1, -14 },
  { 271, 8, 14, 11, 2, -14 },
  { 285, 9, 14, 11, 1, -14 },
  { 301, 3, 10, 11, 5, -10 },
  { 305, 4, 13, 11, 4, -10 },
  { 312, 7, 8, 11, 2, -10 },
  { 319, 8, 6, 11, 2, -9 },
  { 325, 8, 8, 11, 2, -10 },
  { 333, 8, 14, 11, 2, -14 },
  { 347, 10, 14, 11, 1, -14 },
  { 365, 10, 14, 11, 1, -14 },
  { 383, 8, 14, 11, 2, -14 },
  { 397, 9, 14, 11, 1, -14 },
  { 413, 10, 14, 11, 1, -14 },
  { 431, 8, 14, 11, 2, -14 },
  { 445, 8, 14, 11, 2, -14 },
  { 459, 9, 14, 11, 1, -14 },
  { 475, 9, 14, 11, 1, -14 },
  { 491, 8, 14, 11, 2, -14 },
  { 505, 9, 14, 11, 1, -14 },
  { 521, 9, 14, 11, 2, -14 },
  { 537, 8, 14, 11, 2, -14 },
  { 551, 9, 14, 11, 1, -14 },
  { 567, 9, 14, 11, 1, -14 },
  { 583, 9, 14, 11, 1, -14 },
  { 599, 9, 14, 11, 2, -14 },
  { 615, 10, 16, 11, 1, -14 },
  { 635, 9, 14, 11, 2, -14 },
  { 651, 9, 14, 11, 1, -14 },
  { 667, 10, 14, 11, 1, -14 },
  { 685, 9, 14, 11, 1, -14 },
  { 701, 10, 14, 11, 1, -14 },
  { 719, 10, 14, 11, 1, -14 },
  { 737, 10, 14, 11, 1, -14 },
  { 755, 10, 14, 11, 1, -14 },
  { 773, 9, 14, 11, 1, -14 },
  { 789, 4, 18, 11, 4, -15 },
  { 798, 7, 15, 11, 2, -14 },
  { 812, 3, 18, 11, 4, -15 },
  { 819, 7, 8, 11, 2, -14 },
  { 826, 9, 1, 11, 1, 0 },
  { 828, 4, 3, 11, 4, -14 },
  { 830, 9, 10, 11, 1, -10 },
  { 842, 8, 14, 11, 2, -14 },
  { 856, 9, 10, 11, 1, -10 },
  { 868, 9, 14, 11, 1, -14 },
  { 884, 9, 10, 11, 1, -10 },
  { 896, 10, 15, 11, 1, -15 },
  { 915, 9, 14, 11, 1, -10 },
  { 931, 8, 14, 11, 2, -14 },
  { 945, 8, 14, 11, 2, -14 },
  { 959, 6, 18, 11, 2, -14 },
  { 973, 8, 14, 11, 2, -14 },
  { 987, 8, 14, 11, 2, -14 },
  { 1001, 10, 10, 11, 1, -10 },
  { 1014, 8, 10, 11, 2, -10 },
  { 1024, 9, 10, 11, 1, -10 },
  { 1036, 8, 14, 11, 2, -10 },
  { 1050, 9, 14, 11, 1, -10 },
  { 1066, 7, 10, 11, 3, -10 },
  { 1075, 8, 10, 11, 2, -10 },
  { 1085, 9, 12, 11, 1, -12 },
  { 1099, 8, 10, 11, 2, -10 },
  { 1109, 9, 10, 11, 1, -10 },
  { 1121, 11, 10, 11, 0, -10 },
  { 1135, 10, 10, 11, 1, -10 },
  { 1148, 10, 14, 11, 1, -10 },
  { 1166, 9, 10, 11, 1, -10 },
  { 1178, 6, 18, 11, 3, -15 },
  { 1192, 1, 18, 11, 5, -14 },
  { 1195, 6, 18, 11, 3, -15 },
  { 1209, 11, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_Regular19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular19pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_REGULAR19PT7B_H_
