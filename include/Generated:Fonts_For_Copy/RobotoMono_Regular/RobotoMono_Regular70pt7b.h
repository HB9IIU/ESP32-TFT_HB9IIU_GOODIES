#ifndef _ROBOTOMONO_REGULAR70PT7B_H_
#define _ROBOTOMONO_REGULAR70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0x0F, 0xFE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x02, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xC3, 0xE0, 0x00, 0x7F, 0xFF, 0x07,
  0xC0, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0x00,
  0x7F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF8,
  0x00, 0x00, 0x7C, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0xFC, 0x00, 0x03,
  0xE1, 0xFF, 0xFC, 0x00, 0x0F, 0x87, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0xF8, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x1F, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x00,
  0x60, 0x1F, 0x00, 0x78, 0x00, 0x40, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xC1, 0xFE, 0x7F, 0x00, 0x3E, 0x1F, 0xE1, 0xFC,
  0x01, 0xF1, 0xFE, 0x07, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0xC0, 0xFC, 0x7E,
  0x00, 0xFE, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0x3F, 0x3F, 0x80, 0x0F, 0xE3,
  0xF1, 0xF8, 0x00, 0x7F, 0x9F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x7E, 0x00,
  0x07, 0xFF, 0xC3, 0xF0, 0x00, 0x1F, 0xFE, 0x1F, 0x80, 0x00, 0xFF, 0xE0,
  0xFE, 0x00, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x1F,
  0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFF, 0xF3,
  0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x02, 0x40, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x10, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xC7,
  0xC0, 0x3C, 0x03, 0xE7, 0xFC, 0x1E, 0x07, 0xF3, 0xFF, 0x8F, 0x1F, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3E, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xBF, 0xFC, 0x00, 0xFF, 0x3F, 0xFC, 0x03, 0xFC, 0x3F, 0xFC, 0x07, 0xF8,
  0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x7F, 0x80,
  0x3F, 0xFC, 0xFF, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x00, 0x1F, 0x9F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0x80, 0x01, 0xF8, 0x7F, 0xF8, 0x03, 0xF1, 0xFF,
  0xFC, 0x0F, 0xCF, 0xFF, 0xFC, 0x1F, 0xBF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xEF, 0xC0, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xE0,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0xCF, 0xFB, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xFC, 0xFF,
  0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xF0, 0x30, 0x0F, 0x83, 0xF8,
  0xFF, 0x9F, 0xF7, 0xFE, 0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xF1, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x40, 0x1F, 0x03, 0xE0, 0x1F, 0xF0, 0x3C, 0x0F, 0x00,
  0xFF, 0xE0, 0xF0, 0x78, 0x07, 0xFF, 0xC1, 0xE1, 0xE0, 0x3F, 0xFF, 0x07,
  0x8F, 0x81, 0xF8, 0x3C, 0x1E, 0x3C, 0x07, 0xC0, 0xF0, 0x78, 0xF0, 0x3E,
  0x03, 0x80, 0xE7, 0xC0, 0xF0, 0x0E, 0x03, 0x9E, 0x07, 0xC0, 0x78, 0x0F,
  0x78, 0x1E, 0x01, 0xE0, 0x3D, 0xE0, 0x78, 0x07, 0x80, 0xF7, 0x83, 0xE0,
  0x1E, 0x03, 0xDE, 0x0F, 0x80, 0x78, 0x0F, 0xF8, 0x3C, 0x01, 0xE0, 0x3F,
  0xE0, 0xF0, 0x07, 0x80, 0xEF, 0x83, 0xC0, 0x1E, 0x03, 0xBE, 0x0F, 0x00,
  0x78, 0x0E, 0xF8, 0x3C, 0x01, 0xC0, 0x7B, 0xE0, 0xF0, 0x07, 0x01, 0xEF,
  0x83, 0xC0, 0x3C, 0x07, 0xBE, 0x0F, 0x00, 0xF0, 0x1C, 0x78, 0x3E, 0x07,
  0xC0, 0xF1, 0xE0, 0xF8, 0x3F, 0x03, 0x87, 0x81, 0xFF, 0xFE, 0x1E, 0x1E,
  0x07, 0xFF, 0x7F, 0xF0, 0x7C, 0x1F, 0xFD, 0xFF, 0xC0, 0xF0, 0x3F, 0xC3,
  0xFE, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x0F,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC,
  0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFE, 0xFC, 0x00, 0x07, 0xFC, 0xFC,
  0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFF,
  0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x3F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x80,
  0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x07, 0xEF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xF7, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x01, 0xFF, 0x87, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x01, 0xFE, 0x3F,
  0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0xDF, 0x80, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFB, 0xFF, 0xFF, 0x00, 0xFD, 0xFF, 0xEF, 0x80, 0x7E, 0xFF, 0xF7,
  0xE0, 0x3E, 0x7F, 0xFB, 0xF0, 0x3F, 0x3F, 0xFC, 0xF8, 0x1F, 0x1F, 0xFE,
  0x7E, 0x0F, 0x8F, 0xFF, 0x3F, 0x0F, 0xC7, 0xFF, 0x8F, 0x87, 0xC3, 0xFF,
  0xC7, 0xC3, 0xE1, 0xFF, 0xE3, 0xF3, 0xF0, 0xFF, 0xF0, 0xF9, 0xF0, 0x7F,
  0xF8, 0x7C, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xF0,
  0x0F, 0xFF, 0x80, 0x78, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0x3F,
  0xFD, 0xFC, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x3F,
  0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x3F,
  0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x01, 0xF8, 0x3F,
  0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0xFE, 0x3F,
  0xFC, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x3F, 0x3F,
  0xFC, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFF,
  0xF8, 0xFC, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07,
  0xFC, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3E, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x07, 0xFF, 0x83, 0xF0, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x07, 0xF8, 0xFC,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F,
  0xF1, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x80, 0x3F, 0x7E, 0x00, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0xC0, 0x3F, 0x7E,
  0x01, 0xFF, 0x00, 0xF8, 0xFC, 0x07, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7F, 0xC0, 0x7E, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0xFC,
  0x0F, 0xBE, 0x07, 0xE3, 0xF0, 0x3E, 0xF8, 0x1F, 0x8F, 0xC0, 0xFB, 0xE0,
  0x7E, 0x3F, 0x03, 0xEF, 0x81, 0xF0, 0x7C, 0x0F, 0xBE, 0x07, 0xC1, 0xF0,
  0x7C, 0xF8, 0x1F, 0x07, 0xE1, 0xF1, 0xF0, 0xFC, 0x1F, 0x87, 0xC7, 0xC3,
  0xF0, 0x7E, 0x1F, 0x1F, 0x0F, 0xC1, 0xF8, 0x7C, 0x7C, 0x3F, 0x07, 0xE1,
  0xF1, 0xF0, 0xFC, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0x3E, 0x3E, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x0F, 0x8F,
  0x83, 0xE7, 0xE0, 0x3F, 0x3E, 0x0F, 0x9F, 0x80, 0xFD, 0xF0, 0x1F, 0x7E,
  0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x03, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xFE, 0x7F, 0xC0, 0x3F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0xF0, 0x00, 0xFC, 0x1F, 0xFC, 0x01, 0xF8, 0xFF, 0xFE, 0x03, 0xF3, 0xFF,
  0xFF, 0x07, 0xEF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x3F, 0xE0,
  0x01, 0xFE, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFB, 0xFF,
  0xFF, 0xC3, 0xF3, 0xFF, 0xFF, 0x07, 0xE3, 0xFF, 0xF8, 0x0F, 0xC1, 0xFF,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x3F, 0x00, 0x7F, 0xF0, 0x7E,
  0x03, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xF9, 0xF8, 0x3F, 0xFF, 0xFB, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0x9F,
  0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFD, 0xF8,
  0x0F, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x87, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x18,
  0x3F, 0xC0, 0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xC7, 0xE0, 0x00, 0xFF, 0x80, 0x08, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0xFC, 0x07, 0xFF,
  0xF1, 0xF8, 0x1F, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF,
  0xC7, 0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x01, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x03,
  0xF0, 0x60, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFC, 0x0F, 0xFF, 0x01, 0xF8, 0x7F,
  0xFF, 0x83, 0xF1, 0xFF, 0xFF, 0x87, 0xE7, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF,
  0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFE, 0x7F, 0xC0, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x1E, 0x3F, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x03,
  0xFC, 0x1F, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x03,
  0xFC, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x03,
  0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x1F, 0x83,
  0xFC, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x03, 0xF3,
  0xFC, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC,
  0x07, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00,
  0x7F, 0x9F, 0x80, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x0F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFC, 0xFF, 0xE3,
  0xFF, 0x8F, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0x7F,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC3,
  0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xF8, 0x3F, 0xF8, 0x03, 0xF1, 0xFF, 0xFC, 0x07,
  0xEF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x07, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE,
  0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xFC, 0x0F, 0xC7, 0xFF, 0xF0, 0x1F,
  0x87, 0xFF, 0x80, 0x3F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0xF1, 0xF8, 0x1F, 0xFF,
  0xFB, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x01,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x8F, 0xE0,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF,
  0x0F, 0xC0, 0x01, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x3F,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF0, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF,
  0xBF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F,
  0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x06, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF,
  0xFC, 0x3F, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0xC0, 0x1F, 0x9F, 0x00, 0x3F,
  0x80, 0x3E, 0x3F, 0x00, 0xFF, 0x00, 0x7C, 0x7E, 0x01, 0xFE, 0x00, 0xF8,
  0x7C, 0x03, 0xFE, 0x03, 0xF0, 0xF8, 0x07, 0xFC, 0x07, 0xC1, 0xF0, 0x1F,
  0x78, 0x0F, 0x83, 0xF0, 0x3E, 0xF0, 0x1F, 0x07, 0xE0, 0x79, 0xF0, 0x3E,
  0x07, 0xC0, 0xF3, 0xE0, 0x7C, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x1F, 0x07,
  0xC7, 0x83, 0xE0, 0x3E, 0x0F, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x1F, 0x0F,
  0x80, 0x7C, 0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x3C, 0x3C, 0x01, 0xF1,
  0xE0, 0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x03, 0xEF, 0x81, 0xF3,
  0xE0, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x0F, 0xBC, 0x03, 0xCF, 0x00, 0x1F,
  0x78, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x40, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0xCF, 0xFF, 0xFC, 0x00,
  0x1F, 0x7F, 0xFF, 0xF8, 0x00, 0x7D, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xBE, 0x00, 0x3F, 0xF1, 0xFE, 0xF8, 0x00, 0x7F, 0xFF,
  0xF3, 0xC0, 0x00, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph RobotoMono_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 7, 50, 42, 17, -50 },
  { 45, 18, 17, 42, 12, -53 },
  { 84, 38, 50, 42, 2, -50 },
  { 322, 31, 65, 42, 6, -58 },
  { 574, 39, 51, 42, 1, -50 },
  { 823, 37, 51, 42, 4, -50 },
  { 1059, 5, 17, 42, 17, -53 },
  { 1070, 18, 72, 42, 12, -56 },
  { 1232, 18, 72, 42, 11, -56 },
  { 1394, 33, 34, 42, 5, -50 },
  { 1535, 34, 36, 42, 4, -41 },
  { 1688, 10, 18, 42, 12, -7 },
  { 1711, 27, 5, 42, 7, -24 },
  { 1728, 10, 10, 42, 17, -9 },
  { 1741, 26, 54, 42, 9, -50 },
  { 1917, 32, 51, 42, 5, -50 },
  { 2121, 19, 50, 42, 7, -50 },
  { 2240, 33, 50, 42, 3, -50 },
  { 2447, 32, 51, 42, 3, -50 },
  { 2651, 36, 50, 42, 3, -50 },
  { 2876, 32, 51, 42, 6, -50 },
  { 3080, 31, 51, 42, 5, -50 },
  { 3278, 33, 50, 42, 4, -50 },
  { 3485, 32, 51, 42, 6, -50 },
  { 3689, 31, 50, 42, 5, -50 },
  { 3883, 10, 40, 42, 19, -39 },
  { 3933, 11, 50, 42, 17, -39 },
  { 4002, 29, 31, 42, 6, -38 },
  { 4115, 30, 20, 42, 6, -32 },
  { 4190, 30, 31, 42, 6, -38 },
  { 4307, 29, 50, 42, 7, -50 },
  { 4489, 38, 50, 42, 2, -50 },
  { 4727, 37, 50, 42, 3, -50 },
  { 4959, 32, 50, 42, 6, -50 },
  { 5159, 34, 51, 42, 4, -50 },
  { 5376, 34, 50, 42, 5, -50 },
  { 5589, 31, 50, 42, 6, -50 },
  { 5783, 30, 50, 42, 7, -50 },
  { 5971, 35, 51, 42, 3, -50 },
  { 6195, 32, 50, 42, 5, -50 },
  { 6395, 30, 50, 42, 6, -50 },
  { 6583, 33, 51, 42, 3, -50 },
  { 6794, 35, 50, 42, 6, -50 },
  { 7013, 30, 50, 42, 7, -50 },
  { 7201, 33, 50, 42, 5, -50 },
  { 7408, 32, 50, 42, 5, -50 },
  { 7608, 34, 51, 42, 4, -50 },
  { 7825, 32, 50, 42, 7, -50 },
  { 8025, 37, 58, 42, 3, -50 },
  { 8294, 33, 50, 42, 6, -50 },
  { 8501, 35, 51, 42, 4, -50 },
  { 8725, 37, 50, 42, 3, -50 },
  { 8957, 32, 51, 42, 5, -50 },
  { 9161, 37, 50, 42, 2, -50 },
  { 9393, 38, 50, 42, 2, -50 },
  { 9631, 37, 50, 42, 3, -50 },
  { 9863, 37, 50, 42, 2, -50 },
  { 10095, 33, 50, 42, 4, -50 },
  { 10302, 13, 68, 42, 15, -57 },
  { 10413, 26, 54, 42, 8, -50 },
  { 10589, 13, 68, 42, 14, -57 },
  { 10700, 26, 27, 42, 8, -50 },
  { 10788, 32, 5, 42, 5, 0 },
  { 10808, 14, 9, 42, 14, -51 },
  { 10824, 32, 39, 42, 5, -38 },
  { 10980, 31, 54, 42, 6, -53 },
  { 11190, 32, 39, 42, 5, -38 },
  { 11346, 31, 54, 42, 5, -53 },
  { 11556, 32, 39, 42, 5, -38 },
  { 11712, 34, 54, 42, 5, -54 },
  { 11942, 31, 53, 42, 5, -38 },
  { 12148, 31, 53, 42, 6, -53 },
  { 12354, 31, 50, 42, 7, -50 },
  { 12548, 22, 65, 42, 7, -50 },
  { 12727, 33, 53, 42, 6, -53 },
  { 12946, 31, 53, 42, 7, -53 },
  { 13152, 36, 38, 42, 3, -38 },
  { 13323, 30, 38, 42, 6, -38 },
  { 13466, 34, 39, 42, 4, -38 },
  { 13632, 31, 52, 42, 6, -38 },
  { 13834, 31, 52, 42, 5, -38 },
  { 14036, 26, 38, 42, 11, -38 },
  { 14160, 31, 39, 42, 6, -38 },
  { 14312, 31, 47, 42, 5, -46 },
  { 14495, 30, 38, 42, 6, -37 },
  { 14638, 35, 37, 42, 3, -37 },
  { 14800, 39, 37, 42, 2, -37 },
  { 14981, 35, 37, 42, 4, -37 },
  { 15143, 38, 52, 42, 2, -37 },
  { 15390, 32, 37, 42, 5, -37 },
  { 15538, 23, 68, 42, 11, -55 },
  { 15734, 6, 64, 42, 18, -50 },
  { 15782, 23, 68, 42, 11, -55 },
  { 15978, 38, 13, 42, 2, -27 },
};

const GFXfont RobotoMono_Regular70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular70pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_REGULAR70PT7B_H_
