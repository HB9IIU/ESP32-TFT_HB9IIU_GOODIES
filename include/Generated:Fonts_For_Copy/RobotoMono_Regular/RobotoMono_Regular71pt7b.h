#ifndef _ROBOTOMONO_REGULAR71PT7B_H_
#define _ROBOTOMONO_REGULAR71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0x7B, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFE, 0x7F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x04, 0x00, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0xF8,
  0x00, 0xFC, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x7F, 0x07, 0xC0, 0x01, 0xFF,
  0xFC, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x00, 0x00, 0xF8,
  0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xC1, 0xFF, 0xF8,
  0x00, 0x0F, 0x87, 0xFF, 0xF0, 0x00, 0x3E, 0x1F, 0x83, 0xF0, 0x00, 0x7C,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x01, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0x0F,
  0xF1, 0xFC, 0x01, 0xF8, 0xFF, 0x0F, 0xF0, 0x0F, 0xCF, 0xF0, 0x3F, 0xC0,
  0x7E, 0x7F, 0x00, 0xFE, 0x03, 0xF7, 0xF0, 0x03, 0xF8, 0x3F, 0x3F, 0x80,
  0x1F, 0xE1, 0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xCF, 0xC0, 0x01, 0xFC, 0xFE,
  0x7E, 0x00, 0x07, 0xF7, 0xE3, 0xF0, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x00,
  0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xF0, 0x00, 0x0F, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x80, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x00,
  0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x30, 0x01, 0xF0, 0x01, 0x1E, 0x00, 0xF8, 0x03, 0x8F, 0xE0,
  0x7C, 0x0F, 0xEF, 0xFC, 0x3E, 0x1F, 0xF7, 0xFF, 0xDE, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC,
  0x7E, 0x3F, 0x03, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F,
  0x83, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFE, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xFC, 0x03, 0xFC, 0x3F,
  0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0x87, 0xF8, 0x07,
  0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7E, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x1F,
  0xBF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F,
  0x80, 0x07, 0xFC, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x07, 0xFC, 0x00, 0x7E, 0x1F, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF,
  0xE0, 0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFF,
  0x3F, 0xC0, 0x03, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF, 0x1F, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFE, 0x7E,
  0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x7F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xE7, 0xF8, 0x38, 0x0F, 0x81, 0xFE, 0x3F, 0xE3, 0xFF,
  0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x7F, 0xF1, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0,
  0x3C, 0x0F, 0x00, 0x7F, 0xE0, 0x78, 0x7C, 0x07, 0xFF, 0xC1, 0xE1, 0xE0,
  0x1F, 0xFF, 0x07, 0x87, 0x80, 0xFC, 0x3C, 0x0F, 0x3C, 0x07, 0xC0, 0xF0,
  0x3C, 0xF0, 0x1E, 0x03, 0xC0, 0xF3, 0xC0, 0xF8, 0x0F, 0x03, 0xDF, 0x03,
  0xC0, 0x3C, 0x0F, 0x78, 0x1F, 0x00, 0xF0, 0x3D, 0xE0, 0x78, 0x03, 0xC0,
  0xF7, 0x81, 0xE0, 0x0E, 0x03, 0xDE, 0x07, 0x80, 0x78, 0x0F, 0x78, 0x3E,
  0x01, 0xE0, 0x3F, 0xE0, 0xF8, 0x07, 0x80, 0xFF, 0x83, 0xC0, 0x1E, 0x03,
  0xFE, 0x0F, 0x00, 0x78, 0x0F, 0xF8, 0x3C, 0x01, 0xE0, 0x3F, 0xE0, 0xF0,
  0x07, 0x80, 0xEF, 0x83, 0xC0, 0x1E, 0x03, 0xBE, 0x0F, 0x00, 0x78, 0x1E,
  0x78, 0x3E, 0x03, 0xE0, 0x79, 0xE0, 0xF8, 0x1F, 0x83, 0xC7, 0x83, 0xF0,
  0xFE, 0x0F, 0x1E, 0x07, 0xFF, 0xFC, 0x78, 0x7C, 0x1F, 0xFF, 0xFF, 0xE1,
  0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xE0, 0x00, 0xFF, 0xC3, 0xF0, 0x00, 0x1F, 0xF1, 0xF8, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFF, 0x1F,
  0x80, 0x00, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xFE, 0x1F, 0x80, 0x00, 0xFF,
  0x8F, 0xC0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xBF, 0x00,
  0x00, 0x7F, 0x9F, 0x80, 0x00, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xE0, 0x00,
  0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x7E, 0x00, 0x1F, 0xFF, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xF3, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x87,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFB, 0xFF, 0xDF, 0x00,
  0x7D, 0xFF, 0xEF, 0xC0, 0x7E, 0xFF, 0xF7, 0xE0, 0x3E, 0x7F, 0xF9, 0xF0,
  0x1F, 0x3F, 0xFC, 0xFC, 0x1F, 0x9F, 0xFE, 0x7E, 0x0F, 0x8F, 0xFF, 0x1F,
  0x0F, 0xC7, 0xFF, 0x8F, 0xC7, 0xE3, 0xFF, 0xC7, 0xE3, 0xE1, 0xFF, 0xE1,
  0xF3, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0x7F, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F,
  0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x78, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFB, 0xF0, 0x00,
  0xFF, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x3F, 0x80,
  0x1F, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0xE1, 0xF8,
  0x03, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0xFC, 0x1F,
  0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x80,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0xC0, 0x1F, 0xC3, 0xFF, 0xE0,
  0x0F, 0xE1, 0xFF, 0xF0, 0x03, 0xF8, 0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0xFC,
  0x00, 0x7F, 0x3F, 0xFE, 0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x0F, 0xEF, 0xFF,
  0x80, 0x03, 0xF7, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xE0,
  0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x03, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F,
  0xF9, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0xC3, 0xF8, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF8, 0x07, 0xEF,
  0xC0, 0x1F, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0x80, 0x7E, 0x7E, 0x03, 0xFE,
  0x01, 0xF9, 0xF8, 0x0F, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xF0, 0x1F, 0x9F,
  0x80, 0xFF, 0xC0, 0x7E, 0x7E, 0x03, 0xFF, 0x01, 0xF1, 0xF8, 0x0F, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7D, 0xF0, 0x3F, 0x1F, 0x81, 0xF7, 0xC0, 0xFC, 0x3E,
  0x07, 0xCF, 0x83, 0xF0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF3, 0xE0, 0xFC, 0x3F, 0x0F, 0x8F, 0x83, 0xE0, 0xFC,
  0x3E, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x7C, 0x7E, 0x0F, 0xC3, 0xE1, 0xF1,
  0xF8, 0x1F, 0x0F, 0x87, 0xC7, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x81, 0xF1,
  0xF0, 0x7C, 0x7E, 0x07, 0xE7, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x03, 0xE7,
  0xC0, 0x7E, 0x7C, 0x0F, 0x9F, 0x01, 0xF9, 0xF0, 0x3E, 0x7C, 0x07, 0xEF,
  0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x0F, 0xFF,
  0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x00, 0x7E, 0x3F,
  0xC0, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F, 0x07,
  0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0xFC, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0x80, 0xFD,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFF,
  0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0xC0, 0xFC,
  0x7F, 0xFF, 0x80, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xF8,
  0x3F, 0x00, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0xFD,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFE, 0x00, 0xFF,
  0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0x83,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x81, 0xFC, 0x00, 0x00, 0xE0, 0xFF, 0x00, 0x00,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xFC, 0x3F,
  0x03, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xF8, 0x7E,
  0x00, 0x07, 0x40, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x00, 0xFC,
  0x1E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0xFC, 0x1F, 0xFF, 0x81, 0xF8, 0x7F, 0xFF, 0xC3, 0xF1, 0xFF,
  0xFF, 0xC7, 0xE7, 0xFF, 0xFF, 0x8F, 0xDF, 0xC1, 0xFF, 0x9F, 0xFC, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x84, 0x07, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x3F, 0x80, 0xFF, 0x0F, 0xCF, 0xFE, 0x1F, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x3F, 0xFF, 0x03, 0xF0, 0xFF,
  0xFF, 0x87, 0xE7, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFF, 0x1F, 0xBF, 0x87,
  0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0xFF, 0x00,
  0xFC, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFE,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x07, 0xF8,
  0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0xFF, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0x00, 0xFC, 0x1F, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x3E,
  0x01, 0xFF, 0xF8, 0x7C, 0x0F, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFF,
  0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0x0F, 0xC0,
  0x01, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1B, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x01,
  0xFF, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x06, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF,
  0xE3, 0xF0, 0x7F, 0xFF, 0x87, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x03,
  0xF7, 0xC0, 0x0F, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0x0F, 0x9F, 0x00,
  0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x7E, 0x01, 0xFF, 0x00,
  0xFC, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x03, 0xE1, 0xF0,
  0x0F, 0x78, 0x07, 0xC3, 0xF0, 0x3E, 0xF8, 0x0F, 0x87, 0xE0, 0x7D, 0xF0,
  0x3F, 0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x0F, 0x81, 0xE3, 0xC0, 0xF8, 0x1F,
  0x07, 0xC7, 0xC1, 0xF0, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x7E, 0x1F, 0x1F,
  0x0F, 0x80, 0x7C, 0x3C, 0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x03, 0xE7, 0x80,
  0xF1, 0xE0, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00, 0x3D, 0xE0,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xF8, 0xFF, 0xFF, 0x00, 0x01, 0xF3, 0xFF, 0xFF, 0x80, 0x03, 0xEF, 0xFF,
  0xFF, 0x80, 0x0F, 0xDF, 0xC1, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xC0,
  0xFE, 0xF8, 0x00, 0xFF, 0xFF, 0xF9, 0xF0, 0x00, 0x7F, 0xFF, 0xF3, 0xE0,
  0x00, 0x7F, 0xFF, 0xC7, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
};

const GFXglyph RobotoMono_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 8, 50, 43, 17, -50 },
  { 51, 18, 16, 43, 12, -53 },
  { 87, 39, 50, 43, 2, -50 },
  { 331, 32, 66, 43, 6, -59 },
  { 595, 39, 52, 43, 2, -51 },
  { 849, 37, 52, 43, 4, -51 },
  { 1090, 6, 16, 43, 17, -53 },
  { 1102, 19, 73, 43, 12, -57 },
  { 1276, 18, 73, 43, 11, -57 },
  { 1441, 33, 34, 43, 6, -50 },
  { 1582, 35, 37, 43, 4, -42 },
  { 1744, 10, 20, 43, 12, -8 },
  { 1769, 26, 6, 43, 8, -25 },
  { 1789, 10, 10, 43, 17, -9 },
  { 1802, 27, 54, 43, 9, -50 },
  { 1985, 33, 52, 43, 5, -51 },
  { 2200, 20, 50, 43, 7, -50 },
  { 2325, 34, 51, 43, 3, -51 },
  { 2542, 32, 52, 43, 3, -51 },
  { 2750, 36, 50, 43, 3, -50 },
  { 2975, 32, 51, 43, 6, -50 },
  { 3179, 32, 52, 43, 5, -51 },
  { 3387, 34, 50, 43, 4, -50 },
  { 3600, 32, 52, 43, 6, -51 },
  { 3808, 32, 51, 43, 5, -51 },
  { 4012, 10, 40, 43, 19, -39 },
  { 4062, 12, 51, 43, 17, -39 },
  { 4139, 29, 31, 43, 6, -38 },
  { 4252, 31, 20, 43, 6, -33 },
  { 4330, 31, 31, 43, 6, -38 },
  { 4451, 29, 51, 43, 7, -51 },
  { 4636, 38, 51, 43, 2, -51 },
  { 4879, 38, 50, 43, 3, -50 },
  { 5117, 33, 50, 43, 6, -50 },
  { 5324, 35, 52, 43, 4, -51 },
  { 5552, 34, 50, 43, 5, -50 },
  { 5765, 31, 50, 43, 6, -50 },
  { 5959, 31, 50, 43, 7, -50 },
  { 6153, 36, 52, 43, 3, -51 },
  { 6387, 33, 50, 43, 5, -50 },
  { 6594, 31, 50, 43, 6, -50 },
  { 6788, 33, 51, 43, 3, -50 },
  { 6999, 35, 50, 43, 6, -50 },
  { 7218, 31, 50, 43, 7, -50 },
  { 7412, 33, 50, 43, 5, -50 },
  { 7619, 33, 50, 43, 5, -50 },
  { 7826, 35, 52, 43, 4, -51 },
  { 8054, 33, 50, 43, 7, -50 },
  { 8261, 37, 60, 43, 3, -51 },
  { 8539, 33, 50, 43, 6, -50 },
  { 8746, 35, 52, 43, 4, -51 },
  { 8974, 37, 50, 43, 3, -50 },
  { 9206, 33, 51, 43, 5, -50 },
  { 9417, 38, 50, 43, 2, -50 },
  { 9655, 38, 50, 43, 3, -50 },
  { 9893, 37, 50, 43, 3, -50 },
  { 10125, 38, 50, 43, 2, -50 },
  { 10363, 33, 50, 43, 4, -50 },
  { 10570, 14, 69, 43, 15, -58 },
  { 10691, 27, 54, 43, 8, -50 },
  { 10874, 14, 69, 43, 14, -58 },
  { 10995, 27, 27, 43, 8, -50 },
  { 11087, 32, 5, 43, 5, 0 },
  { 11107, 14, 9, 43, 14, -51 },
  { 11123, 32, 39, 43, 5, -38 },
  { 11279, 32, 54, 43, 6, -53 },
  { 11495, 32, 39, 43, 5, -38 },
  { 11651, 31, 54, 43, 5, -53 },
  { 11861, 33, 39, 43, 5, -38 },
  { 12022, 34, 55, 43, 5, -55 },
  { 12256, 32, 53, 43, 5, -38 },
  { 12468, 31, 53, 43, 6, -53 },
  { 12674, 31, 51, 43, 7, -51 },
  { 12872, 23, 66, 43, 7, -51 },
  { 13062, 33, 53, 43, 6, -53 },
  { 13281, 31, 53, 43, 7, -53 },
  { 13487, 36, 38, 43, 3, -38 },
  { 13658, 31, 38, 43, 6, -38 },
  { 13806, 34, 39, 43, 4, -38 },
  { 13972, 32, 52, 43, 6, -38 },
  { 14180, 31, 52, 43, 5, -38 },
  { 14382, 26, 38, 43, 11, -38 },
  { 14506, 31, 39, 43, 6, -38 },
  { 14658, 32, 48, 43, 5, -47 },
  { 14850, 31, 39, 43, 6, -38 },
  { 15002, 36, 38, 43, 3, -38 },
  { 15173, 39, 38, 43, 2, -38 },
  { 15359, 35, 38, 43, 4, -38 },
  { 15526, 38, 53, 43, 2, -38 },
  { 15778, 32, 38, 43, 6, -38 },
  { 15930, 24, 68, 43, 11, -55 },
  { 16134, 5, 64, 43, 19, -50 },
  { 16174, 24, 68, 43, 11, -55 },
  { 16378, 39, 14, 43, 2, -28 },
};

const GFXfont RobotoMono_Regular71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular71pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_REGULAR71PT7B_H_
