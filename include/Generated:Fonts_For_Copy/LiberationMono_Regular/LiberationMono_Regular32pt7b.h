#ifndef _LIBERATIONMONO_REGULAR32PT7B_H_
#define _LIBERATIONMONO_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0xF1, 0xFE, 0x3F,
  0xC7, 0xB8, 0x77, 0x0E, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x18, 0x03,
  0x06, 0x01, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x80, 0x60, 0xC3, 0xFF, 0xFD,
  0xFF, 0xFE, 0x18, 0x10, 0x0C, 0x18, 0x06, 0x0C, 0x02, 0x06, 0x03, 0x03,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0xC0, 0x20, 0x60, 0x10, 0x30, 0x18,
  0x10, 0x0C, 0x18, 0x06, 0x0C, 0x02, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xC6, 0xF1, 0xC3, 0x1C, 0xE1,
  0x8E, 0x70, 0xC3, 0x38, 0x60, 0x0E, 0x30, 0x07, 0x98, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x01, 0x8E, 0x00, 0xC3, 0x80, 0x61, 0xF8, 0x30,
  0xFC, 0x18, 0x77, 0x0C, 0x3B, 0xC6, 0x78, 0xFF, 0xF8, 0x0F, 0xF0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3E, 0x01, 0xCF, 0xE0, 0x33, 0x8C,
  0x0C, 0x71, 0xC3, 0x8C, 0x18, 0x61, 0x83, 0x18, 0x30, 0x67, 0x07, 0x1C,
  0xC0, 0xE3, 0x30, 0x0F, 0xEC, 0x00, 0xFB, 0xBE, 0x00, 0x6F, 0xE0, 0x19,
  0x8E, 0x07, 0x70, 0xC0, 0xCE, 0x18, 0x31, 0xC3, 0x0E, 0x38, 0x61, 0x87,
  0x0C, 0x60, 0x63, 0x9C, 0x0F, 0xE3, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xFE,
  0x00, 0xE3, 0x80, 0x70, 0x70, 0x18, 0x1C, 0x06, 0x06, 0x01, 0xC3, 0x80,
  0x33, 0xC0, 0x0F, 0xC0, 0x07, 0xC1, 0x83, 0xF0, 0x71, 0xCC, 0x18, 0xE3,
  0x86, 0x38, 0x73, 0x8C, 0x0E, 0xC3, 0x03, 0xF0, 0xC0, 0x78, 0x38, 0x0F,
  0x07, 0x0F, 0xE5, 0xFF, 0xBF, 0x1F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x70, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x18,
  0x63, 0x3F, 0xFE, 0x7F, 0x83, 0x80, 0xD8, 0x3B, 0x86, 0x30, 0x82, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x78, 0xF1, 0xC7, 0x8E, 0x1C,
  0x30, 0xE1, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80,
  0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0x1F,
  0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x01, 0xF8, 0x03, 0xB0, 0x07, 0x70,
  0x1C, 0xE0, 0x38, 0xE0, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0xFD, 0xC0, 0xE1, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x00,
  0xDC, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xE0,
  0xF3, 0x80, 0xE7, 0x00, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x78,
  0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x0E, 0xE0, 0x3D, 0xE0, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xB8, 0x03, 0x38, 0x06,
  0x38, 0x0E, 0x38, 0x0C, 0x38, 0x18, 0x38, 0x38, 0x38, 0x70, 0x38, 0x60,
  0x38, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xFC, 0xFF, 0xF9, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x39, 0xF0, 0x7F, 0xF8, 0xF0, 0x79,
  0xC0, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x0E, 0xE0, 0x39, 0xE0, 0xF1, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0xF0, 0x70, 0xF1, 0xC0, 0xE7, 0x00, 0xEE, 0x00, 0x18, 0x00, 0x31, 0xF0,
  0xEF, 0xF9, 0xF8, 0x7B, 0xC0, 0x77, 0x80, 0x7F, 0x00, 0xEC, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0x70, 0x38, 0xF0, 0xF0, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80,
  0xE7, 0x00, 0xCC, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x38, 0x3F, 0xE0,
  0x7F, 0xC1, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0E, 0xE0, 0x3D, 0xE0, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x3F,
  0xE0, 0xE1, 0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07,
  0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x79, 0xC1, 0xF3, 0xFE, 0xE1, 0xF1, 0xC0,
  0x03, 0x80, 0x0E, 0x70, 0x1C, 0xE0, 0x70, 0xE1, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1C, 0x38, 0x70, 0xE1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xCF, 0x1E, 0x38, 0x71,
  0xC3, 0x86, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x80,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x07, 0x70,
  0x07, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xF0, 0x01, 0xFF, 0x00,
  0xE0, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x0C, 0x00, 0x66, 0x1E, 0xD9, 0x8F,
  0xF6, 0xE7, 0x3D, 0xB1, 0x87, 0x3C, 0xC1, 0x8F, 0x30, 0x63, 0xCC, 0x18,
  0xF7, 0x06, 0x2D, 0x81, 0x9B, 0x60, 0xC6, 0xD8, 0x31, 0xB3, 0x1C, 0x6C,
  0xC5, 0x33, 0x3F, 0x7C, 0xE7, 0x9E, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x18, 0x1C, 0x1E, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x30, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x03,
  0x81, 0xC0, 0x70, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x1C, 0x38, 0x01,
  0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x7E, 0x00, 0x0E, 0xFF, 0xC1,
  0xFF, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x1C, 0xE0, 0x71, 0xFF, 0xC3, 0xFF, 0xC7, 0x01, 0xCE, 0x01, 0xDC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xF7, 0xFF, 0xCF,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E,
  0xF0, 0x04, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x06, 0x70, 0x07,
  0x78, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x01, 0xFF, 0xC3,
  0x83, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x39, 0xC0, 0xF3, 0x83, 0xC7, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0,
  0xE7, 0x00, 0xFC, 0x01, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x83, 0xFF, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0x70,
  0x0E, 0xF0, 0x1C, 0xF0, 0x78, 0xFF, 0xE0, 0x7E, 0x00, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x07,
  0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xE0,
  0xF0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF3, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7E, 0xC1, 0xFD, 0x83, 0x7B, 0x86, 0xFB, 0x1D, 0xF7,
  0x33, 0xEE, 0xE7, 0xCD, 0x8F, 0x9F, 0x1F, 0x1E, 0x3E, 0x38, 0x7C, 0x70,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x60, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0x70,
  0x7D, 0xC1, 0xF3, 0x07, 0xCE, 0x1F, 0x18, 0x7C, 0x71, 0xF0, 0xC7, 0xC3,
  0x9F, 0x06, 0x7C, 0x1D, 0xF0, 0x37, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x3C, 0x07, 0xE0, 0x1F, 0xF0, 0x3C, 0x38, 0x70, 0x1C, 0x70,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x70,
  0x1E, 0x70, 0x1C, 0x3C, 0x38, 0x1F, 0xF0, 0x07, 0xC0, 0xFF, 0xC3, 0xFF,
  0xCE, 0x07, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0xF0, 0x3C, 0x38, 0x70, 0x1C, 0x70, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x3C, 0x38,
  0x1F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00, 0xEE,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xFF, 0xE3, 0xFF,
  0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x38, 0xE0, 0x79,
  0xC0, 0x73, 0x80, 0x77, 0x00, 0xEE, 0x00, 0xE0, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0x07, 0x87, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0xC0, 0x07, 0xF0, 0x07, 0x38, 0x03, 0x8F, 0x03,
  0xC3, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x70, 0x0E, 0xE0, 0x39,
  0xE0, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x39, 0xC0,
  0x07, 0x3C, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x00, 0xC7, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x36,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x0C, 0xE0, 0x01, 0x9C, 0x38,
  0x73, 0x87, 0x0E, 0x70, 0xF1, 0xCE, 0x36, 0x38, 0xC6, 0xC7, 0x18, 0xD8,
  0xC3, 0x9B, 0x98, 0x77, 0x33, 0x0E, 0xC6, 0xE1, 0xD8, 0xDC, 0x1B, 0x1F,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x70, 0x07,
  0x9C, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x03, 0x8E, 0x00,
  0x73, 0x80, 0x1D, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x70, 0x70, 0x1C, 0x1E,
  0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1E, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0xBC, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x07, 0x00,
  0xE3, 0xC0, 0x38, 0xE0, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFC, 0x03,
  0x80, 0x0F, 0x80, 0x1B, 0x00, 0x37, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x0C,
  0x0C, 0x18, 0x38, 0x38, 0x60, 0x30, 0xC0, 0x73, 0x00, 0x66, 0x00, 0xDC,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x70, 0x70, 0x70, 0x0F,
  0xC0, 0x3F, 0xF0, 0x78, 0x78, 0x70, 0x38, 0x70, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x0F, 0xFC, 0x3F, 0xFC, 0x78, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x3C, 0xE0, 0x7C, 0xF0, 0xDC, 0x7F, 0x9F, 0x3F, 0x0F, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7E, 0x3B, 0xFC, 0xF8,
  0x7B, 0xC0, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0E, 0xF8, 0x7B, 0xBF, 0xCE,
  0x7C, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x00, 0xFC,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0xEE, 0x03, 0x8E, 0x0F, 0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xF9, 0xCF, 0xFF,
  0x78, 0x6D, 0xC0, 0xF7, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x0F, 0x78, 0x6C, 0xFF,
  0x30, 0xF8, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xE3, 0x80, 0xE7, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0xCE, 0x03, 0x8F, 0x0F, 0x0F, 0xFC, 0x07, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0x8C, 0xFF, 0x37, 0x86,
  0xDC, 0x0F, 0x70, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x86, 0xCF, 0xF3, 0x1F,
  0x8C, 0x00, 0x30, 0x01, 0xDC, 0x07, 0x38, 0x1C, 0xF0, 0xE1, 0xFF, 0x01,
  0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F,
  0x9D, 0xFE, 0xF8, 0x7F, 0x81, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x81, 0xEF, 0xF9, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0xB8, 0x1C, 0xE0, 0xE3, 0x87,
  0x0E, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3D, 0xC0, 0xE3,
  0x83, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xF3, 0x81, 0xCE, 0x03, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xCE, 0x3C, 0xDF, 0x7E,
  0xF3, 0x4E, 0xE3, 0x86, 0xE3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87,
  0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87,
  0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC7, 0xE7, 0x7F, 0xBE, 0x1F, 0xE0,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x18, 0x0F, 0xE0,
  0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x03,
  0x8E, 0x0E, 0x0F, 0xF8, 0x0F, 0xE0, 0xE7, 0xC3, 0xBF, 0xCF, 0x87, 0xBC,
  0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xEF, 0x87, 0xBB, 0xFC, 0xE7, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x0F, 0x8C, 0xFF, 0x37, 0x87, 0xDC, 0x0F, 0x70, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x1D, 0xC0,
  0xF7, 0x86, 0xCF, 0xF7, 0x0F, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE3, 0xFE, 0x7F, 0xEF, 0xFE, 0xE0,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0xFF, 0xC7,
  0x07, 0xB8, 0x0E, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x6F, 0x07, 0x9F, 0xFC,
  0x1F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0F, 0xFF, 0x7F, 0xF8,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xF0, 0x7F,
  0x00, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0xC3, 0x6F, 0xF3, 0x3F, 0x18, 0xE0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCF,
  0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x07, 0x1C, 0x03, 0x8E, 0x00, 0xE6, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D,
  0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80,
  0x03, 0x38, 0x00, 0x67, 0x00, 0x1C, 0xE1, 0xC3, 0x9C, 0x3C, 0x71, 0x8D,
  0x8E, 0x31, 0xB1, 0x87, 0x37, 0x30, 0xEC, 0x6E, 0x1D, 0x8D, 0xC3, 0xB1,
  0xB8, 0x3E, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x00, 0x70,
  0x07, 0x1C, 0x07, 0x07, 0x07, 0x03, 0x83, 0x80, 0xE3, 0x80, 0x3B, 0x80,
  0x0D, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xDC, 0x00, 0xC7,
  0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xE0, 0x38, 0x70, 0x1E, 0x70, 0x07, 0x00,
  0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xC6, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0x70, 0x70, 0x30, 0x38, 0x38, 0x0C, 0x1C, 0x07, 0x1C, 0x01, 0x8E, 0x00,
  0xE6, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x7F, 0x81, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xE0, 0x1F, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x0F, 0xE0, 0x7E,
  0x00, 0x7E, 0x01, 0xFF, 0x83, 0x83, 0xFF, 0x00, 0x7C,
};

const GFXglyph LiberationMono_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 21, 19, 8, -21 },
  { 9, 11, 10, 19, 4, -23 },
  { 23, 17, 21, 19, 1, -21 },
  { 68, 17, 27, 19, 1, -24 },
  { 126, 19, 21, 19, 0, -21 },
  { 176, 18, 21, 19, 1, -21 },
  { 224, 3, 10, 19, 8, -23 },
  { 228, 9, 30, 19, 5, -23 },
  { 262, 9, 30, 19, 5, -23 },
  { 296, 11, 11, 19, 4, -23 },
  { 312, 15, 16, 19, 2, -19 },
  { 342, 7, 10, 19, 4, -5 },
  { 351, 9, 3, 19, 5, -10 },
  { 355, 3, 5, 19, 8, -5 },
  { 357, 15, 23, 19, 2, -23 },
  { 401, 15, 21, 19, 2, -21 },
  { 441, 16, 21, 19, 2, -21 },
  { 483, 15, 21, 19, 2, -21 },
  { 523, 15, 21, 19, 2, -21 },
  { 563, 16, 21, 19, 2, -21 },
  { 605, 15, 21, 19, 2, -21 },
  { 645, 15, 21, 19, 2, -21 },
  { 685, 15, 21, 19, 2, -21 },
  { 725, 15, 21, 19, 2, -21 },
  { 765, 15, 21, 19, 2, -21 },
  { 805, 3, 17, 19, 8, -17 },
  { 812, 7, 22, 19, 5, -17 },
  { 832, 15, 17, 19, 2, -19 },
  { 864, 15, 9, 19, 2, -15 },
  { 881, 15, 17, 19, 2, -19 },
  { 913, 16, 21, 19, 1, -21 },
  { 955, 18, 27, 19, 1, -23 },
  { 1016, 19, 21, 19, 0, -21 },
  { 1066, 15, 21, 19, 3, -21 },
  { 1106, 16, 21, 19, 2, -21 },
  { 1148, 15, 21, 19, 3, -21 },
  { 1188, 15, 21, 19, 3, -21 },
  { 1228, 14, 21, 19, 3, -21 },
  { 1265, 15, 21, 19, 2, -21 },
  { 1305, 14, 21, 19, 3, -21 },
  { 1342, 13, 21, 19, 3, -21 },
  { 1377, 12, 21, 19, 3, -21 },
  { 1409, 16, 21, 19, 3, -21 },
  { 1451, 13, 21, 19, 4, -21 },
  { 1486, 15, 21, 19, 2, -21 },
  { 1526, 14, 21, 19, 3, -21 },
  { 1563, 16, 21, 19, 2, -21 },
  { 1605, 14, 21, 19, 3, -21 },
  { 1642, 16, 27, 19, 2, -21 },
  { 1696, 15, 21, 19, 3, -21 },
  { 1736, 17, 21, 19, 1, -21 },
  { 1781, 17, 21, 19, 1, -21 },
  { 1826, 15, 21, 19, 2, -21 },
  { 1866, 19, 21, 19, 0, -21 },
  { 1916, 19, 21, 19, 0, -21 },
  { 1966, 18, 21, 19, 1, -21 },
  { 2014, 18, 21, 19, 1, -21 },
  { 2062, 17, 21, 19, 1, -21 },
  { 2107, 9, 30, 19, 6, -23 },
  { 2141, 15, 23, 19, 2, -23 },
  { 2185, 9, 30, 19, 4, -23 },
  { 2219, 15, 14, 19, 2, -21 },
  { 2246, 19, 2, 19, 0, 2 },
  { 2251, 7, 4, 19, 6, -23 },
  { 2255, 16, 17, 19, 2, -17 },
  { 2289, 14, 23, 19, 3, -23 },
  { 2330, 15, 17, 19, 2, -17 },
  { 2362, 14, 23, 19, 2, -23 },
  { 2403, 15, 17, 19, 2, -17 },
  { 2435, 15, 23, 19, 2, -23 },
  { 2479, 14, 24, 19, 2, -17 },
  { 2521, 13, 23, 19, 3, -23 },
  { 2559, 16, 23, 19, 2, -23 },
  { 2605, 11, 30, 19, 2, -23 },
  { 2647, 14, 23, 19, 4, -23 },
  { 2688, 15, 23, 19, 2, -23 },
  { 2732, 16, 17, 19, 2, -17 },
  { 2766, 13, 17, 19, 3, -17 },
  { 2794, 15, 17, 19, 2, -17 },
  { 2826, 14, 24, 19, 3, -17 },
  { 2868, 14, 24, 19, 2, -17 },
  { 2910, 12, 17, 19, 4, -17 },
  { 2936, 14, 17, 19, 3, -17 },
  { 2966, 13, 21, 19, 3, -21 },
  { 3001, 13, 17, 19, 3, -17 },
  { 3029, 17, 17, 19, 1, -17 },
  { 3066, 19, 17, 19, 0, -17 },
  { 3107, 17, 17, 19, 1, -17 },
  { 3144, 17, 24, 19, 1, -17 },
  { 3195, 15, 17, 19, 2, -17 },
  { 3227, 13, 30, 19, 4, -23 },
  { 3276, 3, 30, 19, 8, -23 },
  { 3288, 13, 30, 19, 3, -23 },
  { 3337, 16, 4, 19, 2, -13 },
};

const GFXfont LiberationMono_Regular32pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular32pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular32pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _LIBERATIONMONO_REGULAR32PT7B_H_
