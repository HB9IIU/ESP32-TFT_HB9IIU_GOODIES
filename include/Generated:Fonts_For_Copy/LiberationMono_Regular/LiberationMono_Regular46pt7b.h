#ifndef _LIBERATIONMONO_REGULAR46PT7B_H_
#define _LIBERATIONMONO_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x07,
  0x00, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x30, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0,
  0x01, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x30, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x7E, 0x31, 0xF8, 0x7C, 0x18, 0x7C, 0x3C, 0x0C, 0x1F, 0x1E, 0x06, 0x07,
  0x8F, 0x03, 0x03, 0x87, 0x81, 0x80, 0x03, 0xC0, 0xC0, 0x00, 0xF0, 0x60,
  0x00, 0x3F, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0x7F, 0x00, 0x01, 0x87, 0xC0, 0x00, 0xC1, 0xF0, 0x00,
  0x60, 0x78, 0x00, 0x30, 0x1E, 0x00, 0x18, 0x0F, 0x30, 0x0C, 0x07, 0xBC,
  0x06, 0x03, 0xDE, 0x03, 0x01, 0xEF, 0x81, 0x81, 0xE3, 0xE0, 0xC1, 0xF0,
  0xFC, 0x63, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x80, 0x03, 0xC3, 0xFE, 0x00, 0x38, 0x78, 0xF0, 0x07, 0x07,
  0x07, 0x00, 0xF0, 0xF0, 0x78, 0x1E, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38,
  0x38, 0x0E, 0x03, 0x87, 0x80, 0xE0, 0x38, 0x70, 0x0E, 0x07, 0x8E, 0x00,
  0xF0, 0x79, 0xE0, 0x07, 0x07, 0x1C, 0x00, 0x78, 0xF3, 0x80, 0x03, 0xFE,
  0x78, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x1C, 0x7F,
  0xC0, 0x03, 0xCF, 0x1C, 0x00, 0x39, 0xE0, 0xE0, 0x07, 0x1C, 0x0E, 0x00,
  0xF1, 0xC0, 0xE0, 0x0E, 0x1C, 0x0F, 0x01, 0xC1, 0xC0, 0xF0, 0x3C, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x0E, 0x01, 0xE0, 0xE1,
  0xE0, 0x0F, 0x1C, 0x1C, 0x00, 0x7F, 0xC3, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0x01, 0xFE, 0x00, 0xE0, 0xFB,
  0xC0, 0x78, 0x3C, 0x78, 0x1E, 0x1E, 0x1E, 0x07, 0x07, 0x03, 0xC3, 0xC3,
  0xC0, 0x78, 0xF0, 0xF0, 0x1F, 0x38, 0x3C, 0x03, 0xDE, 0x0F, 0x00, 0x7F,
  0x03, 0xC0, 0x0F, 0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0xFE, 0x07, 0xE0,
  0xFF, 0xE4, 0xFF, 0xFE, 0xFF, 0x1F, 0xFE, 0x1F, 0xC1, 0xFE, 0x01, 0xE0,
  0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x38, 0x01, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xC3, 0x82, 0xF1, 0x8E, 0xFD, 0xFF, 0x7F, 0xFC, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x1C, 0x70, 0x3C, 0x38, 0x38,
  0x3C, 0x18, 0x10, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3C, 0x01, 0xF1, 0xF0,
  0x03, 0xC7, 0x80, 0x0F, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0, 0xFF,
  0x0F, 0x83, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0x81, 0xF0, 0x7E, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0xF0,
  0x0F, 0xE3, 0xC0, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF8, 0x3E, 0x07, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xE0,
  0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x1E,
  0xF8, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0,
  0x03, 0xE3, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x71, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00,
  0x38, 0x1E, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1C,
  0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3F,
  0x80, 0x79, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x1F, 0x00, 0x7C,
  0x78, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00,
  0xF9, 0xF0, 0x07, 0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x07, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0xC0,
  0x79, 0xFF, 0xC3, 0xCF, 0xFF, 0x8F, 0x78, 0x3F, 0x3F, 0x80, 0x3E, 0xFC,
  0x00, 0xFB, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00,
  0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8,
  0x78, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xC0, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x0F,
  0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF0, 0x3F, 0x03, 0xE1, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0xBE, 0x00, 0x1E,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1E, 0xF8,
  0x00, 0x79, 0xF0, 0x03, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7E, 0x0F, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x3F, 0x07,
  0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0x9E, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE1, 0xE0, 0x1F,
  0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F,
  0xC0, 0x7E, 0x3E, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0x81, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x3C, 0x1E, 0x3F, 0x8E, 0x0F, 0xEE, 0xE3, 0x87,
  0x1B, 0xB9, 0xC3, 0x82, 0xCE, 0x71, 0xC0, 0xF1, 0x9C, 0x70, 0x3C, 0x76,
  0x38, 0x0F, 0x1F, 0x8E, 0x03, 0xC7, 0xE3, 0x80, 0xE1, 0xF8, 0xE0, 0x38,
  0x7E, 0x70, 0x0E, 0x1F, 0x9C, 0x03, 0x87, 0xE7, 0x00, 0xE1, 0xB9, 0xC0,
  0x70, 0x6E, 0x70, 0x1C, 0x3B, 0x9C, 0x07, 0x0E, 0xE7, 0x03, 0xC3, 0xB8,
  0xE0, 0xF0, 0xCE, 0x38, 0x6C, 0x71, 0xCF, 0x3B, 0x38, 0x71, 0xFC, 0xFC,
  0x1C, 0x3C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x02, 0x01, 0xF0, 0x01, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x78,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1E,
  0x3C, 0x00, 0xF8, 0xF0, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x3F, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x31, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x01, 0x1F, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x3E,
  0x00, 0x3E, 0x3C, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x7F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xE0, 0x3F, 0x0F, 0x00, 0x7C, 0x78, 0x01, 0xF3,
  0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0,
  0x03, 0xE7, 0x80, 0x3E, 0x3C, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC,
  0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0xF8,
  0x00, 0x23, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF8, 0x01,
  0xF1, 0xF8, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xDC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x01, 0xE3, 0xE1, 0xF8,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0xF8, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F,
  0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xEE, 0x01, 0xFF, 0xB8, 0x0F, 0xFE, 0xF0, 0x3B, 0xF9,
  0xC0, 0xEF, 0xE7, 0x87, 0xBF, 0x9E, 0x1C, 0xFE, 0x38, 0x73, 0xF8, 0xF3,
  0xCF, 0xE3, 0xCE, 0x3F, 0x87, 0x38, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFC, 0x3F, 0x83, 0xE0, 0xFE, 0x07, 0x83, 0xF8, 0x1E, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xEF, 0x00, 0xFE, 0xF0, 0x0F, 0xE7,
  0x80, 0xFE, 0x78, 0x0F, 0xE3, 0xC0, 0xFE, 0x3C, 0x0F, 0xE1, 0xE0, 0xFE,
  0x1E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x07, 0x8F,
  0xE0, 0x78, 0xFE, 0x03, 0xCF, 0xE0, 0x3C, 0xFE, 0x01, 0xEF, 0xE0, 0x1E,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x0F,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x3E, 0x0F, 0xC0,
  0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x1F, 0x78, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x1F,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x83,
  0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3C, 0x01, 0xFC,
  0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x01,
  0xF3, 0xC0, 0x1F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xC0,
  0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0xC3,
  0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xEE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0xF8, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x1F,
  0x78, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x01, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0xC0, 0xF0, 0x3C, 0x3C, 0x1F, 0x03,
  0xC3, 0xC1, 0xF0, 0x3C, 0x3C, 0x1F, 0x83, 0xC3, 0xC1, 0xF8, 0x38, 0x3C,
  0x3B, 0x87, 0x83, 0xC3, 0xBC, 0x78, 0x1C, 0x39, 0xC7, 0x81, 0xE3, 0x9C,
  0x78, 0x1E, 0x79, 0xC7, 0x81, 0xE7, 0x1E, 0x78, 0x1E, 0x70, 0xE7, 0x01,
  0xE7, 0x0E, 0x70, 0x0E, 0xE0, 0xE7, 0x00, 0xEE, 0x0F, 0xF0, 0x0E, 0xE0,
  0x7F, 0x00, 0xEE, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x77, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xF0, 0x01, 0xE1,
  0xC0, 0x07, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x70,
  0x1E, 0x01, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x3C, 0x78,
  0x00, 0x71, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xE0, 0x3C, 0x3F, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x8F, 0x80,
  0x6F, 0x0F, 0x83, 0x9E, 0x1F, 0xFF, 0x3F, 0x9F, 0xF8, 0x7F, 0x0F, 0xC0,
  0x3E, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFE, 0x0F,
  0x1F, 0xF8, 0xF7, 0xFF, 0xCF, 0x70, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x1E,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1E, 0xFC,
  0x03, 0xEF, 0xF0, 0x7C, 0xF7, 0xFF, 0xCF, 0x3F, 0xF8, 0xF0, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0,
  0x1F, 0x3E, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xF0, 0xF0, 0x7F, 0xE7, 0x87, 0xFF, 0xBC, 0x7E,
  0x0F, 0xE3, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF8, 0x00, 0xF7,
  0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0xC0, 0x3F, 0x1F, 0x83,
  0xF8, 0x7F, 0xF9, 0xC1, 0xFF, 0x8E, 0x03, 0xF0, 0x78, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x06, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0xF0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x78, 0x7F, 0xE3, 0xC7, 0xFF, 0x9E, 0x7E, 0x1E, 0xF3,
  0xC0, 0x37, 0xBE, 0x00, 0xFD, 0xE0, 0x07, 0xEF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x7E, 0xF0, 0x03, 0xF7, 0xC0, 0x37, 0x9F, 0x07, 0xBC, 0x7F,
  0xF9, 0xE1, 0xFF, 0x8F, 0x03, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x07, 0x83, 0xF0,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7E, 0x0F, 0x1F, 0xF8, 0xF3, 0xFF,
  0xCF, 0x70, 0x7E, 0xFE, 0x03, 0xEF, 0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x80, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0,
  0x1F, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFC, 0xF8, 0x0F, 0x87, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0xF0, 0x01, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1,
  0xE0, 0xF9, 0xEF, 0xE3, 0xFB, 0xDF, 0xCF, 0xF7, 0xE3, 0xF9, 0xFF, 0x87,
  0xE1, 0xFF, 0x07, 0x83, 0xFE, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C,
  0x1F, 0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03, 0xC1,
  0xFE, 0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F,
  0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFE,
  0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1E, 0xF0,
  0x7E, 0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x70, 0x7E, 0xFE, 0x03, 0xEF,
  0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC0,
  0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0xBE, 0x00, 0x1E,
  0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3E, 0x01, 0xF0,
  0xFC, 0x1F, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xF0,
  0xFE, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF, 0xCF, 0x70, 0x7E, 0xFC, 0x03, 0xEF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1E, 0xFC, 0x03, 0xEF, 0x70, 0x7E, 0xF7, 0xFF, 0xCF, 0x3F, 0xF8, 0xF0,
  0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x78, 0x7F, 0xE7, 0xC7, 0xFF, 0xBC, 0x7E,
  0x0F, 0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF8, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x1F, 0x83,
  0xF8, 0x7F, 0xFB, 0xC1, 0xFF, 0x9E, 0x03, 0xF0, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x70,
  0x1F, 0xDE, 0x1F, 0xF7, 0x8F, 0xFD, 0xE7, 0xFF, 0x7B, 0xE0, 0x1E, 0xE0,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x60, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xE7, 0xC0, 0x3E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x30, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xE0, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0x78, 0x07, 0xF7, 0xC0, 0xEF, 0x3F, 0xFC, 0xF1, 0xFF,
  0x8F, 0x0F, 0xE0, 0xF0, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00,
  0x78, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0x83,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xEF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1, 0xE0, 0xF8, 0x1E, 0x3C, 0x1F,
  0x03, 0xC7, 0x83, 0xF0, 0x78, 0xF0, 0x7E, 0x1E, 0x1E, 0x1D, 0xC3, 0xC1,
  0xC3, 0x9C, 0x78, 0x38, 0x73, 0x8F, 0x07, 0x9C, 0x71, 0xE0, 0xF3, 0x8F,
  0x3C, 0x1E, 0x70, 0xE7, 0x03, 0xDC, 0x1D, 0xE0, 0x3B, 0x83, 0xBC, 0x07,
  0x70, 0x3F, 0x80, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x78,
  0x00, 0xF8, 0xF8, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80,
  0x1E, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xC0, 0x1F, 0x0F,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x00,
};

const GFXglyph LiberationMono_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 4, 30, 28, 12, -30 },
  { 16, 15, 14, 28, 6, -33 },
  { 43, 25, 30, 28, 1, -30 },
  { 137, 25, 37, 28, 1, -33 },
  { 253, 28, 30, 28, 0, -30 },
  { 358, 26, 30, 28, 1, -30 },
  { 456, 5, 14, 28, 11, -33 },
  { 465, 12, 43, 28, 8, -33 },
  { 530, 12, 43, 28, 8, -33 },
  { 595, 16, 16, 28, 6, -33 },
  { 627, 22, 23, 28, 3, -27 },
  { 691, 10, 15, 28, 6, -7 },
  { 710, 13, 4, 28, 7, -14 },
  { 717, 5, 7, 28, 11, -7 },
  { 722, 22, 33, 28, 3, -33 },
  { 813, 22, 30, 28, 3, -30 },
  { 896, 22, 30, 28, 3, -30 },
  { 979, 21, 30, 28, 3, -30 },
  { 1058, 22, 30, 28, 3, -30 },
  { 1141, 23, 30, 28, 2, -30 },
  { 1228, 22, 30, 28, 3, -30 },
  { 1311, 22, 30, 28, 3, -30 },
  { 1394, 20, 30, 28, 4, -30 },
  { 1469, 22, 30, 28, 3, -30 },
  { 1552, 21, 30, 28, 3, -30 },
  { 1631, 5, 25, 28, 11, -25 },
  { 1647, 10, 33, 28, 8, -25 },
  { 1689, 22, 24, 28, 3, -27 },
  { 1755, 22, 15, 28, 3, -23 },
  { 1797, 22, 24, 28, 3, -27 },
  { 1863, 22, 30, 28, 2, -30 },
  { 1946, 26, 39, 28, 1, -33 },
  { 2073, 28, 30, 28, 0, -30 },
  { 2178, 22, 30, 28, 4, -30 },
  { 2261, 23, 30, 28, 3, -30 },
  { 2348, 21, 30, 28, 4, -30 },
  { 2427, 21, 30, 28, 4, -30 },
  { 2506, 20, 30, 28, 4, -30 },
  { 2581, 22, 30, 28, 3, -30 },
  { 2664, 20, 30, 28, 4, -30 },
  { 2739, 18, 30, 28, 5, -30 },
  { 2807, 18, 30, 28, 4, -30 },
  { 2875, 24, 30, 28, 4, -30 },
  { 2965, 20, 30, 28, 5, -30 },
  { 3040, 22, 30, 28, 3, -30 },
  { 3123, 20, 30, 28, 4, -30 },
  { 3198, 23, 30, 28, 2, -30 },
  { 3285, 21, 30, 28, 4, -30 },
  { 3364, 24, 39, 28, 2, -30 },
  { 3481, 22, 30, 28, 4, -30 },
  { 3564, 23, 30, 28, 2, -30 },
  { 3651, 24, 30, 28, 2, -30 },
  { 3741, 21, 30, 28, 3, -30 },
  { 3820, 27, 30, 28, 0, -30 },
  { 3922, 28, 30, 28, 0, -30 },
  { 4027, 26, 30, 28, 1, -30 },
  { 4125, 26, 30, 28, 1, -30 },
  { 4223, 24, 30, 28, 2, -30 },
  { 4313, 13, 43, 28, 9, -33 },
  { 4383, 22, 33, 28, 3, -33 },
  { 4474, 12, 43, 28, 6, -33 },
  { 4539, 22, 20, 28, 3, -30 },
  { 4594, 28, 2, 28, 0, 3 },
  { 4601, 10, 6, 28, 9, -33 },
  { 4609, 23, 25, 28, 3, -25 },
  { 4681, 20, 33, 28, 4, -33 },
  { 4764, 21, 25, 28, 3, -25 },
  { 4830, 21, 33, 28, 3, -33 },
  { 4917, 22, 25, 28, 3, -25 },
  { 4986, 22, 33, 28, 3, -33 },
  { 5077, 21, 35, 28, 3, -25 },
  { 5169, 20, 33, 28, 4, -33 },
  { 5252, 22, 33, 28, 3, -33 },
  { 5343, 16, 43, 28, 3, -33 },
  { 5429, 20, 33, 28, 5, -33 },
  { 5512, 22, 33, 28, 3, -33 },
  { 5603, 23, 25, 28, 2, -25 },
  { 5675, 20, 25, 28, 4, -25 },
  { 5738, 22, 25, 28, 3, -25 },
  { 5807, 20, 35, 28, 4, -25 },
  { 5895, 21, 35, 28, 3, -25 },
  { 5987, 18, 25, 28, 5, -25 },
  { 6044, 20, 25, 28, 4, -25 },
  { 6107, 19, 31, 28, 4, -31 },
  { 6181, 20, 25, 28, 4, -25 },
  { 6244, 24, 25, 28, 2, -25 },
  { 6319, 27, 25, 28, 0, -25 },
  { 6404, 23, 25, 28, 2, -25 },
  { 6476, 25, 35, 28, 1, -25 },
  { 6586, 21, 25, 28, 3, -25 },
  { 6652, 19, 43, 28, 5, -33 },
  { 6755, 4, 43, 28, 12, -33 },
  { 6777, 18, 43, 28, 4, -33 },
  { 6874, 23, 6, 28, 2, -18 },
};

const GFXfont LiberationMono_Regular46pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular46pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular46pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _LIBERATIONMONO_REGULAR46PT7B_H_
