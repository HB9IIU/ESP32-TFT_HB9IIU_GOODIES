#ifndef _LIBERATIONMONO_REGULAR8PT7B_H_
#define _LIBERATIONMONO_REGULAR8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xB6, 0x80, 0x17, 0xD4, 0xE0, 0x00, 0x27, 0xB8, 0x6A, 0xB8,
  0x80, 0xD7, 0x0C, 0xD9, 0x80, 0x73, 0x31, 0x6F, 0x80, 0xE0, 0x1A, 0xA4,
  0x15, 0x56, 0x5F, 0x00, 0x22, 0xF2, 0xA0, 0x40, 0x80, 0x11, 0x22, 0x44,
  0x79, 0xB9, 0x70, 0xC9, 0x2E, 0xE5, 0x4E, 0x71, 0x31, 0x70, 0x35, 0x5F,
  0x10, 0x66, 0x11, 0x70, 0xFA, 0xDE, 0xE5, 0x28, 0xF7, 0xDE, 0xF7, 0x9E,
  0x90, 0x41, 0x80, 0x12, 0xC3, 0xF0, 0xF0, 0x86, 0x16, 0x71, 0x20, 0x20,
  0x75, 0x77, 0xBD, 0x59, 0xC0, 0x22, 0x95, 0xE8, 0x80, 0xEA, 0xE9, 0xE0,
  0x78, 0x88, 0x70, 0xF6, 0xDE, 0xF3, 0xCE, 0xF3, 0xC8, 0x78, 0xB9, 0x70,
  0xB7, 0xDA, 0xE9, 0x2E, 0x64, 0x9E, 0xAC, 0xCA, 0xA0, 0x92, 0x4E, 0xDD,
  0xB9, 0x90, 0xB7, 0xFA, 0x79, 0x99, 0x70, 0xF7, 0xC8, 0x79, 0x99, 0x72,
  0x10, 0xEA, 0xEA, 0xA0, 0x74, 0x31, 0x70, 0x71, 0x08, 0x42, 0x00, 0xB6,
  0xDE, 0x8A, 0x94, 0xC2, 0x00, 0x8D, 0x6A, 0xA5, 0x00, 0x53, 0x08, 0xA9,
  0x00, 0x52, 0x88, 0x42, 0x00, 0x71, 0x08, 0x8F, 0x80, 0xEA, 0xAB, 0x04,
  0x22, 0x11, 0xD5, 0x57, 0xD6, 0x80, 0xF8, 0x80, 0x73, 0xA4, 0xE0, 0x1A,
  0xDB, 0xC0, 0xF2, 0x70, 0x27, 0xDB, 0xC0, 0xFE, 0x70, 0x73, 0xC9, 0x00,
  0xF6, 0xF3, 0x80, 0x1A, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x21, 0x92, 0x4E,
  0x92, 0xED, 0x40, 0xC9, 0x25, 0xC0, 0xFB, 0xBB, 0xF6, 0xD0, 0xF6, 0xF0,
  0xF6, 0xF8, 0x00, 0xF6, 0xF2, 0x40, 0xF2, 0x40, 0xF8, 0xF0, 0x9A, 0x46,
  0xB6, 0xF0, 0x92, 0x94, 0x40, 0x8D, 0x7C, 0xA0, 0x52, 0x65, 0x92, 0x94,
  0x42, 0x20, 0xEA, 0x70, 0x69, 0x44, 0x91, 0xFF, 0x89, 0x24, 0x94, 0xF0,
};

const GFXglyph LiberationMono_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 5, 5, 2, -5 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 5, 7, 5, 0, -6 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 5, 5, 5, 0, -5 },
  { 21, 1, 3, 5, 2, -6 },
  { 22, 2, 8, 5, 1, -6 },
  { 24, 2, 8, 5, 1, -6 },
  { 26, 3, 3, 5, 1, -6 },
  { 28, 4, 4, 5, 0, -5 },
  { 30, 2, 2, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 4, 6, 5, 0, -6 },
  { 36, 4, 5, 5, 0, -5 },
  { 39, 3, 5, 5, 1, -5 },
  { 41, 3, 5, 5, 1, -5 },
  { 43, 4, 5, 5, 0, -5 },
  { 46, 4, 5, 5, 0, -5 },
  { 49, 4, 5, 5, 0, -5 },
  { 52, 3, 5, 5, 1, -5 },
  { 54, 3, 5, 5, 1, -5 },
  { 56, 3, 5, 5, 1, -5 },
  { 58, 3, 5, 5, 1, -5 },
  { 60, 1, 4, 5, 2, -4 },
  { 61, 2, 5, 5, 1, -4 },
  { 63, 4, 4, 5, 0, -5 },
  { 65, 4, 3, 5, 0, -4 },
  { 67, 4, 4, 5, 0, -5 },
  { 69, 4, 5, 5, 0, -5 },
  { 72, 5, 7, 5, 0, -6 },
  { 77, 5, 5, 5, 0, -5 },
  { 81, 4, 5, 5, 1, -5 },
  { 84, 4, 5, 5, 0, -5 },
  { 87, 3, 5, 5, 1, -5 },
  { 89, 3, 5, 5, 1, -5 },
  { 91, 3, 5, 5, 1, -5 },
  { 93, 4, 5, 5, 0, -5 },
  { 96, 3, 5, 5, 1, -5 },
  { 98, 3, 5, 5, 1, -5 },
  { 100, 3, 5, 5, 1, -5 },
  { 102, 4, 5, 5, 1, -5 },
  { 105, 3, 5, 5, 1, -5 },
  { 107, 4, 5, 5, 0, -5 },
  { 110, 3, 5, 5, 1, -5 },
  { 112, 4, 5, 5, 0, -5 },
  { 115, 3, 5, 5, 1, -5 },
  { 117, 4, 7, 5, 0, -5 },
  { 121, 4, 5, 5, 1, -5 },
  { 124, 4, 5, 5, 0, -5 },
  { 127, 5, 5, 5, 0, -5 },
  { 131, 3, 5, 5, 1, -5 },
  { 133, 5, 5, 5, 0, -5 },
  { 137, 5, 5, 5, 0, -5 },
  { 141, 5, 5, 5, 0, -5 },
  { 145, 5, 5, 5, 0, -5 },
  { 149, 5, 5, 5, 0, -5 },
  { 153, 2, 8, 5, 2, -6 },
  { 155, 4, 6, 5, 0, -6 },
  { 158, 2, 8, 5, 1, -6 },
  { 160, 3, 3, 5, 1, -5 },
  { 162, 5, 1, 5, 0, 0 },
  { 163, 1, 1, 5, 2, -6 },
  { 164, 5, 4, 5, 0, -4 },
  { 167, 3, 6, 5, 1, -6 },
  { 170, 3, 4, 5, 1, -4 },
  { 172, 3, 6, 5, 1, -6 },
  { 175, 3, 4, 5, 1, -4 },
  { 177, 3, 6, 5, 1, -6 },
  { 180, 3, 6, 5, 1, -4 },
  { 183, 3, 6, 5, 1, -6 },
  { 186, 3, 6, 5, 1, -6 },
  { 189, 3, 8, 5, 0, -6 },
  { 192, 3, 6, 5, 1, -6 },
  { 195, 3, 6, 5, 1, -6 },
  { 198, 4, 4, 5, 0, -4 },
  { 200, 3, 4, 5, 1, -4 },
  { 202, 3, 4, 5, 1, -4 },
  { 204, 3, 6, 5, 1, -4 },
  { 207, 3, 6, 5, 1, -4 },
  { 210, 3, 4, 5, 1, -4 },
  { 212, 3, 4, 5, 1, -4 },
  { 214, 3, 5, 5, 1, -5 },
  { 216, 3, 4, 5, 1, -4 },
  { 218, 5, 4, 5, 0, -4 },
  { 221, 5, 4, 5, 0, -4 },
  { 224, 4, 4, 5, 0, -4 },
  { 226, 5, 6, 5, 0, -4 },
  { 230, 3, 4, 5, 1, -4 },
  { 232, 3, 8, 5, 1, -6 },
  { 235, 1, 8, 5, 2, -6 },
  { 236, 3, 8, 5, 1, -6 },
  { 239, 4, 1, 5, 0, -3 },
};

const GFXfont LiberationMono_Regular8pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular8pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _LIBERATIONMONO_REGULAR8PT7B_H_
