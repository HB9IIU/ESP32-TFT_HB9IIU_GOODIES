#ifndef _LIBERATIONMONO_REGULAR12PT7B_H_
#define _LIBERATIONMONO_REGULAR12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xBA, 0xAA, 0x24, 0x49, 0xF9, 0x22, 0x9F, 0xD2, 0x24, 0x10,
  0xF9, 0x52, 0x83, 0x82, 0x84, 0xEB, 0x7C, 0x20, 0xE5, 0x4A, 0xA7, 0x81,
  0xE5, 0x52, 0xA7, 0x38, 0x50, 0xA1, 0xA5, 0x53, 0xB2, 0x3B, 0xF0, 0x29,
  0x49, 0x24, 0x48, 0x80, 0x88, 0x92, 0x49, 0x2A, 0x00, 0x27, 0x4C, 0x65,
  0x00, 0x20, 0x8F, 0xC8, 0x20, 0xEA, 0xE0, 0xC0, 0x08, 0x21, 0x04, 0x20,
  0x84, 0x30, 0x80, 0x74, 0x63, 0x58, 0xC6, 0x2E, 0x33, 0xC3, 0x0C, 0x30,
  0xC3, 0x3F, 0x74, 0x42, 0x13, 0x22, 0x1F, 0x7C, 0x42, 0x60, 0x86, 0x2F,
  0x10, 0xC5, 0x14, 0x93, 0xF1, 0x04, 0xFC, 0x21, 0xE0, 0x86, 0x2E, 0x76,
  0x61, 0xF8, 0xC7, 0x2E, 0xF8, 0x44, 0x22, 0x10, 0x8C, 0x74, 0x62, 0xE8,
  0xC6, 0x2E, 0x74, 0x63, 0x17, 0x86, 0x2E, 0xC6, 0x48, 0x00, 0x94, 0x80,
  0x0F, 0xC8, 0x3C, 0x0C, 0xFC, 0x00, 0x3F, 0x81, 0xE0, 0x5E, 0x80, 0xF4,
  0x42, 0x13, 0x10, 0x04, 0x3C, 0xC9, 0x0C, 0xFA, 0xB5, 0x6A, 0xDE, 0x40,
  0x88, 0xE0, 0x10, 0x50, 0xA1, 0x64, 0x4F, 0x91, 0xC1, 0xFA, 0x28, 0xBC,
  0x8A, 0x18, 0xFE, 0x7A, 0x28, 0x20, 0x82, 0x0C, 0xDE, 0xF2, 0x28, 0xA3,
  0x8E, 0x28, 0xBC, 0xFA, 0x08, 0x3E, 0x82, 0x08, 0x3F, 0xFC, 0x21, 0xF8,
  0x42, 0x10, 0x7C, 0x61, 0x09, 0xC7, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31,
  0xF9, 0x08, 0x42, 0x10, 0x9F, 0x38, 0x42, 0x10, 0x86, 0x6E, 0x8A, 0x4B,
  0x38, 0xD2, 0x48, 0xA1, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0x8E, 0xF7, 0x7A,
  0xC6, 0x31, 0x8E, 0x73, 0x5A, 0xCE, 0x71, 0x72, 0x28, 0xA3, 0x8E, 0x28,
  0x9C, 0xFA, 0x38, 0xBE, 0x82, 0x08, 0x20, 0x72, 0x28, 0xA3, 0x8E, 0x28,
  0x9C, 0x30, 0x70, 0xFA, 0x38, 0xBE, 0x92, 0x48, 0xA3, 0x3C, 0x89, 0x03,
  0x80, 0xC0, 0xD1, 0x3E, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x8C,
  0x63, 0x18, 0xC6, 0x2E, 0x82, 0x8D, 0x12, 0x22, 0x85, 0x0A, 0x08, 0x83,
  0x06, 0x4A, 0x97, 0xAD, 0x9B, 0x32, 0x44, 0xC8, 0xA0, 0x81, 0x85, 0x11,
  0x23, 0x46, 0x88, 0xA0, 0xC1, 0x02, 0x04, 0x08, 0x7E, 0x08, 0x20, 0x83,
  0x04, 0x10, 0x7F, 0xF8, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x83, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x08, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x22, 0x95, 0x18,
  0x80, 0xFE, 0x44, 0x72, 0x20, 0x9E, 0x8A, 0x6E, 0xC0, 0x84, 0x2F, 0x98,
  0xC6, 0x39, 0xB0, 0x74, 0x61, 0x08, 0x45, 0xC0, 0x08, 0x5F, 0x18, 0xC6,
  0x31, 0x78, 0x74, 0x63, 0xF8, 0x45, 0xC0, 0x3A, 0x3E, 0x84, 0x21, 0x08,
  0x40, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x70, 0x84, 0x2F, 0x98, 0xC6, 0x31,
  0x88, 0x20, 0x0E, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x10, 0xF1, 0x11, 0x11,
  0x11, 0xE0, 0x82, 0x08, 0xA4, 0xA3, 0x89, 0x26, 0x88, 0x60, 0x82, 0x08,
  0x20, 0x82, 0x08, 0xFC, 0xFA, 0xBA, 0x69, 0xA6, 0x9A, 0x40, 0xBE, 0x63,
  0x18, 0xC6, 0x20, 0x74, 0x63, 0x18, 0xC5, 0xC0, 0xBE, 0x63, 0x18, 0xE6,
  0xD0, 0x80, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0x7B, 0x10, 0x84, 0x21,
  0x00, 0x74, 0x70, 0xE0, 0xC5, 0xC0, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x78,
  0x8C, 0x63, 0x18, 0xC5, 0xE0, 0x46, 0x89, 0x11, 0x42, 0x85, 0x04, 0x00,
  0x83, 0x05, 0x4A, 0x96, 0xCD, 0x99, 0x00, 0x89, 0x45, 0x08, 0x51, 0x68,
  0x80, 0x46, 0x88, 0x91, 0x42, 0x83, 0x04, 0x18, 0x60, 0xF8, 0xC4, 0x44,
  0x43, 0xE0, 0x39, 0x08, 0x42, 0x60, 0x84, 0x21, 0x0E, 0xFF, 0xE0, 0xE1,
  0x08, 0x43, 0x04, 0xC4, 0x21, 0x38, 0xE4, 0x60,
};

const GFXglyph LiberationMono_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 4, 4, 7, 2, -9 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 7, 10, 7, 0, -9 },
  { 20, 7, 8, 7, 0, -8 },
  { 27, 7, 8, 7, 0, -8 },
  { 34, 1, 4, 7, 3, -9 },
  { 35, 3, 11, 7, 2, -9 },
  { 40, 3, 11, 7, 2, -9 },
  { 45, 5, 5, 7, 1, -9 },
  { 49, 6, 5, 7, 1, -7 },
  { 53, 2, 4, 7, 2, -2 },
  { 54, 3, 1, 7, 2, -4 },
  { 55, 1, 2, 7, 3, -2 },
  { 56, 6, 9, 7, 1, -9 },
  { 63, 5, 8, 7, 1, -8 },
  { 68, 6, 8, 7, 1, -8 },
  { 74, 5, 8, 7, 1, -8 },
  { 79, 5, 8, 7, 1, -8 },
  { 84, 6, 8, 7, 1, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 5, 8, 7, 1, -8 },
  { 105, 5, 8, 7, 1, -8 },
  { 110, 5, 8, 7, 1, -8 },
  { 115, 1, 7, 7, 3, -7 },
  { 116, 3, 9, 7, 2, -7 },
  { 120, 6, 5, 7, 1, -7 },
  { 124, 6, 4, 7, 1, -6 },
  { 127, 6, 5, 7, 1, -7 },
  { 131, 5, 8, 7, 1, -8 },
  { 136, 7, 11, 7, 0, -9 },
  { 146, 7, 8, 7, 0, -8 },
  { 153, 6, 8, 7, 1, -8 },
  { 159, 6, 8, 7, 1, -8 },
  { 165, 6, 8, 7, 1, -8 },
  { 171, 6, 8, 7, 1, -8 },
  { 177, 5, 8, 7, 1, -8 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 5, 8, 7, 1, -8 },
  { 192, 5, 8, 7, 1, -8 },
  { 197, 5, 8, 7, 1, -8 },
  { 202, 6, 8, 7, 1, -8 },
  { 208, 5, 8, 7, 1, -8 },
  { 213, 5, 8, 7, 1, -8 },
  { 218, 5, 8, 7, 1, -8 },
  { 223, 6, 8, 7, 1, -8 },
  { 229, 6, 8, 7, 1, -8 },
  { 235, 6, 10, 7, 1, -8 },
  { 243, 6, 8, 7, 1, -8 },
  { 249, 7, 8, 7, 0, -8 },
  { 256, 7, 8, 7, 0, -8 },
  { 263, 5, 8, 7, 1, -8 },
  { 268, 7, 8, 7, 0, -8 },
  { 275, 7, 8, 7, 0, -8 },
  { 282, 7, 8, 7, 0, -8 },
  { 289, 7, 8, 7, 0, -8 },
  { 296, 7, 8, 7, 0, -8 },
  { 303, 4, 11, 7, 2, -9 },
  { 309, 6, 9, 7, 1, -9 },
  { 316, 3, 11, 7, 2, -9 },
  { 321, 5, 5, 7, 1, -8 },
  { 325, 7, 1, 7, 0, 1 },
  { 326, 3, 2, 7, 2, -10 },
  { 327, 6, 7, 7, 1, -7 },
  { 333, 5, 9, 7, 1, -9 },
  { 339, 5, 7, 7, 1, -7 },
  { 344, 5, 9, 7, 1, -9 },
  { 350, 5, 7, 7, 1, -7 },
  { 355, 5, 9, 7, 1, -9 },
  { 361, 5, 9, 7, 1, -7 },
  { 367, 5, 9, 7, 1, -9 },
  { 373, 6, 9, 7, 1, -9 },
  { 380, 4, 11, 7, 1, -9 },
  { 386, 6, 9, 7, 1, -9 },
  { 393, 6, 9, 7, 1, -9 },
  { 400, 6, 7, 7, 1, -7 },
  { 406, 5, 7, 7, 1, -7 },
  { 411, 5, 7, 7, 1, -7 },
  { 416, 5, 9, 7, 1, -7 },
  { 422, 5, 9, 7, 1, -7 },
  { 428, 5, 7, 7, 1, -7 },
  { 433, 5, 7, 7, 1, -7 },
  { 438, 5, 9, 7, 1, -9 },
  { 444, 5, 7, 7, 1, -7 },
  { 449, 7, 7, 7, 0, -7 },
  { 456, 7, 7, 7, 0, -7 },
  { 463, 6, 7, 7, 1, -7 },
  { 469, 7, 9, 7, 0, -7 },
  { 477, 5, 7, 7, 1, -7 },
  { 482, 5, 11, 7, 1, -9 },
  { 489, 1, 11, 7, 3, -9 },
  { 491, 5, 11, 7, 1, -9 },
  { 498, 6, 2, 7, 1, -5 },
};

const GFXfont LiberationMono_Regular12pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular12pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _LIBERATIONMONO_REGULAR12PT7B_H_
