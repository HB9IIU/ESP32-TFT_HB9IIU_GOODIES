#ifndef _LIBERATIONMONO_REGULAR66PT7B_H_
#define _LIBERATIONMONO_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB,
  0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07,
  0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x1E, 0x3F,
  0xE0, 0x7F, 0x03, 0xC1, 0xFE, 0x1F, 0xC0, 0x78, 0x0F, 0xC3, 0xF0, 0x0F,
  0x01, 0xFC, 0x7E, 0x01, 0xE0, 0x1F, 0x8F, 0xC0, 0x3C, 0x03, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0xFF, 0xCF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0xFF, 0xC0, 0x00, 0x0F, 0x03, 0xF8,
  0x00, 0x01, 0xE0, 0x3F, 0x80, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x3F, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0xFC, 0x70, 0x03,
  0xC0, 0x0F, 0xFE, 0x00, 0x78, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0x7E, 0xFC,
  0x01, 0xE0, 0x0F, 0xDF, 0xC0, 0x3C, 0x03, 0xF9, 0xFC, 0x07, 0x80, 0x7E,
  0x3F, 0xC0, 0xF0, 0x3F, 0xC3, 0xFF, 0x1E, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xF8, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x01,
  0xE0, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x03,
  0xC0, 0xF0, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x07, 0xC3, 0xC0, 0x00, 0x7E, 0x1F, 0x87, 0xC0, 0x00, 0x3F,
  0xFF, 0x8F, 0x80, 0x00, 0x1F, 0xFF, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0x00, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x7F, 0xF0, 0x00, 0x01,
  0xF0, 0xFF, 0xF8, 0x00, 0x01, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0xE3, 0xF0,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0x01, 0xFF, 0xFC, 0x1F,
  0x00, 0x00, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00,
  0x1F, 0x0F, 0xF0, 0x00, 0x00, 0x7D, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x60, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x3F, 0xBE, 0x00, 0x3E,
  0x03, 0xF9, 0xF8, 0x01, 0xF0, 0x1F, 0x87, 0xC0, 0x0F, 0x81, 0xF8, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x1F, 0x81, 0xF0, 0x3E, 0x00, 0x7E, 0x1F, 0x03, 0xF0, 0x01, 0xF8,
  0xF8, 0x1F, 0x80, 0x07, 0xEF, 0x80, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xE0,
  0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C, 0x04, 0x78, 0x3C,
  0x1E, 0x7F, 0x3C, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF,
  0x80, 0x03, 0xE7, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x02, 0x00, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x0F, 0xF0, 0x3E, 0xFC, 0x0F, 0xF0, 0x3E, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFD, 0xF8, 0x00, 0xFF, 0xF3, 0xF0, 0x01,
  0xFF, 0x87, 0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x87, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x7D, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87,
  0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0xFF, 0xF8,
  0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE3,
  0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFE, 0xFF,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x7F, 0xCF, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0xFE, 0x3F, 0x01, 0xFF,
  0xE0, 0xFC, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x07, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0xFF, 0x8F, 0x78, 0x78,
  0x0F, 0xFC, 0x73, 0xC3, 0xC0, 0xF8, 0x77, 0x9F, 0x3E, 0x0F, 0x81, 0xBC,
  0x79, 0xE0, 0xF8, 0x0F, 0xE3, 0xCF, 0x07, 0x80, 0x3F, 0x1E, 0x78, 0x7C,
  0x01, 0xF0, 0xF7, 0xC3, 0xC0, 0x0F, 0x87, 0xBC, 0x1E, 0x00, 0x7C, 0x3D,
  0xE1, 0xF0, 0x03, 0xE1, 0xEF, 0x0F, 0x00, 0x1F, 0x0F, 0x78, 0x78, 0x00,
  0xF0, 0x7B, 0xC7, 0xC0, 0x07, 0x83, 0xDE, 0x3E, 0x00, 0x3C, 0x1F, 0xF1,
  0xF0, 0x03, 0xE0, 0xFF, 0x8F, 0x00, 0x1F, 0x07, 0xFC, 0x78, 0x00, 0xF0,
  0x3F, 0xC3, 0xC0, 0x07, 0x81, 0xFE, 0x1E, 0x00, 0x3C, 0x0F, 0xF8, 0xF0,
  0x03, 0xE0, 0x77, 0xC7, 0x80, 0x1F, 0x03, 0x9E, 0x3C, 0x00, 0xF8, 0x3C,
  0xF1, 0xE0, 0x0F, 0x81, 0xE7, 0x8F, 0x80, 0x7C, 0x0E, 0x3C, 0x3C, 0x07,
  0xE0, 0xF1, 0xE1, 0xE0, 0x37, 0x07, 0x8F, 0x0F, 0x83, 0xB8, 0x78, 0x7C,
  0x3C, 0x39, 0xE7, 0x81, 0xE1, 0xFF, 0x8F, 0xFC, 0x0F, 0x07, 0xF8, 0x3F,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x40,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xF0,
  0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF8,
  0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x03, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x30, 0x7E, 0x00, 0x00, 0x1E, 0x3F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0xF8, 0x3F, 0x00, 0x0F,
  0xF8, 0x7E, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xFE, 0x1F, 0x80, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x30, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0xFF, 0xFE,
  0xFC, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x00, 0x7E, 0x7F, 0xC0, 0x00, 0x0F, 0xDF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFD, 0xF0, 0x03, 0xFF, 0xFB, 0xE0, 0x07,
  0xFF, 0xF7, 0xC0, 0x0F, 0x7F, 0xE7, 0xC0, 0x3E, 0xFF, 0xCF, 0x80, 0x7D,
  0xFF, 0x9F, 0x81, 0xF3, 0xFF, 0x1F, 0x03, 0xE7, 0xFE, 0x3E, 0x07, 0xCF,
  0xFC, 0x7E, 0x1F, 0x1F, 0xF8, 0x7C, 0x3E, 0x3F, 0xF0, 0xF8, 0x78, 0x7F,
  0xE0, 0xF9, 0xF0, 0xFF, 0xC1, 0xF3, 0xE1, 0xFF, 0x83, 0xE7, 0x83, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x1F, 0x80, 0xFF, 0xC0,
  0x3F, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xE0, 0x00, 0xFF, 0xDF, 0x80,
  0x07, 0xFE, 0x7C, 0x00, 0x3F, 0xFB, 0xF0, 0x01, 0xFF, 0xCF, 0x80, 0x0F,
  0xFE, 0x7E, 0x00, 0x7F, 0xF1, 0xF0, 0x03, 0xFF, 0x8F, 0xC0, 0x1F, 0xFC,
  0x3E, 0x00, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0x07, 0xC0, 0x3F, 0xF8, 0x3F,
  0x01, 0xFF, 0xC1, 0xF8, 0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0xF0, 0x3F, 0x03,
  0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0x1F, 0x07, 0xFF,
  0x00, 0xFC, 0x3F, 0xF8, 0x03, 0xE1, 0xFF, 0xC0, 0x1F, 0x8F, 0xFE, 0x00,
  0x7C, 0x7F, 0xF0, 0x03, 0xF3, 0xFF, 0x80, 0x0F, 0x9F, 0xFC, 0x00, 0x7E,
  0xFF, 0xE0, 0x01, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x1F, 0x80, 0x03, 0xFF, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0xEF, 0xC0, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x87, 0xE0, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x1C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x1F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0xFE, 0x00, 0xF8, 0x1F, 0x00, 0xFF, 0x01, 0xF8, 0x1F, 0x00, 0xFF,
  0x01, 0xF8, 0x1F, 0x81, 0xFF, 0x01, 0xF8, 0x1F, 0x81, 0xFF, 0x01, 0xF8,
  0x1F, 0x81, 0xEF, 0x81, 0xF0, 0x1F, 0x81, 0xE7, 0x81, 0xF0, 0x0F, 0x83,
  0xE7, 0x81, 0xF0, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x0F, 0x83, 0xC7, 0xC3,
  0xF0, 0x0F, 0x83, 0xC7, 0xC3, 0xF0, 0x0F, 0xC7, 0xC3, 0xC3, 0xE0, 0x0F,
  0xC7, 0xC3, 0xE3, 0xE0, 0x07, 0xC7, 0x83, 0xE3, 0xE0, 0x07, 0xC7, 0x83,
  0xE3, 0xE0, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x07, 0xCF, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x00, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x77, 0xC0,
  0xFE, 0x00, 0xF3, 0xF0, 0x7F, 0x81, 0xF9, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF,
  0xC7, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x7E, 0x1F, 0xFF, 0x03, 0xF1, 0xFF, 0xFC, 0x1F, 0x9F, 0xFF, 0xF0, 0xFD,
  0xF0, 0x3F, 0xC7, 0xFE, 0x00, 0x7F, 0x3F, 0xE0, 0x01, 0xF9, 0xFE, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x3F, 0x3F, 0xE0, 0x03,
  0xF9, 0xFF, 0x80, 0x1F, 0x8F, 0xDF, 0x03, 0xFC, 0x7E, 0xFF, 0xFF, 0xC3,
  0xF3, 0xFF, 0xFC, 0x1F, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFC,
  0x07, 0xFF, 0xC3, 0xF0, 0x3F, 0xFF, 0x8F, 0xC3, 0xFF, 0xFF, 0x3F, 0x0F,
  0xF0, 0x3E, 0xFC, 0x7F, 0x00, 0x3F, 0xF1, 0xF8, 0x00, 0x7F, 0xCF, 0xC0,
  0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x1F,
  0xF3, 0xF8, 0x00, 0x7F, 0xC7, 0xF0, 0x03, 0xBF, 0x0F, 0xF0, 0x3E, 0xFC,
  0x3F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0x8F, 0xC0, 0x7F, 0xFC, 0x3F, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0x03, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x0F, 0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0xFF, 0xF3, 0xF1,
  0xFE, 0x07, 0xDF, 0x9F, 0xC0, 0x1E, 0xFC, 0xFC, 0x00, 0x3F, 0xEF, 0xC0,
  0x01, 0xFF, 0x7E, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0xFC,
  0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0xBF, 0x80, 0x07, 0xFC, 0xFE, 0x00,
  0xF7, 0xE7, 0xFC, 0x0F, 0xBF, 0x1F, 0xFF, 0xF9, 0xF8, 0x7F, 0xFF, 0x8F,
  0xC1, 0xFF, 0xF0, 0x7E, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x78, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xC3, 0xFF, 0xE0,
  0xFC, 0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0xF8, 0xFD, 0xF0, 0x3F, 0xCF, 0xFC,
  0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF9, 0xC0, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF8,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x0F, 0xE0,
  0x0F, 0x81, 0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x0F, 0x87, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0xBF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x0F,
  0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0xF8, 0x07,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0xC0,
  0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7F, 0x0F, 0x80,
  0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0x7F, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xF8, 0x7C, 0x7F, 0x81, 0xFF,
  0x3E, 0x7F, 0xE1, 0xFF, 0x9F, 0x7F, 0xF9, 0xFF, 0xEF, 0xB8, 0xFD, 0xE3,
  0xF7, 0xD8, 0x3E, 0xE0, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0,
  0x3F, 0xFE, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F,
  0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80,
  0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF0,
  0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x01, 0xFF,
  0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F,
  0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07,
  0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x0F, 0x83, 0xFF, 0xE0, 0xF8, 0x7F, 0xFF, 0x8F, 0x8F, 0xFF, 0xF8, 0xF9,
  0xF0, 0x3F, 0xCF, 0xBC, 0x00, 0xFE, 0xFB, 0x80, 0x0F, 0xEF, 0xF0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0x1F,
  0xFF, 0xC1, 0xF9, 0xFF, 0xFF, 0x0F, 0xDF, 0x03, 0xFC, 0x7F, 0xE0, 0x07,
  0xF3, 0xFE, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0x7F, 0x80, 0x03, 0xF3, 0xFE, 0x00, 0x1F, 0x9F, 0xF8, 0x01, 0xFC, 0xFD,
  0xF0, 0x3F, 0xC7, 0xEF, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0xC1, 0xF8, 0x7F,
  0xFC, 0x0F, 0xC0, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x07, 0xFF, 0xC3,
  0xF0, 0x3F, 0xFF, 0x8F, 0xC3, 0xFF, 0xFF, 0x3F, 0x0F, 0xF0, 0x3E, 0xFC,
  0x7F, 0x00, 0x3F, 0xF1, 0xF8, 0x00, 0x7F, 0xCF, 0xC0, 0x00, 0xFF, 0x3F,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7E,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x7F, 0xC7, 0xF0, 0x03, 0xBF, 0x0F, 0xF0, 0x3E, 0xFC, 0x3F, 0xFF, 0xF3,
  0xF0, 0x7F, 0xFF, 0x8F, 0xC0, 0x7F, 0xF8, 0x3F, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x7C, 0x7F, 0xFF, 0xDF, 0x1F, 0xC0, 0x17, 0xEF, 0x80, 0x01,
  0xFB, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x38, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xE0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xF7, 0xE0, 0x01, 0xFF, 0x7F, 0x00, 0x3B, 0xF7, 0xF8, 0x0F,
  0xBF, 0x3F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF, 0xC3, 0xF0,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x07,
  0xC7, 0xE0, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x3E, 0x01,
  0xFE, 0x03, 0xF0, 0xF8, 0x07, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0xE0, 0x3E,
  0x0F, 0xC0, 0xF7, 0xC0, 0xF8, 0x3F, 0x03, 0xCF, 0x03, 0xE0, 0x7C, 0x1F,
  0x3C, 0x1F, 0x81, 0xF0, 0x78, 0xF8, 0x7E, 0x07, 0xC1, 0xE3, 0xE1, 0xF8,
  0x1F, 0x8F, 0x87, 0x87, 0xC0, 0x7E, 0x3C, 0x1E, 0x1F, 0x01, 0xF8, 0xF0,
  0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0xF3, 0xF0, 0x0F, 0x9F, 0x03, 0xCF, 0xC0,
  0x3E, 0x78, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x1E, 0xF8, 0x03, 0xEF, 0x80,
  0x7B, 0xE0, 0x0F, 0xBC, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x5F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
};

const GFXglyph LiberationMono_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 6, 43, 40, 17, -43 },
  { 34, 22, 21, 40, 9, -48 },
  { 92, 35, 43, 40, 2, -43 },
  { 281, 35, 52, 40, 2, -47 },
  { 509, 40, 45, 40, 0, -44 },
  { 734, 37, 44, 40, 1, -43 },
  { 938, 7, 21, 40, 16, -48 },
  { 957, 18, 62, 40, 11, -48 },
  { 1097, 18, 62, 40, 11, -48 },
  { 1237, 24, 23, 40, 8, -48 },
  { 1306, 32, 33, 40, 4, -38 },
  { 1438, 14, 21, 40, 8, -10 },
  { 1475, 18, 5, 40, 11, -20 },
  { 1487, 8, 10, 40, 16, -10 },
  { 1497, 32, 49, 40, 4, -48 },
  { 1693, 32, 45, 40, 4, -44 },
  { 1873, 31, 43, 40, 5, -43 },
  { 2040, 30, 44, 40, 5, -44 },
  { 2205, 31, 45, 40, 4, -44 },
  { 2380, 33, 43, 40, 3, -43 },
  { 2558, 31, 44, 40, 4, -43 },
  { 2729, 30, 45, 40, 5, -44 },
  { 2898, 29, 43, 40, 5, -43 },
  { 3054, 31, 45, 40, 4, -44 },
  { 3229, 30, 45, 40, 5, -44 },
  { 3398, 8, 35, 40, 16, -35 },
  { 3433, 14, 46, 40, 11, -35 },
  { 3514, 32, 33, 40, 4, -38 },
  { 3646, 32, 21, 40, 4, -32 },
  { 3730, 32, 33, 40, 4, -38 },
  { 3862, 32, 44, 40, 3, -44 },
  { 4038, 37, 56, 40, 1, -48 },
  { 4297, 40, 43, 40, 0, -43 },
  { 4512, 32, 43, 40, 5, -43 },
  { 4684, 33, 45, 40, 4, -44 },
  { 4870, 31, 43, 40, 5, -43 },
  { 5037, 31, 43, 40, 5, -43 },
  { 5204, 29, 43, 40, 6, -43 },
  { 5360, 32, 45, 40, 4, -44 },
  { 5540, 29, 43, 40, 5, -43 },
  { 5696, 26, 43, 40, 7, -43 },
  { 5836, 26, 44, 40, 6, -43 },
  { 5979, 35, 43, 40, 5, -43 },
  { 6168, 27, 43, 40, 8, -43 },
  { 6314, 31, 43, 40, 4, -43 },
  { 6481, 29, 43, 40, 5, -43 },
  { 6637, 33, 45, 40, 3, -44 },
  { 6823, 31, 43, 40, 5, -43 },
  { 6990, 34, 56, 40, 3, -44 },
  { 7228, 33, 43, 40, 5, -43 },
  { 7406, 33, 45, 40, 3, -44 },
  { 7592, 35, 43, 40, 2, -43 },
  { 7781, 30, 44, 40, 5, -43 },
  { 7946, 39, 43, 40, 0, -43 },
  { 8156, 40, 43, 40, 0, -43 },
  { 8371, 37, 43, 40, 1, -43 },
  { 8570, 37, 43, 40, 1, -43 },
  { 8769, 35, 43, 40, 2, -43 },
  { 8958, 18, 62, 40, 13, -48 },
  { 9098, 32, 49, 40, 4, -48 },
  { 9294, 17, 62, 40, 9, -48 },
  { 9426, 31, 29, 40, 4, -43 },
  { 9539, 40, 3, 40, 0, 4 },
  { 9554, 14, 8, 40, 13, -47 },
  { 9568, 33, 37, 40, 4, -36 },
  { 9721, 29, 49, 40, 6, -48 },
  { 9899, 31, 37, 40, 4, -36 },
  { 10043, 30, 49, 40, 4, -48 },
  { 10227, 31, 37, 40, 4, -36 },
  { 10371, 31, 48, 40, 4, -48 },
  { 10557, 29, 50, 40, 5, -36 },
  { 10739, 28, 48, 40, 6, -48 },
  { 10907, 31, 48, 40, 5, -48 },
  { 11093, 23, 62, 40, 4, -48 },
  { 11272, 28, 48, 40, 8, -48 },
  { 11440, 32, 48, 40, 4, -48 },
  { 11632, 33, 36, 40, 3, -36 },
  { 11781, 28, 36, 40, 6, -36 },
  { 11907, 31, 37, 40, 4, -36 },
  { 12051, 29, 50, 40, 6, -36 },
  { 12233, 30, 50, 40, 4, -36 },
  { 12421, 26, 36, 40, 8, -36 },
  { 12538, 29, 37, 40, 5, -36 },
  { 12673, 27, 45, 40, 6, -44 },
  { 12825, 28, 36, 40, 6, -35 },
  { 12951, 35, 35, 40, 2, -35 },
  { 13105, 38, 35, 40, 1, -35 },
  { 13272, 34, 35, 40, 3, -35 },
  { 13421, 35, 49, 40, 2, -35 },
  { 13636, 29, 35, 40, 5, -35 },
  { 13763, 27, 62, 40, 7, -48 },
  { 13973, 5, 62, 40, 17, -48 },
  { 14012, 27, 62, 40, 5, -48 },
  { 14222, 33, 8, 40, 3, -26 },
};

const GFXfont LiberationMono_Regular66pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular66pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular66pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _LIBERATIONMONO_REGULAR66PT7B_H_
