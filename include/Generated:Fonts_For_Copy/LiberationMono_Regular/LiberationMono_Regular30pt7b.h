#ifndef _LIBERATIONMONO_REGULAR30PT7B_H_
#define _LIBERATIONMONO_REGULAR30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x19, 0x86, 0x61, 0x80, 0x02, 0x04, 0x06, 0x0C, 0x06, 0x0C,
  0x06, 0x08, 0x04, 0x08, 0x0C, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x18,
  0x08, 0x10, 0x18, 0x30, 0x18, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x20,
  0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x20, 0x40, 0x20, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x79, 0x9E, 0x71, 0x8E, 0x61, 0x86,
  0x61, 0x80, 0x71, 0x80, 0x39, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xBC,
  0x01, 0x8E, 0x01, 0x87, 0x01, 0x87, 0x01, 0x87, 0xE1, 0x87, 0xE1, 0x86,
  0x79, 0x9E, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x3C, 0x03,
  0x9F, 0xC0, 0xCE, 0x30, 0x63, 0x0C, 0x38, 0xC3, 0x0C, 0x30, 0xC6, 0x0C,
  0x33, 0x03, 0x8C, 0xC0, 0x7F, 0x60, 0x0F, 0x30, 0x00, 0x0C, 0xF0, 0x06,
  0xFE, 0x03, 0x39, 0xC0, 0xCC, 0x30, 0x63, 0x0C, 0x30, 0xC3, 0x1C, 0x30,
  0xC6, 0x0C, 0x73, 0x03, 0xF9, 0xC0, 0x3C, 0x07, 0xE0, 0x0F, 0xF0, 0x1C,
  0x30, 0x18, 0x38, 0x18, 0x38, 0x18, 0x30, 0x18, 0xE0, 0x1F, 0xC0, 0x0F,
  0x00, 0x3E, 0x0C, 0x76, 0x0E, 0xE3, 0x0C, 0xC3, 0x8C, 0xC1, 0xDC, 0xC0,
  0xD8, 0xC0, 0xF8, 0xE0, 0x78, 0xF0, 0xFC, 0x7F, 0xDF, 0x1F, 0x87, 0xFF,
  0x66, 0x66, 0x66, 0x60, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0,
  0x0C, 0x03, 0x00, 0xC3, 0x33, 0xFF, 0xC7, 0x01, 0xE0, 0xCC, 0x73, 0x88,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3C, 0xE3, 0x9E, 0x71, 0xC6, 0x38, 0xC3, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0x87, 0x1C, 0x0E,
  0x60, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0x9F, 0x1E, 0x7C, 0x79,
  0xF9, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x06, 0x70, 0x38, 0xE1,
  0xC3, 0xFE, 0x03, 0xF0, 0x01, 0x80, 0x0F, 0x00, 0x7E, 0x07, 0xEC, 0x0E,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C,
  0x0E, 0x60, 0x1B, 0x80, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E,
  0xE0, 0x1B, 0x80, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x1F, 0x80, 0x7E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1D, 0xE0,
  0xE3, 0xFF, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0x70, 0x19, 0xC0, 0xC7, 0x07, 0x1C, 0x18, 0x70, 0xC1, 0xC7, 0x07, 0x18,
  0x1C, 0xC0, 0x73, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x7F, 0xF9, 0xFF, 0xE7, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x19, 0xF0, 0x6F, 0xF1, 0xE1, 0xEF, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xF8, 0x07, 0xE0, 0x39, 0xC1, 0xE3, 0xFF,
  0x07, 0xF0, 0x07, 0xC0, 0x7F, 0xC3, 0xC7, 0x8C, 0x0E, 0x70, 0x19, 0x80,
  0x06, 0x00, 0x39, 0xF8, 0xEF, 0xF3, 0xE1, 0xEF, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x76, 0x01, 0xDC, 0x07, 0x70, 0x38, 0xE1, 0xE1, 0xFF, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x98, 0x0E, 0xE0, 0x1B, 0x80, 0x67, 0x03,
  0x9E, 0x1E, 0x1F, 0xE0, 0x7F, 0x87, 0x87, 0x98, 0x06, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xE1, 0xE3, 0xFF, 0x03, 0xF0, 0x0F,
  0xC0, 0xFF, 0x87, 0x87, 0x1C, 0x0E, 0xE0, 0x1B, 0x80, 0x6E, 0x01, 0xF8,
  0x07, 0xE0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF, 0xF7, 0x0F, 0x9C, 0x00, 0x70,
  0x01, 0x98, 0x0E, 0x70, 0x31, 0xE3, 0xC3, 0xFE, 0x03, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x8E, 0x1C, 0x30, 0xE1, 0xC3, 0x06,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x00,
  0x3C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x08, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0xE6, 0x00, 0xFC, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1E, 0x1C, 0x38, 0x0E, 0x30, 0x06,
  0x60, 0x03, 0x61, 0xCB, 0x67, 0xFB, 0xC6, 0x3B, 0xCC, 0x39, 0xCC, 0x31,
  0xD8, 0x31, 0xD8, 0x31, 0x98, 0x33, 0x98, 0x33, 0xD8, 0x63, 0xD8, 0x63,
  0xDC, 0xE6, 0xCF, 0xBE, 0xC7, 0x3C, 0x60, 0x00, 0x60, 0x00, 0x30, 0x04,
  0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0x30, 0x01, 0xCE, 0x00, 0x71, 0x80, 0x18, 0x60,
  0x0E, 0x1C, 0x03, 0x83, 0x00, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFE, 0x0F,
  0xFF, 0xC3, 0x80, 0x70, 0xC0, 0x0C, 0x70, 0x03, 0x9C, 0x00, 0xE6, 0x00,
  0x1B, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x71, 0xFF, 0xC3, 0xFF, 0xC7,
  0x01, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x7B, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x80,
  0xEE, 0x01, 0xDC, 0x01, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0x38, 0x06, 0x70,
  0x1C, 0x70, 0x70, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0x83, 0xFF, 0x8E, 0x0F,
  0x38, 0x0E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0E, 0xE0,
  0x3B, 0x83, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xEF,
  0xFF, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x0E, 0xE0, 0x1F, 0x80,
  0x6E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x1F, 0xF8, 0x7F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x07, 0x70, 0x1C, 0xE0, 0xF1, 0xFF, 0x81,
  0xF8, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xEE, 0x39, 0xFF, 0x0F, 0x80, 0xE0, 0x1C,
  0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80,
  0xE7, 0x00, 0xEE, 0x00, 0xEF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0xF1, 0xC0,
  0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xD8, 0x6F, 0x71, 0xBD, 0xCE, 0xF3,
  0x33, 0xCE, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xB0, 0x7E, 0xE1, 0xF9, 0x87,
  0xE7, 0x1F, 0x9C, 0x7E, 0x31, 0xF8, 0xE7, 0xE1, 0x9F, 0x87, 0x7E, 0x0D,
  0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0x07, 0xE0, 0x1F,
  0xF8, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x3C, 0x38, 0x1F, 0xF8, 0x07,
  0xE0, 0xFF, 0xC3, 0xFF, 0xCE, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xEF, 0xFF, 0x3F, 0xF0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x3C, 0x38,
  0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00, 0xEE,
  0x00, 0xDC, 0x01, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xFF, 0xE3, 0xFF,
  0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x39,
  0xC0, 0x3B, 0x80, 0x77, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xF8, 0x38, 0x3C,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x06, 0xE0, 0x07,
  0xE0, 0x06, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x39, 0xE1, 0xE3, 0xFF, 0x03,
  0xF0, 0xE0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07,
  0x0E, 0x01, 0xC1, 0x80, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x03, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x06, 0x18, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x67,
  0x0C, 0x39, 0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0x78, 0xE3, 0x1E, 0x30, 0xCC,
  0xCC, 0x33, 0x33, 0x0C, 0xCC, 0xC3, 0xB3, 0x70, 0xF8, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x38, 0xE0, 0x07, 0x70, 0x0E, 0x38,
  0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x1C,
  0x38, 0x18, 0x18, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03,
  0x30, 0x0C, 0xC0, 0x61, 0x81, 0x86, 0x0C, 0x1C, 0x30, 0x31, 0xC0, 0xE6,
  0x01, 0x98, 0x06, 0xC0, 0x0C, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x83, 0x0F,
  0xC0, 0x7F, 0xC1, 0xE1, 0xC3, 0x81, 0x86, 0x03, 0x80, 0x07, 0x07, 0xFE,
  0x3F, 0xFC, 0x78, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x9E,
  0x37, 0x1F, 0xEF, 0x9F, 0x0F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x1F, 0x1B, 0xFC, 0xD0, 0xF7, 0x03, 0xB8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1D,
  0xE1, 0xED, 0xFE, 0x67, 0xE0, 0x0F, 0xC0, 0xFF, 0xC7, 0x83, 0x9C, 0x07,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x1D, 0xE0, 0xE3, 0xFF, 0x03, 0xF0, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x7C, 0x67, 0xFB, 0x78, 0x7B,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xDC, 0x0E, 0xF0, 0xB3, 0xFD, 0x8F, 0x8C, 0x0F, 0xC0, 0xFF,
  0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x19, 0xE0, 0xE3, 0xFF, 0x03,
  0xF0, 0x01, 0xFC, 0x1F, 0xF0, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x1F, 0x19, 0xFE, 0xDE, 0x36, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x77,
  0x03, 0xBC, 0x6C, 0xFF, 0x63, 0xE3, 0x00, 0x18, 0x01, 0xDC, 0x0E, 0x70,
  0xE3, 0xFF, 0x07, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC7, 0xCD, 0xFE, 0xD8, 0xFE, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0xEF, 0xFB, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0xFC, 0x0E, 0xE0, 0xE7, 0x0E, 0x38, 0xE1, 0xCE, 0x0E, 0xE0,
  0x7F, 0x03, 0xFC, 0x1E, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x39, 0xC0, 0xEE,
  0x07, 0x70, 0x1C, 0x3F, 0x80, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x3C, 0xFE, 0xFD, 0xCF, 0x3B,
  0x8E, 0x36, 0x18, 0x6C, 0x30, 0xD8, 0x61, 0xB0, 0xC3, 0x61, 0x86, 0xC3,
  0x0D, 0x86, 0x1B, 0x0C, 0x36, 0x18, 0x6C, 0x30, 0xD8, 0x61, 0xB0, 0xC3,
  0xC7, 0xCD, 0xFE, 0xD8, 0xFE, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x39, 0xE1,
  0xE3, 0xFF, 0x03, 0xF0, 0xC7, 0xC6, 0xFF, 0x34, 0x3D, 0xC0, 0xEE, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0x78, 0x7B, 0x7F, 0x98, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0x1F, 0x19, 0xFE, 0xDE, 0x1E, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x77,
  0x03, 0xBC, 0x2C, 0xFF, 0x63, 0xE3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0xC3, 0xF9, 0xFF, 0xB0, 0x7C, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x83, 0x9C, 0x06, 0x70, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x07, 0xE0,
  0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0xFF, 0xEF, 0xFE, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0xF0, 0xFE,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x7E, 0x0F, 0x7F, 0xB3, 0xE3,
  0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C,
  0x18, 0x18, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xD8, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x06, 0x71, 0xE3, 0x9C, 0x78, 0xE7, 0x1E, 0x38,
  0xC7, 0x8C, 0x33, 0x33, 0x0C, 0xCC, 0xC3, 0x33, 0x70, 0xF8, 0x7C, 0x3E,
  0x1F, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0x70, 0x38, 0x70, 0x0E, 0x38, 0x1C,
  0x18, 0x18, 0x1C, 0x38, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x38, 0x38, 0x1C,
  0x70, 0x0C, 0x70, 0x0E, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x70, 0x0E,
  0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x30,
  0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0xC1, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x7C, 0x03, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xFE,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xE0, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x3F, 0xC1, 0xF8, 0x00, 0x7C, 0x03, 0xFE, 0x18, 0x3F,
  0xC0, 0x3E,
};

const GFXglyph LiberationMono_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 2, 20, 18, 8, -20 },
  { 6, 10, 9, 18, 4, -22 },
  { 18, 16, 20, 18, 1, -20 },
  { 58, 16, 24, 18, 1, -22 },
  { 106, 18, 20, 18, 0, -20 },
  { 151, 16, 20, 18, 1, -20 },
  { 191, 4, 9, 18, 7, -22 },
  { 196, 8, 28, 18, 5, -22 },
  { 224, 8, 28, 18, 5, -22 },
  { 252, 10, 10, 18, 4, -22 },
  { 265, 14, 14, 18, 2, -17 },
  { 290, 6, 10, 18, 4, -4 },
  { 298, 8, 2, 18, 5, -9 },
  { 300, 4, 4, 18, 7, -4 },
  { 302, 14, 22, 18, 2, -22 },
  { 341, 14, 20, 18, 2, -20 },
  { 376, 15, 20, 18, 2, -20 },
  { 414, 14, 20, 18, 2, -20 },
  { 449, 14, 20, 18, 2, -20 },
  { 484, 14, 20, 18, 2, -20 },
  { 519, 14, 20, 18, 2, -20 },
  { 554, 14, 20, 18, 2, -20 },
  { 589, 14, 20, 18, 2, -20 },
  { 624, 14, 20, 18, 2, -20 },
  { 659, 14, 20, 18, 2, -20 },
  { 694, 4, 16, 18, 7, -16 },
  { 702, 7, 22, 18, 5, -16 },
  { 722, 14, 15, 18, 2, -17 },
  { 749, 14, 9, 18, 2, -14 },
  { 765, 14, 15, 18, 2, -17 },
  { 792, 15, 20, 18, 1, -20 },
  { 830, 16, 26, 18, 1, -22 },
  { 882, 18, 20, 18, 0, -20 },
  { 927, 15, 20, 18, 2, -20 },
  { 965, 15, 20, 18, 2, -20 },
  { 1003, 14, 20, 18, 2, -20 },
  { 1038, 14, 20, 18, 2, -20 },
  { 1073, 13, 20, 18, 3, -20 },
  { 1106, 14, 20, 18, 2, -20 },
  { 1141, 14, 20, 18, 2, -20 },
  { 1176, 12, 20, 18, 3, -20 },
  { 1206, 11, 20, 18, 3, -20 },
  { 1234, 16, 20, 18, 2, -20 },
  { 1274, 13, 20, 18, 3, -20 },
  { 1307, 14, 20, 18, 2, -20 },
  { 1342, 14, 20, 18, 2, -20 },
  { 1377, 16, 20, 18, 1, -20 },
  { 1417, 14, 20, 18, 2, -20 },
  { 1452, 16, 26, 18, 1, -20 },
  { 1504, 15, 20, 18, 2, -20 },
  { 1542, 16, 20, 18, 1, -20 },
  { 1582, 16, 20, 18, 1, -20 },
  { 1622, 14, 20, 18, 2, -20 },
  { 1657, 18, 20, 18, 0, -20 },
  { 1702, 18, 20, 18, 0, -20 },
  { 1747, 16, 20, 18, 1, -20 },
  { 1787, 16, 20, 18, 1, -20 },
  { 1827, 16, 20, 18, 1, -20 },
  { 1867, 8, 28, 18, 6, -22 },
  { 1895, 14, 22, 18, 2, -22 },
  { 1934, 8, 28, 18, 4, -22 },
  { 1962, 14, 13, 18, 2, -20 },
  { 1985, 18, 1, 18, 0, 2 },
  { 1988, 6, 4, 18, 6, -22 },
  { 1991, 15, 16, 18, 2, -16 },
  { 2021, 13, 22, 18, 3, -22 },
  { 2057, 14, 16, 18, 2, -16 },
  { 2085, 13, 22, 18, 2, -22 },
  { 2121, 14, 16, 18, 2, -16 },
  { 2149, 14, 22, 18, 2, -22 },
  { 2188, 13, 22, 18, 2, -16 },
  { 2224, 12, 22, 18, 3, -22 },
  { 2257, 14, 22, 18, 2, -22 },
  { 2296, 10, 28, 18, 2, -22 },
  { 2331, 13, 22, 18, 3, -22 },
  { 2367, 14, 22, 18, 2, -22 },
  { 2406, 15, 16, 18, 1, -16 },
  { 2436, 12, 16, 18, 3, -16 },
  { 2460, 14, 16, 18, 2, -16 },
  { 2488, 13, 22, 18, 3, -16 },
  { 2524, 13, 22, 18, 2, -16 },
  { 2560, 11, 16, 18, 4, -16 },
  { 2582, 14, 16, 18, 2, -16 },
  { 2610, 12, 20, 18, 3, -20 },
  { 2640, 12, 16, 18, 3, -16 },
  { 2664, 16, 16, 18, 1, -16 },
  { 2696, 18, 16, 18, 0, -16 },
  { 2732, 16, 16, 18, 1, -16 },
  { 2764, 16, 22, 18, 1, -16 },
  { 2808, 14, 16, 18, 2, -16 },
  { 2836, 13, 28, 18, 3, -22 },
  { 2882, 2, 28, 18, 8, -22 },
  { 2889, 13, 28, 18, 2, -22 },
  { 2935, 14, 4, 18, 2, -12 },
};

const GFXfont LiberationMono_Regular30pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular30pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular30pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _LIBERATIONMONO_REGULAR30PT7B_H_
