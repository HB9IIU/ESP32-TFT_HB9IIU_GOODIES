#ifndef _LIBERATIONMONO_REGULAR68PT7B_H_
#define _LIBERATIONMONO_REGULAR68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0x9F, 0xF8, 0x1F, 0xE0, 0x78, 0x3F,
  0xC1, 0xF8, 0x07, 0x81, 0xFC, 0x3F, 0x80, 0x78, 0x0F, 0xC3, 0xF0, 0x07,
  0x80, 0xFE, 0x3F, 0x00, 0x78, 0x07, 0xE3, 0xF0, 0x07, 0x80, 0x70, 0x3F,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0x01, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0x7F, 0xE7,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0xFF, 0xC0, 0x00, 0x07,
  0x83, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x7E, 0x00,
  0x00, 0x78, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x78, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x3F, 0x0C, 0x00, 0x78, 0x03, 0xFF, 0xC0, 0x07,
  0x80, 0x3F, 0xFE, 0x00, 0x78, 0x03, 0xF7, 0xE0, 0x07, 0x80, 0x3F, 0x7F,
  0x00, 0x78, 0x07, 0xF3, 0xF8, 0x07, 0x80, 0xFE, 0x3F, 0xC0, 0x78, 0x1F,
  0xE1, 0xFF, 0x87, 0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E,
  0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0xC3, 0xE0, 0x00,
  0x7C, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xFF,
  0xE1, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x1F,
  0xFF, 0x80, 0x00, 0x1E, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0xC0, 0x00,
  0x01, 0xF7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0C, 0x00,
  0x3F, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0xEF, 0xC0,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x03, 0xF0,
  0x3E, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0xFC,
  0x00, 0x3F, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0xF8, 0x0F, 0xC0, 0x01, 0xFF,
  0xE0, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x80, 0xF0, 0x08, 0xF0, 0x78, 0x1E, 0x7E, 0x1C, 0x7F, 0x3F, 0xEE, 0xFF,
  0xBF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x1C, 0x03, 0xC0, 0x06, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x81, 0xFE, 0x07, 0xEF, 0xC0, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0xF0, 0x3F, 0xC0, 0x7F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFB, 0xF0, 0x00, 0xFF, 0xF9, 0xF8, 0x00, 0x7F, 0xF8, 0xFC, 0x00,
  0x3F, 0xF0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x07, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xF8, 0x01, 0xF8, 0x3F, 0xFE, 0x03, 0xF1, 0xFF,
  0xFF, 0x07, 0xE7, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xFF, 0x1F, 0xFF, 0x03,
  0xFF, 0x3F, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x0F,
  0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF,
  0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x7F, 0xFC, 0x7F,
  0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x3F,
  0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3C, 0x03, 0xFC, 0x39, 0xE1, 0xF0,
  0x3F, 0xF9, 0xE7, 0x87, 0x81, 0xF8, 0xF7, 0x9F, 0x3E, 0x07, 0x81, 0xDE,
  0x3C, 0xF8, 0x3C, 0x03, 0x78, 0xF3, 0xC1, 0xF0, 0x0F, 0xC3, 0xCF, 0x07,
  0x80, 0x1F, 0x0F, 0x7C, 0x3E, 0x00, 0x7C, 0x3D, 0xF0, 0xF0, 0x01, 0xF0,
  0xF7, 0x83, 0xC0, 0x07, 0xC3, 0xDE, 0x1F, 0x00, 0x1E, 0x0F, 0x78, 0x7C,
  0x00, 0x78, 0x3D, 0xE1, 0xE0, 0x03, 0xE0, 0xF7, 0x87, 0x80, 0x0F, 0x83,
  0xDE, 0x3E, 0x00, 0x3E, 0x0F, 0xF8, 0xF8, 0x00, 0xF0, 0x3F, 0xE3, 0xE0,
  0x03, 0xC0, 0xFF, 0x8F, 0x80, 0x0F, 0x03, 0xFE, 0x3E, 0x00, 0x7C, 0x0F,
  0xF8, 0xF8, 0x01, 0xF0, 0x3D, 0xE3, 0xE0, 0x07, 0x80, 0xE7, 0x8F, 0x80,
  0x3E, 0x07, 0x9E, 0x3E, 0x00, 0xF8, 0x1E, 0x78, 0x78, 0x03, 0xE0, 0x79,
  0xE1, 0xE0, 0x1F, 0x83, 0xC7, 0x87, 0xC0, 0xEE, 0x0F, 0x1E, 0x0F, 0x03,
  0xB8, 0x78, 0x7C, 0x3E, 0x3C, 0xE3, 0xC0, 0xF0, 0x7F, 0xE3, 0xFF, 0x03,
  0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x00, 0xFF, 0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x78, 0x7F,
  0x00, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0xFF,
  0xC0, 0x00, 0x0F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFB,
  0xE0, 0x01, 0xFF, 0xFB, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFD,
  0xF0, 0x07, 0xDF, 0xFD, 0xF0, 0x07, 0xDF, 0xFD, 0xF8, 0x07, 0xDF, 0xFC,
  0xF8, 0x0F, 0x9F, 0xFC, 0xF8, 0x0F, 0x9F, 0xFC, 0xFC, 0x1F, 0x9F, 0xFC,
  0x7C, 0x1F, 0x1F, 0xFC, 0x7C, 0x1F, 0x1F, 0xFC, 0x7E, 0x3E, 0x1F, 0xFC,
  0x3E, 0x3E, 0x1F, 0xFC, 0x3E, 0x3E, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0xFC,
  0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0xFC, 0x0F, 0x78, 0x1F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0xFC,
  0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0xC0, 0x01,
  0xFF, 0xDF, 0x80, 0x07, 0xFF, 0x7E, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x7F,
  0xF3, 0xF0, 0x01, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0x1F, 0x80, 0x1F, 0xFC,
  0x3E, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0x07,
  0xE0, 0x1F, 0xFC, 0x0F, 0x80, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0x01, 0xF8, 0x1F, 0xFC, 0x07, 0xE0, 0x7F, 0xF0, 0x0F, 0xC1,
  0xFF, 0xC0, 0x3F, 0x07, 0xFF, 0x00, 0x7C, 0x1F, 0xFC, 0x01, 0xF8, 0x7F,
  0xF0, 0x03, 0xE1, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0x00, 0x1F, 0x1F, 0xFC,
  0x00, 0x7E, 0x7F, 0xF0, 0x01, 0xF9, 0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0x00,
  0x0F, 0xDF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x80, 0x03, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x70, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x00, 0xF8, 0x1F, 0x00,
  0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x78, 0x0F, 0xC0,
  0xFC, 0x0F, 0xBC, 0x07, 0xC0, 0x7E, 0x07, 0xDF, 0x03, 0xE0, 0x1F, 0x03,
  0xEF, 0x81, 0xF0, 0x0F, 0x81, 0xE3, 0xC1, 0xF8, 0x07, 0xE1, 0xF1, 0xE0,
  0xFC, 0x03, 0xF0, 0xF8, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x7C, 0x3F, 0x00,
  0xFC, 0x3C, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0xF1,
  0xF0, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x01, 0xFB, 0xE0, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00, 0x1F, 0xF8,
  0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFC, 0xFC, 0x07, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8,
  0x3F, 0x3F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE3, 0xF7, 0xC0, 0x7F, 0x8F,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0xFF, 0x00,
  0x01, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0x3F, 0xF0, 0x03,
  0xFC, 0xFF, 0xF0, 0x1F, 0xE3, 0xF7, 0xFF, 0xFF, 0x8F, 0xCF, 0xFF, 0xFC,
  0x3F, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x0F, 0xFF, 0x83,
  0xF0, 0x7F, 0xFF, 0x8F, 0xC3, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFE, 0xFC,
  0xFF, 0x80, 0xFB, 0xF3, 0xF8, 0x00, 0xFF, 0xDF, 0xC0, 0x01, 0xFF, 0x7F,
  0x00, 0x03, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0x7E, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xF7, 0xF0, 0x00,
  0x7F, 0xCF, 0xE0, 0x07, 0xFF, 0x3F, 0xE0, 0x7E, 0xFC, 0x7F, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0xE0, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x30,
  0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x7F, 0xFF, 0x8F, 0xC3, 0xFF, 0xFF,
  0x3F, 0x1F, 0xFF, 0xFE, 0xFC, 0xFF, 0x81, 0xFB, 0xF3, 0xF8, 0x01, 0xFF,
  0xDF, 0xC0, 0x03, 0xFF, 0x7F, 0x00, 0x07, 0xFD, 0xF8, 0x00, 0x0F, 0xF7,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFD, 0xFC,
  0x00, 0x3F, 0xF3, 0xF8, 0x01, 0xFF, 0xCF, 0xF8, 0x1F, 0xBF, 0x1F, 0xFF,
  0xFC, 0xFC, 0x7F, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0xF8,
  0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x7E, 0x0F, 0xFF,
  0x83, 0xF1, 0xFF, 0xFE, 0x1F, 0x9F, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xE7,
  0xEF, 0xC0, 0xFF, 0x3F, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x3F, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0xE0, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x3E, 0x3F,
  0xE0, 0xFF, 0xCF, 0x9F, 0xFC, 0x7F, 0xF3, 0xE7, 0xFF, 0x1F, 0xFE, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBE, 0xE1, 0xFB, 0x87, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x01, 0xF0,
  0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF0, 0x07,
  0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x1F,
  0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C,
  0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0xFC, 0x01,
  0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF0,
  0x07, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x07,
  0xE0, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xE1, 0xF9, 0xFF, 0xFF, 0x8F, 0xDF,
  0xFF, 0xFE, 0x7E, 0xFC, 0x0F, 0xFB, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xF0,
  0x7F, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0xF0, 0xFD, 0xFF,
  0xFF, 0xE3, 0xF7, 0xC0, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x01,
  0xFC, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7E, 0xFF, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x0F, 0xEF,
  0xF8, 0x00, 0x7F, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0xF0, 0x1F, 0xE3, 0xF7,
  0xFF, 0xFF, 0x8F, 0xCF, 0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F,
  0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x0F,
  0xFF, 0x83, 0xF0, 0x7F, 0xFF, 0x8F, 0xC3, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF,
  0xFE, 0xFC, 0xFF, 0x80, 0xFB, 0xF3, 0xF8, 0x00, 0xFF, 0xDF, 0xC0, 0x01,
  0xFF, 0x7F, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0x7E, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xF7,
  0xF0, 0x00, 0x7F, 0xCF, 0xE0, 0x07, 0xFF, 0x3F, 0xE0, 0x7E, 0xFC, 0x7F,
  0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03, 0xFF,
  0xE0, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xBE, 0x0F, 0xFF, 0xF7, 0xE3, 0xFF, 0xFE,
  0xFC, 0xFE, 0x00, 0x5F, 0x9F, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x7F, 0x80, 0x1F, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0x00, 0x07, 0xFD,
  0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x0F, 0xBF, 0x3F, 0xFF, 0xFD, 0xF9, 0xFF,
  0xFF, 0xCF, 0xC7, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0x83, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x03, 0xF8,
  0x07, 0xE1, 0xF0, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xE0, 0x1F, 0x87,
  0xE0, 0x3F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7B, 0xC0, 0x7E, 0x1F, 0x81, 0xF7,
  0x80, 0xF8, 0x3F, 0x03, 0xEF, 0x83, 0xF0, 0x3E, 0x07, 0x9F, 0x07, 0xE0,
  0x7C, 0x1F, 0x1E, 0x0F, 0xC0, 0xFC, 0x3E, 0x3E, 0x1F, 0x81, 0xF8, 0x78,
  0x7C, 0x3F, 0x03, 0xF0, 0xF0, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0xF0, 0xF8,
  0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x0F, 0x8F, 0x01, 0xE7, 0xE0, 0x1F, 0x3E,
  0x03, 0xCF, 0xC0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7E, 0xF0, 0x0F, 0xBE,
  0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
};

const GFXglyph LiberationMono_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 7, 45, 41, 17, -45 },
  { 41, 23, 21, 41, 9, -49 },
  { 102, 37, 45, 41, 2, -45 },
  { 311, 36, 54, 41, 2, -49 },
  { 554, 41, 47, 41, 0, -46 },
  { 795, 38, 46, 41, 1, -45 },
  { 1014, 7, 21, 41, 17, -49 },
  { 1033, 19, 63, 41, 11, -49 },
  { 1183, 18, 63, 41, 11, -49 },
  { 1325, 25, 24, 41, 8, -49 },
  { 1400, 33, 33, 41, 4, -39 },
  { 1537, 14, 22, 41, 9, -10 },
  { 1576, 19, 5, 41, 11, -21 },
  { 1588, 8, 10, 41, 16, -10 },
  { 1598, 33, 50, 41, 4, -49 },
  { 1805, 33, 47, 41, 4, -46 },
  { 1999, 33, 45, 41, 5, -45 },
  { 2185, 31, 46, 41, 5, -46 },
  { 2364, 32, 47, 41, 4, -46 },
  { 2552, 34, 45, 41, 3, -45 },
  { 2744, 32, 46, 41, 4, -45 },
  { 2928, 31, 47, 41, 5, -46 },
  { 3111, 31, 45, 41, 5, -45 },
  { 3286, 32, 47, 41, 4, -46 },
  { 3474, 31, 47, 41, 5, -46 },
  { 3657, 8, 36, 41, 16, -36 },
  { 3693, 14, 48, 41, 12, -36 },
  { 3777, 33, 35, 41, 4, -40 },
  { 3922, 33, 22, 41, 4, -33 },
  { 4013, 33, 35, 41, 4, -40 },
  { 4158, 33, 46, 41, 3, -46 },
  { 4348, 38, 57, 41, 1, -49 },
  { 4619, 41, 45, 41, 0, -45 },
  { 4850, 33, 45, 41, 5, -45 },
  { 5036, 34, 47, 41, 4, -46 },
  { 5236, 32, 45, 41, 5, -45 },
  { 5416, 32, 45, 41, 5, -45 },
  { 5596, 30, 45, 41, 6, -45 },
  { 5765, 33, 47, 41, 4, -46 },
  { 5959, 30, 45, 41, 5, -45 },
  { 6128, 27, 45, 41, 7, -45 },
  { 6280, 27, 46, 41, 6, -45 },
  { 6436, 36, 45, 41, 5, -45 },
  { 6639, 29, 45, 41, 8, -45 },
  { 6803, 32, 45, 41, 4, -45 },
  { 6983, 30, 45, 41, 5, -45 },
  { 7152, 34, 47, 41, 3, -46 },
  { 7352, 32, 45, 41, 5, -45 },
  { 7532, 35, 59, 41, 3, -46 },
  { 7791, 34, 45, 41, 5, -45 },
  { 7983, 34, 47, 41, 3, -46 },
  { 8183, 35, 45, 41, 3, -45 },
  { 8380, 31, 46, 41, 5, -45 },
  { 8559, 40, 45, 41, 0, -45 },
  { 8784, 41, 45, 41, 0, -45 },
  { 9015, 39, 45, 41, 1, -45 },
  { 9235, 39, 45, 41, 1, -45 },
  { 9455, 36, 45, 41, 2, -45 },
  { 9658, 18, 63, 41, 14, -49 },
  { 9800, 33, 50, 41, 4, -49 },
  { 10007, 18, 63, 41, 9, -49 },
  { 10149, 32, 30, 41, 4, -45 },
  { 10269, 41, 3, 41, 0, 4 },
  { 10285, 14, 9, 41, 13, -49 },
  { 10301, 35, 38, 41, 4, -37 },
  { 10468, 30, 50, 41, 6, -49 },
  { 10656, 32, 38, 41, 4, -37 },
  { 10808, 30, 50, 41, 5, -49 },
  { 10996, 32, 38, 41, 4, -37 },
  { 11148, 31, 49, 41, 5, -49 },
  { 11338, 30, 51, 41, 5, -37 },
  { 11530, 29, 49, 41, 6, -49 },
  { 11708, 32, 49, 41, 5, -49 },
  { 11904, 24, 63, 41, 4, -49 },
  { 12093, 29, 49, 41, 8, -49 },
  { 12271, 33, 49, 41, 4, -49 },
  { 12474, 34, 37, 41, 3, -37 },
  { 12632, 29, 37, 41, 6, -37 },
  { 12767, 32, 38, 41, 4, -37 },
  { 12919, 30, 51, 41, 6, -37 },
  { 13111, 30, 51, 41, 5, -37 },
  { 13303, 27, 37, 41, 8, -37 },
  { 13428, 29, 38, 41, 6, -37 },
  { 13566, 28, 46, 41, 6, -45 },
  { 13727, 29, 37, 41, 6, -36 },
  { 13862, 36, 36, 41, 2, -36 },
  { 14024, 39, 36, 41, 1, -36 },
  { 14200, 35, 36, 41, 3, -36 },
  { 14358, 37, 50, 41, 2, -36 },
  { 14590, 30, 36, 41, 5, -36 },
  { 14725, 27, 63, 41, 8, -49 },
  { 14938, 5, 63, 41, 18, -49 },
  { 14978, 27, 63, 41, 6, -49 },
  { 15191, 33, 8, 41, 4, -26 },
};

const GFXfont LiberationMono_Regular68pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular68pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular68pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _LIBERATIONMONO_REGULAR68PT7B_H_
