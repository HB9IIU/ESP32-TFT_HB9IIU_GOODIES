#ifndef _LIBERATIONMONO_REGULAR7PT7B_H_
#define _LIBERATIONMONO_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0xF0, 0x15, 0x6F, 0x20, 0x6B, 0x63, 0x70, 0xDE, 0xC7, 0x30,
  0x66, 0x4A, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x50, 0x10, 0x2F, 0x20, 0xC0,
  0x40, 0x80, 0x12, 0x24, 0x40, 0x69, 0xB9, 0x60, 0x2E, 0x22, 0x70, 0x61,
  0x24, 0x70, 0x61, 0x21, 0x70, 0x26, 0x6F, 0x20, 0x68, 0x61, 0x60, 0xD3,
  0x5E, 0xE9, 0x48, 0x69, 0x69, 0x70, 0x69, 0x97, 0x60, 0x90, 0x41, 0x80,
  0x3C, 0x60, 0x6F, 0x43, 0x60, 0x69, 0x20, 0x00, 0x7B, 0xFB, 0xC6, 0x26,
  0x67, 0x90, 0xD7, 0x5E, 0x69, 0x88, 0x60, 0xD6, 0xDC, 0xF3, 0x4E, 0xF3,
  0x48, 0x69, 0x89, 0x70, 0x37, 0xDA, 0xE9, 0x2E, 0x55, 0xC0, 0x3A, 0x6A,
  0x12, 0x4E, 0x9D, 0xF9, 0x90, 0x36, 0xFA, 0x69, 0x99, 0x60, 0xD7, 0xC8,
  0x69, 0x99, 0x62, 0xD7, 0xEA, 0x68, 0x61, 0x70, 0xF2, 0x22, 0x20, 0x99,
  0x99, 0x60, 0x99, 0x56, 0x20, 0x89, 0xBF, 0x50, 0x96, 0x26, 0x90, 0x95,
  0x62, 0x20, 0xF2, 0x24, 0xF0, 0xAA, 0xA0, 0x44, 0x22, 0x10, 0x55, 0x50,
  0x06, 0x50, 0xF0, 0x40, 0x63, 0xDF, 0x9A, 0xDE, 0x68, 0x87, 0x17, 0x99,
  0x70, 0x69, 0xE6, 0x6F, 0x44, 0x40, 0x79, 0x97, 0x70, 0x9A, 0xDA, 0x26,
  0x22, 0x60, 0x2C, 0x92, 0xC0, 0x97, 0x6A, 0x22, 0x22, 0x60, 0xDB, 0xBB,
  0x56, 0xD0, 0x69, 0x96, 0x56, 0xF8, 0x79, 0x97, 0x10, 0x72, 0x40, 0xD1,
  0xB0, 0xBA, 0xC0, 0x36, 0xF0, 0x95, 0x62, 0x99, 0xF5, 0x16, 0x65, 0x95,
  0x62, 0x40, 0x72, 0x4E, 0x4A, 0x44, 0x80, 0xFC, 0xD5, 0x50, 0xE0,
};

const GFXglyph LiberationMono_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 5, 4, 0, -5 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 4, 2, -5 },
  { 16, 2, 6, 4, 1, -5 },
  { 18, 2, 6, 4, 1, -5 },
  { 20, 2, 2, 4, 1, -5 },
  { 21, 4, 3, 4, 0, -4 },
  { 23, 1, 2, 4, 1, -1 },
  { 24, 2, 1, 4, 1, -2 },
  { 25, 1, 1, 4, 2, -1 },
  { 26, 4, 5, 4, 0, -5 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 1, -5 },
  { 49, 3, 5, 4, 1, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 1, 4, 4, 2, -4 },
  { 58, 2, 5, 4, 1, -4 },
  { 60, 4, 3, 4, 0, -4 },
  { 62, 4, 2, 4, 0, -3 },
  { 63, 4, 3, 4, 0, -4 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 6, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 3, 5, 4, 1, -5 },
  { 92, 2, 5, 4, 1, -5 },
  { 94, 3, 5, 4, 1, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 3, 5, 4, 1, -5 },
  { 108, 4, 6, 4, 0, -5 },
  { 111, 3, 5, 4, 1, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 2, 6, 4, 1, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 2, 6, 4, 1, -5 },
  { 144, 4, 3, 4, 0, -5 },
  { 146, 4, 1, 4, 0, 0 },
  { 147, 2, 1, 4, 1, -5 },
  { 148, 4, 4, 4, 0, -4 },
  { 150, 3, 5, 4, 1, -5 },
  { 152, 4, 4, 4, 0, -4 },
  { 154, 4, 5, 4, 0, -5 },
  { 157, 4, 4, 4, 0, -4 },
  { 159, 4, 5, 4, 0, -5 },
  { 162, 4, 5, 4, 0, -4 },
  { 165, 3, 5, 4, 1, -5 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 3, 6, 4, 0, -5 },
  { 173, 3, 5, 4, 1, -5 },
  { 175, 4, 5, 4, 0, -5 },
  { 178, 4, 4, 4, 0, -4 },
  { 180, 3, 4, 4, 1, -4 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 3, 5, 4, 1, -4 },
  { 186, 4, 5, 4, 0, -4 },
  { 189, 3, 4, 4, 1, -4 },
  { 191, 3, 4, 4, 1, -4 },
  { 193, 2, 5, 4, 1, -5 },
  { 195, 3, 4, 4, 1, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 4, 4, 0, -4 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 4, 5, 4, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 3, 6, 4, 1, -5 },
  { 211, 1, 6, 4, 2, -5 },
  { 212, 2, 6, 4, 1, -5 },
  { 214, 4, 1, 4, 0, -3 },
};

const GFXfont LiberationMono_Regular7pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular7pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _LIBERATIONMONO_REGULAR7PT7B_H_
