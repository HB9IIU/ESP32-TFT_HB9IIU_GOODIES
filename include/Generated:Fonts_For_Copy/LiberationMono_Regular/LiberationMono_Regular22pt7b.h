#ifndef _LIBERATIONMONO_REGULAR22PT7B_H_
#define _LIBERATIONMONO_REGULAR22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0xA0, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0x80,
  0x08, 0x40, 0x84, 0x10, 0xC1, 0x08, 0xFF, 0xF1, 0x08, 0x30, 0x82, 0x18,
  0x21, 0x0F, 0xFE, 0x21, 0x06, 0x30, 0x42, 0x04, 0x20, 0x04, 0x00, 0x80,
  0xFE, 0x32, 0x6C, 0x47, 0x88, 0xD1, 0x03, 0xA0, 0x1F, 0x00, 0xB8, 0x11,
  0x82, 0x3C, 0x47, 0x88, 0xD9, 0x39, 0xFC, 0x04, 0x00, 0x80, 0x78, 0x36,
  0x61, 0x31, 0x19, 0x89, 0x8C, 0x48, 0x66, 0x81, 0xEC, 0x00, 0xDE, 0x05,
  0x98, 0x6C, 0x46, 0x62, 0x23, 0x12, 0x19, 0xB0, 0x78, 0x0F, 0x80, 0xC6,
  0x04, 0x30, 0x21, 0x81, 0x98, 0x0F, 0x80, 0x70, 0xC7, 0x84, 0x66, 0x62,
  0x1B, 0x30, 0x70, 0x81, 0x86, 0x1E, 0x1F, 0x1C, 0xFD, 0xB6, 0x90, 0x18,
  0xC3, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61,
  0x83, 0x0C, 0x18, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x60, 0xC6,
  0x18, 0x61, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0x10, 0x10, 0x92, 0xFE, 0x18,
  0x28, 0x6C, 0x44, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x77, 0x66, 0xCC, 0x80, 0xFF,
  0xF0, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x00, 0x1F, 0x06, 0x31, 0x83, 0x30, 0x24, 0x07, 0x80, 0xF3, 0x9E, 0x73,
  0xCE, 0x68, 0x0D, 0x83, 0x30, 0x63, 0x18, 0x3E, 0x00, 0x0C, 0x0F, 0x0E,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xF0, 0x3E, 0x18, 0xEC, 0x1B, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0xF0, 0x1F, 0x06, 0x19,
  0x83, 0x30, 0x60, 0x0C, 0x03, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x0F, 0x01,
  0xB0, 0x77, 0x0C, 0x3E, 0x00, 0x01, 0x80, 0x70, 0x1E, 0x06, 0xC0, 0x98,
  0x23, 0x0C, 0x63, 0x0C, 0xC1, 0x9F, 0xFC, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0xCC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xDE, 0x1C, 0x73, 0x06,
  0x00, 0x60, 0x0F, 0x01, 0xB0, 0x67, 0x1C, 0x3E, 0x00, 0x1F, 0x18, 0x66,
  0x1B, 0x00, 0xC0, 0x37, 0xCE, 0x1B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x06,
  0x63, 0x87, 0x80, 0xFF, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0x1F, 0x06, 0x39, 0x83, 0x30,
  0x66, 0x0C, 0x63, 0x87, 0xC3, 0x86, 0x60, 0xD8, 0x0F, 0x01, 0xB0, 0x67,
  0x0C, 0x3E, 0x00, 0x3E, 0x18, 0xCC, 0x1B, 0x06, 0x80, 0xF0, 0x3C, 0x1D,
  0x8B, 0x3C, 0xC0, 0x60, 0x1B, 0x06, 0xE3, 0x0F, 0x80, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x77, 0x70, 0x00, 0x00, 0x07, 0x76, 0x6C, 0xC8, 0x00, 0x20,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x70, 0x38, 0x18, 0x0C, 0x02, 0x00,
  0x00, 0x1F, 0x0F, 0xF9, 0x83, 0x60, 0x7C, 0x04, 0x01, 0x80, 0x60, 0x38,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x80, 0xC3,
  0x04, 0x08, 0x40, 0x26, 0x75, 0x36, 0x6D, 0x23, 0x6B, 0x1B, 0x58, 0xDE,
  0x86, 0xF4, 0x26, 0xA1, 0x25, 0x99, 0x2C, 0xD9, 0x3B, 0x8C, 0x00, 0x20,
  0x20, 0xC3, 0x03, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x60, 0x1B, 0x00, 0xCC,
  0x0C, 0x60, 0x61, 0x02, 0x0C, 0x3F, 0xE1, 0x01, 0x18, 0x0C, 0xC0, 0x66,
  0x01, 0xE0, 0x0C, 0xFE, 0x30, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0xEF, 0xE3,
  0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xBF, 0xC0, 0x1F, 0x06, 0x19,
  0x81, 0xB0, 0x3E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x81,
  0xB0, 0x33, 0x0C, 0x3F, 0x00, 0xFC, 0x30, 0xCC, 0x1B, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0x3F, 0x80, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFB, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0F, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F,
  0x06, 0x19, 0x83, 0x30, 0x3E, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xC0, 0x7C,
  0x0D, 0x81, 0xB0, 0x33, 0x0E, 0x3F, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xFF,
  0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC7, 0xFC, 0x1F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xF0, 0x78, 0x66, 0x31, 0xF0, 0xC1, 0xD8, 0x33, 0x0C, 0x63,
  0x0C, 0xC1, 0xB0, 0x3E, 0x07, 0x60, 0xCE, 0x18, 0xE3, 0x0C, 0x60, 0xCC,
  0x0D, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFC, 0xE0, 0xFE, 0x1F, 0xC7, 0xE8,
  0xFD, 0x97, 0xB6, 0xF3, 0x9E, 0x73, 0xC6, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xC0, 0xC0, 0xF0, 0x78, 0x3E, 0x1F, 0x0E, 0xC7, 0x63, 0x99,
  0xCC, 0xE3, 0x71, 0xB8, 0x7C, 0x3E, 0x0C, 0x1F, 0x06, 0x31, 0x83, 0x30,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x81, 0xB0, 0x63,
  0x18, 0x3E, 0x00, 0xFF, 0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B,
  0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0x06, 0x31,
  0x83, 0x30, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x81,
  0xB0, 0x63, 0x18, 0x3E, 0x01, 0x80, 0x18, 0x03, 0x00, 0x3C, 0xFF, 0x18,
  0x33, 0x03, 0x60, 0x6C, 0x0D, 0x83, 0x3F, 0xC6, 0x30, 0xC6, 0x18, 0x63,
  0x0E, 0x60, 0xCC, 0x1D, 0x81, 0x80, 0x1F, 0x8E, 0x39, 0x83, 0x30, 0x36,
  0x00, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x36, 0x0C,
  0x7F, 0x00, 0xFF, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x06, 0xE1, 0x8F, 0x80, 0xC0, 0x1B, 0x01, 0x98, 0x0C, 0xE0, 0x63, 0x06,
  0x18, 0x30, 0x61, 0x83, 0x18, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0B, 0x00,
  0x70, 0x03, 0x80, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x36, 0x31, 0x33,
  0x99, 0x94, 0xCC, 0xB6, 0x6D, 0xB1, 0x6D, 0x8A, 0x2C, 0x71, 0xC3, 0x8E,
  0x1C, 0x30, 0x60, 0x31, 0x83, 0x06, 0x38, 0x31, 0x80, 0xD8, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0D, 0x80, 0x66, 0x06, 0x30, 0x60, 0xC7, 0x03, 0x30,
  0x18, 0x60, 0x33, 0x81, 0x8C, 0x18, 0x31, 0xC1, 0x8C, 0x06, 0xC0, 0x1E,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x7F, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xFF, 0xC0, 0xFF, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC,
  0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xFC, 0x0E, 0x01, 0x40, 0x6C, 0x0C, 0x81, 0x18, 0x63, 0x08, 0x23,
  0x06, 0x60, 0xC8, 0x0C, 0xFF, 0xF8, 0x61, 0x86, 0x1F, 0x0E, 0x31, 0x83,
  0x00, 0x60, 0x0C, 0x7F, 0x9C, 0x33, 0x06, 0xC0, 0xD8, 0x39, 0x8B, 0x1E,
  0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xDF, 0x38, 0x6E, 0x1B, 0x02, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB0, 0x6E, 0x3B, 0x7C, 0x1F, 0x06, 0x31,
  0x83, 0x30, 0x7C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0xEC, 0x18, 0xC7,
  0x0F, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x1E, 0xCC, 0x76, 0x0D, 0x83,
  0x60, 0xF0, 0x3C, 0x0D, 0x83, 0x60, 0xD8, 0x37, 0x1C, 0x7B, 0x1F, 0x06,
  0x39, 0x83, 0x30, 0x26, 0x07, 0xFF, 0xF0, 0x03, 0x00, 0x60, 0x4C, 0x18,
  0xC6, 0x0F, 0x80, 0x07, 0xE1, 0x80, 0x60, 0x0C, 0x0F, 0xFE, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x3D, 0xB1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF8, 0xE7, 0xB0, 0x18, 0x0F, 0x06, 0xC6, 0x3E, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x0D, 0xF7, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x03,
  0x03, 0x00, 0x00, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0xFC, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x34, 0x32, 0x39, 0x18, 0x98, 0x58, 0x3E, 0x11, 0x88, 0xE4, 0x32,
  0x0D, 0x07, 0x3E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x87, 0xFF,
  0xD9, 0xDD, 0xCF, 0x19, 0xE3, 0x3C, 0x67, 0x8C, 0xF1, 0x9E, 0x33, 0xC6,
  0x78, 0xCF, 0x19, 0xE3, 0x30, 0xDF, 0x70, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1F, 0x06, 0x39, 0x83, 0x30,
  0x3E, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x60, 0xCC, 0x18, 0xC6, 0x0F, 0x80,
  0xDF, 0x38, 0x6E, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xB0,
  0x6E, 0x1B, 0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0xCC,
  0x76, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0D, 0x83, 0x60, 0xD8, 0x33, 0x1C,
  0x7B, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xCF, 0xD0, 0xE0, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x30, 0xF0, 0x78,
  0x0E, 0x03, 0xF0, 0x3E, 0x03, 0x00, 0xE0, 0xF0, 0x67, 0xC0, 0x30, 0x18,
  0x0C, 0x1F, 0xE3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x7E, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0xEF, 0xB0, 0xC0, 0x78, 0x0D, 0x83, 0x30, 0x67, 0x0C,
  0x63, 0x0C, 0x60, 0xD8, 0x1B, 0x03, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x1E,
  0x00, 0xD8, 0x06, 0xCE, 0x26, 0x73, 0x32, 0x99, 0x96, 0xCD, 0xB6, 0x28,
  0xB1, 0x45, 0x0E, 0x38, 0x70, 0xC0, 0x60, 0xEC, 0x18, 0xC6, 0x0D, 0x81,
  0xB0, 0x1C, 0x03, 0x80, 0xD8, 0x19, 0x86, 0x31, 0x83, 0x60, 0x30, 0xC0,
  0x78, 0x0D, 0x81, 0x30, 0x66, 0x0C, 0x61, 0x0C, 0x60, 0x88, 0x19, 0x03,
  0x60, 0x28, 0x07, 0x00, 0x40, 0x08, 0x03, 0x00, 0xC0, 0x70, 0x00, 0xFF,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x1F,
  0xF0, 0x07, 0x86, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x38, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0x78, 0xFF, 0xFF, 0xF8, 0xF0, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x03, 0x00, 0xE0, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x0F, 0x00, 0x78, 0x10, 0xC4, 0x0F, 0x00,
};

const GFXglyph LiberationMono_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 2, 14, 13, 6, -14 },
  { 5, 7, 7, 13, 3, -16 },
  { 12, 12, 14, 13, 1, -14 },
  { 33, 11, 18, 13, 1, -16 },
  { 58, 13, 14, 13, 0, -14 },
  { 81, 13, 14, 13, 0, -14 },
  { 104, 3, 7, 13, 5, -16 },
  { 107, 6, 21, 13, 4, -16 },
  { 123, 6, 21, 13, 4, -16 },
  { 139, 8, 8, 13, 3, -16 },
  { 147, 11, 11, 13, 1, -13 },
  { 163, 4, 7, 13, 3, -3 },
  { 167, 6, 2, 13, 4, -7 },
  { 169, 3, 3, 13, 5, -3 },
  { 171, 11, 16, 13, 1, -16 },
  { 193, 11, 14, 13, 1, -14 },
  { 213, 10, 14, 13, 2, -14 },
  { 231, 10, 14, 13, 2, -14 },
  { 249, 11, 14, 13, 1, -14 },
  { 269, 11, 14, 13, 1, -14 },
  { 289, 11, 14, 13, 1, -14 },
  { 309, 10, 14, 13, 2, -14 },
  { 327, 9, 14, 13, 2, -14 },
  { 343, 11, 14, 13, 1, -14 },
  { 363, 10, 14, 13, 2, -14 },
  { 381, 3, 12, 13, 5, -12 },
  { 386, 4, 16, 13, 4, -12 },
  { 394, 11, 11, 13, 1, -13 },
  { 410, 11, 5, 13, 1, -10 },
  { 417, 11, 11, 13, 1, -13 },
  { 433, 11, 14, 13, 1, -14 },
  { 453, 13, 19, 13, 0, -16 },
  { 484, 13, 14, 13, 0, -14 },
  { 507, 10, 14, 13, 2, -14 },
  { 525, 11, 14, 13, 1, -14 },
  { 545, 10, 14, 13, 2, -14 },
  { 563, 10, 14, 13, 2, -14 },
  { 581, 10, 14, 13, 2, -14 },
  { 599, 11, 14, 13, 1, -14 },
  { 619, 9, 14, 13, 2, -14 },
  { 635, 9, 14, 13, 2, -14 },
  { 651, 9, 14, 13, 2, -14 },
  { 667, 11, 14, 13, 2, -14 },
  { 687, 9, 14, 13, 3, -14 },
  { 703, 11, 14, 13, 1, -14 },
  { 723, 9, 14, 13, 2, -14 },
  { 739, 11, 14, 13, 1, -14 },
  { 759, 10, 14, 13, 2, -14 },
  { 777, 11, 18, 13, 1, -14 },
  { 802, 11, 14, 13, 2, -14 },
  { 822, 11, 14, 13, 1, -14 },
  { 842, 11, 14, 13, 1, -14 },
  { 862, 10, 14, 13, 2, -14 },
  { 880, 13, 14, 13, 0, -14 },
  { 903, 13, 14, 13, 0, -14 },
  { 926, 13, 14, 13, 0, -14 },
  { 949, 13, 14, 13, 0, -14 },
  { 972, 11, 14, 13, 1, -14 },
  { 992, 6, 21, 13, 4, -16 },
  { 1008, 11, 16, 13, 1, -16 },
  { 1030, 6, 21, 13, 3, -16 },
  { 1046, 11, 10, 13, 1, -14 },
  { 1060, 13, 1, 13, 0, 1 },
  { 1062, 5, 3, 13, 4, -16 },
  { 1064, 11, 12, 13, 1, -12 },
  { 1081, 10, 16, 13, 2, -16 },
  { 1101, 11, 12, 13, 1, -12 },
  { 1118, 10, 16, 13, 1, -16 },
  { 1138, 11, 12, 13, 1, -12 },
  { 1155, 11, 16, 13, 1, -16 },
  { 1177, 9, 17, 13, 2, -12 },
  { 1197, 9, 16, 13, 2, -16 },
  { 1215, 10, 16, 13, 2, -16 },
  { 1235, 8, 21, 13, 1, -16 },
  { 1256, 9, 16, 13, 3, -16 },
  { 1274, 11, 16, 13, 1, -16 },
  { 1296, 11, 12, 13, 1, -12 },
  { 1313, 9, 12, 13, 2, -12 },
  { 1327, 11, 12, 13, 1, -12 },
  { 1344, 10, 17, 13, 2, -12 },
  { 1366, 10, 17, 13, 1, -12 },
  { 1388, 8, 12, 13, 3, -12 },
  { 1400, 9, 12, 13, 2, -12 },
  { 1414, 9, 15, 13, 2, -15 },
  { 1431, 9, 12, 13, 2, -12 },
  { 1445, 11, 12, 13, 1, -12 },
  { 1462, 13, 12, 13, 0, -12 },
  { 1482, 11, 12, 13, 1, -12 },
  { 1499, 11, 17, 13, 1, -12 },
  { 1523, 9, 12, 13, 2, -12 },
  { 1537, 9, 21, 13, 2, -16 },
  { 1561, 1, 21, 13, 6, -16 },
  { 1564, 9, 21, 13, 2, -16 },
  { 1588, 11, 3, 13, 1, -9 },
};

const GFXfont LiberationMono_Regular22pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular22pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular22pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _LIBERATIONMONO_REGULAR22PT7B_H_
