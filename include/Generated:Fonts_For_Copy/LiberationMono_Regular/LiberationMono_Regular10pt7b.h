#ifndef _LIBERATIONMONO_REGULAR10PT7B_H_
#define _LIBERATIONMONO_REGULAR10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0x99, 0x90, 0x28, 0xA7, 0xD2, 0xF9, 0x45, 0x00, 0x11, 0xE5,
  0x94, 0x78, 0x59, 0x5E, 0x10, 0xEA, 0xAF, 0x08, 0x3D, 0x55, 0xC0, 0x31,
  0x23, 0x1A, 0xAA, 0x67, 0xC0, 0xE8, 0x6A, 0xAA, 0x40, 0x95, 0x55, 0x80,
  0x2B, 0x66, 0x44, 0xF4, 0x40, 0x58, 0xC0, 0xC0, 0x11, 0x24, 0x48, 0x80,
  0x69, 0x9F, 0x99, 0x60, 0x65, 0x08, 0x42, 0x13, 0xE0, 0xF9, 0x12, 0x48,
  0xF0, 0xF9, 0x16, 0x19, 0xF0, 0x18, 0xA2, 0x92, 0xFC, 0x20, 0x80, 0xF8,
  0xF1, 0x19, 0xE0, 0x79, 0x8F, 0x99, 0x70, 0xF1, 0x22, 0x44, 0x40, 0xF9,
  0x96, 0x99, 0xF0, 0xE9, 0x9F, 0x19, 0xE0, 0xC0, 0xC0, 0xC0, 0xE8, 0x1E,
  0x8E, 0x10, 0xF0, 0xF0, 0x87, 0x17, 0x80, 0x7A, 0x42, 0x22, 0x00, 0x80,
  0x39, 0x18, 0x6F, 0xD6, 0xA8, 0x12, 0x70, 0x30, 0xC2, 0x92, 0x7A, 0x18,
  0x40, 0xF4, 0xA5, 0xC9, 0xC7, 0xC0, 0x74, 0xA1, 0x08, 0x49, 0xC0, 0xE4,
  0xA5, 0x19, 0x4B, 0x80, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80,
  0x79, 0x8B, 0x99, 0x70, 0x99, 0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0,
  0x71, 0x11, 0x19, 0xE0, 0x95, 0x29, 0xCA, 0x4A, 0x20, 0x88, 0x88, 0x88,
  0xF0, 0x99, 0xFF, 0xB9, 0x90, 0x9D, 0xDD, 0xBB, 0x90, 0x79, 0x24, 0xA1,
  0x49, 0x23, 0x00, 0xF9, 0x9F, 0x88, 0x80, 0x79, 0x24, 0xA1, 0x49, 0x27,
  0x04, 0x1C, 0xF4, 0xA5, 0xEA, 0x4A, 0x40, 0x79, 0x24, 0x0E, 0x0B, 0x27,
  0x80, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x00, 0x99, 0x99, 0x99, 0xF0, 0x85,
  0x24, 0x92, 0x30, 0xC3, 0x00, 0x86, 0x1B, 0x6D, 0x79, 0x24, 0x80, 0x49,
  0x23, 0x0C, 0x31, 0x28, 0x40, 0x85, 0x23, 0x0C, 0x20, 0x82, 0x00, 0x78,
  0x21, 0x08, 0x21, 0x0F, 0xC0, 0xF2, 0x49, 0x24, 0xE0, 0x88, 0x44, 0x21,
  0x10, 0xE4, 0x92, 0x49, 0xE0, 0x66, 0x99, 0xFC, 0x90, 0xF0, 0xBD, 0x2F,
  0x80, 0x88, 0xF9, 0x99, 0xF0, 0xF8, 0x88, 0xF0, 0x11, 0xF9, 0x99, 0xF0,
  0xF9, 0xF8, 0xF0, 0x74, 0xF4, 0x44, 0x40, 0xF9, 0x99, 0xF1, 0xF0, 0x88,
  0xF9, 0x99, 0x90, 0x20, 0x38, 0x42, 0x13, 0xE0, 0x23, 0x92, 0x49, 0xE0,
  0x84, 0x25, 0x4E, 0x52, 0x40, 0xE2, 0x22, 0x22, 0xF0, 0x7C, 0xEB, 0x5A,
  0x80, 0xF9, 0x99, 0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9,
  0x99, 0xF1, 0x10, 0xBC, 0x88, 0x80, 0xF8, 0x71, 0xF0, 0x4F, 0x44, 0x47,
  0x99, 0x99, 0xF0, 0x49, 0x24, 0x8C, 0x30, 0x86, 0xDB, 0x52, 0x48, 0x48,
  0xC3, 0x0C, 0x48, 0x49, 0x24, 0x8C, 0x30, 0x86, 0x00, 0xF2, 0x48, 0xF0,
  0x34, 0x44, 0x84, 0x44, 0x30, 0xFF, 0x80, 0xC2, 0x22, 0x12, 0x22, 0xC0,
  0xC3,
};

const GFXglyph LiberationMono_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 7, 6, 3, -7 },
  { 2, 4, 3, 6, 1, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 6, 9, 6, 0, -8 },
  { 17, 6, 7, 6, 0, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 2, 3, 6, 2, -7 },
  { 30, 2, 9, 6, 2, -7 },
  { 33, 2, 9, 6, 2, -7 },
  { 36, 4, 4, 6, 1, -7 },
  { 38, 4, 5, 6, 1, -6 },
  { 41, 2, 3, 6, 1, -1 },
  { 42, 2, 1, 6, 2, -3 },
  { 43, 2, 1, 6, 2, -1 },
  { 44, 4, 7, 6, 1, -7 },
  { 48, 4, 7, 6, 1, -7 },
  { 52, 5, 7, 6, 1, -7 },
  { 57, 4, 7, 6, 1, -7 },
  { 61, 4, 7, 6, 1, -7 },
  { 65, 6, 7, 6, 0, -7 },
  { 71, 4, 7, 6, 1, -7 },
  { 75, 4, 7, 6, 1, -7 },
  { 79, 4, 7, 6, 1, -7 },
  { 83, 4, 7, 6, 1, -7 },
  { 87, 4, 7, 6, 1, -7 },
  { 91, 2, 5, 6, 2, -5 },
  { 93, 2, 7, 6, 2, -5 },
  { 95, 4, 5, 6, 1, -6 },
  { 98, 4, 3, 6, 1, -5 },
  { 100, 4, 5, 6, 1, -6 },
  { 103, 5, 7, 6, 0, -7 },
  { 108, 6, 9, 6, 0, -7 },
  { 115, 6, 7, 6, 0, -7 },
  { 121, 5, 7, 6, 1, -7 },
  { 126, 5, 7, 6, 1, -7 },
  { 131, 5, 7, 6, 1, -7 },
  { 136, 4, 7, 6, 1, -7 },
  { 140, 4, 7, 6, 1, -7 },
  { 144, 4, 7, 6, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 4, 7, 6, 1, -7 },
  { 156, 4, 7, 6, 1, -7 },
  { 160, 5, 7, 6, 1, -7 },
  { 165, 4, 7, 6, 1, -7 },
  { 169, 4, 7, 6, 1, -7 },
  { 173, 4, 7, 6, 1, -7 },
  { 177, 6, 7, 6, 0, -7 },
  { 183, 4, 7, 6, 1, -7 },
  { 187, 6, 9, 6, 0, -7 },
  { 194, 5, 7, 6, 1, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 6, 7, 6, 0, -7 },
  { 211, 4, 7, 6, 1, -7 },
  { 215, 6, 7, 6, 0, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 6, 7, 6, 0, -7 },
  { 233, 6, 7, 6, 0, -7 },
  { 239, 6, 7, 6, 0, -7 },
  { 245, 3, 9, 6, 2, -7 },
  { 249, 4, 7, 6, 1, -7 },
  { 253, 3, 9, 6, 1, -7 },
  { 257, 4, 4, 6, 1, -7 },
  { 259, 6, 1, 6, 0, 1 },
  { 260, 2, 2, 6, 2, -8 },
  { 261, 5, 5, 6, 1, -5 },
  { 265, 4, 7, 6, 1, -7 },
  { 269, 4, 5, 6, 1, -5 },
  { 272, 4, 7, 6, 1, -7 },
  { 276, 4, 5, 6, 1, -5 },
  { 279, 4, 7, 6, 1, -7 },
  { 283, 4, 7, 6, 1, -5 },
  { 287, 4, 7, 6, 1, -7 },
  { 291, 5, 7, 6, 1, -7 },
  { 296, 3, 9, 6, 1, -7 },
  { 300, 5, 7, 6, 1, -7 },
  { 305, 4, 7, 6, 1, -7 },
  { 309, 5, 5, 6, 0, -5 },
  { 313, 4, 5, 6, 1, -5 },
  { 316, 4, 5, 6, 1, -5 },
  { 319, 4, 7, 6, 1, -5 },
  { 323, 4, 7, 6, 1, -5 },
  { 327, 4, 5, 6, 1, -5 },
  { 330, 4, 5, 6, 1, -5 },
  { 333, 4, 6, 6, 1, -6 },
  { 336, 4, 5, 6, 1, -5 },
  { 339, 6, 5, 6, 0, -5 },
  { 343, 6, 5, 6, 0, -5 },
  { 347, 6, 5, 6, 0, -5 },
  { 351, 6, 7, 6, 0, -5 },
  { 357, 4, 5, 6, 1, -5 },
  { 360, 4, 9, 6, 1, -7 },
  { 365, 1, 9, 6, 3, -7 },
  { 367, 4, 9, 6, 1, -7 },
  { 372, 4, 2, 6, 1, -5 },
};

const GFXfont LiberationMono_Regular10pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular10pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular10pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _LIBERATIONMONO_REGULAR10PT7B_H_
