#ifndef _LIBERATIONMONO_REGULAR49PT7B_H_
#define _LIBERATIONMONO_REGULAR49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70,
  0x1E, 0x70, 0x1E, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x01, 0xC0,
  0x18, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00,
  0x18, 0x03, 0x80, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x0F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x60, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFC, 0x71, 0xFC, 0x7C, 0x1C, 0x1F, 0x1F, 0x07, 0x03, 0xE7,
  0x81, 0xC0, 0xE1, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1F, 0x07, 0x00,
  0x03, 0xE1, 0xC0, 0x00, 0xFE, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0x0F, 0xC0, 0x01, 0xC0, 0xF8, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07,
  0x80, 0x07, 0x01, 0xE7, 0x01, 0xC0, 0x7F, 0xC0, 0x70, 0x1E, 0xF8, 0x1C,
  0x07, 0xBF, 0x07, 0x03, 0xE7, 0xF1, 0xC3, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0xE1, 0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x00, 0xF0, 0xF0, 0xF0, 0x07,
  0x0F, 0x03, 0x80, 0x78, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x83, 0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x81, 0xE3, 0xC0, 0x3C, 0x0F,
  0x1C, 0x01, 0xE0, 0x71, 0xE0, 0x07, 0x87, 0x9E, 0x00, 0x3F, 0xF8, 0xE0,
  0x00, 0xFF, 0x8F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x07, 0x0F, 0xC0,
  0x00, 0x71, 0xFF, 0x00, 0x07, 0x9F, 0xFC, 0x00, 0x39, 0xF1, 0xF0, 0x03,
  0x8F, 0x07, 0x80, 0x3C, 0x70, 0x1C, 0x03, 0xC3, 0x80, 0xE0, 0x1C, 0x1C,
  0x07, 0x01, 0xE0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x0E, 0x01, 0xE0, 0xF0, 0xF0, 0x0F, 0x8F, 0x87, 0x00, 0x3F, 0xF8, 0x70,
  0x00, 0xFF, 0x87, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0x70, 0x1E, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xE7, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0x80, 0x7F, 0x80, 0x3C,
  0x1F, 0xF8, 0x07, 0x07, 0xCF, 0x01, 0xE1, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F,
  0x07, 0x8F, 0x81, 0xE1, 0xE1, 0xE0, 0x1E, 0x3C, 0x3C, 0x01, 0xE7, 0x07,
  0x80, 0x3F, 0xE0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x3F, 0x01, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0xFE, 0x03, 0xE0, 0x7F, 0xFA, 0x7F, 0xFF, 0x3F, 0xC3,
  0xFF, 0xC3, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B,
  0xDE, 0xF7, 0xB9, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C, 0x1F, 0x8E, 0x3F, 0xF7,
  0x7E, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xEE, 0x00,
  0xF3, 0x80, 0xF1, 0xE0, 0x78, 0x70, 0x78, 0x3C, 0x08, 0x08, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0x87,
  0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8,
  0x3F, 0xC1, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0xF8, 0x03, 0xE0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xF7, 0xC0, 0x3F, 0xCF,
  0x80, 0x7E, 0x1F, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xF8, 0x1F, 0xC7, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87,
  0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x7D,
  0xF8, 0x01, 0xF9, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE3, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xF8, 0x03, 0xE3, 0xC0, 0x0F,
  0x9E, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x1F, 0xC0, 0xF1, 0xFF, 0xC3, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xC0,
  0xFE, 0xFC, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78,
  0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xE0, 0xFE, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xC1,
  0xF0, 0x1F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x7E, 0x03, 0xF1, 0xF0, 0x01, 0xF3, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x3F, 0x83, 0xFE, 0x3F, 0xFF,
  0xBC, 0x7F, 0xFE, 0x78, 0x3F, 0xF9, 0xF0, 0x1F, 0xC3, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x7C, 0xF8, 0x01, 0xF0,
  0xF8, 0x07, 0xE1, 0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC7,
  0x81, 0xE0, 0x38, 0xE0, 0xFF, 0x37, 0x9C, 0x3C, 0x6E, 0x77, 0x87, 0x07,
  0xCE, 0xE1, 0xC0, 0xF9, 0xDC, 0x38, 0x1F, 0x3B, 0x8E, 0x03, 0xC7, 0x71,
  0xC0, 0x38, 0x7C, 0x78, 0x0F, 0x0F, 0x8E, 0x01, 0xE1, 0xF1, 0xC0, 0x3C,
  0x7E, 0x38, 0x07, 0x0F, 0xC7, 0x00, 0xE1, 0xF8, 0xE0, 0x1C, 0x3F, 0x1C,
  0x03, 0x87, 0xE3, 0x80, 0xF0, 0xFC, 0x70, 0x1E, 0x1F, 0x8E, 0x03, 0x83,
  0x71, 0xC0, 0xF0, 0xEF, 0x38, 0x1E, 0x1C, 0xE7, 0x86, 0xC7, 0x1C, 0x71,
  0x98, 0xC3, 0x87, 0xF3, 0xF8, 0x78, 0x78, 0x3C, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x01, 0xE0, 0x00, 0xE0, 0x1F, 0x00,
  0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF0,
  0x03, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0,
  0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7E, 0xF0, 0x01, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFC, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x18, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x7C, 0x00, 0x0F, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0x01,
  0xFF, 0x1E, 0x00, 0x7E, 0x3C, 0x00, 0x7E, 0x78, 0x00, 0x7C, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0,
  0x03, 0xF3, 0xC0, 0x0F, 0xC7, 0x80, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x0F, 0xBE,
  0x00, 0x0F, 0x7C, 0x00, 0x19, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBE, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xFC, 0x00, 0x78, 0xFE, 0x07, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x38, 0x01, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3F, 0x07, 0x80,
  0x3F, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x78,
  0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xCF, 0xC0, 0x01, 0xEF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xBE, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x81, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0xC0, 0xF0, 0x03,
  0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFD, 0xC0, 0x7F, 0xFB, 0xC0, 0xFF, 0xF7, 0x81, 0xDF, 0xEF, 0x07, 0xBF,
  0xCF, 0x0F, 0x7F, 0x9E, 0x1C, 0xFF, 0x1C, 0x79, 0xFE, 0x3C, 0xF3, 0xFC,
  0x79, 0xC7, 0xF8, 0x77, 0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC1,
  0xF8, 0x7F, 0x83, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFD, 0xE0,
  0x1F, 0xF7, 0x80, 0x7F, 0xCF, 0x01, 0xFF, 0x3C, 0x07, 0xFC, 0xF8, 0x1F,
  0xF1, 0xE0, 0x7F, 0xC7, 0xC1, 0xFF, 0x0F, 0x07, 0xFC, 0x3C, 0x1F, 0xF0,
  0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x03, 0xC7, 0xFC, 0x0F, 0x1F, 0xF0, 0x1E,
  0x7F, 0xC0, 0x79, 0xFF, 0x00, 0xF7, 0xFC, 0x03, 0xDF, 0xF0, 0x07, 0xBF,
  0xC0, 0x1E, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xF8,
  0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xF8, 0x3F, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x00,
  0x3F, 0x9E, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x3F, 0x78, 0x01, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xF8,
  0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xF8, 0x3F, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0, 0x01,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xDF, 0x80, 0x07, 0xCF, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x0F,
  0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x8F, 0x03, 0xE0, 0x3C,
  0x78, 0x1F, 0x03, 0xE3, 0xC0, 0xFC, 0x1E, 0x1E, 0x07, 0xE0, 0xF0, 0xF0,
  0x7F, 0x07, 0x87, 0xC3, 0xB8, 0x3C, 0x1E, 0x1D, 0xE1, 0xE0, 0xF0, 0xE7,
  0x0F, 0x07, 0x8F, 0x38, 0x70, 0x3C, 0x71, 0xC7, 0x81, 0xE3, 0x8F, 0x3C,
  0x0F, 0x3C, 0x79, 0xE0, 0x39, 0xE1, 0xCF, 0x01, 0xEE, 0x0E, 0x78, 0x0F,
  0x70, 0x7B, 0xC0, 0x7F, 0x81, 0xDC, 0x03, 0xFC, 0x0E, 0xE0, 0x1F, 0xC0,
  0x77, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x1C, 0x07, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x70,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x03, 0xC1,
  0xF0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83, 0xC0, 0x3B,
  0xC1, 0xF8, 0x39, 0xF0, 0x7F, 0xF8, 0xFF, 0x1F, 0xF8, 0x3F, 0x87, 0xF0,
  0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x87, 0xF0, 0x3E, 0x7F, 0xF0, 0xFB,
  0xFF, 0xE3, 0xFE, 0x0F, 0xCF, 0xE0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00,
  0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xEF, 0xC0, 0x0F, 0xBF, 0x80, 0x7C, 0xFF, 0x83, 0xF3, 0xEF, 0xFF, 0x8F,
  0x9F, 0xFC, 0x3E, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0xC7, 0x80, 0x0F, 0x9F, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFB,
  0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xE0, 0x7E, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x3F, 0x83, 0xC3, 0xFF, 0x8F, 0x1F, 0xFF, 0x3C, 0xFC, 0x0E, 0xF3, 0xE0,
  0x1F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x6F,
  0x3F, 0x03, 0xBC, 0x7F, 0xFC, 0xF0, 0xFF, 0xE3, 0xC0, 0xFE, 0x0F, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0,
  0x0F, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xC3, 0xE0, 0x03, 0xC7,
  0xC0, 0x0F, 0x87, 0xE0, 0x7E, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x3C, 0x3F, 0xF8, 0xF1, 0xFF, 0xF3, 0xC7, 0xC1, 0xEF, 0x3E, 0x01, 0xFC,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0x80, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFC, 0xF8, 0x07, 0xF3, 0xF0,
  0x7B, 0xC7, 0xFF, 0xCF, 0x0F, 0xFE, 0x3C, 0x0F, 0xE0, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0x87,
  0xC0, 0x3E, 0x1F, 0x81, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x1F, 0xC1, 0xF3, 0xFF, 0x8F, 0xBF, 0xFE, 0x7F,
  0xC1, 0xFB, 0xF8, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xA0, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x00, 0x7C,
  0x78, 0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x83,
  0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x7B, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xC7, 0xC0, 0x3C, 0x1F,
  0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x1E,
  0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x7D, 0xE0, 0x01,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF0, 0x7C, 0x79, 0xFC, 0x7F, 0x3D, 0xFE, 0x7F, 0xDE, 0xCF,
  0xF1, 0xEF, 0xC3, 0xF0, 0xFB, 0xC1, 0xF0, 0x3D, 0xE0, 0x78, 0x1E, 0xF0,
  0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xDE, 0x07, 0x81, 0xEF,
  0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x7B, 0xC0, 0xF0, 0x3D, 0xE0, 0x78, 0x1E,
  0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xDE, 0x07, 0x81,
  0xEF, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x7B, 0xC0, 0xF0, 0x3D, 0xE0, 0x78,
  0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0x07, 0x8F, 0xFE, 0x3C, 0xFF, 0xF9, 0xFF, 0x07, 0xEF, 0xE0, 0x1F,
  0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0x80,
  0x0F, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x07,
  0xE0, 0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xF8,
  0x7F, 0x03, 0xE7, 0xFF, 0x0F, 0xBF, 0xFE, 0x3E, 0xE0, 0xFC, 0xFE, 0x00,
  0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x07, 0xBF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1E, 0xFC, 0x00, 0xFB, 0xF8, 0x07, 0xCF,
  0xF8, 0x3F, 0x3E, 0xFF, 0xF8, 0xF9, 0xFF, 0xC3, 0xE1, 0xFC, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF8, 0x3C, 0x3F, 0xF8, 0xF1, 0xFF, 0xF3, 0xCF, 0xC0,
  0xEF, 0x3E, 0x01, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F,
  0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFC,
  0xF8, 0x06, 0xF3, 0xF0, 0x3B, 0xC7, 0xFF, 0xCF, 0x0F, 0xFE, 0x3C, 0x0F,
  0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFF, 0xF7, 0xBE, 0x00, 0xF7, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF8, 0x7C, 0x07, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x7D, 0xE0,
  0x01, 0xEF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xBC, 0x00, 0x7D, 0xF8, 0x07, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF8, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x41, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0xBE, 0x01, 0xFD, 0xF8, 0x1D, 0xE7,
  0xFF, 0xCF, 0x1F, 0xFC, 0x78, 0x3F, 0x83, 0xC0, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x00,
  0x3C, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x81,
  0xF0, 0x3E, 0x3C, 0x0F, 0x81, 0xE1, 0xE0, 0x7E, 0x0F, 0x0F, 0x07, 0x70,
  0x78, 0x7C, 0x3B, 0x83, 0xC1, 0xE1, 0xDE, 0x1E, 0x0F, 0x1E, 0x71, 0xF0,
  0x78, 0xE3, 0x8F, 0x03, 0xC7, 0x1E, 0x78, 0x1E, 0x78, 0x73, 0xC0, 0xF3,
  0x83, 0x9E, 0x03, 0x9C, 0x1C, 0xF0, 0x1E, 0xE0, 0x77, 0x80, 0xFE, 0x03,
  0xB8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0x83, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF8,
  0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xF8,
};

const GFXglyph LiberationMono_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 5, 32, 29, 12, -32 },
  { 21, 16, 15, 29, 7, -36 },
  { 51, 27, 32, 29, 1, -32 },
  { 159, 26, 39, 29, 2, -35 },
  { 286, 29, 32, 29, 0, -32 },
  { 402, 27, 32, 29, 1, -32 },
  { 510, 5, 15, 29, 12, -36 },
  { 520, 13, 46, 29, 8, -36 },
  { 595, 13, 46, 29, 8, -36 },
  { 670, 17, 17, 29, 6, -36 },
  { 707, 24, 24, 29, 3, -28 },
  { 779, 11, 16, 29, 6, -7 },
  { 801, 13, 4, 29, 8, -15 },
  { 808, 5, 7, 29, 12, -7 },
  { 813, 24, 36, 29, 3, -36 },
  { 921, 23, 32, 29, 3, -32 },
  { 1013, 23, 32, 29, 4, -32 },
  { 1105, 23, 32, 29, 3, -32 },
  { 1197, 23, 32, 29, 3, -32 },
  { 1289, 25, 32, 29, 2, -32 },
  { 1389, 23, 32, 29, 3, -32 },
  { 1481, 22, 32, 29, 4, -32 },
  { 1569, 22, 32, 29, 4, -32 },
  { 1657, 23, 32, 29, 3, -32 },
  { 1749, 23, 32, 29, 3, -32 },
  { 1841, 5, 26, 29, 12, -26 },
  { 1858, 11, 35, 29, 8, -26 },
  { 1907, 24, 25, 29, 3, -29 },
  { 1982, 24, 16, 29, 3, -24 },
  { 2030, 24, 25, 29, 3, -29 },
  { 2105, 24, 32, 29, 2, -32 },
  { 2201, 27, 42, 29, 1, -36 },
  { 2343, 29, 32, 29, 0, -32 },
  { 2459, 24, 32, 29, 4, -32 },
  { 2555, 24, 32, 29, 3, -32 },
  { 2651, 23, 32, 29, 4, -32 },
  { 2743, 23, 32, 29, 4, -32 },
  { 2835, 21, 32, 29, 5, -32 },
  { 2919, 23, 32, 29, 3, -32 },
  { 3011, 22, 32, 29, 4, -32 },
  { 3099, 20, 32, 29, 5, -32 },
  { 3179, 20, 32, 29, 4, -32 },
  { 3259, 25, 32, 29, 4, -32 },
  { 3359, 20, 32, 29, 6, -32 },
  { 3439, 23, 32, 29, 3, -32 },
  { 3531, 22, 32, 29, 4, -32 },
  { 3619, 25, 32, 29, 2, -32 },
  { 3719, 23, 32, 29, 4, -32 },
  { 3811, 25, 41, 29, 2, -32 },
  { 3940, 24, 32, 29, 4, -32 },
  { 4036, 25, 32, 29, 2, -32 },
  { 4136, 26, 32, 29, 2, -32 },
  { 4240, 23, 32, 29, 3, -32 },
  { 4332, 29, 32, 29, 0, -32 },
  { 4448, 29, 32, 29, 0, -32 },
  { 4564, 28, 32, 29, 1, -32 },
  { 4676, 28, 32, 29, 1, -32 },
  { 4788, 26, 32, 29, 2, -32 },
  { 4892, 13, 46, 29, 10, -36 },
  { 4967, 24, 36, 29, 3, -36 },
  { 5075, 14, 46, 29, 6, -36 },
  { 5156, 23, 22, 29, 3, -32 },
  { 5220, 30, 2, 29, 0, 3 },
  { 5228, 10, 6, 29, 10, -35 },
  { 5236, 25, 26, 29, 3, -26 },
  { 5318, 22, 36, 29, 4, -36 },
  { 5417, 23, 26, 29, 3, -26 },
  { 5492, 22, 36, 29, 3, -36 },
  { 5591, 23, 26, 29, 3, -26 },
  { 5666, 23, 36, 29, 3, -36 },
  { 5770, 22, 36, 29, 3, -26 },
  { 5869, 21, 36, 29, 4, -36 },
  { 5964, 24, 36, 29, 3, -36 },
  { 6072, 17, 46, 29, 3, -36 },
  { 6170, 21, 36, 29, 6, -36 },
  { 6265, 24, 36, 29, 3, -36 },
  { 6373, 25, 26, 29, 2, -26 },
  { 6455, 21, 26, 29, 4, -26 },
  { 6524, 23, 26, 29, 3, -26 },
  { 6599, 22, 36, 29, 4, -26 },
  { 6698, 22, 36, 29, 3, -26 },
  { 6797, 19, 26, 29, 6, -26 },
  { 6859, 21, 26, 29, 4, -26 },
  { 6928, 19, 33, 29, 5, -33 },
  { 7007, 21, 26, 29, 4, -26 },
  { 7076, 26, 26, 29, 2, -26 },
  { 7161, 29, 26, 29, 0, -26 },
  { 7256, 25, 26, 29, 2, -26 },
  { 7338, 26, 36, 29, 2, -26 },
  { 7455, 22, 26, 29, 4, -26 },
  { 7527, 20, 46, 29, 5, -36 },
  { 7642, 4, 46, 29, 13, -36 },
  { 7665, 20, 46, 29, 4, -36 },
  { 7780, 24, 6, 29, 3, -19 },
};

const GFXfont LiberationMono_Regular49pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular49pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular49pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _LIBERATIONMONO_REGULAR49PT7B_H_
