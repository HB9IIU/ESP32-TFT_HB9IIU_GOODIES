#ifndef _LIBERATIONMONO_REGULAR72PT7B_H_
#define _LIBERATIONMONO_REGULAR72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF,
  0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xC3, 0xC7, 0xFE, 0x03, 0xFC, 0x0F, 0x07, 0xFC, 0x1F, 0xC0,
  0x3C, 0x07, 0xF0, 0x7E, 0x00, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xC0, 0x3F,
  0x87, 0xE0, 0x0F, 0x00, 0x7E, 0x1F, 0x80, 0x3C, 0x01, 0xC0, 0x7E, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x00, 0xFF, 0x83,
  0xC0, 0x00, 0x01, 0xFF, 0xCF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xC7, 0xFE, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00, 0x3C,
  0x07, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x03, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0x00, 0x3F, 0x7E,
  0x00, 0x3C, 0x00, 0xFD, 0xF8, 0x00, 0xF0, 0x03, 0xF7, 0xF0, 0x03, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0x00, 0x7F, 0x3F, 0xC0, 0x3C, 0x03, 0xF8, 0x7F,
  0x80, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0xFC,
  0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x7F, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x87, 0xFF,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x01, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC0,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xE1, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x7D, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0xCF, 0xC0, 0x03, 0xE0, 0x3F,
  0x87, 0xE0, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xDF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x3C, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x3C, 0x02, 0x7C, 0x1E, 0x0F, 0x7F,
  0x8F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F,
  0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0E, 0x00, 0xE0, 0x02, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xE0,
  0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xF0, 0x3F, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0xFE, 0xFC,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF7,
  0xE0, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0x80, 0x03, 0xFF,
  0x83, 0xF0, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0xFF, 0xF8, 0x03, 0xF7, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0x80, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x7F, 0x80, 0x07, 0xE0, 0xFF, 0xFC, 0x01, 0xF8, 0xFF, 0xFF,
  0x80, 0x7E, 0x7F, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xC7,
  0xFE, 0x07, 0xF7, 0xE1, 0xFF, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xF1, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x38, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xFF, 0x8F, 0x3C,
  0x3E, 0x01, 0xFF, 0xCF, 0x3E, 0x3E, 0x03, 0xFF, 0xCF, 0x3E, 0x3C, 0x07,
  0xE1, 0xEF, 0x1E, 0x3C, 0x0F, 0x80, 0xFF, 0x1E, 0x7C, 0x1F, 0x80, 0xFE,
  0x1E, 0x7C, 0x1F, 0x00, 0x7E, 0x1E, 0x78, 0x3E, 0x00, 0x7E, 0x1F, 0x78,
  0x3E, 0x00, 0x7E, 0x1F, 0xF8, 0x3C, 0x00, 0x7E, 0x1F, 0xF8, 0x7C, 0x00,
  0x7C, 0x0F, 0xF8, 0x7C, 0x00, 0x7C, 0x0F, 0xF0, 0x7C, 0x00, 0x7C, 0x0F,
  0xF0, 0x78, 0x00, 0x7C, 0x0F, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0xF0, 0xF8,
  0x00, 0x7C, 0x1F, 0xF0, 0xF8, 0x00, 0x78, 0x1F, 0xF0, 0xF8, 0x00, 0xF8,
  0x1F, 0xF0, 0xF8, 0x00, 0xF8, 0x1E, 0xF0, 0xF8, 0x00, 0xF8, 0x1E, 0xF0,
  0xF0, 0x00, 0xF8, 0x1E, 0xF0, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0xF0, 0x01,
  0xF0, 0x1E, 0xF0, 0xF8, 0x01, 0xF0, 0x3E, 0xF0, 0xF8, 0x01, 0xF0, 0x3C,
  0xF0, 0xF8, 0x03, 0xF0, 0x3C, 0xF0, 0xF8, 0x03, 0xF0, 0x3C, 0xF8, 0xF8,
  0x07, 0xF0, 0x78, 0xF8, 0x78, 0x07, 0xF0, 0x78, 0xF8, 0x7C, 0x0E, 0xF0,
  0xF8, 0x78, 0x7E, 0x3E, 0xF1, 0xF0, 0x78, 0x3F, 0xFC, 0xFF, 0xE0, 0x7C,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7C, 0x1F, 0xF0, 0x7F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0x00,
  0x00, 0xFF, 0x87, 0xE0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x01,
  0xFF, 0xC3, 0xF0, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0xCF, 0xC0,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xF7, 0xE0,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0x80, 0x00, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x00,
  0x60, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x07,
  0xF0, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0xC3, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0xF8, 0xFE, 0x00, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC3, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x03, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F,
  0xC7, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0xE0, 0x00, 0x03, 0xF7, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x00, 0xFF,
  0x07, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xF1, 0xF8, 0x00,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xFB,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFB, 0xE0, 0x01, 0xEF, 0xFE, 0xF8,
  0x00, 0xFB, 0xFF, 0xBF, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x1F, 0xBF, 0xF9,
  0xF8, 0x07, 0xCF, 0xFE, 0x7E, 0x01, 0xF3, 0xFF, 0x8F, 0x80, 0xFC, 0xFF,
  0xE3, 0xF0, 0x3E, 0x3F, 0xF8, 0xFC, 0x0F, 0x8F, 0xFE, 0x1F, 0x07, 0xC3,
  0xFF, 0x87, 0xE1, 0xF0, 0xFF, 0xE1, 0xF8, 0xFC, 0x3F, 0xF8, 0x3E, 0x3E,
  0x0F, 0xFE, 0x0F, 0xCF, 0x83, 0xFF, 0x81, 0xF3, 0xE0, 0xFF, 0xE0, 0x7D,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF7, 0xE0, 0x00, 0xFF, 0xEF, 0xC0, 0x01, 0xFF, 0xCF,
  0xC0, 0x03, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0x3F,
  0x00, 0x1F, 0xFE, 0x3F, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xF8, 0x7E,
  0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xC1, 0xF8,
  0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x07, 0xF0,
  0x3F, 0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x0F, 0xC1,
  0xFF, 0xE0, 0x1F, 0x83, 0xFF, 0xC0, 0x1F, 0x87, 0xFF, 0x80, 0x3F, 0x0F,
  0xFF, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x7E, 0x7F,
  0xF8, 0x00, 0xFC, 0x7F, 0xF0, 0x00, 0xFC, 0xFF, 0xE0, 0x01, 0xF9, 0xFF,
  0xC0, 0x01, 0xFB, 0xFF, 0x80, 0x03, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x7F,
  0xF3, 0xF0, 0x00, 0x0F, 0xF9, 0xF8, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x0F, 0xF9, 0xF8,
  0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0xC7,
  0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x1F,
  0xE1, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x03, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xDF, 0x01, 0xF8, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x07, 0xE0,
  0xF8, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE1,
  0xF0, 0xFC, 0x01, 0xF8, 0xF8, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x07, 0xC3,
  0xE0, 0x07, 0xE3, 0xE0, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x0F, 0x9F, 0x80,
  0x1F, 0x9F, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x00, 0x3E,
  0x7C, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x1F,
  0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x0F, 0x7E, 0x03, 0xFC, 0x00, 0xFB, 0xF8, 0x0F,
  0xF8, 0x1F, 0x9F, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x0F, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xF8, 0xFE, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0x03, 0xFC, 0xFF,
  0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF,
  0x80, 0x00, 0xFE, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xE0, 0x03, 0xFC, 0xFF,
  0xF8, 0x0F, 0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE0, 0xFE,
  0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x7F,
  0x07, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xFF, 0x7F, 0x1F, 0xF0, 0x1F, 0xFF,
  0x3F, 0xC0, 0x07, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x3F, 0x80, 0x01, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFF,
  0x3F, 0xC0, 0x07, 0xFF, 0x1F, 0xF0, 0x1F, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F,
  0x0F, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xFF, 0xF0, 0x3F,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xC0, 0xFE, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF,
  0xFF, 0x3F, 0x1F, 0xF0, 0x1F, 0xBF, 0x3F, 0xC0, 0x07, 0xBF, 0x3F, 0x80,
  0x03, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x7F, 0x00,
  0x00, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x3F, 0x80,
  0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xBF, 0x1F, 0xF0, 0x1F, 0x3F, 0x1F, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xFF,
  0xF0, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x07, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x83, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xF1,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFB, 0xF0, 0x3F, 0xE7, 0xFF, 0x80, 0x1F, 0xEF,
  0xFC, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF7, 0x80, 0x3F, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0x87,
  0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3F, 0x03,
  0xE3, 0xFE, 0x07, 0xFC, 0x1F, 0x3F, 0xF8, 0x7F, 0xF0, 0xFB, 0xFF, 0xC7,
  0xFF, 0xC7, 0xDF, 0xFF, 0x3F, 0xFE, 0x3F, 0xE1, 0xFB, 0xC7, 0xF9, 0xFE,
  0x0F, 0xDC, 0x1F, 0xCF, 0xE0, 0x3F, 0xC0, 0x7E, 0x7F, 0x01, 0xFE, 0x03,
  0xF3, 0xF8, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xC0, 0x1F, 0x3F, 0x00, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x00, 0x7E, 0xFC,
  0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0x7E, 0x00,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x00, 0x7E,
  0xFC, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0x7E,
  0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x00,
  0x7E, 0xFC, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x01,
  0xF8, 0x1F, 0xFF, 0x83, 0xF0, 0xFF, 0xFF, 0x87, 0xE3, 0xFF, 0xFF, 0x8F,
  0xCF, 0xFF, 0xFF, 0x9F, 0xDF, 0x81, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0x7F,
  0xE0, 0x00, 0xFE, 0xFF, 0x80, 0x01, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x0F,
  0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xF0, 0xFE, 0xFF,
  0xFF, 0xF8, 0xFE, 0xFC, 0x0F, 0xF8, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xC0,
  0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7E, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x80,
  0x00, 0xFE, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xF8,
  0x0F, 0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xF0, 0xFE, 0x3F,
  0xFF, 0xC0, 0xFE, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF,
  0xFF, 0x7F, 0x1F, 0xF0, 0x1F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x3F, 0x80,
  0x03, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x7E, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x1F, 0xF0,
  0x1F, 0x7F, 0x0F, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F, 0x07, 0xFF,
  0xFC, 0x7F, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xEF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x7E, 0x7F, 0x80, 0x17, 0xEF, 0xC0, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0xEF, 0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFF,
  0x7F, 0x80, 0x0F, 0x7E, 0x7F, 0xC0, 0x7E, 0xFC, 0xFF, 0xFF, 0xF9, 0xF8,
  0xFF, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x87, 0xE0, 0xFF, 0xFC, 0x0F, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xDE, 0x01, 0xF8, 0x7E, 0x03, 0xEF, 0x80, 0xFC, 0x1F, 0x81, 0xF7, 0xC0,
  0x7E, 0x0F, 0xC0, 0xF9, 0xE0, 0x7E, 0x07, 0xE0, 0x78, 0xF8, 0x3F, 0x03,
  0xF0, 0x7C, 0x7C, 0x1F, 0x81, 0xF8, 0x3E, 0x3E, 0x0F, 0xC0, 0xFC, 0x1E,
  0x0F, 0x07, 0xE0, 0x3E, 0x1F, 0x07, 0xC3, 0xF0, 0x1F, 0x8F, 0x83, 0xE3,
  0xF0, 0x0F, 0xC7, 0xC0, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x03,
  0xF3, 0xE0, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x1F, 0x3F, 0x00, 0x7D, 0xF0,
  0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x0F, 0xBC, 0x00, 0x7B, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 7, 47, 43, 18, -47 },
  { 43, 23, 22, 43, 10, -52 },
  { 107, 39, 47, 43, 2, -47 },
  { 337, 38, 58, 43, 2, -52 },
  { 613, 43, 49, 43, 0, -48 },
  { 877, 40, 48, 43, 2, -47 },
  { 1117, 8, 22, 43, 18, -52 },
  { 1139, 19, 67, 43, 12, -52 },
  { 1299, 19, 67, 43, 12, -52 },
  { 1459, 25, 25, 43, 9, -52 },
  { 1538, 35, 35, 43, 4, -42 },
  { 1692, 15, 23, 43, 9, -11 },
  { 1736, 19, 6, 43, 12, -22 },
  { 1751, 9, 11, 43, 17, -11 },
  { 1764, 35, 53, 43, 4, -52 },
  { 1996, 35, 49, 43, 4, -48 },
  { 2211, 35, 47, 43, 5, -47 },
  { 2417, 33, 48, 43, 5, -48 },
  { 2615, 35, 49, 43, 4, -48 },
  { 2830, 36, 47, 43, 4, -47 },
  { 3042, 35, 48, 43, 4, -47 },
  { 3252, 34, 49, 43, 5, -48 },
  { 3461, 32, 47, 43, 6, -47 },
  { 3649, 33, 49, 43, 5, -48 },
  { 3852, 33, 49, 43, 5, -48 },
  { 4055, 9, 38, 43, 17, -38 },
  { 4098, 16, 50, 43, 12, -38 },
  { 4198, 35, 37, 43, 4, -42 },
  { 4360, 35, 23, 43, 4, -35 },
  { 4461, 35, 37, 43, 4, -42 },
  { 4623, 35, 48, 43, 3, -48 },
  { 4833, 40, 62, 43, 2, -52 },
  { 5143, 43, 47, 43, 0, -47 },
  { 5396, 35, 47, 43, 6, -47 },
  { 5602, 36, 49, 43, 4, -48 },
  { 5823, 34, 47, 43, 6, -47 },
  { 6023, 33, 47, 43, 6, -47 },
  { 6217, 31, 47, 43, 7, -47 },
  { 6400, 35, 49, 43, 4, -48 },
  { 6615, 31, 47, 43, 6, -47 },
  { 6798, 29, 47, 43, 7, -47 },
  { 6969, 29, 48, 43, 6, -47 },
  { 7143, 37, 47, 43, 6, -47 },
  { 7361, 31, 47, 43, 8, -47 },
  { 7544, 34, 47, 43, 5, -47 },
  { 7744, 31, 47, 43, 6, -47 },
  { 7927, 36, 49, 43, 4, -48 },
  { 8148, 33, 47, 43, 6, -47 },
  { 8342, 36, 62, 43, 4, -48 },
  { 8621, 35, 47, 43, 6, -47 },
  { 8827, 37, 49, 43, 3, -48 },
  { 9054, 38, 47, 43, 3, -47 },
  { 9278, 33, 48, 43, 5, -47 },
  { 9476, 43, 47, 43, 0, -47 },
  { 9729, 43, 47, 43, 0, -47 },
  { 9982, 41, 47, 43, 1, -47 },
  { 10223, 41, 47, 43, 1, -47 },
  { 10464, 38, 47, 43, 3, -47 },
  { 10688, 20, 67, 43, 14, -52 },
  { 10856, 35, 53, 43, 4, -52 },
  { 11088, 20, 67, 43, 9, -52 },
  { 11256, 33, 32, 43, 5, -47 },
  { 11388, 43, 3, 43, 0, 4 },
  { 11405, 15, 9, 43, 14, -51 },
  { 11422, 37, 40, 43, 4, -39 },
  { 11607, 32, 53, 43, 6, -52 },
  { 11819, 33, 40, 43, 5, -39 },
  { 11984, 32, 53, 43, 5, -52 },
  { 12196, 33, 40, 43, 5, -39 },
  { 12361, 34, 52, 43, 5, -52 },
  { 12582, 32, 54, 43, 5, -39 },
  { 12798, 31, 52, 43, 6, -52 },
  { 13000, 35, 52, 43, 5, -52 },
  { 13228, 25, 67, 43, 4, -52 },
  { 13438, 32, 52, 43, 8, -52 },
  { 13646, 34, 52, 43, 5, -52 },
  { 13867, 37, 39, 43, 3, -39 },
  { 14048, 31, 39, 43, 6, -39 },
  { 14200, 34, 40, 43, 5, -39 },
  { 14370, 32, 54, 43, 6, -39 },
  { 14586, 32, 54, 43, 5, -39 },
  { 14802, 28, 39, 43, 9, -39 },
  { 14939, 31, 40, 43, 6, -39 },
  { 15094, 29, 49, 43, 7, -48 },
  { 15272, 31, 39, 43, 6, -38 },
  { 15424, 39, 38, 43, 2, -38 },
  { 15610, 41, 38, 43, 1, -38 },
  { 15805, 37, 38, 43, 3, -38 },
  { 15981, 39, 53, 43, 2, -38 },
  { 16240, 33, 38, 43, 5, -38 },
  { 16397, 29, 67, 43, 8, -52 },
  { 16640, 6, 67, 43, 19, -52 },
  { 16691, 29, 67, 43, 6, -52 },
  { 16934, 35, 9, 43, 4, -28 },
};

const GFXfont LiberationMono_Regular72pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular72pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular72pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _LIBERATIONMONO_REGULAR72PT7B_H_
