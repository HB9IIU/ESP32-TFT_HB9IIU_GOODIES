#ifndef _LIBERATIONMONO_REGULAR29PT7B_H_
#define _LIBERATIONMONO_REGULAR29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0x00, 0xFF, 0x80, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0x80, 0x06, 0x0C, 0x0C, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0xC1, 0x9F, 0xFF, 0xFF, 0xFF, 0x84, 0x18, 0x08,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x0F, 0xFF, 0xFF, 0xFF, 0xCC, 0x18,
  0x18, 0x30, 0x30, 0x40, 0x41, 0x80, 0x83, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x3F, 0xC1, 0xFF, 0xC7, 0x99, 0xCE, 0x31, 0xD8, 0x63, 0xB0, 0xC0, 0x71,
  0x80, 0x73, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x31, 0xC0, 0x61,
  0x80, 0xC3, 0xC1, 0x87, 0xC3, 0x1D, 0xC6, 0x79, 0xFF, 0xE0, 0xFF, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x3C, 0x03, 0x3F, 0x03, 0x39, 0xC1, 0x98, 0x61,
  0x8C, 0x31, 0x86, 0x19, 0xC3, 0x0C, 0xC1, 0xCE, 0xC0, 0x7E, 0xC0, 0x1E,
  0x6F, 0x80, 0x6F, 0xE0, 0x66, 0x30, 0x37, 0x18, 0x33, 0x0C, 0x31, 0x86,
  0x38, 0xE3, 0x18, 0x31, 0x98, 0x1F, 0xD8, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x1C, 0x70, 0x18, 0x30, 0x18, 0x30, 0x18, 0x70, 0x19, 0xE0, 0x0F,
  0x80, 0x1E, 0x0C, 0x7E, 0x0C, 0x67, 0x0C, 0xC3, 0x18, 0xC3, 0x98, 0xC1,
  0xD8, 0xC0, 0xF0, 0xC0, 0x70, 0xF0, 0xFC, 0x7F, 0xDF, 0x1F, 0x0F, 0xFF,
  0xFF, 0xDB, 0x60, 0x06, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x0C, 0x06, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06,
  0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x0C, 0x03, 0x00,
  0xC3, 0x32, 0xFF, 0xC7, 0x01, 0xE0, 0xD8, 0x63, 0x08, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C,
  0xE7, 0x9C, 0x71, 0x8E, 0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0F,
  0xC0, 0xFF, 0x87, 0x87, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB0,
  0x07, 0xC7, 0x1F, 0x1C, 0x7C, 0x71, 0xF0, 0x07, 0xE0, 0x1B, 0x80, 0x6E,
  0x03, 0x9C, 0x0C, 0x78, 0x70, 0xFF, 0x80, 0xF8, 0x00, 0x03, 0x80, 0x1E,
  0x01, 0xF8, 0x3F, 0xE0, 0xE3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0x9E, 0x1C,
  0xC0, 0x7E, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0xC7, 0x07, 0x38, 0x0E, 0xE0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x7E, 0x01, 0xB8, 0x0E, 0x70, 0x78, 0xFF, 0xC1, 0xFC, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xE6, 0x01,
  0x8C, 0x06, 0x18, 0x18, 0x30, 0x70, 0x60, 0xC0, 0xC3, 0x01, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x7F, 0xF1, 0xFF, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x19, 0xF0, 0x7F, 0xF3, 0xE1, 0xEE, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x7E, 0x01, 0xB8, 0x0E, 0x70, 0x70, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xC0,
  0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70, 0x39, 0x80, 0x0E, 0x00, 0x39, 0xF0,
  0xFF, 0xF3, 0xE1, 0xEF, 0x03, 0xB8, 0x06, 0xE0, 0x1D, 0x80, 0x66, 0x01,
  0x9C, 0x0E, 0x38, 0x70, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x0F, 0xC1, 0xFF, 0x9C, 0x1C, 0xC0, 0x7E, 0x03, 0xF0,
  0x1D, 0x80, 0xEE, 0x0E, 0x1F, 0xE1, 0xFF, 0x1C, 0x1D, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0x70, 0x79, 0xFF, 0x87, 0xF0, 0x0F, 0x81,
  0xFF, 0x1E, 0x3C, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x3B, 0x01, 0xDE, 0x1E, 0x7F, 0xB1, 0xF1, 0x80, 0x1F, 0x80, 0xEC, 0x0E,
  0x70, 0xE1, 0xFF, 0x07, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x38,
  0xE3, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xE3, 0x9C, 0x71,
  0x86, 0x30, 0xC0, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0x00, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x03, 0x80, 0x08, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0xE3, 0x83, 0x9C, 0x07, 0x60, 0x0F, 0x80, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03,
  0xE0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38, 0x0C, 0x30, 0x06, 0x63, 0xDE, 0x66,
  0x5A, 0xCC, 0x33, 0xCC, 0x33, 0xC8, 0x33, 0xD8, 0x33, 0xD8, 0x33, 0x98,
  0x33, 0x98, 0x63, 0x98, 0x62, 0x98, 0x62, 0xD8, 0xE6, 0xCC, 0xA4, 0xC7,
  0x38, 0x60, 0x00, 0x60, 0x00, 0x70, 0x08, 0x38, 0x38, 0x1F, 0xF0, 0x07,
  0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6E, 0x00, 0x77, 0x00,
  0x39, 0x80, 0x18, 0xE0, 0x1C, 0x70, 0x0E, 0x18, 0x06, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xE0, 0x1C, 0xE0, 0x0E, 0x70,
  0x03, 0x30, 0x01, 0xF8, 0x00, 0xE0, 0xFF, 0xC3, 0xFF, 0xCE, 0x07, 0xB8,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xFF, 0xE3, 0xFF, 0xCE,
  0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3B,
  0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x1C, 0x0E, 0xE0,
  0x1F, 0x80, 0x6E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x2E, 0x01, 0xDC, 0x0E, 0x38, 0x78, 0x7F, 0xC0,
  0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x8E, 0x0F, 0x38, 0x1E, 0xE0, 0x3B, 0x80,
  0x6E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x1C, 0xE0, 0xF3, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0xF3, 0xFF, 0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1B,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x07, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x07, 0x38, 0x3C, 0x7F, 0xE0, 0xFC,
  0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x76, 0x07, 0x60, 0x77,
  0x07, 0x78, 0xE3, 0xFC, 0x0F, 0x80, 0xE0, 0x1D, 0xC0, 0x73, 0x81, 0xC7,
  0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80, 0xEE, 0x01, 0xFE,
  0x03, 0xEE, 0x07, 0x9E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x1C,
  0xE0, 0x3D, 0xC0, 0x3B, 0x80, 0x38, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xD8, 0x7F, 0x63, 0x7D,
  0xCD, 0xF3, 0x37, 0xCD, 0x9F, 0x3E, 0x7C, 0x79, 0xF1, 0xC7, 0xC3, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xC0, 0xF0,
  0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xF6, 0x0F, 0xB0, 0x7D, 0xC3,
  0xE6, 0x1F, 0x38, 0xF8, 0xC7, 0xC7, 0x3E, 0x19, 0xF0, 0xEF, 0x83, 0x7C,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0E, 0x07, 0xC0, 0x3F, 0xE0, 0xF0, 0xE1,
  0xC0, 0xE7, 0x01, 0xCE, 0x01, 0xD8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3B, 0x00, 0x77, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x1C, 0x0E,
  0x3C, 0x38, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0xC3, 0xFF, 0xCE, 0x07, 0xB8,
  0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x81, 0xEF,
  0xFF, 0x3F, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xF0, 0xE1, 0xC0, 0xE7,
  0x01, 0xCE, 0x01, 0xD8, 0x03, 0xB0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3B, 0x00, 0x77, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x1C, 0x0E, 0x3C, 0x38,
  0x3F, 0xE0, 0x1F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xE1, 0xFF, 0xE3, 0x81, 0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x3B, 0x80,
  0x70, 0x0F, 0xE0, 0x7F, 0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x00, 0xCE, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0x78, 0x3C, 0x7F, 0xF0, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0x70, 0x71, 0xFF, 0x87, 0xF0, 0xE0, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0x60, 0x38, 0x38,
  0x18, 0x1C, 0x1C, 0x06, 0x0E, 0x03, 0x86, 0x01, 0xC7, 0x00, 0x63, 0x80,
  0x39, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x3B,
  0x00, 0x1D, 0xC7, 0x0C, 0xE3, 0x86, 0x71, 0xE3, 0x39, 0xB1, 0x8C, 0xD9,
  0xC6, 0x6C, 0xE3, 0x33, 0x61, 0xB1, 0xB0, 0xD8, 0xD8, 0x7C, 0x2C, 0x1E,
  0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x80, 0xE0, 0x0E, 0x70, 0x1C, 0x38, 0x1C,
  0x38, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x60, 0x1C, 0x70, 0x18, 0x38,
  0x38, 0x1C, 0x70, 0x1C, 0x60, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0x70, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFE,
  0xFF, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x3C, 0x03, 0x60, 0x1B, 0x81,
  0x8C, 0x0C, 0x60, 0x61, 0x86, 0x0C, 0x30, 0x73, 0x01, 0x98, 0x0D, 0xC0,
  0x3C, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0xE1, 0xC3, 0x87, 0x1F, 0x80, 0xFF,
  0x87, 0x0F, 0x18, 0x1C, 0x00, 0x30, 0x00, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0,
  0x33, 0x80, 0xCE, 0x07, 0x30, 0x1C, 0xE0, 0xF3, 0x86, 0xE7, 0xF3, 0xCF,
  0x87, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xEF,
  0x0E, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x7E, 0x07, 0xF0, 0xED, 0xFE, 0xCF, 0x80, 0x0F, 0xC1, 0xFF,
  0x9E, 0x1E, 0xC0, 0x7E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x03, 0xBC, 0x3C, 0xFF, 0xC1, 0xF8, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x8F, 0x9C, 0xFE, 0xEE, 0x1F,
  0x60, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3B, 0x03, 0xDC, 0x3E, 0x7F, 0x71, 0xF3, 0x80, 0x0F, 0x81,
  0xFF, 0x1E, 0x1C, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x01, 0xBC, 0x3C, 0xFF, 0xC1, 0xF8,
  0x03, 0xFC, 0x1F, 0xF0, 0xE0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0xEF, 0xFF,
  0x83, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x1F, 0x39, 0xFD, 0xDC, 0x3E, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x76, 0x07, 0xB8, 0x7C,
  0xFE, 0xE3, 0xE7, 0x00, 0x38, 0x01, 0xDC, 0x0C, 0xF0, 0xE3, 0xFE, 0x07,
  0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xEF,
  0x0E, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x70, 0x1C, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xBF, 0xCF, 0xE0, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3B, 0x83, 0x9C, 0x38, 0xE1, 0x87, 0x1C,
  0x39, 0xC1, 0xDC, 0x0F, 0xE0, 0x7F, 0x83, 0xDC, 0x1C, 0x70, 0xE1, 0xC7,
  0x0E, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0xEE, 0x39, 0xFE, 0xFB,
  0xCD, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x70, 0xF8, 0x61, 0xF0, 0xC3, 0xE1,
  0x87, 0xC3, 0x0F, 0x86, 0x1F, 0x0C, 0x3E, 0x18, 0x7C, 0x30, 0xF8, 0x61,
  0xF0, 0xC3, 0xCF, 0x8D, 0xFE, 0xF0, 0xEE, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x0F, 0xC0, 0xFF, 0x87, 0x87, 0x1C, 0x0E, 0xE0, 0x3B, 0x80,
  0x6E, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0x70,
  0x39, 0xE1, 0xC3, 0xFE, 0x03, 0xF0, 0xCF, 0x8D, 0xFE, 0xF0, 0xEE, 0x07,
  0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07,
  0xE0, 0x7F, 0x0E, 0xDF, 0xEC, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x1F, 0x39, 0xFD, 0xDC, 0x3E, 0xC0, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x76, 0x07,
  0xB8, 0x7C, 0xFE, 0xE3, 0xE7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x63, 0xF6, 0x7F, 0x6E, 0x06, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0x1C, 0xE0, 0x76, 0x00, 0x38,
  0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x3E, 0x03,
  0xB8, 0x39, 0xFF, 0xC3, 0xF8, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x0F, 0xFF,
  0xFF, 0xCE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0x87, 0xF0, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0xFE, 0x1F, 0x7F, 0x73, 0xE7, 0xE0, 0x0E, 0xC0,
  0x1D, 0xC0, 0x33, 0x80, 0xE3, 0x01, 0xC7, 0x03, 0x0E, 0x0E, 0x0E, 0x18,
  0x1C, 0x70, 0x18, 0xE0, 0x39, 0x80, 0x77, 0x00, 0x6E, 0x00, 0xD8, 0x00,
  0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x76,
  0x1C, 0x33, 0x8E, 0x19, 0xC5, 0x8C, 0x66, 0xCE, 0x33, 0x67, 0x19, 0x9B,
  0x8D, 0x8D, 0x86, 0xC6, 0xC3, 0xE1, 0x61, 0xF0, 0xF0, 0x70, 0x78, 0x38,
  0x3C, 0x70, 0x0C, 0x60, 0x38, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x00, 0xDC,
  0x01, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x3B, 0x80, 0x63, 0x81,
  0xC3, 0x87, 0x07, 0x1C, 0x07, 0x30, 0x07, 0xE0, 0x06, 0xC0, 0x1D, 0xC0,
  0x33, 0x80, 0xE3, 0x01, 0xC7, 0x03, 0x06, 0x0E, 0x0E, 0x18, 0x1C, 0x30,
  0x18, 0xE0, 0x39, 0x80, 0x37, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x03, 0xC0, 0xF8, 0x0F, 0x80,
  0x3C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0F,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x07, 0x0F, 0xE0, 0xFC, 0x00, 0x7C, 0x03, 0xFC, 0x38,
  0x7F, 0xC0, 0x3E,
};

const GFXglyph LiberationMono_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 19, 17, 7, -19 },
  { 9, 9, 9, 17, 4, -21 },
  { 20, 15, 19, 17, 1, -19 },
  { 56, 15, 23, 17, 1, -21 },
  { 100, 17, 19, 17, 0, -19 },
  { 141, 16, 19, 17, 1, -19 },
  { 179, 3, 9, 17, 7, -21 },
  { 183, 8, 27, 17, 5, -21 },
  { 210, 8, 27, 17, 5, -21 },
  { 237, 10, 10, 17, 4, -21 },
  { 250, 14, 14, 17, 2, -17 },
  { 275, 6, 9, 17, 4, -4 },
  { 282, 8, 2, 17, 5, -9 },
  { 284, 3, 4, 17, 7, -4 },
  { 286, 14, 21, 17, 2, -21 },
  { 323, 14, 19, 17, 2, -19 },
  { 357, 14, 19, 17, 2, -19 },
  { 391, 13, 19, 17, 2, -19 },
  { 422, 14, 19, 17, 2, -19 },
  { 456, 15, 19, 17, 1, -19 },
  { 492, 14, 19, 17, 2, -19 },
  { 526, 14, 19, 17, 2, -19 },
  { 560, 13, 19, 17, 2, -19 },
  { 591, 13, 19, 17, 2, -19 },
  { 622, 13, 19, 17, 2, -19 },
  { 653, 3, 16, 17, 7, -16 },
  { 659, 6, 21, 17, 5, -16 },
  { 675, 14, 15, 17, 2, -17 },
  { 702, 14, 9, 17, 2, -14 },
  { 718, 14, 15, 17, 2, -17 },
  { 745, 14, 19, 17, 1, -19 },
  { 779, 16, 25, 17, 1, -21 },
  { 829, 17, 19, 17, 0, -19 },
  { 870, 14, 19, 17, 2, -19 },
  { 904, 14, 19, 17, 2, -19 },
  { 938, 14, 19, 17, 2, -19 },
  { 972, 14, 19, 17, 2, -19 },
  { 1006, 12, 19, 17, 3, -19 },
  { 1035, 14, 19, 17, 2, -19 },
  { 1069, 13, 19, 17, 2, -19 },
  { 1100, 12, 19, 17, 3, -19 },
  { 1129, 12, 19, 17, 2, -19 },
  { 1158, 15, 19, 17, 2, -19 },
  { 1194, 13, 19, 17, 3, -19 },
  { 1225, 14, 19, 17, 2, -19 },
  { 1259, 13, 19, 17, 2, -19 },
  { 1290, 15, 19, 17, 1, -19 },
  { 1326, 14, 19, 17, 2, -19 },
  { 1360, 15, 24, 17, 1, -19 },
  { 1405, 15, 19, 17, 2, -19 },
  { 1441, 15, 19, 17, 1, -19 },
  { 1477, 15, 19, 17, 1, -19 },
  { 1513, 13, 19, 17, 2, -19 },
  { 1544, 17, 19, 17, 0, -19 },
  { 1585, 17, 19, 17, 0, -19 },
  { 1626, 16, 19, 17, 1, -19 },
  { 1664, 16, 19, 17, 1, -19 },
  { 1702, 15, 19, 17, 1, -19 },
  { 1738, 8, 27, 17, 6, -21 },
  { 1765, 14, 21, 17, 2, -21 },
  { 1802, 8, 27, 17, 4, -21 },
  { 1829, 13, 13, 17, 2, -19 },
  { 1851, 17, 1, 17, 0, 2 },
  { 1854, 6, 4, 17, 6, -21 },
  { 1857, 14, 16, 17, 2, -16 },
  { 1885, 12, 21, 17, 3, -21 },
  { 1917, 13, 16, 17, 2, -16 },
  { 1943, 13, 21, 17, 2, -21 },
  { 1978, 13, 16, 17, 2, -16 },
  { 2004, 14, 21, 17, 2, -21 },
  { 2041, 13, 22, 17, 2, -16 },
  { 2077, 12, 21, 17, 3, -21 },
  { 2109, 14, 21, 17, 2, -21 },
  { 2146, 10, 27, 17, 2, -21 },
  { 2180, 13, 21, 17, 3, -21 },
  { 2215, 14, 21, 17, 2, -21 },
  { 2252, 15, 16, 17, 1, -16 },
  { 2282, 12, 16, 17, 3, -16 },
  { 2306, 14, 16, 17, 2, -16 },
  { 2334, 12, 22, 17, 3, -16 },
  { 2367, 13, 22, 17, 2, -16 },
  { 2403, 12, 16, 17, 3, -16 },
  { 2427, 13, 16, 17, 2, -16 },
  { 2453, 11, 20, 17, 3, -20 },
  { 2481, 12, 16, 17, 3, -16 },
  { 2505, 15, 16, 17, 1, -16 },
  { 2535, 17, 16, 17, 0, -16 },
  { 2569, 15, 16, 17, 1, -16 },
  { 2599, 15, 22, 17, 1, -16 },
  { 2641, 13, 16, 17, 2, -16 },
  { 2667, 12, 27, 17, 3, -21 },
  { 2708, 2, 27, 17, 8, -21 },
  { 2715, 12, 27, 17, 2, -21 },
  { 2756, 14, 4, 17, 2, -12 },
};

const GFXfont LiberationMono_Regular29pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular29pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular29pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _LIBERATIONMONO_REGULAR29PT7B_H_
