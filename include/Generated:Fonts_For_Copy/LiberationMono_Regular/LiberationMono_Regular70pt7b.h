#ifndef _LIBERATIONMONO_REGULAR70PT7B_H_
#define _LIBERATIONMONO_REGULAR70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F,
  0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xE3, 0xC7, 0xFE, 0x07, 0xF8, 0x1E, 0x07, 0xF8, 0x3F, 0x80,
  0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0x80, 0x7E, 0x0F, 0xC0, 0x3C, 0x03, 0xF8,
  0xFC, 0x01, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0x00, 0x70, 0x3F, 0x00, 0x78,
  0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x3F,
  0x80, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x3C, 0x00,
  0x00, 0x1F, 0xF9, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3C,
  0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0xFE, 0x00,
  0x00, 0x78, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0xC0, 0x07, 0x80, 0x1F, 0xFE, 0x00,
  0x3C, 0x00, 0xFD, 0xF8, 0x01, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x00, 0x3F,
  0x7F, 0x00, 0x78, 0x01, 0xF9, 0xFC, 0x03, 0xC0, 0x1F, 0xCF, 0xF0, 0x1E,
  0x01, 0xFC, 0x3F, 0xC0, 0xF0, 0x1F, 0xE1, 0xFF, 0xC7, 0x87, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0x81, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x7F,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xF0, 0xFC, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0x87, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC3, 0xFF, 0xC0,
  0x00, 0x03, 0xE1, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x00, 0x00,
  0x7C, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0x81, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x1F, 0xE0, 0x00, 0x00, 0x7E, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xE0, 0x0F, 0xF7, 0xC0, 0x03, 0xE0, 0x1F, 0xC7, 0xE0, 0x03, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x9F, 0x00, 0xFC, 0x00, 0x1F, 0xDF, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xDF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3C, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x02, 0x01, 0xE0, 0x10,
  0xE0, 0x78, 0x1C, 0x7F, 0x1E, 0x3F, 0x9F, 0xF7, 0xBF, 0xE7, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x07, 0x80, 0x04, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0x81, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x01,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE,
  0x07, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFD,
  0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x03, 0xFC, 0x00, 0x0F, 0xC7, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x70, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x00,
  0x7E, 0x1F, 0xFF, 0x80, 0xFC, 0x3F, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0xF0,
  0xFD, 0xFF, 0xFF, 0xF8, 0xFD, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFC,
  0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFF,
  0x1F, 0xF0, 0x1F, 0xBF, 0x0F, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0x3F,
  0x03, 0xFF, 0xFC, 0x3F, 0x01, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x00,
  0x3C, 0x0F, 0x00, 0xFF, 0x8F, 0x3C, 0x1F, 0x01, 0xFF, 0xCF, 0x3E, 0x1E,
  0x03, 0xFF, 0xCF, 0x3E, 0x1E, 0x07, 0xE1, 0xEF, 0x1E, 0x3E, 0x07, 0xC0,
  0xEF, 0x1E, 0x3E, 0x0F, 0x80, 0x7E, 0x1E, 0x3C, 0x1F, 0x00, 0x7E, 0x1E,
  0x3C, 0x1F, 0x00, 0x7E, 0x1E, 0x7C, 0x1E, 0x00, 0x7E, 0x1F, 0x7C, 0x3E,
  0x00, 0x7E, 0x1F, 0x78, 0x3E, 0x00, 0x7E, 0x1F, 0x78, 0x3C, 0x00, 0x7C,
  0x1F, 0x78, 0x7C, 0x00, 0x7C, 0x1F, 0x78, 0x7C, 0x00, 0x7C, 0x1F, 0x78,
  0x7C, 0x00, 0x7C, 0x1F, 0x78, 0x78, 0x00, 0x7C, 0x1F, 0x78, 0x78, 0x00,
  0x78, 0x1E, 0x78, 0x78, 0x00, 0x78, 0x1E, 0xF8, 0x78, 0x00, 0xF8, 0x1E,
  0xF8, 0xF8, 0x00, 0xF8, 0x1E, 0xF8, 0xF8, 0x00, 0xF8, 0x1E, 0x78, 0xF8,
  0x00, 0xF0, 0x1E, 0x78, 0x78, 0x01, 0xF0, 0x3E, 0x78, 0x78, 0x01, 0xF0,
  0x3C, 0x78, 0x78, 0x01, 0xF0, 0x3C, 0x78, 0x78, 0x03, 0xF0, 0x3C, 0x78,
  0x7C, 0x03, 0xF0, 0x78, 0x78, 0x7C, 0x07, 0xF0, 0x78, 0x7C, 0x3E, 0x0F,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0xF1, 0xF0, 0x3C, 0x3F, 0xFC, 0x7F, 0xE0,
  0x3C, 0x1F, 0xFC, 0x7F, 0xE0, 0x3E, 0x0F, 0xF8, 0x7F, 0x80, 0x1E, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0xC3, 0xF0,
  0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFD, 0xF8, 0x00, 0x03, 0xFE, 0xFC, 0x00, 0x0F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0x18, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xC1, 0xFC, 0x00, 0x00, 0x1E, 0x3F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFF,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x01,
  0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x0F, 0xF8, 0xFC, 0x00,
  0x07, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00,
  0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x08, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x00, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xEF,
  0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x7C, 0x00, 0xFB,
  0xFF, 0xDF, 0x00, 0x3E, 0xFF, 0xF7, 0xE0, 0x0F, 0xBF, 0xFC, 0xF8, 0x07,
  0xCF, 0xFF, 0x3F, 0x01, 0xF3, 0xFF, 0xCF, 0xC0, 0xFC, 0xFF, 0xF1, 0xF0,
  0x3E, 0x3F, 0xFC, 0x7E, 0x0F, 0x8F, 0xFF, 0x0F, 0x87, 0xC3, 0xFF, 0xC3,
  0xE1, 0xF0, 0xFF, 0xF0, 0xFC, 0x7C, 0x3F, 0xFC, 0x1F, 0x3E, 0x0F, 0xFF,
  0x07, 0xCF, 0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xC0, 0x01, 0xFF,
  0xBF, 0x00, 0x07, 0xFE, 0x7C, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x7F, 0xE3,
  0xE0, 0x01, 0xFF, 0x8F, 0xC0, 0x07, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0x7E,
  0x00, 0x7F, 0xE1, 0xF8, 0x01, 0xFF, 0x83, 0xF0, 0x07, 0xFE, 0x0F, 0xC0,
  0x1F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x7E, 0x01, 0xFF, 0x80, 0xFC, 0x07,
  0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0x81, 0xFF,
  0x80, 0x3E, 0x07, 0xFE, 0x00, 0xFC, 0x1F, 0xF8, 0x03, 0xF0, 0x7F, 0xE0,
  0x07, 0xE1, 0xFF, 0x80, 0x1F, 0x87, 0xFE, 0x00, 0x3F, 0x1F, 0xF8, 0x00,
  0xFC, 0x7F, 0xE0, 0x01, 0xF9, 0xFF, 0x80, 0x07, 0xE7, 0xFE, 0x00, 0x0F,
  0xDF, 0xF8, 0x00, 0x3F, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x03,
  0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x07,
  0xFC, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x00, 0x3F,
  0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFE,
  0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01,
  0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x01, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x0C, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0x01, 0xF8, 0x1F, 0x80, 0xFF,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x3C, 0x07,
  0xC0, 0x3F, 0x07, 0xCF, 0x81, 0xF0, 0x0F, 0xC1, 0xF3, 0xE0, 0xFC, 0x03,
  0xF0, 0x7C, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x1E, 0x0F, 0xC0, 0x3F, 0x0F,
  0x87, 0xC3, 0xF0, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x0F, 0x0F, 0x80, 0x1F, 0x9F, 0x03, 0xE3, 0xE0,
  0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x3E, 0x7E, 0x00, 0x7E,
  0x78, 0x07, 0x9F, 0x80, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x03, 0xDF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x7E, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x3E, 0xFE, 0x07, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F, 0x01,
  0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFC, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x80,
  0x3F, 0x07, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFC, 0x7F, 0xFF, 0xE1,
  0xF9, 0xFF, 0xFF, 0xE3, 0xF7, 0xE0, 0x7F, 0xC7, 0xEF, 0x00, 0x3F, 0xCF,
  0xFC, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x01,
  0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x3F,
  0x9F, 0xFC, 0x00, 0xFF, 0x3F, 0x7E, 0x07, 0xFC, 0x7E, 0xFF, 0xFF, 0xF8,
  0xFC, 0xFF, 0xFF, 0xE1, 0xF8, 0xFF, 0xFF, 0x83, 0xF0, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFC, 0x3F, 0x83, 0xFF, 0xFE, 0x3F, 0x0F,
  0xFF, 0xFE, 0x7E, 0x3F, 0xFF, 0xFC, 0xFC, 0x7F, 0xC0, 0xFD, 0xF9, 0xFE,
  0x00, 0x7F, 0xF3, 0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x7F, 0xDF, 0xC0,
  0x00, 0x7F, 0xBF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE,
  0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xF3,
  0xF8, 0x00, 0x7F, 0xE7, 0xF8, 0x01, 0xEF, 0xC7, 0xFC, 0x0F, 0xDF, 0x8F,
  0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xF0, 0xFC, 0x07,
  0xFF, 0xC1, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF,
  0xE1, 0xF8, 0x7F, 0xFF, 0xE3, 0xF1, 0xFF, 0xFF, 0xE7, 0xE3, 0xFE, 0x07,
  0xEF, 0xCF, 0xF0, 0x03, 0xDF, 0x9F, 0xC0, 0x03, 0xFF, 0x7F, 0x00, 0x03,
  0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0,
  0x01, 0xFF, 0x9F, 0xE0, 0x07, 0xBF, 0x3F, 0xF0, 0x3F, 0x7E, 0x3F, 0xFF,
  0xFC, 0xFC, 0x3F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0xFE,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE1, 0xFF, 0xF8,
  0x3F, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0xFF, 0xE3, 0xF3, 0xFF, 0xFF, 0xCF,
  0xDF, 0x81, 0xFF, 0x3F, 0x78, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFB, 0xFE,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xCE, 0x00, 0x7F, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xBF, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC,
  0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFD, 0xFC,
  0x00, 0x3F, 0xE3, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x7E, 0x1F, 0x8F, 0xF0, 0x3F, 0xE3, 0xF3, 0xFF, 0x0F, 0xFE, 0x7E, 0xFF,
  0xF3, 0xFF, 0xE7, 0xDF, 0xFE, 0x7F, 0xFC, 0xFF, 0x8F, 0xDE, 0x1F, 0xDF,
  0xE0, 0xFF, 0x81, 0xFB, 0xF8, 0x1F, 0xE0, 0x3F, 0x7F, 0x01, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0x80, 0xFD, 0xF8, 0x07, 0xE0, 0x0F, 0xBF, 0x00, 0xFC,
  0x01, 0xF7, 0xE0, 0x1F, 0x80, 0x3E, 0xFC, 0x03, 0xF0, 0x07, 0xDF, 0x00,
  0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0x00, 0x7D, 0xF0, 0x07, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x01,
  0xF7, 0xC0, 0x1F, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0x7E,
  0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0x00, 0x7D, 0xF0, 0x07, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x01, 0xF7,
  0xC0, 0x1F, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0x00,
  0xFB, 0xE0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0x00, 0x7D, 0xF0, 0x07, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x03,
  0xF0, 0x7F, 0xFE, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xF8, 0xFC,
  0xFF, 0xFF, 0xF3, 0xF7, 0xE0, 0x7F, 0xCF, 0xDE, 0x00, 0x7F, 0xBF, 0xF0,
  0x00, 0xFE, 0xFF, 0x80, 0x01, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x3F, 0xFE,
  0x03, 0xF0, 0xFF, 0xFF, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xBF, 0x03, 0xFE, 0x3F, 0x78, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFC,
  0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x03, 0xF7,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0xE0, 0x00,
  0x3F, 0xBF, 0xE0, 0x00, 0x7F, 0x7F, 0xC0, 0x01, 0xFC, 0xFF, 0xE0, 0x07,
  0xF9, 0xFB, 0xF0, 0x3F, 0xE3, 0xF3, 0xFF, 0xFF, 0xC7, 0xE7, 0xFF, 0xFF,
  0x0F, 0xC7, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xF1, 0xF8, 0x7F, 0xFF, 0xF3, 0xF1, 0xFF,
  0xFF, 0xE7, 0xE3, 0xFE, 0x07, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0x9F, 0xC0,
  0x03, 0xFF, 0x7F, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFF, 0x3F,
  0xC0, 0x0F, 0x7E, 0x3F, 0xE0, 0x7E, 0xFC, 0x7F, 0xFF, 0xF9, 0xF8, 0x7F,
  0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xEF, 0xC0, 0x3F, 0xFF, 0x7E, 0x0F, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0x7E,
  0x1F, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0x7E, 0x7F, 0x80, 0x13, 0xF7, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xC7,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x03, 0xF9, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x1E, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x1F, 0xF7,
  0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFF, 0x3F, 0xC0, 0x7E, 0xFC, 0xFF,
  0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x8F, 0xC3, 0xFF, 0xFC, 0x3F, 0x07, 0xFF,
  0xE0, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFF,
  0x00, 0xFC, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFF, 0x00, 0xFC,
  0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x1F, 0x01,
  0xE7, 0x80, 0xF8, 0x1F, 0x03, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1,
  0xF8, 0x1F, 0x83, 0xC3, 0xC1, 0xF8, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x1F,
  0x87, 0xC3, 0xE1, 0xF8, 0x0F, 0x87, 0x83, 0xE1, 0xF0, 0x0F, 0x8F, 0x81,
  0xE3, 0xF0, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x0F, 0xCF, 0x81, 0xF3, 0xF0,
  0x0F, 0xCF, 0x00, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x7B, 0xE0, 0x07, 0xFE, 0x00, 0x7B,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph LiberationMono_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 6, 46, 42, 18, -46 },
  { 36, 23, 22, 42, 9, -51 },
  { 100, 38, 46, 42, 2, -46 },
  { 319, 37, 56, 42, 2, -50 },
  { 578, 42, 48, 42, 0, -47 },
  { 830, 40, 47, 42, 1, -46 },
  { 1065, 8, 22, 42, 17, -51 },
  { 1087, 18, 66, 42, 12, -51 },
  { 1236, 19, 66, 42, 11, -51 },
  { 1393, 26, 24, 42, 8, -51 },
  { 1471, 34, 35, 42, 4, -41 },
  { 1620, 15, 23, 42, 9, -10 },
  { 1664, 20, 5, 42, 11, -21 },
  { 1677, 8, 10, 42, 17, -10 },
  { 1687, 34, 52, 42, 4, -51 },
  { 1908, 34, 48, 42, 4, -47 },
  { 2112, 34, 46, 42, 5, -46 },
  { 2308, 32, 47, 42, 5, -47 },
  { 2496, 34, 48, 42, 4, -47 },
  { 2700, 34, 46, 42, 4, -46 },
  { 2896, 34, 47, 42, 4, -46 },
  { 3096, 32, 48, 42, 5, -47 },
  { 3288, 32, 46, 42, 5, -46 },
  { 3472, 32, 48, 42, 5, -47 },
  { 3664, 32, 48, 42, 5, -47 },
  { 3856, 8, 37, 42, 17, -37 },
  { 3893, 15, 50, 42, 12, -37 },
  { 3987, 34, 36, 42, 4, -41 },
  { 4140, 34, 22, 42, 4, -34 },
  { 4234, 34, 36, 42, 4, -41 },
  { 4387, 34, 47, 42, 3, -47 },
  { 4587, 40, 61, 42, 1, -51 },
  { 4892, 42, 46, 42, 0, -46 },
  { 5134, 33, 46, 42, 6, -46 },
  { 5324, 35, 48, 42, 4, -47 },
  { 5534, 32, 46, 42, 6, -46 },
  { 5718, 32, 46, 42, 6, -46 },
  { 5902, 30, 46, 42, 7, -46 },
  { 6075, 34, 48, 42, 4, -47 },
  { 6279, 30, 46, 42, 6, -46 },
  { 6452, 28, 46, 42, 7, -46 },
  { 6613, 28, 47, 42, 6, -46 },
  { 6778, 36, 46, 42, 6, -46 },
  { 6985, 30, 46, 42, 8, -46 },
  { 7158, 34, 46, 42, 4, -46 },
  { 7354, 30, 46, 42, 6, -46 },
  { 7527, 35, 48, 42, 3, -47 },
  { 7737, 32, 46, 42, 6, -46 },
  { 7921, 36, 60, 42, 3, -47 },
  { 8191, 34, 46, 42, 6, -46 },
  { 8387, 36, 48, 42, 3, -47 },
  { 8603, 36, 46, 42, 3, -46 },
  { 8810, 32, 47, 42, 5, -46 },
  { 8998, 42, 46, 42, 0, -46 },
  { 9240, 42, 46, 42, 0, -46 },
  { 9482, 40, 46, 42, 1, -46 },
  { 9712, 40, 46, 42, 1, -46 },
  { 9942, 37, 46, 42, 2, -46 },
  { 10155, 19, 66, 42, 14, -51 },
  { 10312, 34, 52, 42, 4, -51 },
  { 10533, 19, 66, 42, 9, -51 },
  { 10690, 32, 31, 42, 5, -46 },
  { 10814, 42, 3, 42, 0, 4 },
  { 10830, 14, 9, 42, 14, -50 },
  { 10846, 36, 39, 42, 4, -38 },
  { 11022, 31, 52, 42, 6, -51 },
  { 11224, 33, 39, 42, 4, -38 },
  { 11385, 31, 52, 42, 5, -51 },
  { 11587, 32, 39, 42, 5, -38 },
  { 11743, 33, 51, 42, 5, -51 },
  { 11954, 31, 53, 42, 5, -38 },
  { 12160, 30, 51, 42, 6, -51 },
  { 12352, 33, 51, 42, 5, -51 },
  { 12563, 25, 66, 42, 4, -51 },
  { 12770, 30, 51, 42, 8, -51 },
  { 12962, 33, 51, 42, 5, -51 },
  { 13173, 35, 38, 42, 3, -38 },
  { 13340, 30, 38, 42, 6, -38 },
  { 13483, 34, 39, 42, 4, -38 },
  { 13649, 31, 53, 42, 6, -38 },
  { 13855, 31, 53, 42, 5, -38 },
  { 14061, 28, 38, 42, 8, -38 },
  { 14194, 30, 39, 42, 6, -38 },
  { 14341, 29, 48, 42, 6, -47 },
  { 14515, 30, 38, 42, 6, -37 },
  { 14658, 38, 37, 42, 2, -37 },
  { 14834, 40, 37, 42, 1, -37 },
  { 15019, 36, 37, 42, 3, -37 },
  { 15186, 38, 52, 42, 2, -37 },
  { 15433, 32, 37, 42, 5, -37 },
  { 15581, 28, 66, 42, 8, -51 },
  { 15812, 6, 66, 42, 18, -51 },
  { 15862, 28, 66, 42, 6, -51 },
  { 16093, 34, 9, 42, 4, -28 },
};

const GFXfont LiberationMono_Regular70pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular70pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular70pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _LIBERATIONMONO_REGULAR70PT7B_H_
