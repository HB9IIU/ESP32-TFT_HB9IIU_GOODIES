#ifndef _LIBERATIONMONO_REGULAR19PT7B_H_
#define _LIBERATIONMONO_REGULAR19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEA, 0x83, 0xC0, 0xCF, 0x38, 0xE3, 0x8E, 0x20, 0x08, 0x41,
  0x10, 0x22, 0x04, 0x47, 0xFE, 0x23, 0x04, 0x40, 0x88, 0xFF, 0xC4, 0x20,
  0x88, 0x11, 0x02, 0x20, 0x08, 0x02, 0x03, 0xF1, 0x26, 0xC8, 0xB2, 0x06,
  0x80, 0xF8, 0x0B, 0x82, 0x20, 0x8C, 0x23, 0x88, 0xB2, 0x63, 0xF0, 0x20,
  0x08, 0x00, 0x70, 0x59, 0x1A, 0x22, 0x44, 0x8C, 0xB0, 0xE4, 0x01, 0x00,
  0x6E, 0x0B, 0x22, 0x44, 0xC8, 0x91, 0x94, 0x1C, 0x0F, 0x02, 0x20, 0xC6,
  0x18, 0x81, 0x30, 0x38, 0x0E, 0x13, 0x66, 0x44, 0x98, 0xD1, 0x0E, 0x31,
  0xC3, 0xCE, 0xFF, 0xA0, 0x19, 0x8C, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x84,
  0x31, 0x86, 0x30, 0xC0, 0x43, 0x0C, 0x61, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0xC6, 0x62, 0x00, 0x10, 0x21, 0x5B, 0xE3, 0x85, 0x99, 0x00, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x33, 0x66,
  0x44, 0xF8, 0xFC, 0x01, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x3E, 0x31, 0x90, 0x78, 0x3C,
  0x1E, 0x67, 0x33, 0x81, 0xC1, 0xE0, 0xD0, 0x6C, 0x61, 0xE0, 0x0C, 0x0E,
  0x39, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x8F,
  0xF8, 0x3E, 0x31, 0x98, 0x68, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x0C, 0x0F, 0xF8, 0x3E, 0x31, 0x90, 0x78, 0x30, 0x18, 0x18, 0x70,
  0x06, 0x01, 0xE0, 0xD0, 0x6C, 0x33, 0xE0, 0x03, 0x03, 0x83, 0xC1, 0x61,
  0x31, 0x98, 0x8C, 0x86, 0xC3, 0x7F, 0xC0, 0xC0, 0x60, 0x30, 0x7F, 0x30,
  0x10, 0x08, 0x04, 0x02, 0xF1, 0x8C, 0x03, 0x01, 0x80, 0xF0, 0x6C, 0x63,
  0xE0, 0x1E, 0x19, 0x98, 0x6C, 0x04, 0x06, 0xF3, 0x8D, 0x83, 0x41, 0xA0,
  0xD8, 0x64, 0x61, 0xE0, 0xFF, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x3E, 0x31, 0x90, 0x68, 0x34,
  0x1B, 0x18, 0x78, 0xC2, 0xC1, 0xE0, 0xF0, 0x6C, 0x33, 0xE0, 0x3E, 0x31,
  0x90, 0x58, 0x3C, 0x1A, 0x0D, 0x8E, 0x7B, 0x01, 0x80, 0xD0, 0x4C, 0x63,
  0xC0, 0xFC, 0x03, 0xF0, 0x33, 0x30, 0x00, 0x03, 0x76, 0x64, 0xC0, 0x00,
  0x81, 0x83, 0x0E, 0x08, 0x03, 0x80, 0x30, 0x06, 0x00, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x80, 0x38, 0x03, 0x00, 0x60, 0x08, 0x18, 0x30,
  0xE0, 0x80, 0x00, 0x3E, 0x31, 0xB0, 0x78, 0x30, 0x18, 0x18, 0x38, 0x18,
  0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x0F, 0x02, 0x18, 0x81, 0x30, 0x34,
  0xEA, 0x93, 0x54, 0x6E, 0x89, 0xD1, 0x3A, 0x25, 0x4D, 0x2E, 0xE4, 0x00,
  0xC0, 0x0C, 0x30, 0xF8, 0x06, 0x01, 0xC0, 0x2C, 0x0D, 0x81, 0x90, 0x23,
  0x0C, 0x61, 0x84, 0x3F, 0xCC, 0x19, 0x81, 0x20, 0x3C, 0x06, 0xFE, 0x30,
  0xCC, 0x1B, 0x06, 0xC1, 0xB0, 0xCF, 0xE3, 0x06, 0xC0, 0xF0, 0x3C, 0x0F,
  0x06, 0xFF, 0x00, 0x1E, 0x18, 0xC6, 0x1B, 0x02, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x26, 0x18, 0x84, 0x1E, 0x00, 0xFC, 0x61, 0xB0, 0x78,
  0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x6F, 0xC0, 0xFF,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0F, 0xF8, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x1E, 0x31, 0x98, 0x78, 0x3C, 0x06, 0x03, 0x1F, 0x83,
  0xC1, 0xE0, 0xD8, 0x64, 0x31, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x3E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x0F, 0x1E, 0x27, 0x80, 0xC1, 0xB0,
  0xCC, 0x33, 0x18, 0xCC, 0x36, 0x0F, 0xC3, 0xB0, 0xC6, 0x30, 0xCC, 0x3B,
  0x06, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xE1, 0xF0, 0xF8, 0xBE, 0x5D, 0x2E, 0xB7, 0x73,
  0x99, 0xCC, 0xE0, 0x70, 0x38, 0x1C, 0x08, 0xE1, 0xF0, 0xFC, 0x7A, 0x3D,
  0x9E, 0xCF, 0x27, 0x9B, 0xC5, 0xE3, 0xF0, 0xF8, 0x7C, 0x18, 0x3E, 0x31,
  0x90, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xD0, 0x6C, 0x61,
  0xE0, 0xFE, 0x60, 0xF0, 0x78, 0x1C, 0x0E, 0x0F, 0x0D, 0xFC, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x00, 0x3E, 0x18, 0xC4, 0x1B, 0x06, 0xC1, 0xB0, 0x2C,
  0x0B, 0x02, 0xC1, 0xB0, 0x64, 0x19, 0x8C, 0x3E, 0x03, 0x00, 0x40, 0x18,
  0x03, 0xC0, 0xFF, 0x30, 0x6C, 0x0B, 0x02, 0xC1, 0xB0, 0x6F, 0xE3, 0x18,
  0xC6, 0x30, 0xCC, 0x33, 0x06, 0xC0, 0xC0, 0x3E, 0x30, 0xF0, 0x78, 0x06,
  0x03, 0xC0, 0x7C, 0x07, 0x00, 0xE0, 0x70, 0x2C, 0x33, 0xE0, 0xFF, 0xC3,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xD0, 0x6C, 0x63, 0xE0, 0xC0, 0x68, 0x0D, 0x81, 0x30, 0x62,
  0x0C, 0x61, 0x0C, 0x60, 0xCC, 0x19, 0x01, 0x60, 0x2C, 0x07, 0x00, 0x60,
  0xC0, 0x38, 0x0F, 0x01, 0xA0, 0x34, 0x66, 0x8C, 0xDB, 0x93, 0x52, 0x6B,
  0x4D, 0x28, 0xE7, 0x18, 0xE3, 0x1C, 0x60, 0xC6, 0x18, 0xC6, 0x0C, 0x80,
  0xB0, 0x1C, 0x01, 0x80, 0x70, 0x1B, 0x02, 0x30, 0xC2, 0x30, 0x66, 0x06,
  0x60, 0x6C, 0x18, 0xC2, 0x08, 0xC1, 0xB0, 0x1E, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xFF, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xFF, 0xC0, 0xFC,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x0C, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0x0C, 0x0A, 0x05, 0x86, 0x42, 0x33, 0x09,
  0x05, 0x81, 0xFF, 0xE0, 0xC6, 0x20, 0x3E, 0x18, 0xC4, 0x10, 0x04, 0x3F,
  0x18, 0x4C, 0x13, 0x0C, 0xC5, 0x1E, 0x70, 0x80, 0x80, 0x80, 0x80, 0x9C,
  0xA6, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0xC3, 0xC6, 0xBC, 0x3E, 0x31, 0x90,
  0x78, 0x0C, 0x06, 0x03, 0x00, 0x83, 0x63, 0x1F, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x33, 0xDB, 0x1D, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x68, 0x36, 0x39,
  0xEC, 0x3E, 0x31, 0x90, 0x78, 0x3F, 0xFE, 0x03, 0x00, 0x83, 0x63, 0x1F,
  0x00, 0x0F, 0x8C, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x3D, 0xB1, 0xD0, 0x78, 0x3C, 0x1E, 0x0F,
  0x06, 0x83, 0x63, 0x9E, 0xC0, 0x6C, 0x36, 0x30, 0xF0, 0x80, 0x80, 0x80,
  0x80, 0x9C, 0xA6, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x0C,
  0x06, 0x00, 0x00, 0x07, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC7, 0xFC, 0x06, 0x0C, 0x00, 0x07, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x0D, 0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3,
  0xC6, 0xCC, 0xD8, 0xF0, 0xF8, 0xCC, 0xC6, 0xC6, 0xC3, 0x7C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7,
  0xFC, 0xBB, 0xE6, 0x73, 0x39, 0x9C, 0x8E, 0x47, 0x23, 0x91, 0xC8, 0xE4,
  0x40, 0x9E, 0xA6, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x3E,
  0x31, 0x90, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x63, 0x1F, 0x00, 0x9C,
  0xA6, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0xC3, 0xC6, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x3D, 0xB1, 0xD0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x63, 0x9E,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0xCF, 0x50, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x7C, 0xC6, 0xC3, 0xC0, 0x78, 0x1E, 0x03, 0x83, 0xC2,
  0x7C, 0x20, 0x41, 0x87, 0xF6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x03,
  0xE0, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC7, 0x7B, 0xC0,
  0xF0, 0x64, 0x19, 0x84, 0x63, 0x0C, 0x83, 0x60, 0x58, 0x1C, 0x07, 0x00,
  0xC0, 0x78, 0x0D, 0x01, 0xA3, 0x36, 0xE4, 0xD4, 0x9A, 0xD3, 0xCE, 0x31,
  0xC6, 0x38, 0xC1, 0x98, 0xC3, 0x20, 0x58, 0x1C, 0x07, 0x03, 0x60, 0x8C,
  0x61, 0x30, 0x60, 0xC0, 0xF0, 0x64, 0x19, 0x84, 0x23, 0x0C, 0x83, 0x60,
  0x58, 0x1C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x18, 0x00, 0x7F, 0x81, 0x80,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x7F, 0xC0, 0x0F, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x30, 0xC0, 0x30, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x18, 0x0F, 0xFF, 0xFF, 0xC0, 0xF0, 0x20, 0x60, 0xC1, 0x83, 0x06,
  0x06, 0x06, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x11, 0xE0, 0xF8, 0x03,
  0xC0,
};

const GFXglyph LiberationMono_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 13, 11, 5, -13 },
  { 5, 6, 6, 11, 3, -14 },
  { 10, 11, 13, 11, 0, -13 },
  { 28, 10, 17, 11, 1, -15 },
  { 50, 11, 13, 11, 0, -13 },
  { 68, 11, 13, 11, 0, -13 },
  { 86, 2, 6, 11, 5, -14 },
  { 88, 5, 18, 11, 3, -14 },
  { 100, 5, 18, 11, 3, -14 },
  { 112, 7, 7, 11, 2, -14 },
  { 119, 9, 9, 11, 1, -11 },
  { 130, 4, 6, 11, 2, -3 },
  { 133, 5, 1, 11, 3, -6 },
  { 134, 2, 3, 11, 5, -3 },
  { 135, 9, 14, 11, 1, -14 },
  { 151, 9, 13, 11, 1, -13 },
  { 166, 9, 13, 11, 1, -13 },
  { 181, 9, 13, 11, 1, -13 },
  { 196, 9, 13, 11, 1, -13 },
  { 211, 9, 13, 11, 1, -13 },
  { 226, 9, 13, 11, 1, -13 },
  { 241, 9, 13, 11, 1, -13 },
  { 256, 9, 13, 11, 1, -13 },
  { 271, 9, 13, 11, 1, -13 },
  { 286, 9, 13, 11, 1, -13 },
  { 301, 2, 10, 11, 5, -10 },
  { 304, 4, 13, 11, 3, -10 },
  { 311, 9, 9, 11, 1, -11 },
  { 322, 9, 5, 11, 1, -9 },
  { 328, 9, 9, 11, 1, -11 },
  { 339, 9, 13, 11, 1, -13 },
  { 354, 11, 16, 11, 0, -14 },
  { 376, 11, 13, 11, 0, -13 },
  { 394, 10, 13, 11, 1, -13 },
  { 411, 10, 13, 11, 1, -13 },
  { 428, 9, 13, 11, 1, -13 },
  { 443, 9, 13, 11, 1, -13 },
  { 458, 8, 13, 11, 2, -13 },
  { 471, 9, 13, 11, 1, -13 },
  { 486, 9, 13, 11, 1, -13 },
  { 501, 8, 13, 11, 2, -13 },
  { 514, 7, 13, 11, 2, -13 },
  { 526, 10, 13, 11, 1, -13 },
  { 543, 8, 13, 11, 2, -13 },
  { 556, 9, 13, 11, 1, -13 },
  { 571, 9, 13, 11, 1, -13 },
  { 586, 9, 13, 11, 1, -13 },
  { 601, 9, 13, 11, 1, -13 },
  { 616, 10, 17, 11, 1, -13 },
  { 638, 10, 13, 11, 1, -13 },
  { 655, 9, 13, 11, 1, -13 },
  { 670, 10, 13, 11, 1, -13 },
  { 687, 9, 13, 11, 1, -13 },
  { 702, 11, 13, 11, 0, -13 },
  { 720, 11, 13, 11, 0, -13 },
  { 738, 11, 13, 11, 0, -13 },
  { 756, 11, 13, 11, 0, -13 },
  { 774, 10, 13, 11, 1, -13 },
  { 791, 5, 18, 11, 4, -14 },
  { 803, 9, 14, 11, 1, -14 },
  { 819, 6, 18, 11, 2, -14 },
  { 833, 9, 8, 11, 1, -13 },
  { 842, 11, 1, 11, 0, 1 },
  { 844, 4, 3, 11, 4, -14 },
  { 846, 10, 10, 11, 1, -10 },
  { 859, 8, 14, 11, 2, -14 },
  { 873, 9, 10, 11, 1, -10 },
  { 885, 9, 14, 11, 1, -14 },
  { 901, 9, 10, 11, 1, -10 },
  { 913, 9, 14, 11, 1, -14 },
  { 929, 9, 14, 11, 1, -10 },
  { 945, 8, 14, 11, 2, -14 },
  { 959, 9, 14, 11, 1, -14 },
  { 975, 7, 18, 11, 1, -14 },
  { 991, 8, 14, 11, 2, -14 },
  { 1005, 9, 14, 11, 1, -14 },
  { 1021, 9, 10, 11, 1, -10 },
  { 1033, 8, 10, 11, 2, -10 },
  { 1043, 9, 10, 11, 1, -10 },
  { 1055, 8, 14, 11, 2, -10 },
  { 1069, 9, 14, 11, 1, -10 },
  { 1085, 8, 10, 11, 2, -10 },
  { 1095, 8, 10, 11, 2, -10 },
  { 1105, 7, 13, 11, 2, -13 },
  { 1117, 8, 10, 11, 2, -10 },
  { 1127, 10, 10, 11, 1, -10 },
  { 1140, 11, 10, 11, 0, -10 },
  { 1154, 10, 10, 11, 1, -10 },
  { 1167, 10, 14, 11, 1, -10 },
  { 1185, 9, 10, 11, 1, -10 },
  { 1197, 8, 18, 11, 2, -14 },
  { 1215, 1, 18, 11, 5, -14 },
  { 1218, 7, 18, 11, 2, -14 },
  { 1234, 9, 2, 11, 1, -7 },
};

const GFXfont LiberationMono_Regular19pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular19pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _LIBERATIONMONO_REGULAR19PT7B_H_
