#ifndef _LIBERATIONMONO_REGULAR63PT7B_H_
#define _LIBERATIONMONO_REGULAR63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x1E, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF8, 0xF1, 0xFF, 0x07, 0xF0, 0x78, 0x3F, 0x87, 0xE0, 0x3C, 0x0F, 0xE3,
  0xF0, 0x1E, 0x03, 0xF1, 0xF0, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x80, 0x70,
  0x7C, 0x03, 0xC0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00, 0xFF, 0x9E, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3C, 0x7F, 0xC0, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x0F,
  0x01, 0xF8, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC6, 0x00, 0x78, 0x03, 0xFF, 0x80,
  0x3C, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0xFB, 0xF0, 0x0F, 0x00, 0xFD, 0xFC,
  0x07, 0x80, 0xFE, 0x7F, 0x03, 0xC0, 0xFE, 0x3F, 0xF1, 0xE1, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0x83, 0xFF, 0xE0, 0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0x7C, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x78,
  0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x3C, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x0F,
  0x80, 0x78, 0x3C, 0x00, 0x1E, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0x7C, 0x3C, 0x00, 0x03, 0xFF, 0xE1, 0xF0, 0x00, 0x07,
  0xFF, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00,
  0x01, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0x8F, 0xFF, 0xC0, 0x00, 0x3C, 0x3E,
  0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x78, 0x00,
  0x3C, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x7C, 0x00, 0x07, 0xFF,
  0x81, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00,
  0x3E, 0x0F, 0xE0, 0x00, 0x07, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x0C, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x1F, 0xFE, 0x00, 0x3E, 0x03, 0xF7,
  0xE0, 0x07, 0xC0, 0xFC, 0x7C, 0x00, 0xF0, 0x3F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xF8, 0x3E,
  0x07, 0xC0, 0x1F, 0x87, 0xC1, 0xF8, 0x01, 0xF8, 0xF0, 0x3F, 0x00, 0x1F,
  0x3E, 0x07, 0xC0, 0x03, 0xF7, 0xC0, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0x80,
  0x03, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0x78, 0xF1,
  0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x80,
  0xBE, 0x1E, 0x1E, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF3,
  0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0E, 0x01, 0xC0, 0x10, 0x04, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x1F,
  0xC0, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xF0,
  0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0xFF, 0xE7,
  0xE0, 0x03, 0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3C, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x0F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F,
  0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x83, 0xFC, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0xFB, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC7, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1C, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0xF8, 0x7F, 0xFC, 0x07, 0xC7,
  0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0xE1, 0xF7, 0xFF, 0xFF, 0x8F, 0xFE, 0x03,
  0xFC, 0x7F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E,
  0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0x80, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x1F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFE,
  0x00, 0x7F, 0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0xE3, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFE, 0xF8, 0x7F, 0xFF, 0xE7, 0xC1,
  0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xC1, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0xF8, 0x03, 0xC1, 0xE0, 0x3F, 0xE7, 0xBC, 0x1E, 0x07,
  0xFE, 0x79, 0xE3, 0xE0, 0xF8, 0x77, 0x9E, 0x3C, 0x1F, 0x03, 0x79, 0xE3,
  0xC1, 0xE0, 0x3F, 0x1E, 0x3C, 0x3C, 0x03, 0xF0, 0xE7, 0x83, 0xC0, 0x1F,
  0x0E, 0x78, 0x7C, 0x01, 0xF0, 0xF7, 0x87, 0x80, 0x1F, 0x0F, 0x78, 0x78,
  0x01, 0xE0, 0xF7, 0x8F, 0x80, 0x1E, 0x0F, 0x78, 0xF0, 0x01, 0xE0, 0xF7,
  0x0F, 0x00, 0x3E, 0x0F, 0xF0, 0xF0, 0x03, 0xE0, 0xEF, 0x0F, 0x00, 0x3C,
  0x0E, 0xF0, 0xF0, 0x03, 0xC0, 0xEF, 0x0F, 0x00, 0x3C, 0x1E, 0xF0, 0xF0,
  0x03, 0xC1, 0xEF, 0x0F, 0x00, 0x7C, 0x1E, 0xF0, 0xF0, 0x07, 0x81, 0xEF,
  0x0F, 0x00, 0x78, 0x1C, 0x70, 0xF0, 0x0F, 0x81, 0xC7, 0x8F, 0x00, 0xF8,
  0x3C, 0x78, 0xF0, 0x0F, 0x83, 0x87, 0x8F, 0x01, 0xB8, 0x78, 0x78, 0x78,
  0x3B, 0x87, 0x87, 0x87, 0xC7, 0x38, 0xF0, 0x3C, 0x3F, 0xF3, 0xFE, 0x03,
  0xC1, 0xFE, 0x1F, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x08, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x01, 0xFF, 0x8F, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x20, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x3F, 0x00, 0x00,
  0x1E, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0, 0x07, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xF0,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x03, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x7E, 0x00, 0xFF, 0xFE,
  0xFC, 0x01, 0xFF, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFE,
  0x00, 0x1F, 0xC1, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x38,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xBF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xC0, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xDF, 0xFB,
  0xC0, 0x0F, 0x7F, 0xEF, 0x80, 0x7D, 0xFF, 0xBE, 0x01, 0xE7, 0xFE, 0x7C,
  0x07, 0x9F, 0xF9, 0xF0, 0x3E, 0x7F, 0xE7, 0xC0, 0xF1, 0xFF, 0x8F, 0x87,
  0xC7, 0xFE, 0x3E, 0x1F, 0x1F, 0xF8, 0xF8, 0x78, 0x7F, 0xE1, 0xF3, 0xE1,
  0xFF, 0x87, 0xCF, 0x87, 0xFE, 0x0F, 0x3C, 0x1F, 0xF8, 0x3E, 0xF0, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF8,
  0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x01,
  0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFB,
  0xE0, 0x03, 0xFF, 0xBE, 0x00, 0x3F, 0xFB, 0xF0, 0x03, 0xFF, 0x9F, 0x00,
  0x3F, 0xF9, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x3F, 0xF8, 0xF8, 0x03, 0xFF,
  0x87, 0xC0, 0x3F, 0xF8, 0x7C, 0x03, 0xFF, 0x83, 0xE0, 0x3F, 0xF8, 0x3E,
  0x03, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF8, 0x3F,
  0xF8, 0x0F, 0x83, 0xFF, 0x80, 0xFC, 0x3F, 0xF8, 0x07, 0xC3, 0xFF, 0x80,
  0x7C, 0x3F, 0xF8, 0x03, 0xE3, 0xFF, 0x80, 0x3E, 0x3F, 0xF8, 0x01, 0xF1,
  0xFF, 0x80, 0x1F, 0x1F, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x0F, 0x9F, 0xF8,
  0x00, 0xFD, 0xFF, 0x80, 0x07, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x7E, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xEF, 0xC0, 0x07, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0x80, 0x03, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0E, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x0C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x7C, 0x07,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xE0, 0x3E, 0x07, 0xC0, 0xFF, 0x80, 0xF8,
  0x1F, 0x03, 0xDF, 0x07, 0xE0, 0x7E, 0x0F, 0x3C, 0x1F, 0x01, 0xF8, 0x3C,
  0xF0, 0x7C, 0x03, 0xE1, 0xF3, 0xC1, 0xF0, 0x0F, 0x87, 0xCF, 0x87, 0xC0,
  0x3E, 0x1E, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x78, 0x7C, 0x03, 0xE3, 0xE1,
  0xF1, 0xF0, 0x0F, 0x8F, 0x87, 0xCF, 0x80, 0x1F, 0x3C, 0x0F, 0x3E, 0x00,
  0x7C, 0xF0, 0x3C, 0xF8, 0x01, 0xF7, 0xC0, 0xF3, 0xE0, 0x07, 0xDE, 0x03,
  0xEF, 0x80, 0x1F, 0x78, 0x07, 0xBE, 0x00, 0x7D, 0xE0, 0x1E, 0xF0, 0x01,
  0xFF, 0x80, 0x7B, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0,
  0x7E, 0x00, 0xF7, 0xE0, 0x7F, 0x83, 0xF3, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x3E,
  0x1F, 0xFF, 0x01, 0xF1, 0xFF, 0xFC, 0x0F, 0x9F, 0xFF, 0xF0, 0x7D, 0xF0,
  0x3F, 0xC3, 0xEE, 0x00, 0x7E, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFE, 0x00, 0xFE, 0x1F, 0x7C, 0x0F, 0xE0,
  0xF9, 0xFF, 0xFF, 0x07, 0xC7, 0xFF, 0xF0, 0x3E, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x3F, 0xFE, 0x1F, 0x07,
  0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x9F, 0x1F, 0xE0, 0x7D, 0xF1, 0xF8, 0x01,
  0xDF, 0x3F, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xF3, 0xF8, 0x01,
  0xDF, 0x1F, 0xE0, 0x7D, 0xF0, 0xFF, 0xFF, 0x9F, 0x07, 0xFF, 0xF1, 0xF0,
  0x3F, 0xFE, 0x1F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0C,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF,
  0xFF, 0x9F, 0x1F, 0xE0, 0x7D, 0xF1, 0xF8, 0x01, 0xDF, 0x3F, 0x00, 0x0F,
  0xF3, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xF3, 0xF0,
  0x00, 0xFF, 0x3F, 0x80, 0x1D, 0xF1, 0xFE, 0x07, 0xDF, 0x0F, 0xFF, 0xF9,
  0xF0, 0x7F, 0xFF, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x0F, 0xF0, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x07, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0xE0, 0x3E, 0x1F, 0xFF, 0x0F, 0x8F, 0xFF, 0xE3, 0xE7, 0xFF,
  0xFC, 0xFB, 0xE0, 0x7F, 0xBE, 0xE0, 0x07, 0xEF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xCC, 0x01, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xF8,
  0x00, 0xFF, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0xF9,
  0xFF, 0x0F, 0xF8, 0xF9, 0xFF, 0x1F, 0xFC, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF,
  0x0F, 0xB8, 0x7E, 0xFE, 0x0F, 0xB0, 0x7E, 0xFE, 0x07, 0xF0, 0x3E, 0xFC,
  0x07, 0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xF8, 0x0F, 0x87, 0xFF, 0xC1, 0xF1, 0xFF, 0xFC, 0x3E, 0x7F, 0xFF,
  0xC7, 0xDF, 0x03, 0xFC, 0xFB, 0x80, 0x1F, 0x9F, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xE1, 0xFF,
  0xF0, 0x1F, 0x1F, 0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0x07, 0xDF, 0x03, 0xFC,
  0x3E, 0xE0, 0x07, 0xE1, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xF8, 0xFE, 0x00, 0x0F, 0xC7,
  0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x07, 0xE1, 0xF7, 0xC0, 0xFF, 0x0F, 0x9F,
  0xFF, 0xF0, 0x7C, 0x7F, 0xFF, 0x03, 0xE1, 0xFF, 0xF0, 0x1F, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x9F, 0x1F,
  0xE0, 0x7D, 0xF1, 0xF8, 0x01, 0xDF, 0x3F, 0x00, 0x0F, 0xF3, 0xF0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x3F,
  0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xDF, 0x1F, 0xE0, 0x7D, 0xF0, 0xFF, 0xFF,
  0x9F, 0x07, 0xFF, 0xF1, 0xF0, 0x3F, 0xFC, 0x1F, 0x00, 0x7F, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xBE, 0x07, 0xFF,
  0xDF, 0x07, 0xFF, 0xEF, 0x87, 0xFF, 0xF7, 0xE7, 0xFF, 0xFB, 0xF3, 0xF0,
  0x04, 0xFB, 0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x38, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0E, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x77, 0xDF, 0xE0, 0x7D,
  0xF3, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0x87, 0xC0, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7C, 0x7E, 0x03, 0xF8, 0x07,
  0xC3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x03, 0xFC, 0x07, 0xC3, 0xE0, 0x7F,
  0xC0, 0xFC, 0x3E, 0x07, 0xBE, 0x0F, 0xC3, 0xF0, 0x79, 0xE0, 0xF8, 0x3F,
  0x07, 0x9E, 0x0F, 0x81, 0xF0, 0xF1, 0xF0, 0xF8, 0x1F, 0x0F, 0x0F, 0x0F,
  0x81, 0xF0, 0xF0, 0xF1, 0xF8, 0x1F, 0x1F, 0x0F, 0x1F, 0x81, 0xF1, 0xE0,
  0x79, 0xF0, 0x1F, 0x1E, 0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x79, 0xF0, 0x0F,
  0xBC, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x3D, 0xF0, 0x0F, 0xFC, 0x03, 0xDE,
  0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x05, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF8,
};

const GFXglyph LiberationMono_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 6, 42, 38, 16, -42 },
  { 33, 20, 20, 38, 9, -46 },
  { 83, 34, 42, 38, 2, -42 },
  { 262, 33, 51, 38, 2, -46 },
  { 473, 38, 44, 38, 0, -43 },
  { 682, 35, 43, 38, 1, -42 },
  { 871, 7, 20, 38, 15, -46 },
  { 889, 16, 59, 38, 11, -46 },
  { 1007, 17, 59, 38, 10, -46 },
  { 1133, 22, 22, 38, 8, -46 },
  { 1194, 30, 30, 38, 4, -36 },
  { 1307, 13, 20, 38, 8, -9 },
  { 1340, 18, 5, 38, 10, -19 },
  { 1352, 7, 9, 38, 15, -9 },
  { 1360, 31, 47, 38, 3, -46 },
  { 1543, 30, 44, 38, 4, -43 },
  { 1708, 30, 42, 38, 5, -42 },
  { 1866, 29, 43, 38, 4, -43 },
  { 2022, 30, 44, 38, 4, -43 },
  { 2187, 32, 42, 38, 3, -42 },
  { 2355, 30, 43, 38, 4, -42 },
  { 2517, 29, 44, 38, 5, -43 },
  { 2677, 28, 42, 38, 5, -42 },
  { 2824, 30, 44, 38, 4, -43 },
  { 2989, 29, 44, 38, 4, -43 },
  { 3149, 7, 33, 38, 15, -33 },
  { 3178, 13, 44, 38, 11, -33 },
  { 3250, 30, 32, 38, 4, -37 },
  { 3370, 30, 20, 38, 4, -31 },
  { 3445, 30, 32, 38, 4, -37 },
  { 3565, 30, 43, 38, 3, -43 },
  { 3727, 36, 55, 38, 1, -46 },
  { 3975, 38, 42, 38, 0, -42 },
  { 4175, 30, 42, 38, 5, -42 },
  { 4333, 32, 44, 38, 3, -43 },
  { 4509, 30, 42, 38, 5, -42 },
  { 4667, 30, 42, 38, 5, -42 },
  { 4825, 27, 42, 38, 6, -42 },
  { 4967, 31, 44, 38, 3, -43 },
  { 5138, 28, 42, 38, 5, -42 },
  { 5285, 26, 42, 38, 6, -42 },
  { 5422, 25, 43, 38, 5, -42 },
  { 5557, 33, 42, 38, 5, -42 },
  { 5731, 27, 42, 38, 7, -42 },
  { 5873, 30, 42, 38, 4, -42 },
  { 6031, 28, 42, 38, 5, -42 },
  { 6178, 32, 44, 38, 3, -43 },
  { 6354, 29, 42, 38, 5, -42 },
  { 6507, 32, 55, 38, 3, -43 },
  { 6727, 31, 42, 38, 5, -42 },
  { 6890, 33, 44, 38, 2, -43 },
  { 7072, 33, 42, 38, 2, -42 },
  { 7246, 29, 43, 38, 4, -42 },
  { 7402, 37, 42, 38, 0, -42 },
  { 7597, 38, 42, 38, 0, -42 },
  { 7797, 36, 42, 38, 1, -42 },
  { 7986, 36, 42, 38, 1, -42 },
  { 8175, 34, 42, 38, 2, -42 },
  { 8354, 16, 59, 38, 13, -46 },
  { 8472, 30, 47, 38, 4, -46 },
  { 8649, 17, 59, 38, 8, -46 },
  { 8775, 30, 28, 38, 4, -42 },
  { 8880, 38, 3, 38, 0, 4 },
  { 8895, 13, 8, 38, 12, -45 },
  { 8908, 32, 35, 38, 4, -34 },
  { 9048, 29, 47, 38, 5, -46 },
  { 9219, 29, 35, 38, 4, -34 },
  { 9346, 28, 47, 38, 4, -46 },
  { 9511, 30, 35, 38, 4, -34 },
  { 9643, 30, 46, 38, 4, -46 },
  { 9816, 28, 47, 38, 4, -34 },
  { 9981, 26, 46, 38, 6, -46 },
  { 10131, 31, 46, 38, 4, -46 },
  { 10310, 22, 59, 38, 4, -46 },
  { 10473, 28, 46, 38, 7, -46 },
  { 10634, 30, 46, 38, 4, -46 },
  { 10807, 32, 34, 38, 3, -34 },
  { 10943, 27, 34, 38, 5, -34 },
  { 11058, 30, 35, 38, 4, -34 },
  { 11190, 29, 47, 38, 5, -34 },
  { 11361, 28, 47, 38, 4, -34 },
  { 11526, 25, 34, 38, 7, -34 },
  { 11633, 28, 35, 38, 5, -34 },
  { 11756, 25, 43, 38, 6, -42 },
  { 11891, 26, 34, 38, 6, -33 },
  { 12002, 34, 33, 38, 2, -33 },
  { 12143, 36, 33, 38, 1, -33 },
  { 12292, 32, 33, 38, 3, -33 },
  { 12424, 34, 46, 38, 2, -33 },
  { 12620, 28, 33, 38, 5, -33 },
  { 12736, 26, 59, 38, 7, -46 },
  { 12928, 5, 59, 38, 16, -46 },
  { 12965, 26, 59, 38, 5, -46 },
  { 13157, 31, 8, 38, 3, -25 },
};

const GFXfont LiberationMono_Regular63pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular63pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular63pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _LIBERATIONMONO_REGULAR63PT7B_H_
