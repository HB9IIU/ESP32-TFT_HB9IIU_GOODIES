#ifndef _LIBERATIONMONO_REGULAR26PT7B_H_
#define _LIBERATIONMONO_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xC7, 0xC7, 0xC7, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0x04, 0x10, 0x30, 0xC0, 0xC3, 0x02, 0x08, 0x08, 0x23, 0xFF,
  0xF1, 0x86, 0x06, 0x18, 0x10, 0x40, 0x41, 0x0F, 0xFF, 0x8C, 0x30, 0x20,
  0x80, 0x82, 0x02, 0x08, 0x18, 0x60, 0x61, 0x80, 0x03, 0x00, 0x0C, 0x01,
  0xFC, 0x0F, 0xFC, 0x73, 0x39, 0x8C, 0x66, 0x30, 0x18, 0xC0, 0x73, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0x18, 0x0C, 0x70, 0x31, 0xF0, 0xC6,
  0xE3, 0x39, 0xFF, 0xC1, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x7C, 0x0C, 0x46,
  0x0C, 0xC6, 0x18, 0xC6, 0x30, 0xC6, 0x30, 0xC6, 0x60, 0x46, 0xC0, 0x3C,
  0x80, 0x01, 0x80, 0x03, 0x3C, 0x06, 0x66, 0x06, 0xC2, 0x0C, 0xC3, 0x18,
  0xC3, 0x18, 0xC2, 0x30, 0x66, 0x60, 0x3C, 0x0F, 0x80, 0x7F, 0x03, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0x67, 0x01, 0xF0, 0x0F, 0x04, 0x7C, 0x33, 0x98,
  0xCC, 0x73, 0x30, 0xC8, 0xC1, 0xE3, 0x03, 0x8E, 0x1F, 0x1F, 0xEF, 0x3E,
  0x1C, 0xFD, 0xB6, 0xDB, 0x0E, 0x18, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0x61,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xE1, 0xC1, 0x83, 0x83, 0x03,
  0x07, 0x60, 0xE0, 0xE0, 0xC1, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0xE1, 0x87, 0x1C, 0x30, 0x0C, 0x06,
  0x13, 0x3F, 0xF3, 0xE0, 0xE0, 0x58, 0x66, 0x23, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0xE3, 0x9C, 0x71, 0x86, 0x30, 0xFF,
  0xFC, 0xFF, 0xF0, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0x1F, 0x83,
  0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0xE3, 0xCE, 0x3C,
  0xE3, 0xC0, 0x3C, 0x07, 0xC0, 0x7E, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x00,
  0x07, 0x00, 0xF0, 0x1B, 0x0F, 0xB0, 0xE3, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x60,
  0x06, 0x00, 0xE0, 0xF8, 0x0F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x3E,
  0x07, 0xF0, 0xE7, 0xFE, 0x1F, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x06,
  0xC0, 0x66, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x19,
  0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xE7,
  0xFE, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x8F, 0xFC, 0xE0, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0xE7, 0xFC, 0x1F, 0x80,
  0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x0C, 0x00, 0xCF, 0x8D, 0xFE,
  0xF0, 0xEE, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x76, 0x07, 0x70, 0xE3, 0xFC,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0x1F, 0x87, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x6E,
  0x06, 0x70, 0xE3, 0xFC, 0x3F, 0xC6, 0x0E, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0xE7, 0xFE, 0x1F, 0x80, 0x1F, 0x07, 0xFC, 0x70, 0xEE, 0x06,
  0xC0, 0x6C, 0x07, 0xC0, 0x7E, 0x07, 0x70, 0xF7, 0xFF, 0x1E, 0x70, 0x06,
  0x00, 0x6E, 0x0E, 0x61, 0xC7, 0xF8, 0x1F, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCE, 0x38,
  0xC7, 0x18, 0x61, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x7C, 0x1F, 0x83, 0xE0,
  0x7C, 0x03, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3C, 0x00, 0x60, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x0C, 0x00,
  0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0, 0x7E, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x07, 0xC0, 0x61, 0x83, 0x01, 0x08, 0x06,
  0x60, 0x09, 0x0E, 0xBC, 0xCA, 0xF2, 0x1B, 0x98, 0x66, 0x61, 0x99, 0x04,
  0x64, 0x13, 0x90, 0xCE, 0x43, 0x39, 0x0C, 0xA4, 0x72, 0xD9, 0xDB, 0x39,
  0xC6, 0x00, 0x08, 0x04, 0x38, 0x60, 0x3E, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x70, 0x0C, 0x30,
  0x18, 0x30, 0x18, 0x18, 0x3F, 0xF8, 0x3F, 0xFC, 0x30, 0x0C, 0x70, 0x0C,
  0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xFF, 0x87, 0xFF, 0x30, 0x39, 0x80,
  0xEC, 0x07, 0x60, 0x33, 0x03, 0x9F, 0xF0, 0xFF, 0xC6, 0x03, 0xB0, 0x0D,
  0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x01, 0xDF, 0xFC, 0xFF, 0x80, 0x0F, 0xC0,
  0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70, 0x11, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x19, 0xC0, 0x63, 0x87,
  0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xC1, 0xEC, 0x0E, 0xC0, 0x7C,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x0E, 0xC1, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0xFF, 0x0E, 0x1C, 0xE0, 0x77, 0x01, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE1,
  0xFF, 0x0F, 0xD8, 0x06, 0xC0, 0x37, 0x01, 0xB8, 0x0C, 0xE0, 0xE3, 0xFE,
  0x07, 0xC0, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x70, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF,
  0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7E, 0x0D, 0xC1, 0x9C, 0x71, 0xFC,
  0x1F, 0x00, 0xC0, 0x73, 0x03, 0x8C, 0x0C, 0x30, 0x70, 0xC3, 0x83, 0x1C,
  0x0C, 0xE0, 0x37, 0x00, 0xFE, 0x03, 0xDC, 0x0E, 0x38, 0x30, 0xE0, 0xC1,
  0xC3, 0x03, 0x8C, 0x07, 0x30, 0x0C, 0xC0, 0x38, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xE0, 0xE0, 0x7E, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xBD, 0x9B, 0xD9, 0x3C, 0xF3, 0xCF, 0x3C, 0xE3, 0xC6,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x87, 0xD8, 0x7D, 0x87, 0xCC, 0x7C, 0xC7, 0xC6, 0x7C,
  0x67, 0xC3, 0x7C, 0x37, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF0,
  0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x76, 0x03, 0xB8, 0x18, 0xE1,
  0xC3, 0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0xFE, 0xC0, 0xEC, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xEF, 0xFC, 0xFF, 0x8C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0,
  0x66, 0x03, 0xB0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06,
  0xC0, 0x76, 0x03, 0xB8, 0x18, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0F, 0x80, 0x3C, 0xFF, 0x87, 0xFF, 0x30, 0x1D, 0x80,
  0x6C, 0x03, 0x60, 0x1B, 0x01, 0xDF, 0xFC, 0xFF, 0x86, 0x18, 0x30, 0xE1,
  0x83, 0x8C, 0x0C, 0x60, 0x73, 0x01, 0x98, 0x0E, 0xC0, 0x38, 0x0F, 0xC1,
  0xFF, 0x1C, 0x1C, 0xC0, 0x76, 0x03, 0xB0, 0x01, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3E, 0x01, 0xF0, 0x0D, 0xC1, 0xE7, 0xFE,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x06, 0xF0, 0xE7, 0xFC, 0x1F, 0x80, 0xE0, 0x06,
  0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0x63, 0x01, 0xC7, 0x03, 0x06, 0x06, 0x0C,
  0x1C, 0x1C, 0x30, 0x18, 0x60, 0x31, 0xC0, 0x73, 0x00, 0x6E, 0x00, 0xD8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x61, 0x8E, 0x63, 0x8E, 0x63, 0xCC, 0x73, 0xCC,
  0x76, 0xCC, 0x36, 0x4C, 0x36, 0x6C, 0x36, 0x6C, 0x3C, 0x68, 0x3C, 0x38,
  0x3C, 0x38, 0x18, 0x38, 0x70, 0x0C, 0x70, 0x38, 0x60, 0xE0, 0xE1, 0x80,
  0xE7, 0x00, 0xDC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x1B,
  0x80, 0x73, 0x00, 0xC3, 0x03, 0x07, 0x0E, 0x06, 0x38, 0x06, 0x60, 0x0E,
  0x60, 0x0E, 0xE0, 0x18, 0xE0, 0x70, 0xC1, 0xC1, 0xC3, 0x01, 0x8E, 0x03,
  0x98, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x7F, 0xF9, 0xFF, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xFF, 0xFF, 0x0E, 0x00, 0xF0, 0x1B, 0x01, 0x90, 0x19, 0x83, 0x18,
  0x30, 0xC6, 0x0C, 0x60, 0x46, 0x06, 0xC0, 0x6C, 0x03, 0xFF, 0xFF, 0xE1,
  0x86, 0x3F, 0x03, 0xFE, 0x38, 0x30, 0x01, 0xC0, 0x0E, 0x1F, 0xF1, 0xFF,
  0x9C, 0x1C, 0xC0, 0xE6, 0x07, 0x30, 0x39, 0xC7, 0xCF, 0xE7, 0xBE, 0x3C,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xFF, 0xCF, 0x0E,
  0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06,
  0xF0, 0xEF, 0xFC, 0xEF, 0x80, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x07, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x77, 0x0E, 0x3F,
  0xC1, 0xF8, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7C, 0xDF, 0xDB,
  0x8F, 0xE0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x07,
  0x71, 0xEF, 0xEC, 0xF9, 0x80, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xC0,
  0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x67, 0x0E, 0x3F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFF, 0x1C, 0x01, 0xC0, 0x18, 0x0F, 0xFF, 0xFF,
  0xF1, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x3E, 0x6F, 0xED, 0xC7, 0xF0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xF8, 0xF7,
  0xF6, 0x7C, 0xC0, 0x1B, 0x03, 0x70, 0xE7, 0xF8, 0x7E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF, 0x3F, 0xF7, 0x87, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0x80, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xEF, 0xF1, 0xF8,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xF0, 0x76, 0x1C, 0xC7,
  0x19, 0xC3, 0x70, 0x6E, 0x0F, 0xE1, 0xCC, 0x31, 0xC6, 0x1C, 0xC1, 0x98,
  0x1B, 0x03, 0x80, 0x7E, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0xDC, 0x76, 0xF7, 0xF9,
  0xE7, 0xC6, 0x3E, 0x31, 0xF1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18,
  0xF0, 0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8C, 0xC7, 0x9F, 0xFB, 0xC3, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xC0, 0x1F, 0x87, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x67, 0x0E, 0x3F, 0xC1, 0xF8,
  0xEF, 0x8F, 0xFC, 0xF0, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x6F, 0x0E, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x3E, 0x6F, 0xED, 0xC7, 0xF0, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xB8, 0xF7, 0xF6, 0x7C,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xC7, 0xFB, 0xF7, 0xC1,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x1F, 0x87, 0xF9, 0x83, 0xB0, 0x36, 0x00, 0xF0, 0x0F, 0xE0,
  0x3E, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x77, 0xFC, 0x3F, 0x00, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x0F, 0xFD, 0xFF, 0x86, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xE1, 0xF8, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xB8, 0xF7, 0xF6, 0x7C, 0xC0, 0xE0, 0x1F, 0x80, 0x66, 0x03,
  0x9C, 0x0C, 0x30, 0x70, 0xC1, 0xC3, 0x86, 0x06, 0x38, 0x1C, 0xC0, 0x33,
  0x00, 0xDC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x36, 0x38, 0xEC, 0x71, 0x9C, 0xF3, 0x1B, 0x66, 0x36,
  0x4C, 0x6C, 0xD8, 0xD1, 0xF1, 0xE1, 0xC3, 0xC3, 0x83, 0x07, 0x00, 0x60,
  0x39, 0x83, 0x8E, 0x18, 0x31, 0xC0, 0xDC, 0x07, 0xC0, 0x1C, 0x00, 0xF0,
  0x0F, 0x80, 0xE6, 0x06, 0x38, 0x60, 0xE7, 0x03, 0x30, 0x1C, 0xE0, 0x1D,
  0x80, 0x66, 0x03, 0x9C, 0x0C, 0x30, 0x70, 0xE1, 0x81, 0x86, 0x07, 0x38,
  0x0C, 0xC0, 0x37, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xC3, 0xF0, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xC0, 0xF0, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1E, 0x07,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x3F,
  0x87, 0xC0, 0x3C, 0x07, 0xF8, 0x70, 0xFF, 0x01, 0xE0,
};

const GFXglyph LiberationMono_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 17, 16, 7, -17 },
  { 6, 8, 8, 16, 4, -19 },
  { 14, 14, 17, 16, 1, -17 },
  { 44, 14, 21, 16, 1, -19 },
  { 81, 16, 17, 16, 0, -17 },
  { 115, 14, 17, 16, 1, -17 },
  { 145, 3, 8, 16, 6, -19 },
  { 148, 7, 24, 16, 4, -19 },
  { 169, 7, 24, 16, 4, -19 },
  { 190, 9, 9, 16, 3, -19 },
  { 201, 13, 12, 16, 1, -15 },
  { 221, 6, 8, 16, 3, -4 },
  { 227, 7, 2, 16, 4, -8 },
  { 229, 3, 4, 16, 6, -4 },
  { 231, 13, 19, 16, 1, -19 },
  { 262, 12, 17, 16, 2, -17 },
  { 288, 12, 17, 16, 2, -17 },
  { 314, 12, 17, 16, 2, -17 },
  { 340, 12, 17, 16, 2, -17 },
  { 366, 13, 17, 16, 1, -17 },
  { 394, 12, 17, 16, 2, -17 },
  { 420, 12, 17, 16, 2, -17 },
  { 446, 12, 17, 16, 2, -17 },
  { 472, 12, 17, 16, 2, -17 },
  { 498, 12, 17, 16, 2, -17 },
  { 524, 3, 14, 16, 6, -14 },
  { 530, 6, 18, 16, 4, -14 },
  { 544, 13, 13, 16, 1, -15 },
  { 566, 13, 8, 16, 1, -13 },
  { 579, 13, 13, 16, 1, -15 },
  { 601, 13, 17, 16, 1, -17 },
  { 629, 14, 22, 16, 1, -19 },
  { 668, 16, 17, 16, 0, -17 },
  { 702, 13, 17, 16, 2, -17 },
  { 730, 14, 17, 16, 1, -17 },
  { 760, 12, 17, 16, 2, -17 },
  { 786, 12, 17, 16, 2, -17 },
  { 812, 12, 17, 16, 2, -17 },
  { 838, 13, 17, 16, 1, -17 },
  { 866, 12, 17, 16, 2, -17 },
  { 892, 10, 17, 16, 3, -17 },
  { 914, 11, 17, 16, 2, -17 },
  { 938, 14, 17, 16, 2, -17 },
  { 968, 11, 17, 16, 3, -17 },
  { 992, 12, 17, 16, 2, -17 },
  { 1018, 12, 17, 16, 2, -17 },
  { 1044, 13, 17, 16, 1, -17 },
  { 1072, 12, 17, 16, 2, -17 },
  { 1098, 13, 22, 16, 1, -17 },
  { 1134, 13, 17, 16, 2, -17 },
  { 1162, 13, 17, 16, 1, -17 },
  { 1190, 14, 17, 16, 1, -17 },
  { 1220, 12, 17, 16, 2, -17 },
  { 1246, 15, 17, 16, 0, -17 },
  { 1278, 16, 17, 16, 0, -17 },
  { 1312, 15, 17, 16, 0, -17 },
  { 1344, 15, 17, 16, 0, -17 },
  { 1376, 14, 17, 16, 1, -17 },
  { 1406, 7, 24, 16, 5, -19 },
  { 1427, 13, 19, 16, 1, -19 },
  { 1458, 7, 24, 16, 3, -19 },
  { 1479, 12, 12, 16, 2, -17 },
  { 1497, 16, 1, 16, 0, 2 },
  { 1499, 5, 3, 16, 5, -18 },
  { 1501, 13, 14, 16, 2, -14 },
  { 1524, 12, 19, 16, 2, -19 },
  { 1553, 12, 14, 16, 2, -14 },
  { 1574, 11, 19, 16, 2, -19 },
  { 1601, 12, 14, 16, 2, -14 },
  { 1622, 12, 19, 16, 2, -19 },
  { 1651, 11, 19, 16, 2, -14 },
  { 1678, 11, 19, 16, 2, -19 },
  { 1705, 12, 19, 16, 2, -19 },
  { 1734, 10, 24, 16, 1, -19 },
  { 1764, 11, 19, 16, 3, -19 },
  { 1791, 12, 19, 16, 2, -19 },
  { 1820, 13, 14, 16, 1, -14 },
  { 1843, 11, 14, 16, 2, -14 },
  { 1863, 12, 14, 16, 2, -14 },
  { 1884, 12, 19, 16, 2, -14 },
  { 1913, 11, 19, 16, 2, -14 },
  { 1940, 10, 14, 16, 3, -14 },
  { 1958, 11, 14, 16, 2, -14 },
  { 1978, 11, 18, 16, 2, -18 },
  { 2003, 11, 14, 16, 2, -14 },
  { 2023, 14, 14, 16, 1, -14 },
  { 2048, 15, 14, 16, 0, -14 },
  { 2075, 13, 14, 16, 1, -14 },
  { 2098, 14, 19, 16, 1, -14 },
  { 2132, 12, 14, 16, 2, -14 },
  { 2153, 10, 24, 16, 3, -19 },
  { 2183, 2, 24, 16, 7, -19 },
  { 2189, 11, 24, 16, 2, -19 },
  { 2222, 13, 4, 16, 1, -11 },
};

const GFXfont LiberationMono_Regular26pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular26pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular26pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _LIBERATIONMONO_REGULAR26PT7B_H_
