#ifndef _LIBERATIONMONO_REGULAR27PT7B_H_
#define _LIBERATIONMONO_REGULAR27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0xE3, 0xF1, 0xB0, 0xD8, 0x6C, 0x36,
  0x1B, 0x0D, 0x86, 0x04, 0x18, 0x10, 0x40, 0xC1, 0x03, 0x0C, 0x08, 0x33,
  0xFF, 0xFF, 0xFF, 0xC6, 0x08, 0x18, 0x60, 0x41, 0x81, 0x06, 0x3F, 0xFF,
  0xFF, 0xFC, 0xC3, 0x02, 0x0C, 0x08, 0x30, 0x20, 0x81, 0x82, 0x00, 0x03,
  0x00, 0x0C, 0x01, 0xFE, 0x0F, 0xFC, 0x73, 0x39, 0x8C, 0x66, 0x31, 0xD8,
  0xC0, 0x7B, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xDE, 0x03, 0x1C, 0x0C, 0x30,
  0x30, 0xF0, 0xC3, 0xE3, 0x1D, 0xCC, 0xE3, 0xFF, 0x87, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0x3C, 0x06, 0x66, 0x0C, 0xC6, 0x0C, 0xC2, 0x18, 0xC3, 0x30,
  0xC3, 0x20, 0xC6, 0x60, 0x66, 0xC0, 0x3D, 0x80, 0x01, 0xBE, 0x03, 0x63,
  0x06, 0x63, 0x06, 0x63, 0x0C, 0x63, 0x18, 0x63, 0x18, 0x63, 0x30, 0x62,
  0x60, 0x3E, 0x07, 0x80, 0x3F, 0xC0, 0x61, 0x81, 0x83, 0x03, 0x06, 0x03,
  0x18, 0x06, 0xE0, 0x0F, 0x00, 0x3C, 0x18, 0xDC, 0x33, 0x18, 0x66, 0x19,
  0x8C, 0x3B, 0x18, 0x3E, 0x30, 0x38, 0x70, 0xF8, 0x7F, 0xBE, 0x7E, 0x3C,
  0xFB, 0x6D, 0xB6, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x06, 0x0E, 0x0C, 0x1C,
  0x1C, 0x18, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x06,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x60, 0x0C, 0x03, 0x04, 0xCB, 0xFF, 0x3F, 0x03, 0x81,
  0xA0, 0xCC, 0x21, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0xE3, 0x8E, 0x31, 0xC6, 0x18, 0x40, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x1F, 0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0xE6, 0xC7, 0x3E, 0x39, 0xF0, 0x0D, 0x80, 0x6C, 0x03, 0x70, 0x39,
  0x81, 0xCE, 0x1C, 0x3F, 0xC0, 0xFC, 0x00, 0x03, 0x00, 0x38, 0x07, 0xC1,
  0xF6, 0x0E, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x83, 0xFE, 0x70, 0xEE, 0x07, 0xE0, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0x83, 0xFE, 0x70, 0xEE, 0x07, 0xC0, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x0F, 0x80, 0xFC, 0x00, 0xE0, 0x03, 0x00, 0x3C,
  0x03, 0xE0, 0x3F, 0x07, 0x7F, 0xE1, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0xD8, 0x03, 0x60, 0x19, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0xC1,
  0x86, 0x06, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xEF, 0x8F, 0xFE, 0xF0, 0xF0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03,
  0xE0, 0x77, 0x0E, 0x7F, 0xE1, 0xF8, 0x0F, 0x81, 0xFE, 0x38, 0x67, 0x07,
  0x60, 0x0E, 0x00, 0xCF, 0x8D, 0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x36, 0x03, 0x70, 0x77, 0x8E, 0x3F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1F, 0x83, 0xFE, 0x70, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0E,
  0x3F, 0xC3, 0xFC, 0x70, 0xFE, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x07,
  0x7F, 0xE1, 0xF8, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x77, 0x0F, 0x3F, 0xB1, 0xF3, 0x00, 0x30, 0x07,
  0xE0, 0x67, 0x0E, 0x7F, 0xC1, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x39, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x77, 0xB9, 0xCC, 0xE6, 0x31,
  0x80, 0x00, 0x18, 0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x03, 0x00,
  0x18, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0C,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xE0, 0x07, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0x40, 0x00,
  0x0F, 0xC1, 0xFF, 0x9E, 0x1E, 0xE0, 0x7E, 0x01, 0xF0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x70, 0xE1,
  0x80, 0xC6, 0x00, 0xCC, 0x77, 0x91, 0x1D, 0x66, 0x33, 0xD8, 0x67, 0xB0,
  0xCF, 0x61, 0x9C, 0xC3, 0x39, 0x06, 0x52, 0x08, 0xA4, 0x31, 0x4C, 0x66,
  0xD9, 0x49, 0x9C, 0xE3, 0x00, 0x03, 0x00, 0x06, 0x01, 0x07, 0x0F, 0x07,
  0xF8, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06,
  0x60, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18,
  0x18, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0x60,
  0x07, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x03, 0x70,
  0x1B, 0x81, 0xDC, 0x1C, 0xFF, 0xC7, 0xFF, 0x38, 0x1D, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xFF, 0xF7, 0xFE, 0x00, 0x07, 0xC0, 0x7F,
  0xC3, 0x87, 0x9C, 0x06, 0x70, 0x19, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x23, 0x01, 0xCF,
  0x0E, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0x07, 0xFE, 0x38, 0x79, 0xC0, 0xEE,
  0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0x70, 0x3B, 0x81, 0xDC, 0x3C, 0xFF, 0xC7, 0xF8, 0x00, 0xFF,
  0xF7, 0xFF, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0xE7, 0xFF, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x87, 0x9C,
  0x0E, 0x70, 0x19, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x87, 0xF6,
  0x1F, 0xD8, 0x07, 0x70, 0x1D, 0xC0, 0x73, 0x01, 0xCF, 0x0F, 0x1F, 0xF8,
  0x1F, 0x00, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0xFF, 0xFF, 0xFC, 0x0F, 0xE1, 0xFC, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xC1, 0xD8, 0x3B, 0x8E, 0x3F, 0xC3, 0xE0, 0xE0, 0x3B, 0x81, 0xCE, 0x0E,
  0x38, 0x70, 0xE3, 0x83, 0x8C, 0x0E, 0x70, 0x3B, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0x38, 0x38, 0xE0, 0xE1, 0xC3, 0x83, 0x8E, 0x07, 0x38, 0x1C, 0xE0,
  0x3B, 0x80, 0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F,
  0xF8, 0xFD, 0x9B, 0xD9, 0xBC, 0xDB, 0xCF, 0x3C, 0xF3, 0xC7, 0x3C, 0x63,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x83, 0xD8, 0x3D, 0xC3, 0xCC, 0x3C, 0xE3, 0xC6, 0x3C, 0x63,
  0xC3, 0x3C, 0x33, 0xC1, 0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70, 0x19, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x19, 0xC0,
  0xE7, 0x03, 0x8E, 0x1C, 0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0x87, 0xFF, 0x38,
  0x1D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0xF7, 0xFF,
  0x3F, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x70, 0x19, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60,
  0x19, 0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x1F, 0xE0, 0x3F, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0xFF, 0xC3, 0xFF, 0x8E, 0x07,
  0x38, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0xFF, 0xE3, 0xFE,
  0x0E, 0x38, 0x38, 0x60, 0xE1, 0xC3, 0x83, 0x8E, 0x0E, 0x38, 0x1C, 0xE0,
  0x3B, 0x80, 0xE0, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0x60, 0x19,
  0xC0, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x3F, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x77, 0x0E, 0x7F, 0xE1, 0xF8, 0xE0, 0x07,
  0x60, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x1C,
  0x18, 0x18, 0x1C, 0x38, 0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60,
  0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60, 0x06, 0x61, 0x86,
  0x61, 0xC6, 0x73, 0xC6, 0x73, 0xC6, 0x33, 0x6E, 0x36, 0x6C, 0x36, 0x6C,
  0x36, 0x6C, 0x36, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x1C, 0x70, 0x0E,
  0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70,
  0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x06,
  0x70, 0x0E, 0x38, 0x1C, 0x18, 0x1C, 0x1C, 0x38, 0x0E, 0x30, 0x06, 0x70,
  0x07, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFD,
  0xFF, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0xFF, 0xFC, 0x07, 0x00, 0xF0, 0x0D, 0x01, 0x98, 0x19, 0x83,
  0x0C, 0x30, 0xC3, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x3C, 0x03, 0xFF, 0xFF,
  0x60, 0xE1, 0xC0, 0x1F, 0x83, 0xFE, 0x1C, 0x39, 0xC1, 0xC0, 0x06, 0x00,
  0x30, 0x7F, 0x8F, 0xFC, 0xF0, 0x66, 0x03, 0x30, 0x39, 0x81, 0xCE, 0x16,
  0x7F, 0xBC, 0xF0, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x7C, 0xEF, 0xEF, 0x8E, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x7F, 0x8E, 0xFF, 0xEE, 0x78, 0x0F, 0xC3,
  0xFE, 0x70, 0x7E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x03, 0x70, 0x73, 0xFE, 0x1F, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x71, 0xE7, 0x7F, 0xF7, 0x0F, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x77, 0x0F,
  0x7F, 0xF1, 0xE7, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x07, 0xE0, 0x3C, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x03, 0x70, 0xF3, 0xFE,
  0x1F, 0x80, 0x03, 0xF0, 0xFF, 0x0E, 0x01, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF,
  0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x37, 0xFF, 0x71,
  0xFE, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x0F, 0x71, 0xF7, 0xFF, 0x1E, 0x70, 0x07, 0x00, 0x76, 0x06, 0x70,
  0xE3, 0xFC, 0x1F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x7C, 0xEF, 0xEF, 0x8E, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x00,
  0x03, 0xFD, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x0E, 0xFF, 0x7E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0E, 0xC1, 0xCC,
  0x18, 0xC3, 0x0C, 0x70, 0xCE, 0x0D, 0xC0, 0xFC, 0x0F, 0x60, 0xC7, 0x0C,
  0x38, 0xC1, 0x8C, 0x1C, 0xC0, 0xEC, 0x06, 0x3F, 0x01, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x3F, 0xFF, 0xFF, 0xF0, 0xCE, 0x7B, 0x7B, 0xEF, 0x79, 0xF8, 0xE7, 0xE3,
  0x0F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xF8,
  0xC3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xC0, 0xE7, 0xCE, 0xFE, 0xF8, 0xEF,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x1F, 0x83, 0xFE, 0x70, 0xEE, 0x07,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x07,
  0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xE7, 0xCE, 0xFE, 0xF8, 0xEF, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x07, 0xF8,
  0xEF, 0xFE, 0xE7, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x1F, 0x77, 0xFF, 0x70, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0x70, 0xF7, 0xFF, 0x1E, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE3, 0xFD, 0xFD,
  0xB0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x1F, 0x83, 0xFE, 0x70, 0x66, 0x07,
  0x60, 0x07, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x03,
  0x60, 0x77, 0xFE, 0x1F, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0xFF,
  0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x03, 0xFC, 0x3F, 0x80, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x76, 0x07, 0x70, 0xB7, 0xFB, 0x3E, 0x30, 0xE0, 0x1F, 0x80, 0x76, 0x01,
  0x9C, 0x0E, 0x30, 0x38, 0xE0, 0xC3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x33,
  0x80, 0xCC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x60, 0x07, 0x60, 0x07, 0x60, 0x06, 0x61, 0xC6, 0x63, 0xC6, 0x73, 0xC6,
  0x73, 0x4E, 0x36, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x34, 0x2C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x1C, 0x60, 0x18, 0xC0, 0xE3, 0x87, 0x06, 0x18, 0x0C,
  0xC0, 0x3F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x3B, 0x01, 0xCE, 0x06,
  0x18, 0x38, 0x31, 0xC0, 0xE6, 0x01, 0xC0, 0xE0, 0x0F, 0x80, 0x76, 0x01,
  0x9C, 0x06, 0x30, 0x38, 0xE0, 0xC1, 0x87, 0x06, 0x18, 0x1C, 0x60, 0x33,
  0x80, 0xCC, 0x01, 0xB0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xFC, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x0F,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x0F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x1F, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0xFE,
  0x1F, 0x80, 0x3C, 0x03, 0xFE, 0x3C, 0x3F, 0xE0, 0x3E,
};

const GFXglyph LiberationMono_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 18, 16, 7, -18 },
  { 6, 9, 8, 16, 4, -20 },
  { 15, 14, 18, 16, 1, -18 },
  { 47, 14, 22, 16, 1, -20 },
  { 86, 16, 18, 16, 0, -18 },
  { 122, 15, 18, 16, 1, -18 },
  { 156, 3, 8, 16, 7, -20 },
  { 159, 7, 26, 16, 5, -20 },
  { 182, 8, 26, 16, 4, -20 },
  { 208, 10, 9, 16, 3, -20 },
  { 220, 13, 14, 16, 2, -16 },
  { 243, 6, 9, 16, 3, -4 },
  { 250, 8, 2, 16, 4, -8 },
  { 252, 3, 4, 16, 7, -4 },
  { 254, 14, 20, 16, 1, -20 },
  { 289, 13, 18, 16, 2, -18 },
  { 319, 13, 18, 16, 2, -18 },
  { 349, 12, 18, 16, 2, -18 },
  { 376, 12, 18, 16, 2, -18 },
  { 403, 14, 18, 16, 1, -18 },
  { 435, 12, 18, 16, 2, -18 },
  { 462, 12, 18, 16, 2, -18 },
  { 489, 12, 18, 16, 2, -18 },
  { 516, 12, 18, 16, 2, -18 },
  { 543, 12, 18, 16, 2, -18 },
  { 570, 3, 15, 16, 7, -15 },
  { 576, 5, 20, 16, 5, -15 },
  { 589, 13, 14, 16, 2, -16 },
  { 612, 13, 8, 16, 2, -13 },
  { 625, 13, 14, 16, 2, -16 },
  { 648, 13, 18, 16, 1, -18 },
  { 678, 15, 24, 16, 1, -20 },
  { 723, 16, 18, 16, 0, -18 },
  { 759, 13, 18, 16, 2, -18 },
  { 789, 14, 18, 16, 1, -18 },
  { 821, 13, 18, 16, 2, -18 },
  { 851, 13, 18, 16, 2, -18 },
  { 881, 11, 18, 16, 3, -18 },
  { 906, 14, 18, 16, 1, -18 },
  { 938, 12, 18, 16, 2, -18 },
  { 965, 11, 18, 16, 3, -18 },
  { 990, 11, 18, 16, 2, -18 },
  { 1015, 14, 18, 16, 2, -18 },
  { 1047, 12, 18, 16, 3, -18 },
  { 1074, 12, 18, 16, 2, -18 },
  { 1101, 12, 18, 16, 2, -18 },
  { 1128, 14, 18, 16, 1, -18 },
  { 1160, 13, 18, 16, 2, -18 },
  { 1190, 14, 23, 16, 1, -18 },
  { 1231, 14, 18, 16, 2, -18 },
  { 1263, 14, 18, 16, 1, -18 },
  { 1295, 14, 18, 16, 1, -18 },
  { 1327, 12, 18, 16, 2, -18 },
  { 1354, 16, 18, 16, 0, -18 },
  { 1390, 16, 18, 16, 0, -18 },
  { 1426, 16, 18, 16, 0, -18 },
  { 1462, 16, 18, 16, 0, -18 },
  { 1498, 14, 18, 16, 1, -18 },
  { 1530, 8, 26, 16, 5, -20 },
  { 1556, 13, 20, 16, 2, -20 },
  { 1589, 7, 26, 16, 4, -20 },
  { 1612, 12, 12, 16, 2, -18 },
  { 1630, 16, 1, 16, 0, 2 },
  { 1632, 6, 3, 16, 5, -19 },
  { 1635, 13, 15, 16, 2, -15 },
  { 1660, 12, 20, 16, 2, -20 },
  { 1690, 12, 15, 16, 2, -15 },
  { 1713, 12, 20, 16, 2, -20 },
  { 1743, 12, 15, 16, 2, -15 },
  { 1766, 12, 20, 16, 2, -20 },
  { 1796, 12, 21, 16, 2, -15 },
  { 1828, 12, 20, 16, 2, -20 },
  { 1858, 13, 20, 16, 2, -20 },
  { 1891, 9, 26, 16, 2, -20 },
  { 1921, 12, 20, 16, 3, -20 },
  { 1951, 13, 20, 16, 2, -20 },
  { 1984, 14, 15, 16, 1, -15 },
  { 2011, 12, 15, 16, 2, -15 },
  { 2034, 12, 15, 16, 2, -15 },
  { 2057, 12, 21, 16, 2, -15 },
  { 2089, 12, 21, 16, 2, -15 },
  { 2121, 11, 15, 16, 3, -15 },
  { 2142, 12, 15, 16, 2, -15 },
  { 2165, 11, 19, 16, 2, -19 },
  { 2192, 12, 15, 16, 2, -15 },
  { 2215, 14, 15, 16, 1, -15 },
  { 2242, 16, 15, 16, 0, -15 },
  { 2272, 14, 15, 16, 1, -15 },
  { 2299, 14, 21, 16, 1, -15 },
  { 2336, 12, 15, 16, 2, -15 },
  { 2359, 11, 26, 16, 3, -20 },
  { 2395, 2, 26, 16, 7, -20 },
  { 2402, 11, 26, 16, 2, -20 },
  { 2438, 14, 4, 16, 1, -11 },
};

const GFXfont LiberationMono_Regular27pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular27pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular27pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _LIBERATIONMONO_REGULAR27PT7B_H_
