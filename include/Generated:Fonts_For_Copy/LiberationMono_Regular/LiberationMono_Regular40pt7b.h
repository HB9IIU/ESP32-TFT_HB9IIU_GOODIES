#ifndef _LIBERATIONMONO_REGULAR40PT7B_H_
#define _LIBERATIONMONO_REGULAR40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x76, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x70, 0x79, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x00,
  0xC0, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80,
  0xC0, 0x06, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x30, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF0, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x03, 0x80, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x38, 0x01,
  0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xF8, 0xC7, 0xC7, 0x86, 0x1E, 0x38, 0x30, 0x79, 0xC1,
  0x83, 0x8E, 0x0C, 0x00, 0x70, 0x60, 0x03, 0xC3, 0x00, 0x0F, 0x98, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xBF, 0x80, 0x0C,
  0x3E, 0x00, 0x60, 0xF0, 0x03, 0x03, 0xB8, 0x18, 0x1F, 0xC0, 0xC0, 0xEF,
  0x06, 0x07, 0x7C, 0x30, 0x79, 0xF1, 0x8F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x1F,
  0x00, 0x1C, 0x7F, 0xC0, 0x1C, 0x71, 0xC0, 0x38, 0xE0, 0xE0, 0x70, 0xE0,
  0xE0, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE0, 0xE3, 0x80, 0xE0,
  0xE3, 0x80, 0xE0, 0xE7, 0x00, 0x71, 0xCE, 0x00, 0x3F, 0xCE, 0x00, 0x1F,
  0x1C, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x33, 0xFE, 0x00, 0x73, 0x8E, 0x00,
  0xE7, 0x07, 0x01, 0xC7, 0x07, 0x01, 0xC7, 0x07, 0x03, 0x87, 0x07, 0x07,
  0x07, 0x07, 0x06, 0x07, 0x07, 0x0E, 0x07, 0x07, 0x1C, 0x03, 0x8E, 0x18,
  0x03, 0xFC, 0x38, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xE1, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38,
  0x03, 0x81, 0xC0, 0x07, 0x1E, 0x00, 0x1D, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x18, 0x1F, 0xC0, 0x70, 0xF7, 0x01, 0xC7, 0x8E, 0x0E, 0x3C, 0x3C,
  0x38, 0xE0, 0x70, 0xE3, 0x80, 0xE7, 0x0E, 0x03, 0xDC, 0x38, 0x07, 0xE0,
  0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xF8, 0xFC, 0x1F, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x43, 0x0B, 0xED, 0xFF, 0xFF, 0xC3, 0xF0, 0x07,
  0x80, 0x3F, 0x01, 0xCE, 0x0E, 0x38, 0x38, 0x70, 0x40, 0x80, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x0F,
  0x87, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x1C, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x1C,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0xF0,
  0xEF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38,
  0x01, 0xC3, 0xC0, 0x3C, 0x1E, 0x0F, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF7, 0x01, 0xF8, 0xE0, 0x3C, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xF8,
  0x3E, 0x78, 0x07, 0x9C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x03,
  0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x80, 0x1E, 0xF8, 0x03, 0xCF, 0x81, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x1C,
  0x70, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x3F, 0x80, 0xEF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xE0, 0x7C, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x07, 0x8F, 0x83, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x78, 0x3E, 0x3C, 0x07, 0x9E,
  0x00, 0xE7, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x7E, 0x0F, 0x7F,
  0xE3, 0xBF, 0xFC, 0xEE, 0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x07, 0x78, 0x03, 0xCF,
  0x01, 0xF3, 0xE0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0xBC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0x7F,
  0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xC7, 0xC0, 0xFB, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xF7,
  0xC0, 0xF9, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0x78, 0x07, 0xDF, 0x07, 0xF3, 0xFF, 0xDC, 0x7F, 0xE7, 0x07, 0xE3, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0xF0, 0x07, 0x9E, 0x03, 0xC7, 0xC1,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x03, 0xE7, 0x80,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x78, 0x1C, 0x03,
  0xC0, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x00, 0xC3, 0x80, 0x03, 0x8E, 0x1E,
  0x36, 0x70, 0xFC, 0xDD, 0xC7, 0x1F, 0x76, 0x18, 0x3C, 0xD8, 0xE0, 0xE3,
  0xE3, 0x03, 0x8F, 0x9C, 0x0E, 0x3E, 0x70, 0x38, 0xF1, 0x80, 0xE3, 0xC6,
  0x03, 0x0F, 0x38, 0x0C, 0x3C, 0xE0, 0x70, 0xF3, 0x81, 0xC7, 0xCE, 0x07,
  0x1F, 0x18, 0x1C, 0x6E, 0x60, 0xE1, 0xB9, 0xC3, 0x8E, 0xE7, 0x1F, 0x31,
  0x8F, 0xCF, 0x87, 0x1E, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x01, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE3,
  0x80, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0,
  0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x07, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xF0, 0x7C, 0x3E, 0x03,
  0xE7, 0xC0, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x0C, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x04, 0x78, 0x00, 0x77,
  0x80, 0x0F, 0x3C, 0x01, 0xE3, 0xE0, 0x1E, 0x1F, 0x07, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x78, 0x1F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3B,
  0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x0F, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x81, 0xF0, 0x7C, 0x3C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x80,
  0x0C, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF3, 0xE0, 0x0F,
  0x1F, 0x03, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3E, 0x1E, 0x3F,
  0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x01,
  0xE1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC1, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xC0, 0x1F, 0x1F, 0x00, 0xF0,
  0x7C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF8,
  0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x01, 0xF7, 0x80,
  0x07, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0xE0, 0xFF, 0xB8, 0x77,
  0xEE, 0x1D, 0xF9, 0xC6, 0x7E, 0x73, 0x9F, 0x9C, 0xE7, 0xE3, 0xB1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFB, 0x80, 0xFE, 0xF0, 0x3F, 0x9C, 0x0F, 0xE7,
  0x83, 0xF8, 0xE0, 0xFE, 0x38, 0x3F, 0x87, 0x0F, 0xE1, 0xC3, 0xF8, 0x78,
  0xFE, 0x0E, 0x3F, 0x83, 0xCF, 0xE0, 0x73, 0xF8, 0x1E, 0xFE, 0x03, 0x9F,
  0x80, 0xF7, 0xE0, 0x1D, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xF0, 0xFC, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F,
  0x0F, 0x81, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x78, 0x07, 0xEF, 0x00, 0x3D, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x3C, 0x03, 0xC7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0xF0, 0x03,
  0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x03, 0xCF, 0x00, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F,
  0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C,
  0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xE0, 0x7C, 0x78, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x60, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1E,
  0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xE7,
  0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1C,
  0x38, 0x7E, 0x1C, 0x38, 0x7E, 0x1C, 0x38, 0x76, 0x1C, 0x3C, 0x67, 0x3C,
  0x3C, 0xE7, 0x3C, 0x1C, 0xE7, 0x38, 0x1C, 0xE7, 0x38, 0x1D, 0xC3, 0xB8,
  0x1D, 0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x1D, 0x81, 0xB8, 0x0D, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xCF, 0x00, 0x0E, 0x1C, 0x00, 0x78,
  0x78, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x0F,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3D,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x87, 0x80, 0x0F, 0x1C,
  0x00, 0x3C, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0C,
  0xC0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x0C,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x7C, 0x1F, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xE0, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0x70, 0x07, 0xC3, 0xC0, 0x7E, 0x1F, 0x0E, 0xF0, 0xFF, 0xF7,
  0xF3, 0xFF, 0x1F, 0x87, 0xE0, 0x7C, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC3, 0xF0,
  0x73, 0xFE, 0x1D, 0xFF, 0xC7, 0xE0, 0xF9, 0xF0, 0x1E, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x07, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0x7C, 0x07, 0x9F, 0x83, 0xE7, 0x7F, 0xF1, 0xCF, 0xF8, 0x71, 0xFC, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x3E, 0x78, 0x07, 0xBC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xDE, 0x01, 0xE7, 0xE0, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x1F, 0xC7, 0x1F, 0xF3, 0x9F, 0xFD, 0xDF,
  0x07, 0xEF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x78, 0x0F, 0xBE, 0x0F, 0xCF, 0xFE, 0xE3,
  0xFE, 0x70, 0xFC, 0x38, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xF8,
  0x3C, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x03, 0x9E, 0x00, 0xF3, 0xE0, 0xF8, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xB9, 0xF0, 0x7E, 0x78, 0x0F, 0xBC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x1E,
  0xF0, 0x07, 0x9E, 0x03, 0xE7, 0xC1, 0xF8, 0xFF, 0xEE, 0x1F, 0xF3, 0x83,
  0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0xE0,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xF8,
  0xE7, 0xFC, 0xEF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3E, 0x03, 0xEF, 0xFF, 0xBF, 0xF8, 0x7F, 0x80, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x1E, 0xE0, 0x1E, 0x70, 0x1E, 0x38, 0x1E, 0x1C, 0x1F, 0x0E, 0x0F, 0x07,
  0x0F, 0x03, 0x8F, 0x01, 0xCF, 0x00, 0xEF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0x78, 0x0E, 0x1E, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC0, 0xF0, 0xE0,
  0x3C, 0x70, 0x1E, 0x38, 0x07, 0x9C, 0x01, 0xEE, 0x00, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE7, 0x87, 0xCE, 0xFC, 0xFE,
  0xEF, 0xEF, 0xEF, 0x9F, 0x8F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0x7F, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F,
  0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0,
  0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E,
  0x0F, 0x07, 0x70, 0xFC, 0x39, 0xFF, 0x1D, 0xFF, 0xCF, 0xC1, 0xF7, 0xC0,
  0x7B, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x1C, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x07,
  0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0xC0, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x01, 0xFC, 0x00, 0x70, 0xFC, 0x1C, 0xFF, 0x87, 0x7F, 0xF1, 0xF8, 0x3E,
  0x7C, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x01, 0xE7, 0xE0, 0xF9, 0xDF, 0xFC,
  0x73, 0xFE, 0x1C, 0x7F, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xE3, 0xC7, 0xFC, 0xE3, 0xFF, 0xB9, 0xF0, 0x7E, 0x78, 0x0F, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0x9E, 0x03, 0xE7, 0xC1, 0xF8, 0xFF, 0xEE, 0x1F, 0xF3, 0x83, 0xF0,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBC, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x1E, 0x78, 0x03,
  0x9C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x70, 0x03, 0xFC, 0x00, 0xE7, 0x80, 0x78, 0xFF, 0xFC, 0x1F, 0xFE,
  0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x01, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x0F, 0x78,
  0x0F, 0xBE, 0x0F, 0xCF, 0xFE, 0xF7, 0xFE, 0x78, 0xFC, 0x3C, 0x70, 0x00,
  0x39, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0E, 0x1C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x78, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x3C, 0x1E, 0x38, 0x3C, 0x1C, 0x38,
  0x7E, 0x1C, 0x38, 0x7E, 0x1C, 0x38, 0x66, 0x3C, 0x3C, 0xE6, 0x3C, 0x3C,
  0xE7, 0x3C, 0x1C, 0xE7, 0x38, 0x1C, 0xC3, 0x38, 0x1D, 0xC3, 0xB8, 0x1D,
  0xC3, 0xB8, 0x1D, 0x81, 0xB8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x70, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03,
  0xC1, 0xC0, 0x78, 0x1E, 0x07, 0x00, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x39,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0xF0, 0xE0, 0x0E, 0x0F, 0x01,
  0xE0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x0F,
  0x70, 0x00, 0x39, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x3C,
  0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x1E, 0x03, 0x80, 0x78, 0x0F, 0x01,
  0xC0, 0x3C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80,
  0x0F, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xC0,
};

const GFXglyph LiberationMono_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 4, 26, 24, 10, -26 },
  { 14, 14, 12, 24, 5, -29 },
  { 35, 22, 26, 24, 1, -26 },
  { 107, 21, 32, 24, 1, -29 },
  { 191, 24, 26, 24, 0, -26 },
  { 269, 22, 26, 24, 1, -26 },
  { 341, 4, 12, 24, 10, -29 },
  { 347, 10, 37, 24, 7, -29 },
  { 394, 10, 37, 24, 7, -29 },
  { 441, 14, 14, 24, 5, -29 },
  { 466, 20, 19, 24, 2, -23 },
  { 514, 9, 13, 24, 5, -6 },
  { 529, 10, 3, 24, 7, -12 },
  { 533, 4, 6, 24, 10, -6 },
  { 536, 20, 29, 24, 2, -29 },
  { 609, 20, 26, 24, 2, -26 },
  { 674, 19, 26, 24, 3, -26 },
  { 736, 18, 26, 24, 3, -26 },
  { 795, 19, 26, 24, 2, -26 },
  { 857, 20, 26, 24, 2, -26 },
  { 922, 19, 26, 24, 2, -26 },
  { 984, 18, 26, 24, 3, -26 },
  { 1043, 18, 26, 24, 3, -26 },
  { 1102, 18, 26, 24, 3, -26 },
  { 1161, 18, 26, 24, 3, -26 },
  { 1220, 4, 22, 24, 10, -22 },
  { 1231, 8, 29, 24, 7, -22 },
  { 1260, 20, 20, 24, 2, -23 },
  { 1310, 20, 13, 24, 2, -20 },
  { 1343, 20, 20, 24, 2, -23 },
  { 1393, 19, 26, 24, 2, -26 },
  { 1455, 22, 34, 24, 1, -29 },
  { 1549, 24, 26, 24, 0, -26 },
  { 1627, 20, 26, 24, 3, -26 },
  { 1692, 20, 26, 24, 2, -26 },
  { 1757, 19, 26, 24, 3, -26 },
  { 1819, 19, 26, 24, 3, -26 },
  { 1881, 17, 26, 24, 4, -26 },
  { 1937, 20, 26, 24, 2, -26 },
  { 2002, 18, 26, 24, 3, -26 },
  { 2061, 16, 26, 24, 4, -26 },
  { 2113, 16, 26, 24, 3, -26 },
  { 2165, 21, 26, 24, 3, -26 },
  { 2234, 16, 26, 24, 5, -26 },
  { 2286, 18, 26, 24, 3, -26 },
  { 2345, 18, 26, 24, 3, -26 },
  { 2404, 20, 26, 24, 2, -26 },
  { 2469, 19, 26, 24, 3, -26 },
  { 2531, 20, 34, 24, 2, -26 },
  { 2616, 20, 26, 24, 3, -26 },
  { 2681, 20, 26, 24, 2, -26 },
  { 2746, 22, 26, 24, 1, -26 },
  { 2818, 18, 26, 24, 3, -26 },
  { 2877, 24, 26, 24, 0, -26 },
  { 2955, 24, 26, 24, 0, -26 },
  { 3033, 22, 26, 24, 1, -26 },
  { 3105, 22, 26, 24, 1, -26 },
  { 3177, 22, 26, 24, 1, -26 },
  { 3249, 11, 37, 24, 8, -29 },
  { 3300, 20, 29, 24, 2, -29 },
  { 3373, 11, 37, 24, 5, -29 },
  { 3424, 18, 18, 24, 3, -26 },
  { 3465, 24, 2, 24, 0, 2 },
  { 3471, 8, 5, 24, 8, -28 },
  { 3476, 21, 22, 24, 2, -22 },
  { 3534, 18, 29, 24, 3, -29 },
  { 3600, 18, 22, 24, 3, -22 },
  { 3650, 17, 29, 24, 3, -29 },
  { 3712, 18, 22, 24, 3, -22 },
  { 3762, 18, 29, 24, 3, -29 },
  { 3828, 18, 30, 24, 3, -22 },
  { 3896, 16, 29, 24, 4, -29 },
  { 3954, 19, 29, 24, 3, -29 },
  { 4023, 14, 37, 24, 2, -29 },
  { 4088, 17, 29, 24, 5, -29 },
  { 4150, 19, 29, 24, 3, -29 },
  { 4219, 20, 22, 24, 2, -22 },
  { 4274, 17, 22, 24, 3, -22 },
  { 4321, 18, 22, 24, 3, -22 },
  { 4371, 18, 30, 24, 3, -22 },
  { 4439, 18, 30, 24, 3, -22 },
  { 4507, 15, 22, 24, 5, -22 },
  { 4549, 18, 22, 24, 3, -22 },
  { 4599, 16, 28, 24, 4, -28 },
  { 4655, 17, 22, 24, 4, -22 },
  { 4702, 22, 22, 24, 1, -22 },
  { 4763, 24, 22, 24, 0, -22 },
  { 4829, 20, 22, 24, 2, -22 },
  { 4884, 22, 30, 24, 1, -22 },
  { 4967, 18, 22, 24, 3, -22 },
  { 5017, 17, 37, 24, 4, -29 },
  { 5096, 4, 37, 24, 10, -29 },
  { 5115, 17, 37, 24, 3, -29 },
  { 5194, 20, 5, 24, 2, -16 },
};

const GFXfont LiberationMono_Regular40pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular40pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular40pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _LIBERATIONMONO_REGULAR40PT7B_H_
