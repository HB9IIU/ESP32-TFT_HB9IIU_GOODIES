#ifndef _JETBRAINSMONO_EXTRABOLD43PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x83,
  0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x1F, 0x07,
  0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xDC, 0xFE, 0x7E, 0x73, 0xFB, 0xF9, 0xC7, 0xEF, 0xE7, 0x00,
  0x1F, 0x9C, 0x00, 0x7F, 0x70, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xCF, 0xE0, 0x07, 0x1F, 0xC0, 0x1C, 0x7F,
  0xFC, 0x71, 0xFF, 0xF9, 0xC7, 0xFF, 0xE7, 0x1F, 0xFF, 0xFD, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x7C, 0x7F, 0xE0, 0x0F, 0x1F, 0xFE, 0x03, 0xC3, 0xC7, 0xC0, 0xF8, 0xF8,
  0x78, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xE1, 0xE1, 0xE0, 0x7C, 0x3C, 0x7C,
  0x0F, 0x87, 0x8F, 0x00, 0xF0, 0xF3, 0xC0, 0x1F, 0xFE, 0xF8, 0x01, 0xFF,
  0xBE, 0x00, 0x1F, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x3E,
  0xFF, 0xC0, 0x07, 0xBF, 0xF8, 0x01, 0xE7, 0xCF, 0x80, 0x7C, 0xF0, 0xF0,
  0x1F, 0x3E, 0x1E, 0x03, 0xC7, 0xC3, 0xC0, 0xF0, 0xF8, 0x78, 0x3E, 0x1F,
  0x0F, 0x07, 0x81, 0xE1, 0xE1, 0xE0, 0x3E, 0x7C, 0x7C, 0x07, 0xFF, 0x9F,
  0x00, 0x7F, 0xE7, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x08, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0x7F, 0xFC, 0x7E,
  0x7E, 0xFE, 0x7E, 0xFE, 0x7E, 0xFC, 0xFE, 0x3F, 0xFC, 0xFC, 0x3F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7E, 0x07, 0xE0,
  0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFE, 0x7E, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x07,
  0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x1F, 0x00, 0x0C, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x83, 0xFF, 0x0F, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xC0,
  0x3E, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x3C, 0x0C, 0x7C, 0x3C,
  0x3C, 0x7E, 0x3C, 0xFE, 0x7F, 0xB9, 0xFE, 0xFF, 0xDB, 0xFE, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF,
  0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3,
  0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0x81, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3,
  0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xCE,
  0x3F, 0xFD, 0xF3, 0xFF, 0xDF, 0xBF, 0xFD, 0xFB, 0xFF, 0xDF, 0xBF, 0xFC,
  0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0xF0, 0xFE, 0x07, 0x07, 0xF0,
  0x30, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1C, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0xFD, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xFC, 0x0F, 0xEF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x87, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x83, 0xFD, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0x03, 0xFB,
  0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xE7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF0,
  0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xEF, 0xC0, 0xFF, 0x7F, 0x00, 0xF1,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x0F, 0x83,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x07, 0xE0, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF1,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x1F, 0x9F, 0xF8, 0x3F, 0xDF, 0xF8, 0x7F, 0xEF, 0xF8, 0x7F,
  0x7F, 0xF8, 0x7C, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC,
  0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC,
  0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xDF, 0xF8, 0x1F, 0x9F, 0xF8, 0x06, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x83,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xE0, 0xFF,
  0xBF, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0xC3, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFE, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0xC3, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFB, 0xFC,
  0x3F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F,
  0x01, 0xFC, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x07,
  0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F,
  0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3,
  0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF0,
  0x0F, 0xEF, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xDF, 0xFB, 0xCF, 0x7F, 0xEF, 0x3D, 0xFF, 0xBC,
  0xF7, 0xFE, 0x77, 0x9F, 0xF9, 0xFE, 0xFF, 0xE7, 0xFB, 0xFF, 0x9F, 0xCF,
  0xFE, 0x3F, 0x3F, 0xFC, 0xFC, 0xFF, 0xF3, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0xFB, 0xE1,
  0xFF, 0xBE, 0x1F, 0xF9, 0xE1, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF8, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0x79, 0xFF, 0x87, 0xDF, 0xF8,
  0x7D, 0xFF, 0x83, 0xDF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xF0, 0x7F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0,
  0x3F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0xC3, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E,
  0x07, 0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7E, 0x1F, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xF8, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xEF,
  0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xF8, 0x7F, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03,
  0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x3E, 0x0F, 0xBE, 0x1F, 0x87, 0xDF,
  0x0F, 0xC3, 0xEF, 0x87, 0xE1, 0xF7, 0xC3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7D,
  0xF0, 0xFC, 0x3E, 0xF8, 0x7E, 0x3F, 0x7C, 0x7F, 0x1F, 0x3E, 0x3B, 0x8F,
  0x9F, 0x9D, 0xE7, 0xC7, 0xCE, 0x73, 0xE3, 0xE7, 0x39, 0xF1, 0xF3, 0x9C,
  0xF8, 0xF9, 0xCE, 0x7C, 0x7C, 0xE7, 0x3E, 0x3E, 0x73, 0x9F, 0x1F, 0x39,
  0xCF, 0x8F, 0xBC, 0xE7, 0x87, 0xDC, 0x7B, 0xC3, 0xEE, 0x3D, 0xE1, 0xF7,
  0x0E, 0xF0, 0x7B, 0x87, 0xF8, 0x3D, 0xC3, 0xFC, 0x1E, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0,
  0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0x9F, 0x01, 0xF9, 0xF0, 0x1F, 0x9F, 0x81,
  0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC3, 0xFD, 0xFC, 0x0F, 0xEF,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFE, 0xFC, 0xFF, 0xE7, 0xE1, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0xFC, 0xFF, 0x8F, 0xDF, 0xFC, 0xFD, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFD, 0xFF, 0xCF, 0xCF, 0xFC, 0xFC,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x1F, 0xF3,
  0xF3, 0xFF, 0xBF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF,
  0x7F, 0xFB, 0xF3, 0xFF, 0x3F, 0x0F, 0xE3, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xE0, 0x7E, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF1, 0xFF, 0x3F, 0x3F,
  0xFB, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xF7, 0xFF, 0xBF, 0x3F, 0xFB, 0xF1, 0xFF,
  0x3F, 0x03, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xFC, 0xFF,
  0x8F, 0xDF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFC,
  0x03, 0xFB, 0xF0, 0x1F, 0xEF, 0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF,
  0xC0, 0x3F, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xF9, 0xE1, 0xF3,
  0xEF, 0xCF, 0xEF, 0xFF, 0x7F, 0xBF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFF, 0xE1,
  0xE3, 0xFF, 0x87, 0x8F, 0xFE, 0x1E, 0x3F, 0xF8, 0x78, 0xFF, 0xE1, 0xE3,
  0xFF, 0x87, 0x8F, 0xFE, 0x1E, 0x3F, 0xF8, 0x78, 0xFF, 0xE1, 0xE3, 0xFF,
  0x87, 0x8F, 0xFE, 0x1E, 0x3F, 0xF8, 0x78, 0xFF, 0xE1, 0xE3, 0xFF, 0x87,
  0x8F, 0xFE, 0x1E, 0x3F, 0xF8, 0x78, 0xFF, 0xE1, 0xE3, 0xFF, 0x87, 0x8F,
  0xFE, 0x1E, 0x3F, 0xFC, 0x7E, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xDF, 0xFC, 0xFC, 0xFF,
  0xCF, 0xC7, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF7, 0xFF, 0xBF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFB, 0xF7, 0xFF, 0xBF, 0x3F, 0xF3, 0xF0, 0xFE, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0x07, 0xEF, 0xFC,
  0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xCF, 0xFB, 0xF8,
  0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFC, 0x1E, 0x0F, 0xBE, 0x0F, 0x07, 0xDF, 0x0F, 0x83,
  0xEF, 0x87, 0xE1, 0xF7, 0xC3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7D, 0xF0, 0xFC,
  0x7C, 0xFC, 0x7E, 0x3E, 0x3E, 0x77, 0x1F, 0x1F, 0x39, 0xCF, 0x8F, 0x9C,
  0xE7, 0xC7, 0xCE, 0x73, 0xE3, 0xE7, 0x39, 0xF1, 0xF3, 0x9D, 0xF0, 0xF9,
  0xCE, 0xF8, 0x3F, 0xE7, 0x7C, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xE0,
  0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC,
  0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xF7, 0xF1, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFB, 0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 31, 26, 9, -31 },
  { 32, 16, 13, 26, 5, -31 },
  { 58, 24, 31, 26, 1, -31 },
  { 151, 22, 43, 26, 2, -37 },
  { 270, 27, 32, 26, -1, -32 },
  { 378, 24, 32, 26, 1, -32 },
  { 474, 6, 13, 26, 10, -31 },
  { 484, 14, 41, 26, 7, -36 },
  { 556, 14, 41, 26, 5, -36 },
  { 628, 24, 22, 26, 1, -26 },
  { 694, 21, 21, 26, 2, -25 },
  { 750, 11, 14, 26, 6, -7 },
  { 770, 14, 6, 26, 6, -17 },
  { 781, 8, 8, 26, 9, -8 },
  { 789, 22, 41, 26, 2, -36 },
  { 902, 20, 32, 26, 3, -32 },
  { 982, 21, 31, 26, 3, -31 },
  { 1064, 21, 32, 26, 2, -32 },
  { 1148, 21, 31, 26, 2, -31 },
  { 1230, 21, 31, 26, 2, -31 },
  { 1312, 20, 31, 26, 3, -31 },
  { 1390, 22, 31, 26, 2, -31 },
  { 1476, 22, 31, 26, 2, -31 },
  { 1562, 22, 32, 26, 2, -32 },
  { 1650, 22, 32, 26, 2, -32 },
  { 1738, 8, 24, 26, 9, -24 },
  { 1762, 11, 31, 26, 6, -24 },
  { 1805, 20, 24, 26, 3, -26 },
  { 1865, 19, 17, 26, 3, -23 },
  { 1906, 20, 24, 26, 3, -26 },
  { 1966, 17, 31, 26, 5, -31 },
  { 2032, 24, 40, 26, 1, -32 },
  { 2152, 24, 31, 26, 1, -31 },
  { 2245, 21, 31, 26, 3, -31 },
  { 2327, 21, 32, 26, 3, -32 },
  { 2411, 21, 31, 26, 3, -31 },
  { 2493, 20, 31, 26, 3, -31 },
  { 2571, 20, 31, 26, 3, -31 },
  { 2649, 21, 32, 26, 3, -32 },
  { 2733, 20, 31, 26, 3, -31 },
  { 2811, 19, 31, 26, 3, -31 },
  { 2885, 21, 31, 26, 1, -31 },
  { 2967, 22, 31, 26, 3, -31 },
  { 3053, 19, 31, 26, 4, -31 },
  { 3127, 22, 31, 26, 2, -31 },
  { 3213, 20, 31, 26, 3, -31 },
  { 3291, 20, 32, 26, 3, -32 },
  { 3371, 22, 31, 26, 3, -31 },
  { 3457, 21, 40, 26, 3, -32 },
  { 3562, 21, 31, 26, 3, -31 },
  { 3644, 22, 32, 26, 2, -32 },
  { 3732, 22, 31, 26, 2, -31 },
  { 3818, 20, 31, 26, 3, -31 },
  { 3896, 24, 31, 26, 1, -31 },
  { 3989, 25, 31, 26, 0, -31 },
  { 4086, 24, 31, 26, 1, -31 },
  { 4179, 24, 31, 26, 1, -31 },
  { 4272, 20, 31, 26, 3, -31 },
  { 4350, 13, 41, 26, 7, -36 },
  { 4417, 22, 41, 26, 2, -36 },
  { 4530, 13, 41, 26, 5, -36 },
  { 4597, 20, 16, 26, 3, -31 },
  { 4637, 20, 6, 26, 3, 1 },
  { 4652, 12, 6, 26, 6, -34 },
  { 4661, 21, 24, 26, 2, -24 },
  { 4724, 20, 31, 26, 3, -31 },
  { 4802, 20, 24, 26, 3, -24 },
  { 4862, 20, 31, 26, 3, -31 },
  { 4940, 20, 24, 26, 3, -24 },
  { 5000, 21, 31, 26, 2, -31 },
  { 5082, 20, 32, 26, 3, -24 },
  { 5162, 20, 31, 26, 3, -31 },
  { 5240, 21, 34, 26, 3, -34 },
  { 5330, 18, 42, 26, 3, -34 },
  { 5425, 22, 31, 26, 3, -31 },
  { 5511, 23, 31, 26, 1, -31 },
  { 5601, 22, 24, 26, 2, -24 },
  { 5667, 20, 24, 26, 3, -24 },
  { 5727, 20, 24, 26, 3, -24 },
  { 5787, 20, 32, 26, 3, -24 },
  { 5867, 20, 32, 26, 3, -24 },
  { 5947, 21, 24, 26, 4, -24 },
  { 6010, 22, 24, 26, 2, -24 },
  { 6076, 22, 30, 26, 1, -30 },
  { 6159, 20, 24, 26, 3, -24 },
  { 6219, 24, 24, 26, 1, -24 },
  { 6291, 25, 24, 26, 0, -24 },
  { 6366, 24, 24, 26, 1, -24 },
  { 6438, 24, 32, 26, 1, -24 },
  { 6534, 20, 24, 26, 3, -24 },
  { 6594, 20, 41, 26, 3, -36 },
  { 6697, 6, 41, 26, 10, -36 },
  { 6728, 20, 41, 26, 3, -36 },
  { 6831, 22, 11, 26, 2, -21 },
};

const GFXfont JetBrainsMono_ExtraBold43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_EXTRABOLD43PT7B_H_
