#ifndef _JETBRAINSMONO_EXTRABOLD42PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x73,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E,
  0x00, 0xF8, 0x3C, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3E,
  0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE7, 0x3F, 0xFF,
  0x39, 0xFF, 0xF9, 0xCF, 0xFF, 0xCE, 0x00, 0x7E, 0x70, 0x03, 0xFB, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xBF, 0xC0, 0x1C, 0xFE,
  0x00, 0xE3, 0xF0, 0x07, 0x1F, 0xFE, 0x38, 0xFF, 0xF9, 0xCF, 0xFF, 0xEE,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x03, 0xE3, 0xFE, 0x00,
  0x78, 0xFF, 0xE0, 0x1E, 0x1F, 0xFE, 0x07, 0xC3, 0xC3, 0xC0, 0xF0, 0xF8,
  0x78, 0x3C, 0x1F, 0x0F, 0x0F, 0x03, 0xE1, 0xE3, 0xE0, 0x7C, 0x3C, 0x78,
  0x0F, 0x87, 0x9E, 0x00, 0xF9, 0xF7, 0xC0, 0x1F, 0xFD, 0xF0, 0x01, 0xFF,
  0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF7, 0xFC, 0x00, 0x3D,
  0xFF, 0xC0, 0x0F, 0x3F, 0xF8, 0x03, 0xEF, 0x8F, 0x80, 0x79, 0xE0, 0xF0,
  0x1E, 0x3C, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1F, 0x0F, 0x03, 0xE7, 0xC3, 0xC0, 0x3F, 0xF8, 0xF8, 0x03, 0xFE, 0x3E,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x7E, 0xFD, 0xF9, 0xFB, 0xF1, 0xFB, 0xF7, 0xE3, 0xFF,
  0xCF, 0xC3, 0xFF, 0x9F, 0x83, 0xFE, 0x3F, 0x07, 0xFC, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0x83, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x18, 0x03,
  0xC0, 0x7E, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x83,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFC, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE3,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x04, 0x0F, 0x80, 0x8E, 0x1F, 0x0F, 0x3F, 0x1C, 0x3E, 0x7F,
  0x39, 0xFC, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x03,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xE7,
  0xC0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3E,
  0x00, 0x60, 0x30, 0x00, 0x40, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFB,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0x3F, 0xF9, 0xF3, 0xFF,
  0x9F, 0xBF, 0xF9, 0xF3, 0xFF, 0x9F, 0x3F, 0xF8, 0x43, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x9F,
  0x80, 0xF8, 0xFC, 0x07, 0x87, 0xE0, 0x30, 0x3F, 0x01, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE,
  0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0x9F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x3F, 0x83, 0xF7,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xFD, 0xFF,
  0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF9, 0xE0, 0x1F, 0xBF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE,
  0x0F, 0xE3, 0xFC, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC, 0xFE, 0x07, 0xEF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFB,
  0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xC7, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x3F, 0xFB,
  0xF0, 0xFF, 0xBF, 0x81, 0xF9, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x08, 0x1F, 0x9F, 0xDF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xCF,
  0xFF, 0xFF, 0xFD, 0xFC, 0x7E, 0x02, 0x01, 0xF8, 0x7F, 0x1F, 0xF3, 0xFE,
  0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0,
  0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF1,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0xBE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3C, 0xFF, 0xC1, 0xFC,
  0xFF, 0x87, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x1F, 0xFC, 0x7E, 0x1F,
  0xF8, 0xF8, 0x3F, 0xF1, 0xF0, 0x7F, 0xE3, 0xE0, 0xFF, 0xC7, 0xC1, 0xFF,
  0x8F, 0x83, 0xFF, 0x1F, 0x07, 0xFE, 0x3E, 0x0F, 0xFC, 0x7C, 0x1F, 0xF8,
  0x7C, 0x3F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0x7F, 0xC1, 0xFC, 0xFF, 0x80,
  0x60, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0x01, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7E, 0x1F, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07,
  0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC1, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0x80, 0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0xBF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF,
  0xF9, 0xFE, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xF9, 0xFE, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8,
  0x0F, 0xEF, 0xC0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F,
  0x03, 0xF9, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFB, 0x83, 0xBF, 0xFE, 0x1D, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xDE, 0x77, 0xFE, 0xF7, 0xBF, 0xF7, 0xBD, 0xFF, 0xBD,
  0xEF, 0xFC, 0xFE, 0x7F, 0xE7, 0xF3, 0xFF, 0x3F, 0x9F, 0xF8, 0xFC, 0xFF,
  0xC7, 0xC7, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xE0, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x78, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFB, 0xC3, 0xFF, 0xBE, 0x3F, 0xFB, 0xE3, 0xFF, 0x9E, 0x3F,
  0xF9, 0xF3, 0xFF, 0x9F, 0x3F, 0xF8, 0xF3, 0xFF, 0x8F, 0xBF, 0xF8, 0xFB,
  0xFF, 0x87, 0xBF, 0xF8, 0x7D, 0xFF, 0x87, 0xDF, 0xF8, 0x3D, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFB, 0xFE, 0xFE, 0x07,
  0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF0, 0x3F, 0xDF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF,
  0xFB, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xEF, 0xF0, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E,
  0x07, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0x83, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF9,
  0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xCF, 0xF9, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xEF, 0xF0, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFC,
  0x3E, 0x0F, 0xBE, 0x1F, 0x0F, 0xDF, 0x0F, 0x87, 0xEF, 0x87, 0xC3, 0xE7,
  0xC3, 0xE1, 0xF3, 0xE1, 0xF8, 0xF9, 0xF0, 0xDC, 0x7C, 0xF8, 0xEE, 0x3E,
  0x7C, 0x77, 0x1F, 0x3E, 0x3B, 0x8F, 0x9F, 0x1D, 0xC7, 0xCF, 0x8E, 0xE3,
  0xE3, 0xE7, 0x71, 0xF1, 0xF3, 0xB8, 0xF0, 0xF9, 0xCE, 0x78, 0x7C, 0xE7,
  0x3C, 0x3E, 0xF3, 0xBE, 0x1F, 0x71, 0xDF, 0x0F, 0xB8, 0xEF, 0x87, 0xDC,
  0x77, 0xC3, 0xEE, 0x3B, 0xE1, 0xF7, 0x1D, 0xF0, 0xFB, 0x8E, 0xF8, 0x3D,
  0xC7, 0xF8, 0x1E, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xF3, 0xF0, 0x07,
  0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0,
  0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x01, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xBE, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x01, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7C, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x30, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xEF, 0xE3, 0xFE, 0x7F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x80, 0xFC, 0xFF, 0x0F, 0xDF, 0xF8, 0xFD,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFD, 0xFF, 0xCF, 0xDF,
  0xF8, 0xFC, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x08, 0x3F, 0x1F,
  0xE7, 0xE7, 0xFE, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xEF, 0xC7, 0xF9, 0xF8, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xF1, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xEF, 0xF9, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x03, 0xFC, 0xFC, 0xFF, 0xDF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x7E, 0x3F, 0xCF, 0xC1, 0xE1, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x80, 0xFC, 0xFF, 0x0F, 0xDF, 0xF8, 0xFD, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF,
  0x01, 0xFD, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0xFE, 0x1F, 0x87, 0xF0,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0,
  0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x80, 0x87, 0xDF, 0x1F, 0xBF, 0xFD, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1F, 0x1F, 0x00, 0x08, 0x0F, 0xCF, 0xF0, 0xFD, 0xFF, 0x8F,
  0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7E, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x0F, 0xCF, 0xF0, 0xFD, 0xFF, 0x8F,
  0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xDF, 0xFC, 0xFD,
  0xFF, 0x8F, 0xCF, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0x00, 0x03, 0xFC, 0xFC, 0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFD, 0xF8, 0xFF, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0C, 0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF9,
  0xFB, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xC7, 0xF9, 0xF8,
  0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFE, 0x07, 0xEF,
  0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3,
  0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x3E,
  0x0F, 0xBE, 0x1F, 0x07, 0xDF, 0x0F, 0x87, 0xCF, 0x87, 0xC3, 0xE7, 0xC3,
  0xF1, 0xF3, 0xE1, 0xB8, 0xF9, 0xF1, 0xDC, 0x7C, 0x78, 0xEE, 0x3E, 0x3E,
  0x77, 0x1F, 0x1F, 0x3B, 0x8F, 0x0F, 0x9D, 0xCF, 0x87, 0xCE, 0x77, 0xC3,
  0xE7, 0x3B, 0xE1, 0xF7, 0x1D, 0xF0, 0x7B, 0x8E, 0xF8, 0x3D, 0xC7, 0x78,
  0x1F, 0xE3, 0xBC, 0x0F, 0xF1, 0xDE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x01,
  0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F,
  0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xCF, 0xC0, 0x7F, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x3F, 0xBF, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xE0,
  0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x83, 0xF7, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xE3, 0xF3, 0xEF, 0x87, 0xFF, 0xBE, 0x1F,
  0xFE, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x20, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 16, 13, 25, 5, -31 },
  { 55, 23, 31, 25, 1, -31 },
  { 145, 21, 43, 25, 2, -37 },
  { 258, 27, 31, 25, -1, -31 },
  { 363, 23, 31, 25, 1, -31 },
  { 453, 7, 13, 25, 9, -31 },
  { 465, 13, 40, 25, 7, -35 },
  { 530, 14, 40, 25, 5, -35 },
  { 600, 23, 23, 25, 1, -26 },
  { 667, 21, 20, 25, 2, -24 },
  { 720, 11, 13, 25, 6, -6 },
  { 738, 13, 6, 25, 6, -17 },
  { 748, 9, 8, 25, 8, -8 },
  { 757, 21, 40, 25, 2, -35 },
  { 862, 20, 31, 25, 3, -31 },
  { 940, 21, 31, 25, 3, -31 },
  { 1022, 21, 31, 25, 2, -31 },
  { 1104, 21, 31, 25, 2, -31 },
  { 1186, 20, 31, 25, 2, -31 },
  { 1264, 20, 31, 25, 3, -31 },
  { 1342, 21, 31, 25, 2, -31 },
  { 1424, 21, 31, 25, 2, -31 },
  { 1506, 21, 31, 25, 2, -31 },
  { 1588, 21, 31, 25, 2, -31 },
  { 1670, 9, 24, 25, 8, -24 },
  { 1697, 11, 31, 25, 6, -24 },
  { 1740, 19, 24, 25, 3, -26 },
  { 1797, 19, 16, 25, 3, -22 },
  { 1835, 19, 24, 25, 3, -26 },
  { 1892, 17, 31, 25, 5, -31 },
  { 1958, 23, 39, 25, 1, -31 },
  { 2071, 23, 31, 25, 1, -31 },
  { 2161, 21, 31, 25, 3, -31 },
  { 2243, 20, 31, 25, 3, -31 },
  { 2321, 20, 31, 25, 3, -31 },
  { 2399, 19, 31, 25, 3, -31 },
  { 2473, 20, 31, 25, 3, -31 },
  { 2551, 20, 31, 25, 3, -31 },
  { 2629, 19, 31, 25, 3, -31 },
  { 2703, 19, 31, 25, 3, -31 },
  { 2777, 21, 31, 25, 1, -31 },
  { 2859, 21, 31, 25, 3, -31 },
  { 2941, 19, 31, 25, 4, -31 },
  { 3015, 21, 31, 25, 2, -31 },
  { 3097, 20, 31, 25, 3, -31 },
  { 3175, 20, 31, 25, 3, -31 },
  { 3253, 21, 31, 25, 3, -31 },
  { 3335, 20, 39, 25, 3, -31 },
  { 3433, 21, 31, 25, 3, -31 },
  { 3515, 21, 31, 25, 2, -31 },
  { 3597, 22, 31, 25, 2, -31 },
  { 3683, 20, 31, 25, 3, -31 },
  { 3761, 23, 31, 25, 1, -31 },
  { 3851, 25, 31, 25, 0, -31 },
  { 3948, 23, 31, 25, 1, -31 },
  { 4038, 24, 31, 25, 1, -31 },
  { 4131, 19, 31, 25, 3, -31 },
  { 4205, 13, 40, 25, 7, -35 },
  { 4270, 21, 40, 25, 2, -35 },
  { 4375, 13, 40, 25, 5, -35 },
  { 4440, 20, 17, 25, 3, -31 },
  { 4483, 20, 6, 25, 3, 1 },
  { 4498, 12, 6, 25, 6, -33 },
  { 4507, 21, 24, 25, 2, -24 },
  { 4570, 20, 31, 25, 3, -31 },
  { 4648, 20, 24, 25, 3, -24 },
  { 4708, 19, 31, 25, 3, -31 },
  { 4782, 20, 24, 25, 3, -24 },
  { 4842, 21, 31, 25, 2, -31 },
  { 4924, 19, 32, 25, 3, -24 },
  { 5000, 20, 31, 25, 3, -31 },
  { 5078, 21, 33, 25, 3, -33 },
  { 5165, 17, 41, 25, 3, -33 },
  { 5253, 21, 31, 25, 3, -31 },
  { 5335, 23, 31, 25, 1, -31 },
  { 5425, 21, 24, 25, 2, -24 },
  { 5488, 20, 24, 25, 3, -24 },
  { 5548, 20, 24, 25, 3, -24 },
  { 5608, 20, 32, 25, 3, -24 },
  { 5688, 19, 32, 25, 3, -24 },
  { 5764, 21, 24, 25, 3, -24 },
  { 5827, 21, 24, 25, 2, -24 },
  { 5890, 21, 30, 25, 1, -30 },
  { 5969, 20, 23, 25, 3, -23 },
  { 6027, 23, 23, 25, 1, -23 },
  { 6094, 25, 23, 25, 0, -23 },
  { 6166, 23, 23, 25, 1, -23 },
  { 6233, 23, 31, 25, 1, -23 },
  { 6323, 19, 23, 25, 3, -23 },
  { 6378, 19, 40, 25, 3, -35 },
  { 6473, 7, 40, 25, 9, -35 },
  { 6508, 19, 40, 25, 3, -35 },
  { 6603, 22, 11, 25, 2, -20 },
};

const GFXfont JetBrainsMono_ExtraBold42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_EXTRABOLD42PT7B_H_
