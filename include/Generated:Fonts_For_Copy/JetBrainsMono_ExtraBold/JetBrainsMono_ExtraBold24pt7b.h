#ifndef _JETBRAINSMONO_EXTRABOLD24PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x00, 0x0F, 0xFF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC6, 0x06, 0x38, 0x18, 0xE0, 0xE3,
  0x03, 0x8C, 0x0E, 0x31, 0xFF, 0xF7, 0xFF, 0xC7, 0x1C, 0x1C, 0x60, 0x71,
  0x81, 0x8E, 0x06, 0x38, 0xFF, 0xFB, 0xFF, 0xE3, 0x8C, 0x0E, 0x30, 0x31,
  0xC0, 0xC7, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x3F, 0xC7, 0xFE,
  0x7F, 0xFF, 0x6F, 0xF6, 0x0F, 0x60, 0x7E, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x06, 0xF0, 0x67, 0xF6, 0x7F, 0x6F, 0x7F, 0xF7, 0xFE, 0x1F, 0xC0, 0x60,
  0x06, 0x00, 0x60, 0x18, 0x0E, 0xFC, 0x1B, 0xB8, 0x67, 0x31, 0xCE, 0x67,
  0x1C, 0xCC, 0x3F, 0xB0, 0x3E, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1D, 0xC0,
  0x7F, 0xE0, 0xDC, 0xC3, 0x31, 0x8E, 0x63, 0x38, 0xC6, 0x61, 0xFD, 0x81,
  0xF0, 0x0F, 0x00, 0xFE, 0x0F, 0xF0, 0xF3, 0xC7, 0x0E, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x7C, 0x07, 0xF3, 0xFB, 0xDD, 0xCF, 0xEE, 0x3E, 0x71, 0xF3,
  0x87, 0x1F, 0xFC, 0x7F, 0xF1, 0xFB, 0xC0, 0xFF, 0xFF, 0xF7, 0x77, 0x03,
  0x0F, 0x1F, 0x3E, 0x78, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3F, 0x1F, 0x0F, 0x03, 0xC0, 0xF0,
  0xF8, 0xFC, 0x3C, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0xFC, 0xF8, 0xE0, 0x80, 0x07, 0x00, 0x38,
  0x01, 0xC1, 0x0E, 0x2E, 0x67, 0x7F, 0x7F, 0xFF, 0xC0, 0xE0, 0x0F, 0x81,
  0xEE, 0x0E, 0x78, 0xF1, 0xC1, 0x08, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x3E, 0x78, 0xF3, 0xC7, 0x8E, 0x1C, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0x27, 0xBF, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x27, 0xF7, 0x7F, 0x77, 0xF6, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x70, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0x0F, 0x03, 0xE1, 0xFC, 0x7F, 0x8E,
  0xF1, 0x9E, 0x23, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xFC, 0x7F, 0xE7,
  0xFF, 0xF0, 0xFF, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFC, 0x0F, 0xE0,
  0xFE, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xF7, 0xFE, 0x7F, 0xE1,
  0xFC, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x70, 0x07,
  0x00, 0x71, 0x07, 0x7C, 0x7F, 0xE7, 0x9F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0x0F, 0x78, 0xF7, 0xFE, 0x3F, 0xE1, 0xFC, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x98, 0x7F, 0xE7, 0xFF, 0xF8, 0xFF,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0xFF, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xF7, 0x0F, 0x70, 0xF7,
  0xDE, 0x3F, 0xC3, 0xFC, 0x7D, 0xE7, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xF7,
  0xFF, 0x7F, 0xE1, 0xFC, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xF7, 0xFF, 0x3E, 0xE0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0xF7, 0xFC, 0xE0, 0x00, 0x00,
  0x07, 0xBF, 0xFF, 0x00, 0x3C, 0x7C, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0xF1, 0xE3, 0x8F, 0x1E, 0x38, 0xF0, 0x00, 0x20, 0x1C, 0x0F, 0x87,
  0xF3, 0xF9, 0xFC, 0x3C, 0x07, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xF0,
  0x0E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x18, 0x03, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xF8, 0x0F, 0x0F, 0xE7, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00,
  0xF0, 0x7F, 0x3F, 0xDF, 0xF0, 0x78, 0x1C, 0x0E, 0xFF, 0x7F, 0xBF, 0x9F,
  0x0E, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0x0F, 0x81, 0xFF,
  0x1F, 0xFD, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x8E, 0xF8, 0xFF, 0xCF, 0x7E,
  0x71, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0x1D, 0xF8, 0xFF, 0xE3,
  0x87, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0xF7, 0x07, 0x38, 0x39, 0xC1,
  0xCF, 0x1E, 0x38, 0xFF, 0xC7, 0xFE, 0x3F, 0xFB, 0xC3, 0xDE, 0x0E, 0xF0,
  0x77, 0x03, 0xC0, 0xF8, 0x1F, 0xF3, 0xFF, 0x71, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x3E, 0xFF, 0x1F, 0xFB, 0x8F, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F,
  0xFF, 0xFF, 0xDF, 0xE0, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF,
  0x07, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0xF8, 0x1F, 0xF3, 0xFF, 0x7F,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF8, 0xFF, 0xFE, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0xFF,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x03,
  0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x07, 0xF0, 0x0F, 0x00, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0xE1,
  0xFC, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x77, 0x07, 0x78, 0xF7,
  0xFF, 0x3F, 0xE1, 0xFC, 0xE0, 0xFE, 0x1E, 0xE1, 0xEE, 0x3C, 0xE3, 0xCE,
  0x3C, 0xE7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x8E, 0x78, 0xE3, 0xCE,
  0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xFF, 0x0F, 0xF8,
  0xFF, 0x9F, 0xF9, 0xBF, 0xDF, 0xED, 0xFE, 0xFF, 0xEF, 0x7E, 0xF7, 0xE7,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xC7, 0xEE, 0x7E, 0xE7, 0xF6,
  0x7F, 0x77, 0xF7, 0x7F, 0x37, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x0F, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78,
  0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xFC, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xE0,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xEF, 0xFE, 0xFF, 0x8F, 0xE0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x03, 0xFC, 0x7F,
  0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xE1,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8E, 0x78, 0xE7,
  0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x1F, 0x0F, 0x03, 0xFC, 0x7F,
  0xE7, 0xDF, 0xF0, 0xFF, 0x00, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x0F, 0x00, 0x7F, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78,
  0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xE0, 0x7F, 0x83, 0xFC, 0x1D, 0xE0, 0xE7,
  0x0F, 0x38, 0x79, 0xE3, 0x8F, 0x1C, 0x39, 0xE1, 0xCF, 0x0F, 0x70, 0x7B,
  0x81, 0xDC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xE3,
  0x9F, 0x8E, 0x7E, 0x39, 0xD8, 0xE7, 0x67, 0x9D, 0xDE, 0x77, 0x69, 0xDD,
  0xA6, 0x76, 0x99, 0xDB, 0x67, 0x4F, 0x9D, 0x3E, 0x74, 0xF9, 0xF3, 0xE3,
  0xCF, 0x8F, 0x3E, 0x3C, 0x78, 0xF1, 0xC0, 0x78, 0x3D, 0xE1, 0xE3, 0xC7,
  0x8F, 0x3C, 0x1E, 0xF0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1F,
  0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7B, 0xC3, 0xCF, 0x0F, 0x1E, 0x78,
  0x7B, 0xE0, 0xF0, 0xF0, 0x3D, 0xE0, 0xF7, 0x87, 0x8E, 0x1E, 0x3C, 0x70,
  0x73, 0xC1, 0xEE, 0x07, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFF,
  0xDF, 0xFB, 0xFF, 0x7F, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xF8, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D,
  0xC3, 0x9C, 0x39, 0xE7, 0x8E, 0x70, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF1, 0xE3, 0x8F, 0x1F, 0xC3, 0xFE, 0x7F, 0xF7, 0x0F, 0x00, 0xF1,
  0xFF, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0xFF, 0xF1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0xFF, 0xFF, 0xDD,
  0xF0, 0x1F, 0xC3, 0xFE, 0x7F, 0xF7, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0xF7, 0x8F, 0x7F, 0xF3, 0xFE, 0x1F, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xEF, 0x7F, 0xF7, 0xFF, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF,
  0x1F, 0xC3, 0xFE, 0x79, 0xE7, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x07, 0x0F, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0x00, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x3E,
  0xF7, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78,
  0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x3F, 0xE3, 0xFE, 0x3F,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0xFF,
  0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3C, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x00, 0x00,
  0x07, 0xF9, 0xFE, 0x7F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0xFF, 0xBF, 0xCF, 0xE0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1F, 0xE1, 0xEE, 0x3C, 0xE3, 0xCE,
  0x78, 0xFF, 0x8F, 0xF0, 0xFF, 0x8E, 0x78, 0xE3, 0xCE, 0x3C, 0xE1, 0xEE,
  0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0xFF, 0xFF, 0xE7, 0x7E,
  0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E,
  0x67, 0xE6, 0x70, 0xEF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0xFE,
  0x7F, 0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F,
  0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0xEF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0xEE, 0xF9, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x3E, 0xF7, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF7, 0xFF, 0x3E,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xEF, 0xCE, 0xFE, 0xFF, 0xEF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x3F, 0xC7, 0xFE, 0x79, 0xF7, 0x00, 0x78, 0x07, 0xF8,
  0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFE, 0x3F, 0xFF, 0x3F, 0xE3, 0xF0, 0xF0, 0x7F, 0x83, 0x9C, 0x3C,
  0xE1, 0xE7, 0x8E, 0x1C, 0xF0, 0xE7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x00, 0xE3, 0x9F, 0x8E, 0x76, 0x39, 0xDD, 0xE7,
  0x77, 0x99, 0xDA, 0x67, 0x6B, 0x9D, 0xBE, 0x74, 0xF8, 0xD3, 0xE3, 0xCF,
  0x8F, 0x3C, 0x3C, 0x70, 0xF0, 0xF3, 0xCF, 0x0F, 0x78, 0x7F, 0x81, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0xC1, 0xEE, 0x1E, 0x78, 0xF1, 0xEF,
  0x0F, 0x80, 0xF0, 0x7F, 0x87, 0x9C, 0x3C, 0xF1, 0xC7, 0x9E, 0x1E, 0xF0,
  0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE3, 0xF8, 0x7E, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x7F, 0x87,
  0xF1, 0xFE, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x38, 0x00, 0x10, 0x07, 0xC3, 0xFE, 0x3E, 0xF7, 0xE7, 0xFE,
  0x3F, 0x00, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 18, 14, 5, -18 },
  { 10, 9, 8, 14, 3, -18 },
  { 19, 14, 18, 14, 0, -18 },
  { 51, 12, 24, 14, 1, -21 },
  { 87, 15, 18, 14, 0, -18 },
  { 121, 13, 18, 14, 1, -18 },
  { 151, 4, 8, 14, 5, -18 },
  { 155, 8, 23, 14, 4, -20 },
  { 178, 8, 23, 14, 3, -20 },
  { 201, 13, 13, 14, 1, -15 },
  { 223, 12, 12, 14, 1, -14 },
  { 241, 7, 8, 14, 3, -4 },
  { 248, 8, 4, 14, 3, -10 },
  { 252, 5, 5, 14, 5, -5 },
  { 256, 12, 23, 14, 1, -20 },
  { 291, 12, 18, 14, 1, -18 },
  { 318, 11, 18, 14, 2, -18 },
  { 343, 12, 18, 14, 1, -18 },
  { 370, 12, 18, 14, 1, -18 },
  { 397, 12, 18, 14, 1, -18 },
  { 424, 12, 18, 14, 1, -18 },
  { 451, 12, 18, 14, 1, -18 },
  { 478, 12, 18, 14, 1, -18 },
  { 505, 12, 18, 14, 1, -18 },
  { 532, 12, 18, 14, 1, -18 },
  { 559, 5, 13, 14, 5, -13 },
  { 568, 7, 17, 14, 3, -13 },
  { 583, 11, 14, 14, 2, -15 },
  { 603, 10, 10, 14, 2, -13 },
  { 616, 11, 14, 14, 2, -15 },
  { 636, 9, 18, 14, 3, -18 },
  { 657, 13, 22, 14, 1, -18 },
  { 693, 13, 18, 14, 1, -18 },
  { 723, 11, 18, 14, 2, -18 },
  { 748, 12, 18, 14, 1, -18 },
  { 775, 11, 18, 14, 2, -18 },
  { 800, 11, 18, 14, 2, -18 },
  { 825, 11, 18, 14, 2, -18 },
  { 850, 12, 18, 14, 1, -18 },
  { 877, 11, 18, 14, 2, -18 },
  { 902, 10, 18, 14, 2, -18 },
  { 925, 12, 18, 14, 0, -18 },
  { 952, 12, 18, 14, 2, -18 },
  { 979, 11, 18, 14, 2, -18 },
  { 1004, 12, 18, 14, 1, -18 },
  { 1031, 12, 18, 14, 1, -18 },
  { 1058, 12, 18, 14, 1, -18 },
  { 1085, 12, 18, 14, 2, -18 },
  { 1112, 12, 22, 14, 1, -18 },
  { 1145, 12, 18, 14, 2, -18 },
  { 1172, 12, 18, 14, 1, -18 },
  { 1199, 12, 18, 14, 1, -18 },
  { 1226, 12, 18, 14, 1, -18 },
  { 1253, 13, 18, 14, 1, -18 },
  { 1283, 14, 18, 14, 0, -18 },
  { 1315, 14, 18, 14, 0, -18 },
  { 1347, 14, 18, 14, 0, -18 },
  { 1379, 11, 18, 14, 2, -18 },
  { 1404, 7, 23, 14, 4, -20 },
  { 1425, 12, 23, 14, 1, -20 },
  { 1460, 7, 23, 14, 3, -20 },
  { 1481, 12, 10, 14, 1, -18 },
  { 1496, 12, 3, 14, 1, 1 },
  { 1501, 6, 4, 14, 4, -19 },
  { 1504, 12, 13, 14, 1, -13 },
  { 1524, 11, 18, 14, 2, -18 },
  { 1549, 12, 13, 14, 1, -13 },
  { 1569, 12, 18, 14, 1, -18 },
  { 1596, 12, 13, 14, 1, -13 },
  { 1616, 12, 18, 14, 1, -18 },
  { 1643, 12, 17, 14, 1, -13 },
  { 1669, 11, 18, 14, 2, -18 },
  { 1694, 11, 19, 14, 2, -19 },
  { 1721, 10, 23, 14, 2, -19 },
  { 1750, 12, 18, 14, 2, -18 },
  { 1777, 13, 18, 14, 1, -18 },
  { 1807, 12, 13, 14, 1, -13 },
  { 1827, 11, 13, 14, 2, -13 },
  { 1845, 12, 13, 14, 1, -13 },
  { 1865, 11, 17, 14, 2, -13 },
  { 1889, 12, 17, 14, 1, -13 },
  { 1915, 12, 13, 14, 2, -13 },
  { 1935, 12, 13, 14, 1, -13 },
  { 1955, 12, 17, 14, 1, -17 },
  { 1981, 11, 13, 14, 2, -13 },
  { 1999, 13, 13, 14, 1, -13 },
  { 2021, 14, 13, 14, 0, -13 },
  { 2044, 13, 13, 14, 1, -13 },
  { 2066, 13, 17, 14, 1, -13 },
  { 2094, 11, 13, 14, 2, -13 },
  { 2112, 11, 23, 14, 2, -20 },
  { 2144, 4, 23, 14, 5, -20 },
  { 2156, 11, 23, 14, 2, -20 },
  { 2188, 12, 7, 14, 1, -12 },
};

const GFXfont JetBrainsMono_ExtraBold24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_EXTRABOLD24PT7B_H_
