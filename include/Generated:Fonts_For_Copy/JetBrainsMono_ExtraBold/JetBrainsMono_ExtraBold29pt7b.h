#ifndef _JETBRAINSMONO_EXTRABOLD29PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0x38, 0x00, 0x03,
  0xBF, 0xF7, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0x71, 0xE0, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x38, 0xF0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3E,
  0xFE, 0x79, 0xBE, 0xF3, 0x01, 0xE6, 0x03, 0xEC, 0x07, 0xF8, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0x7C, 0x06, 0x7F, 0xCC, 0xFF,
  0x9B, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x0F, 0xF0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x3E, 0x03, 0xDF, 0xC0, 0xEF, 0x38, 0x73,
  0x8E, 0x38, 0xE3, 0x9C, 0x38, 0xE7, 0x0E, 0x3B, 0x81, 0xFD, 0xC0, 0x3F,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x20, 0x03, 0xBF, 0x01, 0xDF,
  0xE0, 0xEE, 0x38, 0x3B, 0x8E, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x07, 0x79,
  0xC1, 0xFC, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C,
  0x78, 0x3C, 0x38, 0x3C, 0x04, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7F,
  0x00, 0x7F, 0x81, 0xFF, 0x9E, 0xF3, 0xDE, 0xF3, 0xFC, 0xF1, 0xFC, 0xF0,
  0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x1F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0xF0, 0xFC, 0x7F, 0x3F, 0x8F, 0x87,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7F, 0x0F, 0xC1,
  0xF0, 0x1C, 0xE0, 0x3E, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1E,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x7C, 0x1E, 0x0F, 0x87, 0xE3, 0xF3, 0xF8, 0xFC, 0x3E, 0x0E, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x63, 0x8E, 0xF9, 0x9E,
  0xFD, 0xFE, 0xFF, 0xFF, 0x0F, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0xF0,
  0x3E, 0x78, 0x3C, 0x7C, 0x1C, 0x30, 0x08, 0x20, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3F, 0x3E, 0x3C,
  0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23,
  0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0xC7, 0xFF,
  0xBF, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF3, 0x3F, 0xDE,
  0xFF, 0x7B, 0xFD, 0xCF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7B, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x07,
  0xFC, 0x3F, 0xF0, 0xFB, 0xC3, 0x8F, 0x0C, 0x3C, 0x20, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xF3, 0xF7, 0xE7, 0x83, 0xDF, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xE0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE3, 0xEF, 0xFF, 0x9F, 0xFC,
  0x1F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0xF8, 0xF7, 0xF3, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF, 0x9F, 0xFC,
  0x1F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3D, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xE3,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x3E, 0xFC, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xBE, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x1F, 0xE1,
  0xFF, 0xC7, 0xFF, 0xBE, 0x3E, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xBE, 0x3E,
  0x7F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xFC, 0xF8, 0xFB, 0xC1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0x78, 0x3E, 0xFD, 0xFD, 0xFF, 0xF1, 0xFD, 0xE0, 0xE7, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x7B, 0xEF, 0xFE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0xFB, 0xFF, 0x9E, 0x1E, 0x3E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF0,
  0x00, 0x08, 0x00, 0xC0, 0x1E, 0x07, 0xF0, 0xFF, 0x9F, 0xF3, 0xFC, 0x1F,
  0x80, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFC, 0x01,
  0xE0, 0x03, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x07,
  0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x00,
  0x38, 0x0F, 0xC1, 0xFE, 0x3F, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x18, 0x00,
  0x80, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x3F, 0xF3, 0xFE, 0x3F, 0xC3, 0xF8, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE1, 0xF7, 0xE3, 0xF7, 0xE3, 0xCF, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F,
  0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE3, 0x8F, 0xE3, 0xFF, 0xE1, 0xF7,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x7C, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x3E,
  0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBC, 0x3E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF,
  0xC7, 0xFF, 0xBF, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1F, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F,
  0xE1, 0xFF, 0xC7, 0xFF, 0xBF, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0,
  0x7F, 0xE0, 0xFB, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x3E, 0x3C, 0x7C,
  0x78, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0x3E, 0x1E,
  0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF9, 0xE1, 0xF3, 0xC1, 0xF7, 0x83,
  0xEF, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0x63, 0xFF, 0xC6, 0xFF,
  0xCD, 0xFF, 0xBB, 0xFB, 0x77, 0xF7, 0xDF, 0xEF, 0xBF, 0xDF, 0x7F, 0x9E,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xE0, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF8, 0xFE, 0xE3, 0xFB, 0x8F, 0xEF, 0x3F, 0x9C, 0xFF,
  0x73, 0xFD, 0xEF, 0xF3, 0xBF, 0xCE, 0xFF, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F, 0xE1, 0xFF, 0xC7, 0xFF,
  0xBF, 0x3E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7B, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0xFF, 0xE1, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1E, 0xF0,
  0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x1F, 0xE1, 0xFF, 0xC7, 0xFF, 0xBF, 0x3E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0xCF, 0x8F, 0x1E,
  0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x7C, 0x0F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xEF, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x07, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x3E, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8,
  0x7B, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0xF0, 0x1F, 0xF8, 0x1E,
  0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x3C, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xF1, 0xC7, 0xF8, 0xF3, 0xDC, 0x79, 0xEE, 0x3C, 0xF7, 0x1E,
  0x7B, 0x9F, 0x3D, 0xCD, 0x9C, 0xE6, 0xCE, 0x7B, 0x67, 0x3D, 0xB3, 0x9E,
  0xDD, 0xCF, 0x66, 0xE7, 0xB3, 0x71, 0xD9, 0xB8, 0xFC, 0xFC, 0x7C, 0x7E,
  0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE0, 0xF8,
  0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7C, 0x78,
  0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0x8F, 0x07, 0xC7,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xE0, 0xF7,
  0x83, 0xCF, 0x1E, 0x3C, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0x83, 0xC0, 0x07, 0xC0, 0xFF, 0x9F, 0xFF,
  0x7F, 0xFE, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xEF, 0xFF, 0xDF,
  0xFF, 0x9F, 0xDF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xCF, 0x8F, 0x7F, 0x3F, 0xFE, 0xFF, 0xFB, 0xE1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF,
  0xBD, 0xFC, 0xF3, 0xE0, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0xF8,
  0x7F, 0xC1, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFE,
  0x1F, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x9F, 0xBD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xF7, 0x80, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF,
  0xBE, 0x3E, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3F, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFC, 0xF9, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xCF, 0xFE, 0x7F, 0xE3,
  0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF,
  0x8F, 0x7F, 0x3F, 0xFE, 0xFF, 0xFB, 0xE1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7C, 0x03, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x07, 0xFC, 0x1F, 0x78, 0x7C, 0xF0, 0xF9, 0xE3, 0xE3, 0xC7, 0xC7, 0xFF,
  0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x78, 0xF8, 0xF1, 0xF1, 0xE1, 0xF3,
  0xC3, 0xE7, 0x83, 0xEF, 0x03, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xF7, 0x3D,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0xFF, 0x39, 0xFE, 0x73, 0xFC, 0xE7, 0xF9,
  0xCF, 0xF3, 0x9F, 0xE7, 0x3F, 0xCE, 0x7F, 0x9C, 0xFF, 0x39, 0xFE, 0x73,
  0xFC, 0xE7, 0xF9, 0xCF, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8,
  0x7B, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0x1F, 0xC0, 0xFF, 0xC7,
  0xFF, 0xBF, 0xFE, 0xF8, 0x7B, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF0,
  0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFB, 0xFF,
  0xEF, 0x7F, 0x3C, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x3F, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xE7, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0xF3, 0xF1, 0xEF, 0xF3, 0xDF, 0xF7, 0xF7, 0xEF, 0x87, 0xDF, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3,
  0xE1, 0xF7, 0x80, 0x0F, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1E, 0xFF,
  0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF0, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E,
  0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xF1, 0xC3, 0xB8, 0xE3, 0xDC, 0x79, 0xEE, 0x3C, 0xF7, 0x1E,
  0x73, 0xDB, 0x39, 0xED, 0x9C, 0xF6, 0xCE, 0x3B, 0x67, 0x1D, 0x9F, 0x8E,
  0xCF, 0xC7, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C,
  0xF8, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1E, 0xF8,
  0x3E, 0x78, 0x7C, 0x7C, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1E,
  0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0x8F,
  0xF8, 0x7F, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFF, 0x80,
  0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x3E, 0x00,
  0xFE, 0x1F, 0xFE, 0x3F, 0xBE, 0x7F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 11, 9, 17, 3, -21 },
  { 28, 16, 21, 17, 1, -21 },
  { 70, 15, 29, 17, 1, -25 },
  { 125, 18, 21, 17, 0, -21 },
  { 173, 16, 21, 17, 1, -21 },
  { 215, 4, 9, 17, 7, -21 },
  { 220, 10, 27, 17, 4, -24 },
  { 254, 10, 27, 17, 3, -24 },
  { 288, 16, 16, 17, 1, -18 },
  { 320, 14, 14, 17, 2, -17 },
  { 345, 8, 9, 17, 4, -4 },
  { 354, 9, 4, 17, 4, -12 },
  { 359, 6, 6, 17, 6, -6 },
  { 364, 15, 27, 17, 1, -24 },
  { 415, 14, 21, 17, 2, -21 },
  { 452, 14, 21, 17, 2, -21 },
  { 489, 15, 21, 17, 1, -21 },
  { 529, 14, 21, 17, 2, -21 },
  { 566, 13, 21, 17, 2, -21 },
  { 601, 14, 21, 17, 2, -21 },
  { 638, 15, 21, 17, 1, -21 },
  { 678, 15, 21, 17, 1, -21 },
  { 718, 14, 21, 17, 2, -21 },
  { 755, 15, 21, 17, 1, -21 },
  { 795, 6, 16, 17, 6, -16 },
  { 807, 8, 21, 17, 4, -16 },
  { 828, 13, 17, 17, 2, -18 },
  { 856, 13, 11, 17, 2, -15 },
  { 874, 13, 17, 17, 2, -18 },
  { 902, 12, 21, 17, 3, -21 },
  { 934, 16, 26, 17, 1, -21 },
  { 986, 16, 21, 17, 1, -21 },
  { 1028, 14, 21, 17, 2, -21 },
  { 1065, 14, 21, 17, 2, -21 },
  { 1102, 14, 21, 17, 2, -21 },
  { 1139, 13, 21, 17, 2, -21 },
  { 1174, 14, 21, 17, 2, -21 },
  { 1211, 14, 21, 17, 2, -21 },
  { 1248, 13, 21, 17, 2, -21 },
  { 1283, 13, 21, 17, 2, -21 },
  { 1318, 14, 21, 17, 1, -21 },
  { 1355, 15, 21, 17, 2, -21 },
  { 1395, 13, 21, 17, 3, -21 },
  { 1430, 15, 21, 17, 1, -21 },
  { 1470, 14, 21, 17, 2, -21 },
  { 1507, 14, 21, 17, 2, -21 },
  { 1544, 15, 21, 17, 2, -21 },
  { 1584, 14, 26, 17, 2, -21 },
  { 1630, 14, 21, 17, 2, -21 },
  { 1667, 15, 21, 17, 1, -21 },
  { 1707, 15, 21, 17, 1, -21 },
  { 1747, 14, 21, 17, 2, -21 },
  { 1784, 16, 21, 17, 1, -21 },
  { 1826, 17, 21, 17, 0, -21 },
  { 1871, 16, 21, 17, 1, -21 },
  { 1913, 17, 21, 17, 0, -21 },
  { 1958, 13, 21, 17, 2, -21 },
  { 1993, 9, 27, 17, 5, -24 },
  { 2024, 15, 27, 17, 1, -24 },
  { 2075, 8, 27, 17, 4, -24 },
  { 2102, 14, 11, 17, 2, -21 },
  { 2122, 14, 4, 17, 2, 1 },
  { 2129, 8, 4, 17, 4, -23 },
  { 2133, 15, 16, 17, 1, -16 },
  { 2163, 14, 21, 17, 2, -21 },
  { 2200, 14, 16, 17, 2, -16 },
  { 2228, 13, 21, 17, 2, -21 },
  { 2263, 14, 16, 17, 2, -16 },
  { 2291, 15, 21, 17, 1, -21 },
  { 2331, 13, 21, 17, 2, -16 },
  { 2366, 14, 21, 17, 2, -21 },
  { 2403, 14, 23, 17, 2, -23 },
  { 2444, 12, 28, 17, 2, -23 },
  { 2486, 15, 21, 17, 2, -21 },
  { 2526, 15, 21, 17, 1, -21 },
  { 2566, 15, 16, 17, 1, -16 },
  { 2596, 14, 16, 17, 2, -16 },
  { 2624, 14, 16, 17, 2, -16 },
  { 2652, 14, 21, 17, 2, -16 },
  { 2689, 13, 21, 17, 2, -16 },
  { 2724, 15, 16, 17, 2, -16 },
  { 2754, 15, 16, 17, 1, -16 },
  { 2784, 15, 20, 17, 1, -20 },
  { 2822, 14, 16, 17, 2, -16 },
  { 2850, 16, 16, 17, 1, -16 },
  { 2882, 17, 16, 17, 0, -16 },
  { 2916, 16, 16, 17, 1, -16 },
  { 2948, 16, 21, 17, 1, -16 },
  { 2990, 13, 16, 17, 2, -16 },
  { 3016, 13, 27, 17, 2, -24 },
  { 3060, 4, 27, 17, 7, -24 },
  { 3074, 13, 27, 17, 2, -24 },
  { 3118, 15, 7, 17, 1, -14 },
};

const GFXfont JetBrainsMono_ExtraBold29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_EXTRABOLD29PT7B_H_
