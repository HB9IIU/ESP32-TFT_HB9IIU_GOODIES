#ifndef _JETBRAINSMONO_EXTRABOLD31PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x07, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x8F, 0x0E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0x80, 0xE1,
  0xC0, 0x70, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x8E, 0x1C, 0x07,
  0x0E, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xE3, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7D, 0xBE, 0x7D, 0x9F, 0x79, 0x80, 0x7D, 0x80, 0x7D, 0x80, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xBF, 0x01, 0x9F,
  0x01, 0x9F, 0xF9, 0x9F, 0x7D, 0x9F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00,
  0xEF, 0xE0, 0x39, 0xFE, 0x0F, 0x79, 0xE1, 0xCE, 0x1C, 0x71, 0xC3, 0x9C,
  0x38, 0x77, 0x87, 0x9C, 0xE0, 0x7F, 0xB8, 0x07, 0xEE, 0x00, 0x31, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xBE, 0x00, 0xEF, 0xF0, 0x3B, 0xDE,
  0x0E, 0x71, 0xC3, 0xCE, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE7, 0x87, 0xFC,
  0xE0, 0x7F, 0x38, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0xFF, 0xDE, 0x7B, 0xC7,
  0xF9, 0xE3, 0xFC, 0xF0, 0xFC, 0x78, 0x3E, 0x3E, 0x1F, 0x1F, 0xBF, 0xC7,
  0xFF, 0xE1, 0xFF, 0x78, 0x7F, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7,
  0x80, 0x00, 0xC0, 0xF0, 0x7C, 0x7F, 0x3F, 0xCF, 0xC7, 0xE1, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F,
  0x01, 0xC0, 0x10, 0x80, 0x38, 0x0F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x7C, 0x7F, 0x3F, 0x8F,
  0xC3, 0xE0, 0xE0, 0x20, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x06, 0x1C, 0x33, 0xCE, 0x7B, 0xF6, 0xFD, 0xFF, 0xFF, 0x1F, 0xFC,
  0x01, 0xE0, 0x01, 0xDC, 0x01, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0,
  0xF8, 0x18, 0x30, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x3F, 0x3F, 0x3E,
  0x3E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE2, 0x7F, 0xDE, 0xFF, 0xBD, 0xFF, 0x7B, 0xFE,
  0x67, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xF7, 0xFF,
  0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x7F,
  0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0x7C, 0x3C, 0xF8, 0x61, 0xF0, 0x83, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0xCF,
  0xDF, 0x07, 0xBC, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF,
  0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF9, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0xF0, 0x3D, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x1F, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF,
  0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1E, 0xF8, 0x7C, 0xFD, 0xF8, 0xFF,
  0xE0, 0xFF, 0x03, 0xFF, 0x8F, 0x9F, 0xBE, 0x1F, 0x78, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0x78, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF,
  0x3F, 0xDE, 0x1F, 0xBE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7C, 0x1F,
  0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x87, 0xC0,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xCF, 0xFC,
  0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0x3C, 0x01, 0xF0, 0x3F, 0xC3, 0xFE,
  0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xC0, 0x00, 0xFE, 0x07, 0xFE,
  0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF9,
  0xFF, 0xCF, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xE7, 0xE7, 0x80, 0xF7, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF1, 0xF7, 0xF8, 0xFD, 0xFC, 0xFB, 0xFE, 0x78,
  0xFF, 0x3C, 0x7F, 0x9E, 0x3F, 0xCF, 0x1F, 0xE7, 0x8F, 0xF3, 0xC7, 0xF9,
  0xE3, 0xFC, 0xFB, 0xFE, 0x3F, 0x7F, 0x1F, 0x3F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x06,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x07, 0x9F,
  0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xF1, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x7B,
  0xE0, 0x3E, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3D, 0xFF, 0xFB, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xC0,
  0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xE7,
  0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0xFF, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBE, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF9, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xF9, 0xF0,
  0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x37, 0xF6,
  0x77, 0xF7, 0x7F, 0xF7, 0x7F, 0xF7, 0x6F, 0xF3, 0xEF, 0xF3, 0xEF, 0xF3,
  0xEF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F,
  0xF7, 0x1F, 0xEE, 0x3F, 0xDE, 0x7F, 0x9C, 0xFF, 0x39, 0xFE, 0x7B, 0xFC,
  0xF7, 0xF8, 0xEF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF,
  0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xFF,
  0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF9, 0xF0,
  0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x3E, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7E, 0x3E, 0x7C, 0x1F, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7,
  0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0x78,
  0x3C, 0x3C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0xF0, 0xE3, 0xFC,
  0x78, 0xF7, 0x1E, 0x3D, 0xC7, 0x8F, 0x71, 0xF3, 0xDE, 0x7C, 0xF7, 0x9B,
  0x3D, 0xE6, 0xCF, 0x79, 0xB3, 0x9E, 0x6C, 0xE7, 0xBB, 0x39, 0xEE, 0xCE,
  0x7B, 0x33, 0x8E, 0xCC, 0xE3, 0xB3, 0xF8, 0xEC, 0xFE, 0x3B, 0x1F, 0x8E,
  0xC7, 0xE3, 0xB1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0x87, 0xC7, 0xC3, 0xE3, 0xC0,
  0xFB, 0xE0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC1, 0xF7, 0xC0, 0xFB,
  0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0xBE, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01,
  0xEE, 0x03, 0xDE, 0x0F, 0xBC, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE0,
  0xF7, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE7, 0xEF, 0x83,
  0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xDF, 0x3F, 0x3E, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0xFC,
  0x7F, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x3E, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xF7, 0xFF, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0x9F, 0xFF, 0x1F,
  0xFC, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xCF, 0xCF, 0xBF, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xF7, 0xC7, 0xCF, 0x80, 0x1F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xE3, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x83, 0xFF,
  0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0x7E, 0x07, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0x3E, 0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x8F, 0x9F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xC0, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0xFC,
  0x7F, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xE1, 0xF7, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0x01, 0x00, 0x07, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x07, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xFF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8,
  0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0xF7, 0x9E, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF,
  0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF,
  0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xFB, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7,
  0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3E, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xDF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xFB, 0xF1,
  0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFC, 0xFB, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0xFF, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xDF,
  0x1F, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0xF3, 0xF1, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xF7, 0xE3, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0x80, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x8F,
  0xFF, 0xFF, 0x3F, 0xFE, 0x1F, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xE0, 0xF8, 0x0F,
  0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0xDE, 0x01, 0xEF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xF0,
  0xE1, 0xDC, 0x78, 0xF7, 0x1E, 0x3D, 0xE7, 0x8F, 0x79, 0xF3, 0xDE, 0x6C,
  0xE7, 0x9B, 0x39, 0xE6, 0xCE, 0x3B, 0xB7, 0x8E, 0xCD, 0xE3, 0xB3, 0x78,
  0xFC, 0xFE, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x00, 0xFC, 0x1F, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xEF, 0x81, 0xF7,
  0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xF7, 0xC1, 0xF3, 0xE1, 0xF8, 0xF8, 0xF8, 0x3E,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xFC, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE3,
  0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1F, 0x7C, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE3, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x1E,
  0x00, 0x7F, 0x87, 0x7F, 0x87, 0xFF, 0xC7, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFE, 0x00, 0x7C,
};

const GFXglyph JetBrainsMono_ExtraBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 12, 10, 19, 3, -23 },
  { 31, 17, 23, 19, 1, -23 },
  { 80, 16, 31, 19, 1, -27 },
  { 142, 19, 23, 19, 0, -23 },
  { 197, 17, 23, 19, 1, -23 },
  { 246, 5, 10, 19, 7, -23 },
  { 253, 10, 30, 19, 5, -26 },
  { 291, 10, 30, 19, 4, -26 },
  { 329, 17, 16, 19, 1, -19 },
  { 363, 15, 15, 19, 2, -18 },
  { 392, 8, 10, 19, 4, -5 },
  { 402, 10, 4, 19, 4, -12 },
  { 407, 6, 6, 19, 6, -6 },
  { 412, 15, 29, 19, 2, -26 },
  { 467, 15, 23, 19, 2, -23 },
  { 511, 15, 23, 19, 2, -23 },
  { 555, 15, 23, 19, 2, -23 },
  { 599, 15, 23, 19, 2, -23 },
  { 643, 14, 23, 19, 2, -23 },
  { 684, 15, 23, 19, 2, -23 },
  { 728, 16, 23, 19, 1, -23 },
  { 774, 16, 23, 19, 1, -23 },
  { 820, 15, 23, 19, 2, -23 },
  { 864, 16, 23, 19, 1, -23 },
  { 910, 6, 17, 19, 6, -17 },
  { 923, 9, 22, 19, 4, -17 },
  { 948, 14, 17, 19, 2, -19 },
  { 978, 14, 12, 19, 2, -16 },
  { 999, 14, 17, 19, 2, -19 },
  { 1029, 13, 23, 19, 3, -23 },
  { 1067, 17, 29, 19, 1, -23 },
  { 1129, 17, 23, 19, 1, -23 },
  { 1178, 15, 23, 19, 2, -23 },
  { 1222, 15, 23, 19, 2, -23 },
  { 1266, 15, 23, 19, 2, -23 },
  { 1310, 14, 23, 19, 2, -23 },
  { 1351, 15, 23, 19, 2, -23 },
  { 1395, 15, 23, 19, 2, -23 },
  { 1439, 15, 23, 19, 2, -23 },
  { 1483, 14, 23, 19, 2, -23 },
  { 1524, 15, 23, 19, 1, -23 },
  { 1568, 16, 23, 19, 2, -23 },
  { 1614, 14, 23, 19, 3, -23 },
  { 1655, 16, 23, 19, 1, -23 },
  { 1701, 15, 23, 19, 2, -23 },
  { 1745, 15, 23, 19, 2, -23 },
  { 1789, 16, 23, 19, 2, -23 },
  { 1835, 15, 29, 19, 2, -23 },
  { 1890, 16, 23, 19, 2, -23 },
  { 1936, 16, 23, 19, 1, -23 },
  { 1982, 16, 23, 19, 1, -23 },
  { 2028, 15, 23, 19, 2, -23 },
  { 2072, 17, 23, 19, 1, -23 },
  { 2121, 18, 23, 19, 0, -23 },
  { 2173, 17, 23, 19, 1, -23 },
  { 2222, 18, 23, 19, 0, -23 },
  { 2274, 14, 23, 19, 2, -23 },
  { 2315, 10, 29, 19, 5, -26 },
  { 2352, 15, 29, 19, 2, -26 },
  { 2407, 9, 29, 19, 4, -26 },
  { 2440, 15, 12, 19, 2, -23 },
  { 2463, 15, 4, 19, 2, 1 },
  { 2471, 8, 4, 19, 5, -24 },
  { 2475, 15, 17, 19, 2, -17 },
  { 2507, 15, 23, 19, 2, -23 },
  { 2551, 15, 17, 19, 2, -17 },
  { 2583, 15, 23, 19, 2, -23 },
  { 2627, 15, 17, 19, 2, -17 },
  { 2659, 15, 23, 19, 2, -23 },
  { 2703, 15, 23, 19, 2, -17 },
  { 2747, 15, 23, 19, 2, -23 },
  { 2791, 15, 25, 19, 2, -25 },
  { 2838, 13, 31, 19, 2, -25 },
  { 2889, 16, 23, 19, 2, -23 },
  { 2935, 17, 23, 19, 1, -23 },
  { 2984, 16, 17, 19, 1, -17 },
  { 3018, 15, 17, 19, 2, -17 },
  { 3050, 15, 17, 19, 2, -17 },
  { 3082, 15, 23, 19, 2, -17 },
  { 3126, 15, 23, 19, 2, -17 },
  { 3170, 15, 17, 19, 3, -17 },
  { 3202, 15, 17, 19, 2, -17 },
  { 3234, 16, 22, 19, 1, -22 },
  { 3278, 15, 17, 19, 2, -17 },
  { 3310, 17, 17, 19, 1, -17 },
  { 3347, 18, 17, 19, 0, -17 },
  { 3386, 17, 17, 19, 1, -17 },
  { 3423, 17, 23, 19, 1, -17 },
  { 3472, 14, 17, 19, 2, -17 },
  { 3502, 14, 29, 19, 2, -26 },
  { 3553, 5, 29, 19, 7, -26 },
  { 3572, 14, 29, 19, 2, -26 },
  { 3623, 16, 8, 19, 1, -15 },
};

const GFXfont JetBrainsMono_ExtraBold31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_EXTRABOLD31PT7B_H_
