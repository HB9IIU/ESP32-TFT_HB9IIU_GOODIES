#ifndef _JETBRAINSMONO_EXTRABOLD28PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0x77,
  0xFF, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8E, 0x18, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x8F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC3,
  0x83, 0x8E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xF0, 0x1F, 0xF0,
  0xFF, 0xE7, 0xFF, 0xDE, 0xDF, 0x7B, 0x3D, 0xEC, 0x07, 0xB0, 0x1F, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x03, 0x7C, 0x0C, 0xFF, 0xB3,
  0xFE, 0xCF, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x3F, 0x81, 0xDF, 0xC1, 0xDC, 0x71,
  0xCE, 0x39, 0xC7, 0x1C, 0xE3, 0x8E, 0xE0, 0xFE, 0xE0, 0x7F, 0x60, 0x0E,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3B, 0xE0, 0x3B, 0xF8, 0x3B, 0x9C,
  0x19, 0xC7, 0x1C, 0xE3, 0x9C, 0x71, 0xDC, 0x39, 0xCE, 0x0F, 0xEE, 0x03,
  0xE0, 0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC3, 0xC7, 0x87, 0x0F,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xFC, 0xFF,
  0x7B, 0xDE, 0x7F, 0xBC, 0x7E, 0x78, 0xFC, 0xF0, 0xF1, 0xF3, 0xF1, 0xFF,
  0xF3, 0xFF, 0xE3, 0xF9, 0xE0, 0xFF, 0xFF, 0xFF, 0x77, 0x00, 0x40, 0x70,
  0x7C, 0x3F, 0x1F, 0xCF, 0xC7, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xF0, 0x1C, 0x80, 0x70, 0x3E, 0x1F, 0x8F,
  0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0xF8, 0xFD, 0xFC, 0xFC, 0x7C,
  0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x1C, 0x27, 0x39, 0xDF,
  0x6F, 0xFF, 0xFF, 0x9F, 0xFC, 0x07, 0x80, 0x1D, 0xC0, 0x7B, 0xC1, 0xE7,
  0xC3, 0xC7, 0x83, 0x0E, 0x02, 0x08, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0x8F, 0x3C, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFD,
  0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xBB, 0xFF,
  0xDF, 0xEE, 0xFF, 0x67, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xCF,
  0xDF, 0xFC, 0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F,
  0xF0, 0xF7, 0xC3, 0x9F, 0x08, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0x7F, 0xE0, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x83, 0xDE, 0x0F, 0x7C, 0x7D,
  0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xFC, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0x9F, 0xFC, 0x3F, 0x80, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF7, 0xC1, 0xEF, 0x83, 0xDE,
  0x07, 0xFC, 0x0F, 0xBC, 0x1E, 0x7C, 0x7C, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x7D, 0xE0, 0xF7, 0x83,
  0xDE, 0x1F, 0x3C, 0xF8, 0xFF, 0xC0, 0xFE, 0x0F, 0xFC, 0x7E, 0xF9, 0xE0,
  0xF7, 0x83, 0xFE, 0x0F, 0x78, 0x3D, 0xF1, 0xF7, 0xFF, 0xCF, 0xFE, 0x0F,
  0xE0, 0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xDF, 0x07,
  0xBC, 0x0F, 0x78, 0x1F, 0xF8, 0x3C, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF, 0xE1,
  0xF7, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x77, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xEF, 0xFF, 0xFF, 0x1C, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0xCF, 0x3E, 0x78, 0xF1, 0xE7, 0x80, 0x00, 0x08, 0x03,
  0xC0, 0x7E, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x1E, 0x00, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x07, 0x00, 0x3F, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0xF8, 0x3F, 0xC7, 0xF8, 0xFF,
  0x0F, 0xE0, 0x7C, 0x03, 0x00, 0x10, 0x00, 0xFF, 0x9F, 0xFB, 0xFF, 0x83,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x3F, 0xE7, 0xF8, 0xFE, 0x1E, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x3F, 0xE0, 0xFF, 0xF3, 0xE3, 0xEF, 0x01, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0xE7, 0xE3, 0xFF, 0xCF, 0xFF, 0x9E, 0x3F, 0x3C, 0x7E, 0x78, 0xFC,
  0xF1, 0xF9, 0xE3, 0xF3, 0xC7, 0xE7, 0x8F, 0xC7, 0xFF, 0x8F, 0xBF, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEE, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1C, 0xF0, 0x78, 0xE0, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFF, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF,
  0x80, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC1,
  0xEF, 0x07, 0xBC, 0x3C, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0x3C, 0x3E, 0xF0,
  0x7B, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF1, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF0, 0x07, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x0F, 0xF0, 0x7F, 0xEF, 0xDF, 0xFC, 0xFF, 0xE1, 0xFC, 0x00,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xE7, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x00, 0x07, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0x8F, 0xF8,
  0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xEF, 0xDF, 0xFC, 0xFF, 0xE1,
  0xFC, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0x07, 0xFC, 0x1E,
  0xFC, 0xF9, 0xFF, 0xE7, 0xFF, 0x07, 0xF0, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F,
  0xBC, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3C, 0xF8, 0xF3, 0xE3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0,
  0xFB, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0x63, 0xFE, 0xCF, 0xFF, 0xDF, 0xFF,
  0xB7, 0xFB, 0x6F, 0xF7, 0xDF, 0xEF, 0xBF, 0xDE, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xF0, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x3F,
  0xB9, 0xFD, 0xCF, 0xEF, 0x7F, 0x3B, 0xF9, 0xDF, 0xCF, 0x7E, 0x3B, 0xF1,
  0xDF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xF0, 0x0F,
  0x01, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0xCF, 0xDF, 0xFC, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFE, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF,
  0x87, 0xFF, 0x3F, 0xFC, 0xF8, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0x7B, 0xF7, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xBC, 0x3E, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF1, 0xFB, 0xFF,
  0xCF, 0xFF, 0x3F, 0xF0, 0xF3, 0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0,
  0xF3, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9F,
  0xFF, 0x78, 0x7D, 0xE0, 0xF7, 0x80, 0x1E, 0x00, 0x7E, 0x01, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x3D,
  0xF1, 0xF7, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFD,
  0xFB, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x07, 0x70,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0xF1, 0xC7, 0xF8, 0xE3,
  0x9C, 0xF1, 0xCE, 0x78, 0xE7, 0x36, 0x73, 0x9B, 0x39, 0xCD, 0x9C, 0xE6,
  0xDE, 0x73, 0x6F, 0x39, 0xB7, 0x9E, 0xDB, 0x8F, 0xED, 0xC7, 0xE6, 0xE1,
  0xF3, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC0, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xE1, 0xE7, 0xC3, 0xEF,
  0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7F, 0x01, 0xFE, 0x03, 0xDE, 0x0F, 0xBC, 0x1E, 0x7C, 0x7C, 0x78, 0xF0,
  0xFB, 0xE0, 0xF7, 0x81, 0xF0, 0xF8, 0x0F, 0x7C, 0x1F, 0x3C, 0x1E, 0x3C,
  0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFC, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3B, 0x83, 0xDE, 0x1E, 0xF1, 0xE3, 0x8F,
  0x1E, 0x70, 0xF7, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x03, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x78,
  0x7C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x7F, 0xFD, 0xF0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFB, 0xCF, 0xCF, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x18, 0x7B, 0xF3, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFD, 0xEF, 0xC0, 0x07, 0x01, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF,
  0x8F, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0xFF, 0xCF, 0xBF, 0xF9, 0xFF, 0xC3, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0xC7, 0x9F, 0xBD, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF,
  0xDF, 0xDE, 0x7C, 0xF0, 0x07, 0x01, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x8F, 0xBF, 0xF9, 0xFF, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3,
  0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0C, 0x01, 0xFB, 0xDF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xBC, 0xF9, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xCF, 0xFC,
  0x7F, 0xC3, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x18,
  0x7B, 0xF3, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xFF, 0x0F, 0xBC, 0x3C, 0xF1,
  0xF3, 0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0x3E, 0x3C,
  0x7C, 0xF0, 0xF3, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x06, 0x31,
  0xDE, 0xFB, 0xBF, 0xF7, 0x9C, 0xFF, 0x39, 0xFE, 0x73, 0xFC, 0xE7, 0xF9,
  0xCF, 0xF3, 0x9F, 0xE7, 0x3F, 0xCE, 0x7F, 0x9C, 0xFF, 0x39, 0xFE, 0x73,
  0xFC, 0xE7, 0xF9, 0xCF, 0x01, 0x87, 0xBF, 0x3F, 0xFD, 0xFF, 0xFF, 0x8F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x07, 0x01, 0xFF, 0x1F, 0xFD, 0xFF,
  0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0xDF, 0xBF, 0xF9, 0xFF, 0x83, 0xF8, 0x01, 0x87, 0xBF, 0x3F,
  0xFD, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xDE, 0xFC, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0C, 0x01, 0xFB, 0xDF, 0xDF,
  0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFF, 0x9F, 0xFF, 0xFD, 0xFD, 0xE7, 0xCF, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC3, 0xDF, 0xCF, 0x7F, 0xBF,
  0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x78, 0x3D, 0xE0, 0x07, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x3D, 0xFF, 0xF3, 0xFF,
  0x87, 0xFC, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFB, 0xF7, 0xFF, 0x3F, 0xF0,
  0x7F, 0x00, 0xF0, 0x3F, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x1E, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xF1, 0xC7, 0xB8, 0xE3, 0x9C,
  0x71, 0xCE, 0x68, 0xE7, 0x36, 0x73, 0x9B, 0x79, 0xED, 0xBC, 0xF6, 0xDC,
  0x3B, 0x6E, 0x1F, 0xB7, 0x0F, 0x9B, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xE0, 0xF8, 0xF0, 0xF8, 0x7E, 0xF8, 0xF0, 0xFB, 0xE0, 0xF7, 0x81, 0xFE,
  0x01, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1,
  0xF7, 0xC7, 0xC7, 0x8F, 0x0F, 0xBE, 0x0F, 0x80, 0xF8, 0x3F, 0xF0, 0x79,
  0xE0, 0xF3, 0xE3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0xBE, 0x0F, 0x78, 0x1E,
  0xF0, 0x1D, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x01, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0xE3,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x1E, 0xFE, 0x3F, 0xFE, 0x7F,
  0x9F, 0xFE, 0x3F, 0xDC, 0x3F, 0x80, 0x1C, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 11, 8, 17, 3, -20 },
  { 25, 15, 20, 17, 1, -20 },
  { 63, 14, 28, 17, 1, -24 },
  { 112, 17, 21, 17, 0, -21 },
  { 157, 15, 21, 17, 1, -21 },
  { 197, 4, 8, 17, 6, -20 },
  { 201, 10, 27, 17, 4, -24 },
  { 235, 9, 27, 17, 3, -24 },
  { 266, 15, 15, 17, 1, -17 },
  { 295, 13, 13, 17, 2, -16 },
  { 317, 7, 8, 17, 4, -4 },
  { 324, 9, 4, 17, 4, -11 },
  { 329, 5, 5, 17, 6, -5 },
  { 333, 14, 26, 17, 1, -23 },
  { 379, 13, 21, 17, 2, -21 },
  { 414, 14, 20, 17, 2, -20 },
  { 449, 14, 21, 17, 1, -21 },
  { 486, 14, 20, 17, 1, -20 },
  { 521, 13, 20, 17, 2, -20 },
  { 554, 13, 20, 17, 2, -20 },
  { 587, 15, 20, 17, 1, -20 },
  { 625, 14, 20, 17, 1, -20 },
  { 660, 14, 21, 17, 1, -21 },
  { 697, 15, 21, 17, 1, -21 },
  { 737, 5, 16, 17, 6, -16 },
  { 747, 7, 20, 17, 4, -16 },
  { 765, 13, 16, 17, 2, -17 },
  { 791, 13, 11, 17, 2, -15 },
  { 809, 13, 16, 17, 2, -17 },
  { 835, 11, 20, 17, 3, -20 },
  { 863, 15, 26, 17, 1, -21 },
  { 912, 15, 20, 17, 1, -20 },
  { 950, 14, 20, 17, 2, -20 },
  { 985, 13, 21, 17, 2, -21 },
  { 1020, 13, 20, 17, 2, -20 },
  { 1053, 13, 20, 17, 2, -20 },
  { 1086, 13, 20, 17, 2, -20 },
  { 1119, 13, 21, 17, 2, -21 },
  { 1154, 13, 20, 17, 2, -20 },
  { 1187, 13, 20, 17, 2, -20 },
  { 1220, 14, 20, 17, 1, -20 },
  { 1255, 14, 20, 17, 2, -20 },
  { 1290, 12, 20, 17, 3, -20 },
  { 1320, 15, 20, 17, 1, -20 },
  { 1358, 13, 20, 17, 2, -20 },
  { 1391, 13, 21, 17, 2, -21 },
  { 1426, 14, 20, 17, 2, -20 },
  { 1461, 14, 26, 17, 2, -21 },
  { 1507, 14, 20, 17, 2, -20 },
  { 1542, 14, 21, 17, 1, -21 },
  { 1579, 15, 20, 17, 1, -20 },
  { 1617, 13, 20, 17, 2, -20 },
  { 1650, 15, 20, 17, 1, -20 },
  { 1688, 17, 20, 17, 0, -20 },
  { 1731, 15, 20, 17, 1, -20 },
  { 1769, 16, 20, 17, 0, -20 },
  { 1809, 13, 20, 17, 2, -20 },
  { 1842, 8, 26, 17, 5, -23 },
  { 1868, 14, 26, 17, 1, -23 },
  { 1914, 9, 26, 17, 3, -23 },
  { 1944, 13, 10, 17, 2, -20 },
  { 1961, 13, 4, 17, 2, 1 },
  { 1968, 8, 4, 17, 4, -22 },
  { 1972, 14, 16, 17, 1, -16 },
  { 2000, 13, 20, 17, 2, -20 },
  { 2033, 13, 16, 17, 2, -16 },
  { 2059, 13, 20, 17, 2, -20 },
  { 2092, 13, 16, 17, 2, -16 },
  { 2118, 14, 20, 17, 1, -20 },
  { 2153, 13, 21, 17, 2, -16 },
  { 2188, 13, 20, 17, 2, -20 },
  { 2221, 14, 22, 17, 2, -22 },
  { 2260, 12, 27, 17, 2, -22 },
  { 2301, 14, 20, 17, 2, -20 },
  { 2336, 15, 20, 17, 1, -20 },
  { 2374, 15, 16, 17, 1, -16 },
  { 2404, 13, 16, 17, 2, -16 },
  { 2430, 13, 16, 17, 2, -16 },
  { 2456, 13, 21, 17, 2, -16 },
  { 2491, 13, 21, 17, 2, -16 },
  { 2526, 14, 16, 17, 2, -16 },
  { 2554, 14, 16, 17, 1, -16 },
  { 2582, 14, 20, 17, 1, -20 },
  { 2617, 13, 15, 17, 2, -15 },
  { 2642, 15, 15, 17, 1, -15 },
  { 2671, 17, 15, 17, 0, -15 },
  { 2703, 15, 15, 17, 1, -15 },
  { 2732, 15, 20, 17, 1, -15 },
  { 2770, 13, 15, 17, 2, -15 },
  { 2795, 13, 26, 17, 2, -23 },
  { 2838, 5, 26, 17, 6, -23 },
  { 2855, 13, 26, 17, 2, -23 },
  { 2898, 15, 7, 17, 1, -13 },
};

const GFXfont JetBrainsMono_ExtraBold28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_EXTRABOLD28PT7B_H_
