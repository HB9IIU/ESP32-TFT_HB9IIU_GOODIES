#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &JetBrainsMono_ExtraBold6pt7b, 6, "JetBrainsMono_ExtraBold6pt7b" },
  { &JetBrainsMono_ExtraBold7pt7b, 7, "JetBrainsMono_ExtraBold7pt7b" },
  { &JetBrainsMono_ExtraBold8pt7b, 8, "JetBrainsMono_ExtraBold8pt7b" },
  { &JetBrainsMono_ExtraBold9pt7b, 9, "JetBrainsMono_ExtraBold9pt7b" },
  { &JetBrainsMono_ExtraBold10pt7b, 10, "JetBrainsMono_ExtraBold10pt7b" },
  { &JetBrainsMono_ExtraBold11pt7b, 11, "JetBrainsMono_ExtraBold11pt7b" },
  { &JetBrainsMono_ExtraBold12pt7b, 12, "JetBrainsMono_ExtraBold12pt7b" },
  { &JetBrainsMono_ExtraBold13pt7b, 13, "JetBrainsMono_ExtraBold13pt7b" },
  { &JetBrainsMono_ExtraBold14pt7b, 14, "JetBrainsMono_ExtraBold14pt7b" },
  { &JetBrainsMono_ExtraBold15pt7b, 15, "JetBrainsMono_ExtraBold15pt7b" },
  { &JetBrainsMono_ExtraBold16pt7b, 16, "JetBrainsMono_ExtraBold16pt7b" },
  { &JetBrainsMono_ExtraBold17pt7b, 17, "JetBrainsMono_ExtraBold17pt7b" },
  { &JetBrainsMono_ExtraBold18pt7b, 18, "JetBrainsMono_ExtraBold18pt7b" },
  { &JetBrainsMono_ExtraBold19pt7b, 19, "JetBrainsMono_ExtraBold19pt7b" },
  { &JetBrainsMono_ExtraBold20pt7b, 20, "JetBrainsMono_ExtraBold20pt7b" },
  { &JetBrainsMono_ExtraBold21pt7b, 21, "JetBrainsMono_ExtraBold21pt7b" },
  { &JetBrainsMono_ExtraBold22pt7b, 22, "JetBrainsMono_ExtraBold22pt7b" },
  { &JetBrainsMono_ExtraBold23pt7b, 23, "JetBrainsMono_ExtraBold23pt7b" },
  { &JetBrainsMono_ExtraBold24pt7b, 24, "JetBrainsMono_ExtraBold24pt7b" },
  { &JetBrainsMono_ExtraBold25pt7b, 25, "JetBrainsMono_ExtraBold25pt7b" },
  { &JetBrainsMono_ExtraBold26pt7b, 26, "JetBrainsMono_ExtraBold26pt7b" },
  { &JetBrainsMono_ExtraBold27pt7b, 27, "JetBrainsMono_ExtraBold27pt7b" },
  { &JetBrainsMono_ExtraBold28pt7b, 28, "JetBrainsMono_ExtraBold28pt7b" },
  { &JetBrainsMono_ExtraBold29pt7b, 29, "JetBrainsMono_ExtraBold29pt7b" },
  { &JetBrainsMono_ExtraBold30pt7b, 30, "JetBrainsMono_ExtraBold30pt7b" },
  { &JetBrainsMono_ExtraBold31pt7b, 31, "JetBrainsMono_ExtraBold31pt7b" },
  { &JetBrainsMono_ExtraBold32pt7b, 32, "JetBrainsMono_ExtraBold32pt7b" },
  { &JetBrainsMono_ExtraBold33pt7b, 33, "JetBrainsMono_ExtraBold33pt7b" },
  { &JetBrainsMono_ExtraBold34pt7b, 34, "JetBrainsMono_ExtraBold34pt7b" },
  { &JetBrainsMono_ExtraBold35pt7b, 35, "JetBrainsMono_ExtraBold35pt7b" },
  { &JetBrainsMono_ExtraBold36pt7b, 36, "JetBrainsMono_ExtraBold36pt7b" },
  { &JetBrainsMono_ExtraBold37pt7b, 37, "JetBrainsMono_ExtraBold37pt7b" },
  { &JetBrainsMono_ExtraBold38pt7b, 38, "JetBrainsMono_ExtraBold38pt7b" },
  { &JetBrainsMono_ExtraBold39pt7b, 39, "JetBrainsMono_ExtraBold39pt7b" },
  { &JetBrainsMono_ExtraBold40pt7b, 40, "JetBrainsMono_ExtraBold40pt7b" },
  { &JetBrainsMono_ExtraBold41pt7b, 41, "JetBrainsMono_ExtraBold41pt7b" },
  { &JetBrainsMono_ExtraBold42pt7b, 42, "JetBrainsMono_ExtraBold42pt7b" },
  { &JetBrainsMono_ExtraBold43pt7b, 43, "JetBrainsMono_ExtraBold43pt7b" },
  { &JetBrainsMono_ExtraBold44pt7b, 44, "JetBrainsMono_ExtraBold44pt7b" },
  { &JetBrainsMono_ExtraBold45pt7b, 45, "JetBrainsMono_ExtraBold45pt7b" },
  { &JetBrainsMono_ExtraBold46pt7b, 46, "JetBrainsMono_ExtraBold46pt7b" },
  { &JetBrainsMono_ExtraBold47pt7b, 47, "JetBrainsMono_ExtraBold47pt7b" },
  { &JetBrainsMono_ExtraBold48pt7b, 48, "JetBrainsMono_ExtraBold48pt7b" },
  { &JetBrainsMono_ExtraBold49pt7b, 49, "JetBrainsMono_ExtraBold49pt7b" },
  { &JetBrainsMono_ExtraBold50pt7b, 50, "JetBrainsMono_ExtraBold50pt7b" },
  { &JetBrainsMono_ExtraBold51pt7b, 51, "JetBrainsMono_ExtraBold51pt7b" },
  { &JetBrainsMono_ExtraBold52pt7b, 52, "JetBrainsMono_ExtraBold52pt7b" },
  { &JetBrainsMono_ExtraBold53pt7b, 53, "JetBrainsMono_ExtraBold53pt7b" },
  { &JetBrainsMono_ExtraBold54pt7b, 54, "JetBrainsMono_ExtraBold54pt7b" },
  { &JetBrainsMono_ExtraBold55pt7b, 55, "JetBrainsMono_ExtraBold55pt7b" },
  { &JetBrainsMono_ExtraBold56pt7b, 56, "JetBrainsMono_ExtraBold56pt7b" },
  { &JetBrainsMono_ExtraBold57pt7b, 57, "JetBrainsMono_ExtraBold57pt7b" },
  { &JetBrainsMono_ExtraBold58pt7b, 58, "JetBrainsMono_ExtraBold58pt7b" },
  { &JetBrainsMono_ExtraBold59pt7b, 59, "JetBrainsMono_ExtraBold59pt7b" },
  { &JetBrainsMono_ExtraBold60pt7b, 60, "JetBrainsMono_ExtraBold60pt7b" },
  { &JetBrainsMono_ExtraBold61pt7b, 61, "JetBrainsMono_ExtraBold61pt7b" },
  { &JetBrainsMono_ExtraBold62pt7b, 62, "JetBrainsMono_ExtraBold62pt7b" },
  { &JetBrainsMono_ExtraBold63pt7b, 63, "JetBrainsMono_ExtraBold63pt7b" },
  { &JetBrainsMono_ExtraBold64pt7b, 64, "JetBrainsMono_ExtraBold64pt7b" },
  { &JetBrainsMono_ExtraBold65pt7b, 65, "JetBrainsMono_ExtraBold65pt7b" },
  { &JetBrainsMono_ExtraBold66pt7b, 66, "JetBrainsMono_ExtraBold66pt7b" },
  { &JetBrainsMono_ExtraBold67pt7b, 67, "JetBrainsMono_ExtraBold67pt7b" },
  { &JetBrainsMono_ExtraBold68pt7b, 68, "JetBrainsMono_ExtraBold68pt7b" },
  { &JetBrainsMono_ExtraBold69pt7b, 69, "JetBrainsMono_ExtraBold69pt7b" },
  { &JetBrainsMono_ExtraBold70pt7b, 70, "JetBrainsMono_ExtraBold70pt7b" },
  { &JetBrainsMono_ExtraBold71pt7b, 71, "JetBrainsMono_ExtraBold71pt7b" },
  { &JetBrainsMono_ExtraBold72pt7b, 72, "JetBrainsMono_ExtraBold72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
