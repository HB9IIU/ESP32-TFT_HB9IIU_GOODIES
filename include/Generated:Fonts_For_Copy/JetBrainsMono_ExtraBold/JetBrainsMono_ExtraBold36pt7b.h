#ifndef _JETBRAINSMONO_EXTRABOLD36PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xE0, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x1E, 0xF8,
  0x7B, 0xE1, 0xEF, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83,
  0xC0, 0x78, 0x38, 0x07, 0x87, 0x80, 0x78, 0x78, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x3C, 0x1E, 0x03, 0xC1, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xF7, 0xEF, 0xDC, 0xFB, 0xE7,
  0x3E, 0xFD, 0xC0, 0x3F, 0x70, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x77, 0xF0,
  0x1C, 0xFC, 0x07, 0x3F, 0xF9, 0xCF, 0xFF, 0x73, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x1E, 0x7F, 0xC0,
  0x78, 0xFF, 0xC1, 0xE3, 0xC7, 0x83, 0x87, 0x87, 0x0F, 0x0F, 0x0E, 0x3C,
  0x1E, 0x1C, 0x70, 0x3C, 0x79, 0xE0, 0x3D, 0xF7, 0x80, 0x7F, 0xDE, 0x00,
  0x7F, 0x38, 0x00, 0x30, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x7B, 0xFC, 0x01, 0xEF, 0xFC, 0x03, 0x9E, 0x78, 0x0F,
  0x78, 0x70, 0x3C, 0xF0, 0xE0, 0xF1, 0xE1, 0xC1, 0xC3, 0xC3, 0x87, 0x83,
  0x8F, 0x1E, 0x07, 0xFE, 0x38, 0x07, 0xF9, 0xF0, 0x07, 0xE0, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0xDF, 0x3E, 0xF9, 0xFF, 0xCF, 0x8F, 0xFC, 0xF8, 0x7F, 0x8F, 0x87, 0xF8,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xBE, 0x0F, 0xF3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xDE, 0x00, 0x60, 0x3C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0x8F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x01, 0xE0, 0x0C,
  0xC0, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0x0F, 0xC0,
  0xF8, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x40, 0xF0, 0x47, 0x0F, 0x1C, 0x7C, 0xE3, 0xEF, 0xE6, 0xFE, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xBC, 0x00,
  0xF9, 0xE0, 0x0F, 0x9F, 0x01, 0xF1, 0xF8, 0x3F, 0x0F, 0x80, 0xE0, 0xF0,
  0x04, 0x04, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x9F, 0xCF, 0xC7,
  0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xFB, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x19, 0xFF, 0x9E, 0xFF, 0xDF, 0x7F, 0xEF,
  0xBF, 0xF3, 0xDF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7D, 0xFC, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0xDF, 0x83, 0xCF, 0xC1, 0xC7, 0xE0, 0x83, 0xF0, 0x41, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x8F,
  0xEF, 0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF1, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE3, 0xF7, 0xE1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xF0, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xEF,
  0xC1, 0xF7, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xEF, 0xE1, 0xFB, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xEF,
  0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xE1, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F,
  0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xE3, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x01,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x07,
  0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x3F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0x7E, 0x0F,
  0xBF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x3F, 0xFF, 0xFF, 0xFB, 0xE0, 0x1F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F,
  0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0,
  0x78, 0x3E, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x03,
  0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0x0F, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x03, 0x8F, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF1, 0xF3,
  0xFF, 0x1F, 0x1F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E,
  0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE1, 0xFF, 0x1F, 0x1F, 0xF0,
  0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0x7C, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xBE, 0x00, 0xFB, 0xE0, 0x0F,
  0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x07,
  0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xF3, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xF3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xBF, 0x8F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFE, 0x00, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x9F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xE3, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8E, 0xFF, 0xF3,
  0xBF, 0xDC, 0xEF, 0xF7, 0x7B, 0xFD, 0xDC, 0xFF, 0x7F, 0x7F, 0xCF, 0xDF,
  0xF3, 0xF7, 0xFC, 0xF9, 0xFF, 0x3E, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xDE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFD, 0xE3, 0xFE, 0xF1, 0xFF, 0x78, 0xFF, 0x9E, 0x7F,
  0xCF, 0x3F, 0xE7, 0x9F, 0xF1, 0xEF, 0xF8, 0xF7, 0xFC, 0x7B, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xC0, 0x01, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xFB, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFD, 0xFC, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF,
  0x80, 0xFB, 0xF0, 0x3F, 0x7E, 0x1F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F,
  0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF,
  0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0,
  0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xE7, 0xF3, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x0F,
  0xC7, 0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x3F, 0x07, 0xCF, 0xC1, 0xFB, 0xF0,
  0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE3, 0xF9, 0xFF, 0xFE,
  0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFB, 0xF9, 0xFD, 0xFF, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xF8, 0x78,
  0x7B, 0xC3, 0xC3, 0xDE, 0x3E, 0x1E, 0xF1, 0xF0, 0xF7, 0x8F, 0x8F, 0xBC,
  0x7E, 0x7D, 0xE3, 0xF3, 0xEF, 0x1F, 0x9E, 0x78, 0xDC, 0xF3, 0xE6, 0xE7,
  0x9F, 0x37, 0x3C, 0xFB, 0x99, 0xE3, 0xDC, 0xCF, 0x1E, 0xE6, 0x78, 0xF7,
  0x33, 0xC7, 0xB9, 0xDE, 0x3D, 0xCE, 0xF1, 0xEC, 0x77, 0x0F, 0x63, 0xF8,
  0x7B, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x00, 0xFE, 0x07, 0xE7, 0xE0, 0x7C,
  0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF9, 0xF0, 0x0F, 0xBF,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x1F, 0x83,
  0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0x7C, 0x3E, 0x0F,
  0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x9F, 0x00, 0xF9,
  0xF0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7B,
  0xE0, 0x7C, 0xF0, 0x3E, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x07, 0xCF,
  0x83, 0xE7, 0xC0, 0xFF, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0,
  0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFB, 0xE7, 0xF9, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF3, 0xF1, 0xFB, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFE,
  0x7E, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7F, 0xFF, 0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xC0,
  0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x3F, 0x3E, 0x7F, 0xDF, 0x3F, 0xEF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF9, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xEF, 0x8F, 0xE7, 0xC0, 0x07, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x0F, 0xCF, 0x9F, 0xF7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xEF, 0x8F, 0xF7, 0xC3, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF3,
  0xF1, 0xFB, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0, 0x00, 0x80, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xFF, 0xE0, 0x7E, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x81, 0xFC,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0xF7, 0x8F, 0x3F, 0xF7, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF1,
  0xE7, 0xFC, 0x79, 0xFF, 0x1E, 0x7F, 0xC7, 0x9F, 0xF1, 0xE7, 0xFC, 0x79,
  0xFF, 0x1E, 0x7F, 0xC7, 0x9F, 0xF1, 0xE7, 0xFC, 0x79, 0xFF, 0x1E, 0x7F,
  0xC7, 0x9F, 0xF1, 0xE7, 0xFC, 0x79, 0xFF, 0x1E, 0x7F, 0xC7, 0x9F, 0xFC,
  0xFC, 0x7E, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7E, 0xFE, 0x7F, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0xFC, 0x7E, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0x7F, 0x9F, 0x9F, 0x8F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0x9F,
  0xF7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFE, 0x7F, 0x7F, 0xFF, 0xBF, 0xF7, 0xCF,
  0xFB, 0xE3, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0xFC, 0x3E, 0xFF, 0x8F, 0xBF, 0xF3,
  0xFF, 0xFE, 0xFF, 0x7F, 0xBF, 0x07, 0xEF, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0xFC,
  0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7E, 0xFE, 0x7F, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0xF8, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x1E,
  0x1E, 0xF1, 0xF0, 0xF7, 0x8F, 0x8F, 0xBC, 0x7C, 0x79, 0xF3, 0xF3, 0xCF,
  0x9B, 0x9E, 0x3C, 0xDC, 0xF1, 0xE6, 0x67, 0x8F, 0x73, 0x3C, 0x7B, 0x9B,
  0xE3, 0xDC, 0xDE, 0x1E, 0xE7, 0xF0, 0xF6, 0x3F, 0x83, 0xF1, 0xFC, 0x1F,
  0x8F, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x80, 0xFE, 0x07,
  0xE7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F, 0x9F, 0x00, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xBF, 0x01,
  0xF9, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x3E, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x9F, 0x80, 0xF9,
  0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x3D, 0xFF, 0x87, 0xBF, 0xF8,
  0xFF, 0x9F, 0xBF, 0xF1, 0xFF, 0xFE, 0x1F, 0xF7, 0xC1, 0xFE, 0x00, 0x1F,
  0x00,
};

const GFXglyph JetBrainsMono_ExtraBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 14, 11, 22, 4, -26 },
  { 41, 20, 26, 22, 1, -26 },
  { 106, 18, 36, 22, 2, -31 },
  { 187, 23, 26, 22, -1, -26 },
  { 262, 20, 27, 22, 1, -27 },
  { 330, 5, 11, 22, 8, -26 },
  { 337, 11, 34, 22, 6, -30 },
  { 384, 12, 34, 22, 4, -30 },
  { 435, 20, 19, 22, 1, -22 },
  { 483, 18, 18, 22, 2, -21 },
  { 524, 9, 11, 22, 5, -5 },
  { 537, 12, 5, 22, 5, -14 },
  { 545, 7, 7, 22, 7, -7 },
  { 552, 18, 34, 22, 2, -30 },
  { 629, 17, 27, 22, 2, -27 },
  { 687, 17, 26, 22, 3, -26 },
  { 743, 18, 27, 22, 2, -27 },
  { 804, 17, 26, 22, 2, -26 },
  { 860, 17, 26, 22, 2, -26 },
  { 916, 17, 26, 22, 2, -26 },
  { 972, 18, 26, 22, 2, -26 },
  { 1031, 18, 26, 22, 2, -26 },
  { 1090, 18, 27, 22, 2, -27 },
  { 1151, 18, 27, 22, 2, -27 },
  { 1212, 7, 20, 22, 7, -20 },
  { 1230, 10, 26, 22, 5, -20 },
  { 1263, 16, 20, 22, 3, -22 },
  { 1303, 16, 14, 22, 3, -19 },
  { 1331, 16, 20, 22, 3, -22 },
  { 1371, 15, 26, 22, 4, -26 },
  { 1420, 20, 33, 22, 1, -27 },
  { 1503, 20, 26, 22, 1, -26 },
  { 1568, 18, 26, 22, 2, -26 },
  { 1627, 18, 27, 22, 2, -27 },
  { 1688, 18, 26, 22, 2, -26 },
  { 1747, 16, 26, 22, 3, -26 },
  { 1799, 16, 26, 22, 3, -26 },
  { 1851, 18, 27, 22, 2, -27 },
  { 1912, 17, 26, 22, 2, -26 },
  { 1968, 16, 26, 22, 3, -26 },
  { 2020, 18, 26, 22, 1, -26 },
  { 2079, 19, 26, 22, 2, -26 },
  { 2141, 16, 26, 22, 3, -26 },
  { 2193, 18, 26, 22, 2, -26 },
  { 2252, 17, 26, 22, 2, -26 },
  { 2308, 17, 27, 22, 2, -27 },
  { 2366, 19, 26, 22, 2, -26 },
  { 2428, 18, 33, 22, 2, -27 },
  { 2503, 18, 26, 22, 2, -26 },
  { 2562, 18, 27, 22, 2, -27 },
  { 2623, 19, 26, 22, 1, -26 },
  { 2685, 17, 26, 22, 2, -26 },
  { 2741, 20, 26, 22, 1, -26 },
  { 2806, 21, 26, 22, 0, -26 },
  { 2875, 20, 26, 22, 1, -26 },
  { 2940, 20, 26, 22, 1, -26 },
  { 3005, 16, 26, 22, 3, -26 },
  { 3057, 11, 34, 22, 6, -30 },
  { 3104, 18, 34, 22, 2, -30 },
  { 3181, 11, 34, 22, 4, -30 },
  { 3228, 17, 14, 22, 2, -26 },
  { 3258, 17, 5, 22, 2, 1 },
  { 3269, 10, 5, 22, 5, -28 },
  { 3276, 17, 20, 22, 2, -20 },
  { 3319, 17, 26, 22, 2, -26 },
  { 3375, 18, 20, 22, 2, -20 },
  { 3420, 17, 26, 22, 2, -26 },
  { 3476, 17, 20, 22, 2, -20 },
  { 3519, 18, 26, 22, 2, -26 },
  { 3578, 17, 26, 22, 2, -20 },
  { 3634, 17, 26, 22, 2, -26 },
  { 3690, 17, 29, 22, 3, -29 },
  { 3752, 14, 35, 22, 3, -29 },
  { 3814, 19, 26, 22, 2, -26 },
  { 3876, 19, 26, 22, 1, -26 },
  { 3938, 18, 20, 22, 2, -20 },
  { 3983, 17, 20, 22, 2, -20 },
  { 4026, 17, 20, 22, 2, -20 },
  { 4069, 17, 26, 22, 2, -20 },
  { 4125, 17, 26, 22, 2, -20 },
  { 4181, 18, 20, 22, 3, -20 },
  { 4226, 18, 20, 22, 2, -20 },
  { 4271, 18, 25, 22, 1, -25 },
  { 4328, 17, 20, 22, 2, -20 },
  { 4371, 20, 20, 22, 1, -20 },
  { 4421, 21, 20, 22, 0, -20 },
  { 4474, 20, 20, 22, 1, -20 },
  { 4524, 20, 26, 22, 1, -20 },
  { 4589, 16, 20, 22, 3, -20 },
  { 4629, 16, 34, 22, 3, -30 },
  { 4697, 6, 34, 22, 8, -30 },
  { 4723, 16, 34, 22, 3, -30 },
  { 4791, 19, 9, 22, 1, -17 },
};

const GFXfont JetBrainsMono_ExtraBold36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_EXTRABOLD36PT7B_H_
