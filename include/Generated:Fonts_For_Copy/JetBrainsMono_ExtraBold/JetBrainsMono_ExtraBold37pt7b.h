#ifndef _JETBRAINSMONO_EXTRABOLD37PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0xC0, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE3, 0xC1,
  0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCC, 0xFF, 0xF3, 0x3F, 0xFC, 0xC0, 0x3F, 0x30, 0x0F, 0xEC, 0x01,
  0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0C, 0xFC, 0x03, 0x1F, 0x00, 0xC7, 0xFE, 0x31,
  0xFF, 0xCC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x1F, 0xE0, 0x1E, 0x3F, 0xF0, 0x3C, 0x78,
  0xF0, 0x78, 0x78, 0x70, 0x70, 0x78, 0x70, 0xF0, 0x78, 0x71, 0xE0, 0x78,
  0x71, 0xC0, 0x38, 0xF3, 0xC0, 0x3F, 0xF7, 0x80, 0x1F, 0xEF, 0x00, 0x0F,
  0xCE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7B, 0xF0, 0x00, 0xF7, 0xFC, 0x01, 0xEF, 0xFC, 0x01, 0xCF, 0x1E, 0x03,
  0xCE, 0x1E, 0x07, 0x8E, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x0E, 0x1E, 0x1E,
  0x0F, 0x1E, 0x3C, 0x0F, 0xFC, 0x38, 0x07, 0xFC, 0xF8, 0x03, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x1F, 0x81,
  0xF0, 0xF8, 0x1E, 0x0F, 0xC1, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0xDF, 0x3E, 0xF8, 0xFB, 0xEF, 0x8F, 0xFC, 0xF8, 0x7F, 0xCF, 0x83,
  0xF8, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xBE, 0x0F, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x7D, 0xF7, 0x80, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1,
  0xFF, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83,
  0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0xC0, 0x0F, 0x00,
  0xFC, 0x0F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0xFE, 0x1F, 0xE7, 0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0x0F, 0x80,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x06, 0x0F, 0x06, 0x78, 0xF1, 0xE7, 0xE6, 0x7E, 0xFF, 0x6F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x7D,
  0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x0E,
  0x07, 0x00, 0x20, 0x20, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC7, 0xE1,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xBF, 0xBF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE7,
  0x9F, 0xF9, 0xF7, 0xFE, 0x7D, 0xFF, 0x9F, 0x7F, 0xE7, 0x9F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xF7,
  0xFB, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C,
  0x0F, 0x9F, 0x03, 0x87, 0xC0, 0xC1, 0xF0, 0x20, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF,
  0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE1, 0xF7, 0xF0, 0xFB, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x1C, 0x07, 0xDF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xC0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x40, 0x3F, 0x7F, 0x07, 0xDF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03,
  0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0x9F, 0xC7, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3E,
  0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x3F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFC, 0xFE, 0x7E, 0x1F, 0xBF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xF3, 0xFD, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xF1, 0xFD, 0xF8, 0x1F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x7E, 0x07,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFB, 0xE0, 0xFE, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x0F, 0x07,
  0xE1, 0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xC0,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x03, 0xF7, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xEF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF1, 0xF1, 0xFF, 0x1F, 0x0F, 0xF1, 0xF0, 0xFF, 0x1F,
  0x0F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1,
  0xF0, 0xFF, 0x1F, 0x9F, 0xF0, 0xFF, 0xFF, 0x07, 0xE7, 0xF0, 0x3C, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xC7, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xBF, 0x1F,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xBF, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x83,
  0xF7, 0xFB, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xBF, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xF7, 0xFB,
  0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xF3, 0xFD, 0xFF, 0xFE, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xFB, 0xF0,
  0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xB9, 0xFF,
  0xF7, 0x3B, 0xFE, 0xF7, 0x7F, 0xDF, 0xEF, 0xF9, 0xFD, 0xFF, 0x3F, 0x3F,
  0xE7, 0xE7, 0xFC, 0xFC, 0xFF, 0xCF, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFE, 0xF1, 0xFF, 0xBC, 0x7F, 0xEF,
  0x9F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x9F, 0x7F, 0xE3, 0xDF, 0xF8, 0xF7,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xEF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xBF, 0xBF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF7, 0xFB, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xFB, 0xF9, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0x9F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF,
  0x80, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFB, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03,
  0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0,
  0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0xF8, 0x78, 0x7D, 0xE1, 0xE1, 0xF7, 0x87, 0xC7, 0xDE, 0x1F, 0x1E,
  0x78, 0x7C, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9F, 0x3F, 0x1E, 0x7C,
  0xFC, 0x79, 0xF3, 0xB1, 0xE7, 0xCE, 0xCF, 0x9F, 0x33, 0x3E, 0x3C, 0xCE,
  0xF8, 0xF3, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0,
  0xF7, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0x71, 0xBC, 0x3D, 0x86, 0xF0, 0xF6,
  0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x00, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xFC, 0x0F, 0xC3, 0xE0,
  0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x80,
  0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0x3E, 0x7C, 0x0F, 0xBF,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC0, 0x00, 0xE0, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xF7, 0xC0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC7,
  0x83, 0xF3, 0xF8, 0xFD, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x7F, 0xCF, 0xCF, 0xE0, 0x01, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x7F, 0xBF,
  0xDF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x70, 0xFC, 0x7F, 0xBF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFB, 0xF0, 0xFC, 0xFC, 0x01,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x7E,
  0x0F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x07, 0xFB, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x1E, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3, 0x83, 0xF3, 0xF8, 0xFD, 0xFF, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x87, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F,
  0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x83, 0xF3, 0xE1, 0xFC, 0xF8, 0x7E, 0x3E,
  0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xE3, 0xF0, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC,
  0xF8, 0x1F, 0xBE, 0x07, 0xFF, 0x80, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0x07, 0x1E, 0xF9, 0xF3, 0xFF, 0x7F, 0x7F, 0xFF,
  0xEF, 0x9E, 0x7F, 0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3,
  0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7,
  0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F,
  0xF8, 0xF1, 0xFF, 0x1E, 0x3E, 0x00, 0x38, 0x3F, 0x3F, 0x8F, 0xDF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7F, 0xBF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x3F, 0x3F, 0x8F, 0xDF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xF7, 0xFC, 0xFC, 0xFE, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x07, 0xFB,
  0xF3, 0xFE, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x87, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xBF, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x38, 0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xFC, 0x03,
  0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0,
  0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F,
  0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xF8, 0x78, 0x7D, 0xE1, 0xE1, 0xF7, 0x87, 0x87, 0x9E, 0x1F, 0x1E, 0x78,
  0xFC, 0x79, 0xF3, 0xF1, 0xE7, 0xCF, 0xC7, 0x8F, 0x3B, 0x3E, 0x3C, 0xCC,
  0xF8, 0xF3, 0x3B, 0xC3, 0xCC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0,
  0xFF, 0x3B, 0xC1, 0xFC, 0x6F, 0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0xFE, 0x07, 0xF3, 0xF0, 0xFE,
  0x3F, 0x0F, 0xC1, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x3F,
  0x0F, 0xC3, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC1, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0xDF,
  0x00, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFC,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x1F, 0x7F, 0xE1, 0xF7, 0xFF, 0x1F, 0x7F, 0xF1, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xEF, 0x87, 0xFE, 0xF8, 0x3F, 0xC0, 0x00, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 14, 11, 22, 4, -27 },
  { 42, 20, 27, 22, 1, -27 },
  { 110, 18, 37, 22, 2, -32 },
  { 194, 24, 27, 22, -1, -27 },
  { 275, 20, 27, 22, 1, -27 },
  { 343, 6, 11, 22, 8, -27 },
  { 352, 12, 35, 22, 6, -31 },
  { 405, 12, 35, 22, 4, -31 },
  { 458, 20, 20, 22, 1, -23 },
  { 508, 18, 18, 22, 2, -21 },
  { 549, 10, 12, 22, 5, -6 },
  { 564, 12, 5, 22, 5, -15 },
  { 572, 8, 7, 22, 7, -7 },
  { 579, 18, 35, 22, 2, -31 },
  { 658, 18, 27, 22, 2, -27 },
  { 719, 18, 27, 22, 3, -27 },
  { 780, 18, 27, 22, 2, -27 },
  { 841, 18, 27, 22, 2, -27 },
  { 902, 17, 27, 22, 2, -27 },
  { 960, 18, 27, 22, 2, -27 },
  { 1021, 19, 27, 22, 2, -27 },
  { 1086, 18, 27, 22, 2, -27 },
  { 1147, 18, 27, 22, 2, -27 },
  { 1208, 19, 27, 22, 2, -27 },
  { 1273, 8, 21, 22, 7, -21 },
  { 1294, 10, 27, 22, 5, -21 },
  { 1328, 17, 21, 22, 3, -23 },
  { 1373, 16, 14, 22, 3, -19 },
  { 1401, 17, 21, 22, 3, -23 },
  { 1446, 15, 27, 22, 4, -27 },
  { 1497, 20, 34, 22, 1, -27 },
  { 1582, 20, 27, 22, 1, -27 },
  { 1650, 19, 27, 22, 2, -27 },
  { 1715, 18, 27, 22, 2, -27 },
  { 1776, 18, 27, 22, 2, -27 },
  { 1837, 17, 27, 22, 3, -27 },
  { 1895, 17, 27, 22, 3, -27 },
  { 1953, 18, 27, 22, 2, -27 },
  { 2014, 18, 27, 22, 2, -27 },
  { 2075, 16, 27, 22, 3, -27 },
  { 2129, 18, 27, 22, 1, -27 },
  { 2190, 19, 27, 22, 2, -27 },
  { 2255, 16, 27, 22, 4, -27 },
  { 2309, 19, 27, 22, 2, -27 },
  { 2374, 18, 27, 22, 2, -27 },
  { 2435, 18, 27, 22, 2, -27 },
  { 2496, 19, 27, 22, 2, -27 },
  { 2561, 19, 34, 22, 2, -27 },
  { 2642, 19, 27, 22, 2, -27 },
  { 2707, 18, 27, 22, 2, -27 },
  { 2768, 20, 27, 22, 1, -27 },
  { 2836, 18, 27, 22, 2, -27 },
  { 2897, 20, 27, 22, 1, -27 },
  { 2965, 22, 27, 22, 0, -27 },
  { 3040, 20, 27, 22, 1, -27 },
  { 3108, 21, 27, 22, 1, -27 },
  { 3179, 16, 27, 22, 3, -27 },
  { 3233, 12, 35, 22, 6, -31 },
  { 3286, 18, 35, 22, 2, -31 },
  { 3365, 11, 35, 22, 5, -31 },
  { 3414, 18, 14, 22, 2, -27 },
  { 3446, 18, 5, 22, 2, 1 },
  { 3458, 10, 5, 22, 6, -29 },
  { 3465, 18, 21, 22, 2, -21 },
  { 3513, 18, 27, 22, 2, -27 },
  { 3574, 18, 21, 22, 2, -21 },
  { 3622, 18, 27, 22, 2, -27 },
  { 3683, 18, 21, 22, 2, -21 },
  { 3731, 18, 27, 22, 2, -27 },
  { 3792, 18, 28, 22, 2, -21 },
  { 3855, 18, 27, 22, 2, -27 },
  { 3916, 18, 29, 22, 3, -29 },
  { 3982, 15, 36, 22, 3, -29 },
  { 4050, 18, 27, 22, 3, -27 },
  { 4111, 20, 27, 22, 1, -27 },
  { 4179, 19, 21, 22, 2, -21 },
  { 4229, 18, 21, 22, 2, -21 },
  { 4277, 18, 21, 22, 2, -21 },
  { 4325, 18, 28, 22, 2, -21 },
  { 4388, 18, 28, 22, 2, -21 },
  { 4451, 18, 21, 22, 3, -21 },
  { 4499, 18, 21, 22, 2, -21 },
  { 4547, 19, 26, 22, 1, -26 },
  { 4609, 18, 20, 22, 2, -20 },
  { 4654, 20, 20, 22, 1, -20 },
  { 4704, 22, 20, 22, 0, -20 },
  { 4759, 20, 20, 22, 1, -20 },
  { 4809, 20, 27, 22, 1, -20 },
  { 4877, 17, 20, 22, 3, -20 },
  { 4920, 16, 35, 22, 3, -31 },
  { 4990, 6, 35, 22, 8, -31 },
  { 5017, 16, 35, 22, 3, -31 },
  { 5087, 20, 10, 22, 1, -18 },
};

const GFXfont JetBrainsMono_ExtraBold37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_EXTRABOLD37PT7B_H_
