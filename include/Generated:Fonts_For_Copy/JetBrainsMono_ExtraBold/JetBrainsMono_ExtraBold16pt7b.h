#ifndef _JETBRAINSMONO_EXTRABOLD16PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x03, 0xF0, 0xDF, 0x7D, 0xF3, 0xCC, 0x19, 0x0C,
  0x84, 0xCF, 0xF7, 0xF9, 0x98, 0xC8, 0x64, 0xFF, 0x93, 0x19, 0x8C, 0xC0,
  0x10, 0x10, 0x3C, 0x7E, 0xF7, 0xD0, 0xF0, 0xFC, 0x7E, 0x1F, 0x17, 0xD7,
  0xFE, 0x7C, 0x10, 0x10, 0x70, 0xFE, 0x6D, 0x93, 0x6C, 0xFE, 0x0B, 0x00,
  0x80, 0x7E, 0x34, 0x89, 0x24, 0x4B, 0x1E, 0x38, 0x7E, 0x66, 0x60, 0x60,
  0xF0, 0xF3, 0xDF, 0xCE, 0xCE, 0xFE, 0x7B, 0xFF, 0xC0, 0x0C, 0xF7, 0x98,
  0x63, 0x8E, 0x38, 0xE1, 0x86, 0x1C, 0x3C, 0x70, 0x40, 0xC7, 0x1C, 0x71,
  0x8C, 0x63, 0x18, 0xCE, 0x7F, 0x72, 0x00, 0x0C, 0x06, 0x13, 0x2F, 0x7F,
  0xF0, 0xE0, 0xD8, 0xE6, 0x12, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x77, 0x66, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0x06, 0x0E,
  0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0,
  0x3C, 0x7E, 0xE6, 0xC7, 0xC7, 0xDF, 0xDF, 0xC7, 0xC7, 0xC7, 0xFE, 0x7C,
  0x1C, 0x7C, 0xFC, 0xDC, 0x9C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF,
  0x3C, 0x7E, 0xE6, 0xC7, 0x06, 0x0E, 0x1C, 0x3C, 0x78, 0xE0, 0xFF, 0xFF,
  0xFE, 0xFE, 0x06, 0x1C, 0x38, 0x3E, 0x0E, 0x07, 0x07, 0xC7, 0xFE, 0x7C,
  0x0E, 0x38, 0x61, 0xC7, 0x0C, 0xF9, 0xE3, 0xFF, 0xFC, 0x18, 0x30, 0xFE,
  0xFE, 0xE0, 0xE0, 0xEC, 0xFE, 0xE7, 0x07, 0x07, 0xE7, 0xFE, 0x7C, 0x1C,
  0x18, 0x38, 0x30, 0x60, 0xFE, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE, 0x7C, 0xFF,
  0xFF, 0xFF, 0xC6, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x3C,
  0x7E, 0xE6, 0xC7, 0xE6, 0x7E, 0x7E, 0xE6, 0xC7, 0xC7, 0xFE, 0x7C, 0x3C,
  0x7E, 0xE7, 0xC3, 0xC7, 0xE7, 0x7E, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0x7D,
  0x80, 0x1F, 0xE0, 0x37, 0x30, 0x00, 0x07, 0x76, 0x6C, 0x02, 0x0C, 0x7F,
  0xCE, 0x1E, 0x1F, 0x07, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81,
  0xC3, 0xE0, 0xF0, 0x61, 0xDF, 0x78, 0xC0, 0xF3, 0xEF, 0xC3, 0x0D, 0xF7,
  0x98, 0x00, 0x0E, 0x18, 0x1E, 0x1F, 0x98, 0x6C, 0x3C, 0xFE, 0x6F, 0x27,
  0x93, 0xC9, 0xE6, 0xF3, 0xEC, 0x06, 0x01, 0xE0, 0x70, 0x1C, 0x0F, 0x07,
  0x87, 0xC3, 0x61, 0xB8, 0xCC, 0x7E, 0x7F, 0x31, 0xD8, 0xFC, 0x30, 0xF8,
  0xFE, 0xC7, 0xC7, 0xC6, 0xFC, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE, 0xFC, 0x3C,
  0x7E, 0xE7, 0xC7, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE7, 0xFE, 0x7C, 0xF8,
  0xFE, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFE, 0xFC, 0xFF,
  0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0xE1, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3C, 0x7E,
  0xE7, 0xC7, 0xC0, 0xC0, 0xCF, 0xCF, 0xC7, 0xE7, 0xFE, 0x7C, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFC,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x1F, 0x1F, 0x1F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xE3, 0xE3, 0x7F, 0x3E, 0xC7, 0xC7, 0xC6,
  0xCE, 0xCC, 0xFC, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7, 0xC7, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC7, 0xE7, 0xA7, 0xEF,
  0xFB, 0xFB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xE3, 0xF3,
  0xF3, 0xD3, 0xDB, 0xDB, 0xCB, 0xCF, 0xCF, 0xC7, 0x3C, 0x7E, 0xE6, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0x7C, 0xF8, 0xFE, 0xCF, 0xC3,
  0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xE6, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0x7C, 0x0C, 0x06, 0x07, 0xF8,
  0xFE, 0xCF, 0xC7, 0xC7, 0xFF, 0xFE, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7, 0x3C,
  0x7E, 0xE7, 0xC0, 0xE0, 0xFC, 0x7E, 0x0F, 0x07, 0xC7, 0xFE, 0x7C, 0xFF,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0x7C, 0xE1,
  0xB0, 0xD8, 0xEE, 0x67, 0x31, 0x98, 0xDC, 0x6C, 0x3E, 0x0F, 0x07, 0x83,
  0x80, 0xCD, 0xE6, 0xF3, 0x79, 0xB5, 0xDB, 0xAD, 0xD6, 0xEB, 0x77, 0xB9,
  0xDC, 0xCE, 0x60, 0x63, 0xB9, 0x8D, 0xC7, 0xC1, 0xE0, 0xE0, 0x70, 0x3C,
  0x3E, 0x1B, 0x9C, 0xFC, 0x70, 0xE1, 0xB1, 0xDC, 0xC6, 0x63, 0x60, 0xF0,
  0x78, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x71, 0xC3,
  0x0E, 0x18, 0x71, 0xC3, 0xFF, 0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7F, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18,
  0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0xFF, 0xE0, 0x18, 0x38, 0x3C, 0x6C, 0x66, 0xE6, 0xC7,
  0xFF, 0xFF, 0xFF, 0xE3, 0x8E, 0x3C, 0x7E, 0xE7, 0x07, 0x7F, 0xC7, 0xC7,
  0xFF, 0x7F, 0xC0, 0xC0, 0xC0, 0xDC, 0xDE, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7,
  0xFE, 0xDE, 0x3C, 0x7E, 0xE7, 0xC0, 0xC0, 0xC0, 0xE7, 0xFE, 0x7C, 0x07,
  0x07, 0x07, 0x77, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x3C,
  0x7E, 0xC7, 0xC7, 0xFF, 0xC0, 0xC1, 0xFE, 0x7C, 0x0F, 0x1F, 0x38, 0x38,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x77, 0xFF, 0xE7, 0xC7,
  0xC7, 0xC7, 0xFF, 0x7F, 0x27, 0x06, 0x7E, 0x7C, 0xC0, 0xC0, 0xC0, 0xDC,
  0xDE, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x18, 0x1C, 0x18, 0x00,
  0x78, 0x78, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x0C, 0x1C, 0x30,
  0x07, 0xEF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xBF, 0x7C, 0xE0,
  0xE0, 0xE0, 0xE7, 0xE6, 0xEE, 0xEC, 0xFC, 0xFC, 0xEE, 0xE6, 0xE7, 0xFC,
  0x7E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0xE1,
  0xF0, 0xF6, 0xFF, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDC, 0xDE,
  0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x3C, 0x7E, 0xE7, 0xC7, 0xC7,
  0xC7, 0xE7, 0xFE, 0x7C, 0xDC, 0xDE, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE,
  0xDE, 0xC0, 0xC0, 0xC0, 0x77, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF,
  0x7F, 0x07, 0x07, 0x07, 0xFE, 0xFF, 0xE7, 0xE3, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x7C, 0xFE, 0xC7, 0xE0, 0x7E, 0x0F, 0xC7, 0xFF, 0x7E, 0x30, 0x30,
  0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x1E, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0x7C, 0xE1, 0xB1, 0xDC, 0xC6, 0x63, 0x71,
  0xB0, 0xF8, 0x3C, 0x1C, 0x00, 0xCC, 0xE6, 0xF3, 0x6F, 0xB7, 0x5B, 0xAD,
  0xDE, 0xE6, 0x73, 0x00, 0x63, 0xBB, 0x8F, 0x83, 0xC1, 0xC0, 0xF0, 0xFC,
  0xE6, 0xE3, 0x80, 0xE1, 0xB1, 0xDC, 0xC6, 0x63, 0x70, 0xF0, 0x78, 0x3C,
  0x0C, 0x0E, 0x07, 0x03, 0x00, 0xFF, 0xFC, 0x38, 0xE3, 0x8E, 0x18, 0x7F,
  0xFE, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0xBE, 0x7C, 0x1C, 0x38, 0x70, 0xE1,
  0xC1, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE0, 0xC1, 0x83, 0x06,
  0x0F, 0x8F, 0x38, 0x60, 0xC1, 0x87, 0x1E, 0x38, 0x00, 0x60, 0xF3, 0xDB,
  0xDF,
};

const GFXglyph JetBrainsMono_ExtraBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 6, 5, 10, 2, -12 },
  { 10, 9, 12, 10, 0, -12 },
  { 24, 8, 16, 10, 1, -14 },
  { 40, 10, 12, 10, 0, -12 },
  { 55, 8, 12, 10, 1, -12 },
  { 67, 2, 5, 10, 4, -12 },
  { 69, 6, 15, 10, 2, -13 },
  { 81, 5, 15, 10, 2, -13 },
  { 91, 9, 9, 10, 0, -10 },
  { 102, 8, 8, 10, 1, -9 },
  { 110, 4, 5, 10, 2, -2 },
  { 113, 5, 2, 10, 2, -6 },
  { 115, 3, 3, 10, 3, -3 },
  { 117, 8, 15, 10, 1, -13 },
  { 132, 8, 12, 10, 1, -12 },
  { 144, 8, 12, 10, 1, -12 },
  { 156, 8, 12, 10, 1, -12 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 7, 12, 10, 1, -12 },
  { 191, 8, 12, 10, 1, -12 },
  { 203, 8, 12, 10, 1, -12 },
  { 215, 8, 12, 10, 1, -12 },
  { 227, 8, 12, 10, 1, -12 },
  { 239, 8, 12, 10, 1, -12 },
  { 251, 3, 9, 10, 3, -9 },
  { 255, 4, 12, 10, 2, -9 },
  { 261, 7, 9, 10, 1, -10 },
  { 269, 7, 6, 10, 1, -8 },
  { 275, 7, 9, 10, 1, -10 },
  { 283, 6, 12, 10, 2, -12 },
  { 292, 9, 15, 10, 0, -12 },
  { 309, 9, 12, 10, 0, -12 },
  { 323, 8, 12, 10, 1, -12 },
  { 335, 8, 12, 10, 1, -12 },
  { 347, 8, 12, 10, 1, -12 },
  { 359, 7, 12, 10, 1, -12 },
  { 370, 8, 12, 10, 1, -12 },
  { 382, 8, 12, 10, 1, -12 },
  { 394, 8, 12, 10, 1, -12 },
  { 406, 7, 12, 10, 1, -12 },
  { 417, 8, 12, 10, 0, -12 },
  { 429, 8, 12, 10, 1, -12 },
  { 441, 7, 12, 10, 2, -12 },
  { 452, 8, 12, 10, 1, -12 },
  { 464, 8, 12, 10, 1, -12 },
  { 476, 8, 12, 10, 1, -12 },
  { 488, 8, 12, 10, 1, -12 },
  { 500, 8, 15, 10, 1, -12 },
  { 515, 8, 12, 10, 1, -12 },
  { 527, 8, 12, 10, 1, -12 },
  { 539, 8, 12, 10, 1, -12 },
  { 551, 8, 12, 10, 1, -12 },
  { 563, 9, 12, 10, 0, -12 },
  { 577, 9, 12, 10, 0, -12 },
  { 591, 9, 12, 10, 0, -12 },
  { 605, 9, 12, 10, 0, -12 },
  { 619, 7, 12, 10, 1, -12 },
  { 630, 5, 15, 10, 3, -13 },
  { 640, 8, 15, 10, 1, -13 },
  { 655, 5, 15, 10, 2, -13 },
  { 665, 8, 7, 10, 1, -12 },
  { 672, 8, 3, 10, 1, 0 },
  { 675, 5, 3, 10, 2, -13 },
  { 677, 8, 9, 10, 1, -9 },
  { 686, 8, 12, 10, 1, -12 },
  { 698, 8, 9, 10, 1, -9 },
  { 707, 8, 12, 10, 1, -12 },
  { 719, 8, 9, 10, 1, -9 },
  { 728, 8, 12, 10, 1, -12 },
  { 740, 8, 12, 10, 1, -9 },
  { 752, 8, 12, 10, 1, -12 },
  { 764, 8, 13, 10, 1, -13 },
  { 777, 7, 16, 10, 1, -13 },
  { 791, 8, 12, 10, 1, -12 },
  { 803, 9, 12, 10, 0, -12 },
  { 817, 8, 9, 10, 1, -9 },
  { 826, 8, 9, 10, 1, -9 },
  { 835, 8, 9, 10, 1, -9 },
  { 844, 8, 12, 10, 1, -9 },
  { 856, 8, 12, 10, 1, -9 },
  { 868, 8, 9, 10, 1, -9 },
  { 877, 8, 9, 10, 1, -9 },
  { 886, 8, 11, 10, 1, -11 },
  { 897, 8, 9, 10, 1, -9 },
  { 906, 9, 9, 10, 0, -9 },
  { 917, 9, 9, 10, 0, -9 },
  { 928, 9, 9, 10, 0, -9 },
  { 939, 9, 12, 10, 0, -9 },
  { 953, 7, 9, 10, 1, -9 },
  { 961, 7, 15, 10, 1, -13 },
  { 975, 2, 15, 10, 4, -13 },
  { 979, 7, 15, 10, 1, -13 },
  { 993, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraBold16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_EXTRABOLD16PT7B_H_
