#ifndef _JETBRAINSMONO_EXTRABOLD30PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x80, 0x00, 0x07, 0xBF, 0xFD, 0xE0, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xF7, 0x8E, 0x70, 0xE0, 0x07, 0x0E, 0x07, 0x1E,
  0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x70, 0x38, 0x70, 0x78, 0xF0,
  0x78, 0xE0, 0x70, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7D, 0xBE, 0x79, 0x9E,
  0x79, 0x80, 0x7D, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x01, 0xFE, 0x01, 0x9E, 0x01, 0x9F, 0xF9, 0x9F, 0x79, 0x9E,
  0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x3E, 0x01, 0xDF, 0xC0, 0xE7, 0xF8, 0x3B, 0x8E,
  0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x8E, 0x39, 0xC1, 0xFE, 0xE0, 0x7F, 0x70,
  0x0F, 0x9C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x9E, 0x00, 0xEF, 0xE0,
  0x77, 0xF8, 0x39, 0xC7, 0x0E, 0x71, 0xC7, 0x1C, 0x73, 0x87, 0x1D, 0xC1,
  0xEE, 0x70, 0x7F, 0xB8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3E, 0xFC, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x8F, 0xFF, 0xDF, 0xF3, 0xDE, 0xF1, 0xFE,
  0xF0, 0xFC, 0xF0, 0xFC, 0xF0, 0x78, 0xFD, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC1, 0xF0, 0xFC, 0x7F,
  0x3F, 0x9F, 0x87, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC0,
  0xFC, 0x3F, 0xC7, 0xF0, 0x7C, 0x0F, 0x00, 0x40, 0xE0, 0x3E, 0x0F, 0xC3,
  0xF8, 0x7F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC3, 0xE1,
  0xF8, 0xFC, 0xFF, 0x3F, 0x8F, 0x83, 0x80, 0x80, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x43, 0xC2, 0x71, 0x8E, 0xF9, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFE, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0x70, 0x1E, 0x78, 0x3E, 0x7C, 0x3C,
  0x3C, 0x1C, 0x38, 0x08, 0x10, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C,
  0x78, 0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xDE, 0xFF, 0x7B, 0xFD, 0xEF, 0xF7, 0xBF, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0x07, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1E, 0x78,
  0x38, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xC3, 0xEF, 0x07, 0xFE, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xDF, 0xFE,
  0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF1, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFB, 0xF3, 0xFF,
  0xEF, 0xFF, 0xFE, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3D, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xC0,
  0xFF, 0x03, 0xFE, 0x1F, 0x7C, 0xF9, 0xFF, 0xE1, 0xFE, 0x0F, 0xFC, 0x7F,
  0xFB, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xDF,
  0xFE, 0x7F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7C, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xBC, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x73, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0x78, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0,
  0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0,
  0x3E, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0x07, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x8F, 0xF8,
  0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x80, 0x00, 0xFF, 0x0F, 0xFC,
  0xFF, 0xEF, 0xFF, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF3, 0xFF,
  0x3F, 0xE3, 0xFC, 0x3F, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0xE7, 0xE1, 0xF7,
  0xE3, 0xFF, 0xE3, 0xCF, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE3, 0x87, 0xE3, 0xCF, 0xE3, 0xFF, 0xE1, 0xF7, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C,
  0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x79, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xCF, 0x1F, 0xDE, 0x07, 0xBC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x1F,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xC0,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xDF,
  0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0x0F, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3D, 0xE1, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF,
  0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0xFB,
  0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x83, 0xFC, 0x00, 0xF0, 0x3F, 0xE0, 0x7B,
  0xC1, 0xF7, 0x83, 0xEF, 0x0F, 0x9E, 0x1F, 0x3C, 0x7C, 0x78, 0xF8, 0xF1,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1E, 0x3E, 0x3C, 0x7C,
  0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xF3, 0xC1, 0xF7, 0x83, 0xEF, 0x03, 0xFE,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xF6, 0x6F, 0xF7, 0xEF, 0xF7, 0xEF, 0xF3, 0xEF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFE, 0xE3, 0xFF, 0xCF,
  0xFF, 0x3F, 0xDC, 0xFF, 0x7B, 0xFD, 0xEF, 0xF3, 0xBF, 0xCF, 0xFF, 0x3D,
  0xFC, 0x77, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB, 0xFF, 0xF3, 0xFF, 0xC3,
  0xFF, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xF3, 0xC1,
  0xE7, 0x83, 0xEF, 0x07, 0xDE, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0,
  0x7F, 0x80, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x7C, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xF1, 0xE3,
  0xFC, 0x78, 0xF7, 0x1E, 0x39, 0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0x78, 0xE7,
  0x1E, 0x39, 0xEF, 0xDE, 0x7B, 0xF7, 0x9E, 0xCD, 0xE7, 0xB3, 0x79, 0xEC,
  0xDE, 0x7B, 0x37, 0x0E, 0xCD, 0xC3, 0xB3, 0x70, 0xEC, 0xDC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0,
  0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C,
  0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xDF, 0x03,
  0xE3, 0xC0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0,
  0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C,
  0x78, 0x79, 0xE1, 0xEF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xC0, 0x1F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xF7, 0xC3, 0xEF, 0x83, 0xC0, 0x07, 0x87, 0xFF, 0x3F,
  0xFE, 0xFF, 0xFD, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xFF,
  0xBF, 0xEF, 0x1F, 0x9E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC7, 0x0F, 0x7F, 0x3D, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF,
  0xFF, 0xFD, 0xFE, 0xF7, 0xFB, 0xCF, 0xC0, 0x07, 0x80, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x0F, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x38, 0xF3,
  0xFB, 0xDF, 0xEF, 0xFF, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xDF, 0xEF,
  0x7F, 0xBC, 0xFC, 0xF0, 0x07, 0x80, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8,
  0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x0E, 0x3C, 0xFE, 0xF7, 0xFB, 0xFF, 0xFF, 0xF8,
  0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE,
  0x1F, 0xFF, 0xFD, 0xFE, 0xF7, 0xFB, 0xC7, 0xCF, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC7, 0x0F, 0x7F, 0x3D, 0xFE, 0xFF, 0xFF, 0xF1,
  0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0F, 0x80, 0x7E,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF7,
  0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xFE, 0x0F, 0xFC, 0x3E, 0xF8, 0x7D,
  0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE7, 0xC3, 0xEF, 0x87, 0xFF, 0x07,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF3, 0x1C, 0xFF,
  0xBE, 0xFF, 0xBE, 0xFB, 0xDF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xC3, 0xDF, 0xCF, 0x7F,
  0xBF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3C, 0x07, 0x80, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F,
  0xFF, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF1, 0xC3, 0xDF, 0xCF, 0x7F,
  0xBF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F, 0xBD, 0xFE, 0xF3,
  0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x3C,
  0xFE, 0xF7, 0xFB, 0xFF, 0xEF, 0xF8, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xF7, 0xFB,
  0xDF, 0xEF, 0x3F, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0xF8, 0xE1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1E, 0x78, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0xF8, 0x1F, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xF7,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0xF1, 0xE3, 0xFC, 0x78, 0xF7, 0x1E, 0x39, 0xC7, 0x8E,
  0x71, 0xE3, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEE, 0xDE, 0x7B, 0x37, 0x8E,
  0xCD, 0xC3, 0xB3, 0x70, 0xEC, 0xDC, 0x3B, 0x37, 0x0E, 0xCF, 0xC3, 0xF3,
  0xF0, 0xF8, 0x7C, 0x1E, 0x1E, 0x00, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x7C, 0x3E,
  0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E,
  0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFF, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x0F,
  0x7F, 0x8F, 0xFF, 0x8F, 0xF3, 0xEF, 0xF1, 0xFF, 0xF1, 0xFE, 0x00, 0xFC,
};

const GFXglyph JetBrainsMono_ExtraBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 12, 9, 18, 3, -22 },
  { 32, 16, 22, 18, 1, -22 },
  { 76, 16, 30, 18, 1, -26 },
  { 136, 18, 22, 18, 0, -22 },
  { 186, 16, 22, 18, 1, -22 },
  { 230, 4, 9, 18, 7, -22 },
  { 235, 10, 29, 18, 5, -25 },
  { 272, 10, 29, 18, 3, -25 },
  { 309, 16, 16, 18, 1, -18 },
  { 341, 14, 14, 18, 2, -17 },
  { 366, 8, 10, 18, 4, -5 },
  { 376, 10, 4, 18, 4, -12 },
  { 381, 6, 6, 18, 6, -6 },
  { 386, 16, 28, 18, 1, -25 },
  { 442, 14, 22, 18, 2, -22 },
  { 481, 15, 22, 18, 2, -22 },
  { 523, 15, 22, 18, 1, -22 },
  { 565, 14, 22, 18, 2, -22 },
  { 604, 14, 22, 18, 2, -22 },
  { 643, 14, 22, 18, 2, -22 },
  { 682, 16, 22, 18, 1, -22 },
  { 726, 16, 22, 18, 1, -22 },
  { 770, 14, 22, 18, 2, -22 },
  { 809, 16, 22, 18, 1, -22 },
  { 853, 6, 17, 18, 6, -17 },
  { 866, 8, 22, 18, 4, -17 },
  { 888, 14, 17, 18, 2, -18 },
  { 918, 14, 12, 18, 2, -16 },
  { 939, 14, 17, 18, 2, -18 },
  { 969, 12, 22, 18, 3, -22 },
  { 1002, 16, 27, 18, 1, -22 },
  { 1056, 16, 22, 18, 1, -22 },
  { 1100, 15, 22, 18, 2, -22 },
  { 1142, 14, 22, 18, 2, -22 },
  { 1181, 15, 22, 18, 2, -22 },
  { 1223, 14, 22, 18, 2, -22 },
  { 1262, 14, 22, 18, 2, -22 },
  { 1301, 14, 22, 18, 2, -22 },
  { 1340, 14, 22, 18, 2, -22 },
  { 1379, 14, 22, 18, 2, -22 },
  { 1418, 15, 22, 18, 1, -22 },
  { 1460, 15, 22, 18, 2, -22 },
  { 1502, 13, 22, 18, 3, -22 },
  { 1538, 16, 22, 18, 1, -22 },
  { 1582, 14, 22, 18, 2, -22 },
  { 1621, 14, 22, 18, 2, -22 },
  { 1660, 15, 22, 18, 2, -22 },
  { 1702, 15, 27, 18, 2, -22 },
  { 1753, 15, 22, 18, 2, -22 },
  { 1795, 16, 22, 18, 1, -22 },
  { 1839, 16, 22, 18, 1, -22 },
  { 1883, 14, 22, 18, 2, -22 },
  { 1922, 16, 22, 18, 1, -22 },
  { 1966, 18, 22, 18, 0, -22 },
  { 2016, 16, 22, 18, 1, -22 },
  { 2060, 18, 22, 18, 0, -22 },
  { 2110, 14, 22, 18, 2, -22 },
  { 2149, 9, 28, 18, 5, -25 },
  { 2181, 15, 28, 18, 1, -25 },
  { 2234, 9, 28, 18, 4, -25 },
  { 2266, 14, 12, 18, 2, -22 },
  { 2287, 14, 4, 18, 2, 1 },
  { 2294, 9, 5, 18, 4, -24 },
  { 2300, 15, 17, 18, 1, -17 },
  { 2332, 14, 22, 18, 2, -22 },
  { 2371, 14, 17, 18, 2, -17 },
  { 2401, 14, 22, 18, 2, -22 },
  { 2440, 14, 17, 18, 2, -17 },
  { 2470, 15, 22, 18, 1, -22 },
  { 2512, 14, 22, 18, 2, -17 },
  { 2551, 14, 22, 18, 2, -22 },
  { 2590, 15, 24, 18, 2, -24 },
  { 2635, 13, 29, 18, 2, -24 },
  { 2683, 15, 22, 18, 2, -22 },
  { 2725, 16, 22, 18, 1, -22 },
  { 2769, 16, 17, 18, 1, -17 },
  { 2803, 14, 17, 18, 2, -17 },
  { 2833, 14, 17, 18, 2, -17 },
  { 2863, 14, 22, 18, 2, -17 },
  { 2902, 14, 22, 18, 2, -17 },
  { 2941, 15, 17, 18, 2, -17 },
  { 2973, 16, 17, 18, 1, -17 },
  { 3007, 15, 21, 18, 1, -21 },
  { 3047, 14, 17, 18, 2, -17 },
  { 3077, 16, 17, 18, 1, -17 },
  { 3111, 18, 17, 18, 0, -17 },
  { 3150, 16, 17, 18, 1, -17 },
  { 3184, 16, 22, 18, 1, -17 },
  { 3228, 14, 17, 18, 2, -17 },
  { 3258, 14, 28, 18, 2, -25 },
  { 3307, 4, 28, 18, 7, -25 },
  { 3321, 14, 28, 18, 2, -25 },
  { 3370, 16, 7, 18, 1, -14 },
};

const GFXfont JetBrainsMono_ExtraBold30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_EXTRABOLD30PT7B_H_
