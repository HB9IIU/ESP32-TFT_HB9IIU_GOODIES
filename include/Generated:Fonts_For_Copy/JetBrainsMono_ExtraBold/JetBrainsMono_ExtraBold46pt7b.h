#ifndef _JETBRAINSMONO_EXTRABOLD46PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFB,
  0xF8, 0x7E, 0x7C, 0x1F, 0x9F, 0x07, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xC0, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC1, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFB, 0xBF, 0xCF,
  0xE7, 0x3F, 0xDF, 0xCE, 0x3F, 0xBF, 0x9C, 0x00, 0x7F, 0x38, 0x00, 0xFE,
  0x70, 0x01, 0xFE, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xCF, 0xF0, 0x03, 0x8F, 0xE0, 0x07, 0x1F,
  0xC0, 0x0E, 0x1F, 0xFF, 0x1C, 0x7F, 0xFF, 0x38, 0xFF, 0xFE, 0x73, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x7F, 0xC0, 0x07, 0xC7, 0xFF, 0x00, 0x7C, 0x7F, 0xFC,
  0x07, 0xC3, 0xE3, 0xE0, 0x3C, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x78, 0x3E,
  0x0F, 0x83, 0xC3, 0xE0, 0x7C, 0x1E, 0x1E, 0x03, 0xE0, 0xF1, 0xF0, 0x0F,
  0x07, 0x9F, 0x00, 0x7C, 0x7C, 0xF0, 0x03, 0xFF, 0xEF, 0x80, 0x0F, 0xFE,
  0xF8, 0x00, 0x3F, 0xCF, 0x80, 0x00, 0x10, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x7F, 0x00,
  0x03, 0xEF, 0xFC, 0x00, 0x3E, 0xFF, 0xF0, 0x01, 0xE7, 0xFF, 0xC0, 0x1F,
  0x7C, 0x3E, 0x01, 0xF3, 0xE0, 0xF0, 0x1F, 0x1F, 0x07, 0x80, 0xF0, 0xF8,
  0x3C, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0x81, 0xF0, 0xF8,
  0x7C, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0xC7, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0xBF,
  0xFF, 0x1F, 0xDF, 0x9F, 0xCF, 0xCF, 0xC7, 0xEF, 0xE7, 0xE3, 0xFF, 0xE3,
  0xF0, 0xFF, 0xF1, 0xF8, 0x3F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7E, 0x07, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFE, 0x7F, 0x07, 0xFE,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB,
  0xF7, 0xEF, 0xC0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x20, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xF0,
  0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0x01, 0xF0, 0x08,
  0xE0, 0xF8, 0x1C, 0x7C, 0x3C, 0x3E, 0x7F, 0x1E, 0x7F, 0x3F, 0xEE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF9,
  0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x7E,
  0x07, 0xC0, 0x0E, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC7, 0x9F, 0xFF, 0x3F, 0x7F, 0xFC, 0xFD, 0xFF, 0xF3, 0xF7, 0xFF, 0xCF,
  0xDF, 0xFF, 0x3E, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFC, 0xFE, 0x03, 0xC3, 0xF8, 0x0E, 0x0F,
  0xE0, 0x30, 0x3F, 0x80, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF1,
  0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x0F, 0xF7, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x81, 0xFB, 0xFF, 0x87, 0xEF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF9, 0xFF, 0x7F, 0xE7, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC2, 0x00, 0x3F, 0x9F, 0xE0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0x81,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x01,
  0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xF8, 0x3F, 0xCF, 0xE0, 0x3F,
  0x9F, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFC, 0x03,
  0xF3, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x8F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0x80, 0x07,
  0x81, 0xFC, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFC, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xF0, 0x03, 0xF9,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x1E, 0x3F, 0xFC, 0x1F, 0xEF, 0xFF, 0x0F, 0xFD, 0xFF, 0xC3,
  0xFF, 0x7F, 0xF0, 0xFC, 0x7F, 0xFC, 0x7E, 0x0F, 0xFF, 0x1F, 0x83, 0xFF,
  0xC7, 0xE0, 0xFF, 0xF1, 0xF8, 0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x1F, 0x83,
  0xFF, 0xC7, 0xE0, 0xFF, 0xF1, 0xF8, 0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x1F,
  0x83, 0xFF, 0xC7, 0xE0, 0xFF, 0xF0, 0xFE, 0xFF, 0xFC, 0x3F, 0xF7, 0xFF,
  0x07, 0xF9, 0xFF, 0xC0, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x81,
  0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7,
  0xF0, 0x7F, 0xCF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF,
  0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xE7, 0xFE, 0xFF, 0xCF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFE,
  0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x7F, 0x00, 0xFE,
  0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFB, 0xC3, 0xFF,
  0xFB, 0xC3, 0xFF, 0xFB, 0xC7, 0xBF, 0xFB, 0xE7, 0xBF, 0xFD, 0xE7, 0xBF,
  0xFD, 0xEF, 0xBF, 0xFD, 0xEF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F,
  0xFC, 0xFF, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0x7E, 0x7F, 0xFC, 0x7E, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x83, 0xFF, 0xBE, 0x0F,
  0xFE, 0xFC, 0x3F, 0xFD, 0xF0, 0xFF, 0xF7, 0xC3, 0xFF, 0xDF, 0x8F, 0xFF,
  0x3E, 0x3F, 0xFC, 0xF8, 0xFF, 0xF3, 0xF3, 0xFF, 0xC7, 0xCF, 0xFF, 0x1F,
  0x3F, 0xFC, 0x7E, 0xFF, 0xF0, 0xFB, 0xFF, 0xC3, 0xEF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xBF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F,
  0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x1F,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x87,
  0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xE0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFC, 0x1F, 0x07, 0xEF, 0x83, 0xF0, 0xFD, 0xF0, 0x7E, 0x1F, 0xBE, 0x0F,
  0xC3, 0xF7, 0xC1, 0xF8, 0x7E, 0xFC, 0x3F, 0x0F, 0xDF, 0x87, 0xE1, 0xFB,
  0xF1, 0xFC, 0x3E, 0x7E, 0x3F, 0x87, 0xCF, 0xC7, 0x70, 0xF9, 0xF8, 0xEF,
  0x1F, 0x3F, 0x1D, 0xE3, 0xE3, 0xE3, 0xBC, 0x7C, 0x7C, 0x73, 0x8F, 0x8F,
  0x8E, 0x73, 0xF1, 0xF1, 0xCE, 0x7E, 0x3E, 0x79, 0xCF, 0xC7, 0xCF, 0x39,
  0xF0, 0xF9, 0xE7, 0x3E, 0x1F, 0xB8, 0xF7, 0xC3, 0xF7, 0x1E, 0xF8, 0x7E,
  0xE3, 0xDF, 0x07, 0xDC, 0x7B, 0xE0, 0xFB, 0x87, 0x7C, 0x1F, 0x70, 0xEF,
  0x83, 0xFE, 0x1D, 0xF0, 0x7F, 0xC3, 0xBE, 0x0F, 0xF8, 0x77, 0x81, 0xFE,
  0x0E, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x9F, 0xE0,
  0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x7F,
  0x87, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xF1,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8,
  0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F,
  0x1F, 0x80, 0xFE, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0x3F, 0x80,
  0xFF, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0x1F,
  0xFC, 0xFE, 0x1F, 0xF1, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0x03, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xBF, 0xFC, 0xFE, 0xFF, 0xE3,
  0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x03, 0xC1, 0xFC, 0x3F, 0xC7, 0xF3, 0xFF, 0x9F, 0xCF, 0xFF, 0x7F,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xDF, 0xCF, 0xFF, 0x7F, 0x1F, 0xF9, 0xFC, 0x3F, 0xC7,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFF, 0x7F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x7F, 0x03, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC7, 0xF3, 0xFF, 0x9F, 0xCF,
  0xFF, 0x7F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFD,
  0xFC, 0xFF, 0xF7, 0xF1, 0xFF, 0x9F, 0xC3, 0xFC, 0x7F, 0x03, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0x03, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x60, 0x70, 0xF9, 0xF9, 0xFC, 0xFB, 0xF9, 0xFE,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x7E, 0x7F, 0xFC, 0x7C, 0x3F,
  0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F,
  0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F,
  0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F,
  0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F,
  0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0x00, 0x0F, 0x03,
  0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x03,
  0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xBF, 0xFC, 0xFE, 0xFF, 0xE3, 0xF8, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC7,
  0xF3, 0xFF, 0x9F, 0xCF, 0xFF, 0x7F, 0x7F, 0xFD, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xCF, 0xFF,
  0x7F, 0x1F, 0xF9, 0xFC, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x03, 0xF1, 0xFF, 0x0F, 0xCF,
  0xFF, 0x3F, 0x7F, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xC0,
  0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0x03, 0xEF,
  0x83, 0xF0, 0xFD, 0xF0, 0x7E, 0x1F, 0xBE, 0x0F, 0xC3, 0xF7, 0xE1, 0xF8,
  0x7C, 0xFC, 0x3F, 0x0F, 0x9F, 0x8F, 0xE1, 0xF1, 0xF1, 0xDC, 0x3E, 0x3E,
  0x3B, 0xC7, 0xC7, 0xC7, 0x79, 0xF8, 0xF8, 0xE7, 0x3F, 0x1F, 0x9C, 0xE7,
  0xC3, 0xF7, 0x9C, 0xF8, 0x7E, 0xF3, 0x9F, 0x07, 0xDE, 0x73, 0xE0, 0xFB,
  0x8F, 0x7C, 0x1F, 0x71, 0xFF, 0x83, 0xEE, 0x1F, 0xF0, 0x7D, 0xC3, 0xFC,
  0x0F, 0xB8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x9F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0xC0,
  0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x3F,
  0x7F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFC, 0xFE, 0x3F,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFE, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 18, 14, 28, 5, -34 },
  { 67, 26, 34, 28, 1, -34 },
  { 178, 23, 46, 28, 2, -40 },
  { 311, 29, 34, 28, -1, -34 },
  { 435, 25, 34, 28, 2, -34 },
  { 542, 7, 14, 28, 10, -34 },
  { 555, 15, 45, 28, 7, -39 },
  { 640, 15, 45, 28, 5, -39 },
  { 725, 25, 24, 28, 1, -28 },
  { 800, 22, 22, 28, 3, -26 },
  { 861, 12, 14, 28, 6, -7 },
  { 882, 15, 6, 28, 6, -18 },
  { 894, 9, 9, 28, 9, -9 },
  { 905, 23, 43, 28, 2, -38 },
  { 1029, 22, 34, 28, 3, -34 },
  { 1123, 22, 34, 28, 4, -34 },
  { 1217, 23, 34, 28, 2, -34 },
  { 1315, 23, 34, 28, 2, -34 },
  { 1413, 21, 34, 28, 3, -34 },
  { 1503, 22, 34, 28, 3, -34 },
  { 1597, 24, 34, 28, 2, -34 },
  { 1699, 23, 34, 28, 2, -34 },
  { 1797, 23, 34, 28, 2, -34 },
  { 1895, 24, 34, 28, 2, -34 },
  { 1997, 9, 26, 28, 9, -26 },
  { 2027, 12, 33, 28, 7, -26 },
  { 2077, 21, 26, 28, 3, -28 },
  { 2146, 20, 18, 28, 4, -24 },
  { 2191, 21, 26, 28, 3, -28 },
  { 2260, 19, 34, 28, 5, -34 },
  { 2341, 26, 42, 28, 1, -34 },
  { 2478, 25, 34, 28, 1, -34 },
  { 2585, 23, 34, 28, 3, -34 },
  { 2683, 22, 34, 28, 3, -34 },
  { 2777, 22, 34, 28, 3, -34 },
  { 2871, 20, 34, 28, 4, -34 },
  { 2956, 22, 34, 28, 3, -34 },
  { 3050, 22, 34, 28, 3, -34 },
  { 3144, 22, 34, 28, 3, -34 },
  { 3238, 20, 34, 28, 4, -34 },
  { 3323, 23, 35, 28, 1, -34 },
  { 3424, 23, 34, 28, 3, -34 },
  { 3522, 21, 34, 28, 4, -34 },
  { 3612, 24, 34, 28, 2, -34 },
  { 3714, 22, 34, 28, 3, -34 },
  { 3808, 22, 34, 28, 3, -34 },
  { 3902, 23, 34, 28, 3, -34 },
  { 4000, 23, 42, 28, 3, -34 },
  { 4121, 23, 34, 28, 3, -34 },
  { 4219, 23, 34, 28, 2, -34 },
  { 4317, 24, 34, 28, 2, -34 },
  { 4419, 22, 34, 28, 3, -34 },
  { 4513, 25, 34, 28, 1, -34 },
  { 4620, 27, 34, 28, 0, -34 },
  { 4735, 26, 34, 28, 1, -34 },
  { 4846, 26, 34, 28, 1, -34 },
  { 4957, 21, 34, 28, 3, -34 },
  { 5047, 14, 43, 28, 8, -38 },
  { 5123, 23, 43, 28, 2, -38 },
  { 5247, 14, 43, 28, 6, -38 },
  { 5323, 22, 18, 28, 3, -34 },
  { 5373, 22, 7, 28, 3, 1 },
  { 5393, 12, 6, 28, 7, -36 },
  { 5402, 23, 26, 28, 2, -26 },
  { 5477, 22, 34, 28, 3, -34 },
  { 5571, 22, 26, 28, 3, -26 },
  { 5643, 22, 34, 28, 3, -34 },
  { 5737, 22, 26, 28, 3, -26 },
  { 5809, 23, 34, 28, 2, -34 },
  { 5907, 22, 34, 28, 3, -26 },
  { 6001, 22, 34, 28, 3, -34 },
  { 6095, 23, 36, 28, 3, -36 },
  { 6199, 18, 44, 28, 4, -36 },
  { 6298, 24, 34, 28, 3, -34 },
  { 6400, 25, 34, 28, 1, -34 },
  { 6507, 24, 26, 28, 2, -26 },
  { 6585, 22, 26, 28, 3, -26 },
  { 6657, 22, 26, 28, 3, -26 },
  { 6729, 22, 34, 28, 3, -26 },
  { 6823, 22, 34, 28, 3, -26 },
  { 6917, 22, 26, 28, 4, -26 },
  { 6989, 23, 26, 28, 2, -26 },
  { 7064, 23, 32, 28, 2, -32 },
  { 7156, 22, 25, 28, 3, -25 },
  { 7225, 25, 25, 28, 1, -25 },
  { 7304, 27, 25, 28, 0, -25 },
  { 7389, 25, 25, 28, 1, -25 },
  { 7468, 25, 33, 28, 1, -25 },
  { 7572, 21, 25, 28, 3, -25 },
  { 7638, 21, 43, 28, 3, -38 },
  { 7751, 7, 43, 28, 10, -38 },
  { 7789, 21, 43, 28, 3, -38 },
  { 7902, 24, 12, 28, 2, -22 },
};

const GFXfont JetBrainsMono_ExtraBold46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_EXTRABOLD46PT7B_H_
