#ifndef _JETBRAINSMONO_EXTRABOLD47PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFD,
  0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFB,
  0xFE, 0x7F, 0xB9, 0xFE, 0x7F, 0x38, 0xFE, 0x7F, 0x38, 0xFE, 0x7F, 0x38,
  0x00, 0x7F, 0x38, 0x00, 0x7F, 0xB8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x39,
  0xFF, 0x00, 0x38, 0xFF, 0x00, 0x38, 0x7F, 0x00, 0x38, 0x7F, 0xFE, 0x38,
  0x7F, 0xFF, 0x38, 0xFF, 0x7F, 0xB8, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x3F, 0xE0, 0x01, 0xE1, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0x80,
  0x7C, 0x3F, 0x7E, 0x03, 0xE0, 0xF0, 0x78, 0x0F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x7C, 0x07,
  0xC1, 0xF3, 0xE0, 0x0F, 0x8F, 0x9F, 0x00, 0x3F, 0xFE, 0x78, 0x00, 0x7F,
  0xF3, 0xE0, 0x01, 0xFF, 0xDF, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC1,
  0x00, 0x00, 0x1F, 0x3F, 0xC0, 0x00, 0xFB, 0xFF, 0x80, 0x07, 0xCF, 0xFF,
  0x00, 0x1E, 0x7E, 0xFC, 0x00, 0xF9, 0xF0, 0xF8, 0x07, 0xC7, 0x83, 0xE0,
  0x3E, 0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x3E, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x07, 0x83, 0xE0, 0xF0, 0x1F, 0x0F, 0x87, 0xC0, 0x7F, 0xFC, 0x3E, 0x00,
  0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0x8F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x02, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xDF, 0x87,
  0xEF, 0xEF, 0xE7, 0xF7, 0xE3, 0xFB, 0xF3, 0xF0, 0xFF, 0xF9, 0xF8, 0x7F,
  0xF8, 0xFC, 0x1F, 0xFC, 0x7E, 0x07, 0xFC, 0x3F, 0x01, 0xFE, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x83, 0xFF, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0x80, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x01, 0xF0, 0x30,
  0xF0, 0x78, 0x3C, 0x7F, 0x1E, 0x3F, 0x9F, 0xE7, 0x9F, 0xE7, 0xFE, 0xCF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0xFC, 0x0F, 0xC0, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFC, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0x0F,
  0xFF, 0x1F, 0x3F, 0xFC, 0xFC, 0xFF, 0xF3, 0xF3, 0xFF, 0xCF, 0xCF, 0xFF,
  0x3F, 0x3F, 0xFC, 0x78, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xF8, 0xFE, 0x03, 0xC3, 0xF8, 0x0E,
  0x0F, 0xE0, 0x20, 0x3F, 0x80, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0x00, 0x7E, 0x7F, 0xC1, 0xFB,
  0xFF, 0xC7, 0xEF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xF7, 0xFE,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE,
  0x3F, 0xC1, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC,
  0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xC3, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x07, 0xF9, 0xFC, 0x00, 0xE3, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE1, 0xFE, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0x7F, 0x8F, 0xC0,
  0x0F, 0xC1, 0xFE, 0x1F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xE7,
  0xFF, 0x07, 0xFD, 0xFF, 0xC3, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xC7, 0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC,
  0x7E, 0x07, 0xFF, 0x1F, 0x81, 0xFF, 0xC7, 0xE0, 0x7F, 0xF1, 0xF8, 0x1F,
  0xFC, 0x7E, 0x07, 0xFF, 0x1F, 0x81, 0xFF, 0xC7, 0xE0, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xC1, 0xFF, 0x7F, 0xF0,
  0x3F, 0x9F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xC1, 0xFF, 0xBF, 0x80,
  0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7,
  0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xF3, 0xFF, 0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xF3, 0xFF, 0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xC3, 0xDF,
  0xFB, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFF, 0xE7, 0xFF, 0xFD, 0xE7, 0xBF,
  0xFD, 0xE7, 0xBF, 0xFD, 0xF7, 0xBF, 0xFC, 0xFF, 0xBF, 0xFC, 0xFF, 0x3F,
  0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFB, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0x7C, 0x3F, 0xFD, 0xF0, 0xFF, 0xF7, 0xE3, 0xFF,
  0xCF, 0x8F, 0xFF, 0x3E, 0x3F, 0xFC, 0xFC, 0xFF, 0xF1, 0xF3, 0xFF, 0xC7,
  0xCF, 0xFF, 0x1F, 0xBF, 0xFC, 0x3E, 0xFF, 0xF0, 0xF9, 0xFF, 0xC3, 0xF7,
  0xFF, 0x07, 0xDF, 0xFC, 0x1F, 0x7F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFC, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0x81,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0,
  0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x1F, 0x83, 0xF7, 0xC1, 0xF8, 0x3F, 0x7C,
  0x1F, 0x83, 0xE7, 0xE1, 0xF8, 0x3E, 0x7E, 0x1F, 0x83, 0xE7, 0xE1, 0xF8,
  0x7E, 0x7E, 0x1F, 0xC7, 0xE7, 0xE1, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7,
  0xE3, 0xFC, 0x7E, 0x7E, 0x3D, 0xC7, 0xE3, 0xE3, 0xDC, 0x7E, 0x3E, 0x39,
  0xC7, 0xC3, 0xE3, 0x9C, 0x7C, 0x3E, 0x39, 0xC7, 0xC3, 0xE3, 0x9E, 0x7C,
  0x3F, 0x39, 0xE7, 0xC3, 0xF7, 0x9E, 0x7C, 0x3F, 0x79, 0xE7, 0xC3, 0xF7,
  0x8E, 0x7C, 0x3F, 0x78, 0xEF, 0xC1, 0xF7, 0x0E, 0xFC, 0x1F, 0x70, 0xEF,
  0x81, 0xF7, 0x0E, 0xF8, 0x1F, 0x70, 0xEF, 0x81, 0xF7, 0x0F, 0xF8, 0x1F,
  0x70, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF,
  0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF3, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x07,
  0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7E, 0xF8,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80,
  0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0xCF, 0xE0, 0x7F, 0xBF,
  0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F,
  0x1F, 0xFE, 0xFE, 0x1F, 0xF1, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC3, 0xF9, 0xFF, 0x8F, 0xEF, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xBF, 0xFC, 0xFE, 0x7F,
  0xE3, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF,
  0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF8,
  0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF1, 0xFC, 0x7F, 0xE7, 0xF3, 0xFF,
  0xDF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0x7F, 0x1F,
  0xFD, 0xFC, 0x3F, 0xC7, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFE, 0x0F, 0xEF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F,
  0x7F, 0x83, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF1, 0xFC, 0x7F, 0xE7, 0xF3, 0xFF, 0xDF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF1,
  0xFF, 0xDF, 0xC3, 0xFC, 0x7F, 0x01, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC3, 0xF9, 0xFF,
  0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0xFC, 0xF8, 0xFC, 0xFD, 0xF9, 0xFE, 0xFF, 0xFD, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC,
  0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC,
  0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC,
  0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC,
  0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC,
  0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFE, 0x3F, 0xC3, 0xF9,
  0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x3F, 0xC3, 0xF9,
  0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xBF, 0xFC, 0xFE, 0x7F, 0xE3, 0xF8, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x7F, 0xE7, 0xF3,
  0xFF, 0xDF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0x7F,
  0x1F, 0xF9, 0xFC, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x3F, 0xC1, 0xF9, 0xFF, 0xE3, 0xF3, 0xFF,
  0xE7, 0xEF, 0xFF, 0xCF, 0xDF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF,
  0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0xFC, 0x0F, 0x83, 0xF7, 0xC1, 0xF8, 0x3F, 0x7C, 0x1F, 0x83, 0xE7,
  0xE1, 0xF8, 0x3E, 0x7E, 0x1F, 0x83, 0xE7, 0xE1, 0xF8, 0x7E, 0x7E, 0x1F,
  0xC7, 0xE3, 0xE1, 0xFC, 0x7E, 0x3E, 0x3D, 0xC7, 0xE3, 0xE3, 0xDC, 0x7C,
  0x3E, 0x39, 0xC7, 0xC3, 0xF3, 0x9C, 0x7C, 0x3F, 0x39, 0xCF, 0xC3, 0xF3,
  0x9E, 0xFC, 0x1F, 0x79, 0xEF, 0xC1, 0xF7, 0x9E, 0xF8, 0x1F, 0x78, 0xEF,
  0x81, 0xF7, 0x0E, 0xF8, 0x1F, 0x70, 0xEF, 0x81, 0xFF, 0x0E, 0xF8, 0x1F,
  0xF0, 0xEF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xCF,
  0xF0, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0xFF,
  0x01, 0xFC, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xF0, 0x1F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFC, 0x7F, 0x3F, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFE, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 18, 14, 28, 5, -34 },
  { 67, 26, 34, 28, 1, -34 },
  { 178, 24, 48, 28, 2, -41 },
  { 322, 30, 35, 28, -1, -35 },
  { 454, 25, 35, 28, 2, -35 },
  { 564, 7, 14, 28, 11, -34 },
  { 577, 16, 45, 28, 7, -39 },
  { 667, 16, 45, 28, 5, -39 },
  { 757, 26, 25, 28, 1, -29 },
  { 839, 23, 23, 28, 3, -27 },
  { 906, 12, 15, 28, 7, -7 },
  { 929, 15, 7, 28, 7, -19 },
  { 943, 10, 9, 28, 9, -9 },
  { 955, 24, 44, 28, 2, -39 },
  { 1087, 22, 35, 28, 3, -35 },
  { 1184, 22, 34, 28, 4, -34 },
  { 1278, 23, 35, 28, 2, -35 },
  { 1379, 23, 34, 28, 2, -34 },
  { 1477, 22, 34, 28, 3, -34 },
  { 1571, 22, 34, 28, 3, -34 },
  { 1665, 24, 34, 28, 2, -34 },
  { 1767, 24, 34, 28, 2, -34 },
  { 1869, 24, 35, 28, 2, -35 },
  { 1974, 24, 35, 28, 2, -35 },
  { 2079, 10, 26, 28, 9, -26 },
  { 2112, 12, 34, 28, 7, -26 },
  { 2163, 22, 27, 28, 3, -29 },
  { 2238, 20, 19, 28, 4, -25 },
  { 2286, 22, 27, 28, 3, -29 },
  { 2361, 19, 34, 28, 5, -34 },
  { 2442, 26, 43, 28, 1, -35 },
  { 2582, 26, 34, 28, 1, -34 },
  { 2693, 23, 34, 28, 3, -34 },
  { 2791, 23, 35, 28, 3, -35 },
  { 2892, 23, 34, 28, 3, -34 },
  { 2990, 21, 34, 28, 4, -34 },
  { 3080, 22, 34, 28, 3, -34 },
  { 3174, 23, 35, 28, 3, -35 },
  { 3275, 22, 34, 28, 3, -34 },
  { 3369, 20, 34, 28, 4, -34 },
  { 3454, 23, 35, 28, 1, -34 },
  { 3555, 24, 34, 28, 3, -34 },
  { 3657, 21, 34, 28, 4, -34 },
  { 3747, 24, 34, 28, 2, -34 },
  { 3849, 22, 34, 28, 3, -34 },
  { 3943, 22, 35, 28, 3, -35 },
  { 4040, 24, 34, 28, 3, -34 },
  { 4142, 23, 43, 28, 3, -35 },
  { 4266, 24, 34, 28, 3, -34 },
  { 4368, 24, 35, 28, 2, -35 },
  { 4473, 24, 34, 28, 2, -34 },
  { 4575, 22, 34, 28, 3, -34 },
  { 4669, 26, 34, 28, 1, -34 },
  { 4780, 28, 34, 28, 0, -34 },
  { 4899, 26, 34, 28, 1, -34 },
  { 5010, 27, 34, 28, 1, -34 },
  { 5125, 21, 34, 28, 4, -34 },
  { 5215, 14, 44, 28, 8, -39 },
  { 5292, 24, 44, 28, 2, -39 },
  { 5424, 14, 44, 28, 6, -39 },
  { 5501, 22, 18, 28, 3, -34 },
  { 5551, 22, 7, 28, 3, 1 },
  { 5571, 13, 7, 28, 7, -37 },
  { 5583, 23, 26, 28, 2, -26 },
  { 5658, 22, 34, 28, 3, -34 },
  { 5752, 23, 26, 28, 3, -26 },
  { 5827, 22, 34, 28, 3, -34 },
  { 5921, 22, 26, 28, 3, -26 },
  { 5993, 24, 34, 28, 2, -34 },
  { 6095, 22, 34, 28, 3, -26 },
  { 6189, 22, 34, 28, 3, -34 },
  { 6283, 23, 37, 28, 3, -37 },
  { 6390, 19, 45, 28, 4, -37 },
  { 6497, 24, 34, 28, 3, -34 },
  { 6599, 26, 34, 28, 1, -34 },
  { 6710, 24, 26, 28, 2, -26 },
  { 6788, 22, 26, 28, 3, -26 },
  { 6860, 22, 26, 28, 3, -26 },
  { 6932, 22, 34, 28, 3, -26 },
  { 7026, 22, 34, 28, 3, -26 },
  { 7120, 23, 26, 28, 4, -26 },
  { 7195, 24, 26, 28, 2, -26 },
  { 7273, 23, 33, 28, 2, -33 },
  { 7368, 22, 26, 28, 3, -26 },
  { 7440, 26, 26, 28, 1, -26 },
  { 7525, 28, 26, 28, 0, -26 },
  { 7616, 26, 26, 28, 1, -26 },
  { 7701, 26, 34, 28, 1, -26 },
  { 7812, 22, 26, 28, 3, -26 },
  { 7884, 21, 44, 28, 4, -39 },
  { 8000, 7, 44, 28, 11, -39 },
  { 8039, 21, 44, 28, 4, -39 },
  { 8155, 24, 12, 28, 2, -23 },
};

const GFXfont JetBrainsMono_ExtraBold47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_EXTRABOLD47PT7B_H_
