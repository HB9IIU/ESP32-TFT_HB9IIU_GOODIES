#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x18,
  0xC0, 0x86, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x10, 0xC0, 0x84, 0x0C, 0x20,
  0x63, 0x02, 0x18, 0x10, 0xC0, 0x84, 0x0C, 0x20, 0x61, 0x02, 0x18, 0x10,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x08, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x02,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00,
  0x40, 0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0x60, 0x60, 0x00, 0x20, 0x30, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x02, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x08, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xE1,
  0x07, 0x00, 0xE0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x10, 0x10, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x06, 0x20, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x04, 0x04, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x20, 0x60, 0x00,
  0x30, 0x60, 0x10, 0x18, 0x70, 0x0F, 0x0C, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x0C, 0x07, 0x08, 0x00, 0xC0, 0x60, 0xC0, 0x18,
  0x0C, 0x0C, 0x01, 0x80, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x0C,
  0x06, 0x00, 0xC1, 0x80, 0x60, 0x08, 0x18, 0x06, 0x01, 0x83, 0x00, 0x60,
  0x18, 0x30, 0x04, 0x01, 0x86, 0x00, 0xC0, 0x18, 0x60, 0x0C, 0x01, 0x0C,
  0x00, 0xC0, 0x30, 0xC0, 0x0C, 0x03, 0x18, 0x7E, 0xC0, 0x31, 0x8E, 0x6C,
  0x06, 0x31, 0xC3, 0xC0, 0x63, 0x18, 0x3C, 0x0C, 0x63, 0x03, 0xC0, 0xC6,
  0x30, 0x3C, 0x18, 0xC6, 0x03, 0x63, 0x0C, 0x60, 0x37, 0xF1, 0x8C, 0x03,
  0x3C, 0x18, 0xC0, 0x30, 0x03, 0x0C, 0x03, 0x00, 0x30, 0x80, 0x30, 0x06,
  0x18, 0x03, 0x00, 0x61, 0x80, 0x20, 0x0C, 0x18, 0x06, 0x00, 0xC1, 0x80,
  0x60, 0x18, 0x10, 0x06, 0x01, 0x81, 0x00, 0x60, 0x30, 0x30, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0x20, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x18, 0x0C, 0x03, 0x01, 0x00, 0x80, 0x30, 0x30, 0x18, 0x01, 0x06, 0x01,
  0x00, 0x18, 0xC0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x06, 0x18, 0x00, 0x60, 0x40, 0x03, 0x03, 0x00,
  0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40, 0x20, 0x02, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x04, 0x00, 0x60, 0x60, 0x01,
  0x03, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x19, 0x80,
  0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0x90, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x10,
  0xC0, 0x81, 0x0C, 0x06, 0x08, 0x60, 0x30, 0xC6, 0x01, 0x86, 0x20, 0x04,
  0x23, 0x00, 0x33, 0x18, 0x01, 0x98, 0x80, 0x0D, 0x8C, 0x00, 0x2C, 0x60,
  0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x38,
  0x30, 0x01, 0x60, 0xC0, 0x1B, 0x06, 0x01, 0x88, 0x18, 0x38, 0x40, 0x7F,
  0x83, 0x00, 0x60, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23, 0x18, 0xC4,
  0x21, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x80, 0x61, 0x80,
  0x31, 0x01, 0x0D, 0x1F, 0x03, 0xF0, 0x03, 0x00, 0x06, 0x80, 0x08, 0xC0,
  0x30, 0x40, 0x60, 0x60, 0xC0, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x03,
  0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF,
  0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0x0E, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x60,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x20,
  0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x20, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x04, 0x02, 0x00, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x02, 0x03, 0x00, 0x18, 0x70, 0x00, 0x7F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x0D, 0x83, 0x31, 0xC4, 0x71, 0xB8,
  0x32, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x70, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1E,
  0x03, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x08, 0x00, 0x60,
  0x07, 0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x24, 0x00, 0x00, 0x64, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x10, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x20, 0x00, 0x40,
  0x20, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x40, 0x02, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x60, 0x01, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0xC0,
  0x0E, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC7, 0xF0, 0x01, 0x1E, 0x70, 0x06, 0x60,
  0x30, 0x0D, 0x80, 0x30, 0x1E, 0x00, 0x60, 0x38, 0x00, 0x60, 0xE0, 0x00,
  0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x60, 0x80, 0x00, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0x40, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x70, 0x03, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x38, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x01,
  0x00, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x02, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x40, 0x30, 0x00, 0x60, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE6, 0x00, 0x03, 0x83, 0x00, 0x07,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x38, 0x00, 0x40, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x20, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x38, 0x03, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0x03, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x20, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x20, 0x00, 0xE0, 0x80, 0x03, 0x83, 0x00, 0x1E, 0x0C,
  0x00, 0xD0, 0x18, 0x06, 0xC0, 0x70, 0x33, 0x00, 0xFF, 0x8C, 0x00, 0xF8,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x02, 0x07, 0x00, 0x0F,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x70, 0x38, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x0F, 0xE0, 0xC3, 0x00, 0xF3, 0x03, 0x18, 0x06, 0x0C,
  0x0C, 0x60, 0x30, 0x30, 0x31, 0x80, 0xC0, 0xC0, 0xCC, 0x06, 0x02, 0x03,
  0x30, 0x18, 0x18, 0x08, 0xC0, 0xC0, 0x60, 0x22, 0x03, 0x01, 0x81, 0x98,
  0x18, 0x0C, 0x06, 0x60, 0x60, 0x30, 0x19, 0x81, 0x80, 0xC0, 0x64, 0x04,
  0x03, 0x01, 0x10, 0x30, 0x18, 0x0C, 0xC0, 0xC0, 0x60, 0x33, 0x03, 0x01,
  0x80, 0x8C, 0x0C, 0x06, 0x06, 0x30, 0x20, 0x30, 0x18, 0xC0, 0x80, 0xC0,
  0x43, 0x02, 0x07, 0x03, 0x08, 0x08, 0x14, 0x0C, 0x20, 0x30, 0xD0, 0x60,
  0x80, 0xC2, 0x43, 0x02, 0x03, 0x19, 0x9C, 0x08, 0x07, 0xC7, 0xE0, 0x20,
  0x04, 0x04, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00,
  0x13, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x34,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xF8, 0x00,
  0x10, 0x1E, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x02, 0x00, 0x18, 0x01, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x10, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x20,
  0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x18, 0x3E, 0x00, 0x0C, 0x01, 0xC0, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x08, 0x01,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0x80, 0x40, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x10, 0x3C, 0x00, 0x18, 0x03, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x00, 0x06,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00,
  0x20, 0x30, 0x00, 0x10, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x06, 0x00,
  0x02, 0x02, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x03, 0x02, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x04, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x00, 0x80, 0x03, 0x80, 0x40, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x08, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x38, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x03, 0x00, 0x07, 0xF8,
  0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18,
  0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x10, 0x01, 0x00, 0x00, 0x40, 0x04, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x04, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x20, 0x02,
  0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x40, 0x04, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x20, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x04, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x70, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x08, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01,
  0xB6, 0x00, 0x00, 0x34, 0xC0, 0x00, 0x05, 0x18, 0x00, 0x01, 0xC1, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10,
  0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00,
  0x40, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x01, 0xA0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0B, 0x00, 0x00, 0x0D, 0x80,
  0x16, 0x00, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x00, 0x24, 0x00, 0xD8, 0x00,
  0x00, 0xD8, 0x01, 0xB0, 0x00, 0x01, 0x30, 0x02, 0x60, 0x00, 0x06, 0x60,
  0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x18, 0x80, 0x00, 0x31, 0x00, 0x31, 0x00,
  0x00, 0x66, 0x00, 0x62, 0x00, 0x01, 0x8C, 0x00, 0x84, 0x00, 0x03, 0x18,
  0x03, 0x08, 0x00, 0x0C, 0x20, 0x06, 0x10, 0x00, 0x18, 0x40, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x10, 0x60, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x06, 0x08, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x30, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC0,
  0xC0, 0x30, 0x18, 0x01, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x0C, 0x02, 0x03, 0x00, 0x80, 0x18, 0x04, 0x04, 0x03, 0x00, 0x20,
  0x08, 0x18, 0x06, 0x00, 0x40, 0x10, 0x20, 0x0C, 0x01, 0x80, 0x20, 0xC0,
  0x10, 0x03, 0x00, 0x41, 0x00, 0x20, 0x06, 0x00, 0xC6, 0x00, 0xC0, 0x08,
  0x01, 0x8C, 0x01, 0x80, 0x30, 0x03, 0x30, 0x03, 0x00, 0x60, 0x06, 0x60,
  0x04, 0x00, 0xC0, 0x0D, 0x80, 0x18, 0x01, 0x80, 0x1B, 0x00, 0x30, 0x02,
  0x00, 0x3C, 0x00, 0x60, 0x0C, 0x00, 0x78, 0x00, 0xC0, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x08, 0x01,
  0xE0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x60, 0x07, 0x80, 0x00, 0xC0, 0x09,
  0x00, 0x01, 0x80, 0x12, 0x00, 0x02, 0x00, 0x66, 0x00, 0x0C, 0x00, 0xCC,
  0x00, 0x18, 0x01, 0x98, 0x00, 0x30, 0x02, 0x30, 0x00, 0x60, 0x0C, 0x20,
  0x00, 0x80, 0x18, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x61, 0x80,
  0x0C, 0x00, 0x83, 0x00, 0x18, 0x03, 0x02, 0x00, 0x20, 0x06, 0x04, 0x00,
  0xC0, 0x0C, 0x0C, 0x01, 0x80, 0x18, 0x18, 0x03, 0x00, 0x20, 0x30, 0x04,
  0x00, 0xC0, 0x60, 0x18, 0x01, 0x80, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x60,
  0x04, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x00, 0x30, 0x06, 0x06, 0x00,
  0x60, 0x04, 0x0C, 0x00, 0xC0, 0x08, 0x18, 0x01, 0x00, 0x18, 0x30, 0x06,
  0x00, 0x30, 0x40, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x00, 0x86, 0x00, 0x40, 0x01, 0x88, 0x01, 0x80, 0x03, 0x30, 0x03, 0x00,
  0x06, 0x60, 0x06, 0x00, 0x0C, 0xC0, 0x08, 0x00, 0x09, 0x80, 0x30, 0x00,
  0x1A, 0x00, 0x60, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x78, 0x01, 0x80, 0x00,
  0xF0, 0x02, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x08, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x02,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x78, 0x00, 0x60, 0x1C, 0x00,
  0x60, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x02, 0x01, 0x80, 0x06, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x18, 0x02, 0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x06,
  0x01, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0xF8, 0x00,
  0x60, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x02, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x06, 0x01, 0x00, 0x06, 0x03, 0x00, 0x04, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x06, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x04, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x10,
  0x06, 0x00, 0x30, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x03, 0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0x60, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x02,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x80, 0x03,
  0x00, 0x3C, 0x03, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x08, 0x00, 0x04,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x10, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x40, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x20, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x40, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x80, 0x00, 0xCC, 0x00, 0x05, 0x00, 0x01, 0x98, 0x00,
  0x1A, 0x00, 0x06, 0x30, 0x00, 0x34, 0x00, 0x0C, 0x60, 0x00, 0x48, 0x00,
  0x30, 0xC0, 0x01, 0x90, 0x00, 0x61, 0x80, 0x03, 0x20, 0x00, 0xC3, 0x00,
  0x0C, 0x40, 0x03, 0x06, 0x00, 0x18, 0x80, 0x06, 0x0C, 0x00, 0x23, 0x00,
  0x18, 0x18, 0x00, 0xC6, 0x00, 0x30, 0x30, 0x01, 0x8C, 0x00, 0x60, 0x60,
  0x06, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x30, 0x03, 0x01, 0x80, 0x10, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x0C,
  0x01, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x06, 0x01, 0x80, 0x30, 0x08, 0x0C,
  0x02, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x01,
  0x80, 0x80, 0x60, 0x60, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x01,
  0x81, 0x00, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x18, 0x30, 0x06, 0x0C, 0x00,
  0x30, 0x40, 0x08, 0x30, 0x00, 0x61, 0x80, 0x10, 0x60, 0x00, 0xC3, 0x00,
  0x20, 0x80, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x03, 0x18, 0x00, 0x84, 0x00,
  0x06, 0x20, 0x01, 0x18, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x00, 0x19, 0x80,
  0x04, 0x40, 0x00, 0x36, 0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x12, 0x00,
  0x00, 0x90, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0xD8, 0x00, 0x02, 0xC0,
  0x01, 0xA0, 0x00, 0x05, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x08,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x04, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x36, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x20, 0x00,
  0xC3, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x10, 0x0C, 0x01, 0x01, 0x80, 0x10,
  0x18, 0x01, 0x03, 0x00, 0x10, 0x30, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x8C, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x19, 0x00, 0x00, 0xB0, 0x00,
  0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x80, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x40, 0x00, 0x1F, 0x00,
  0x01, 0xFE, 0x30, 0x0E, 0x0C, 0xC0, 0x60, 0x1A, 0x03, 0x00, 0x68, 0x18,
  0x00, 0xA0, 0x60, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x30,
  0x00, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0xF0, 0x18, 0x06,
  0xC0, 0x60, 0x32, 0x00, 0xC1, 0x88, 0x01, 0xFC, 0x60, 0x01, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x63, 0xFC, 0x01, 0x98, 0x38, 0x06,
  0xC0, 0x60, 0x16, 0x00, 0xC0, 0x50, 0x03, 0x03, 0xC0, 0x0C, 0x0E, 0x00,
  0x10, 0x38, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x18, 0x00, 0x10,
  0x60, 0x00, 0x41, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C,
  0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0E, 0x00,
  0x30, 0x78, 0x01, 0x81, 0xA0, 0x0C, 0x04, 0xC0, 0x60, 0x13, 0x83, 0x00,
  0xC7, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x38,
  0x20, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x1C, 0x10, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x30, 0x00, 0xFF,
  0x18, 0x00, 0xE0, 0xCC, 0x00, 0xC0, 0x34, 0x00, 0xC0, 0x1A, 0x00, 0xC0,
  0x07, 0x00, 0x60, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0x40, 0x00, 0x40, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01,
  0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0xB0, 0x03, 0x00, 0xD8, 0x01, 0x80,
  0xC8, 0x00, 0x60, 0xC4, 0x00, 0x1F, 0xC6, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0C, 0x18, 0x06, 0x03, 0x03, 0x00, 0xC1,
  0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x03, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0xE0,
  0x40, 0xF0, 0x3F, 0xF0, 0x0F, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x08, 0x0E, 0x0E, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF8, 0xC0, 0x07, 0x06, 0x60, 0x06, 0x01, 0xA0, 0x06, 0x00,
  0xD0, 0x06, 0x00, 0x28, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x0E, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x07, 0x80, 0x18, 0x06,
  0xC0, 0x0C, 0x06, 0x40, 0x03, 0x06, 0x60, 0x00, 0xFE, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01,
  0x00, 0x30, 0x00, 0xE0, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x0F, 0x00, 0x11, 0xFE, 0x01, 0xB8, 0x38, 0x0D, 0x00,
  0xC0, 0x58, 0x02, 0x03, 0x80, 0x10, 0x38, 0x00, 0x81, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x04,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30,
  0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x60, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x40, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x00, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80,
  0x01, 0x8C, 0x00, 0x04, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xCF, 0x00, 0x03,
  0x6C, 0x00, 0x0F, 0x10, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x40, 0x60, 0x01, 0x00, 0x80, 0x0C, 0x02, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0xCF, 0xF0, 0xFF, 0x80, 0x6C, 0x0C, 0xE0, 0xE0, 0x3C, 0x02,
  0xC0, 0x30, 0x14, 0x01, 0xE0, 0x08, 0x0E, 0x00, 0xE0, 0x04, 0x0E, 0x00,
  0x60, 0x02, 0x07, 0x00, 0x30, 0x01, 0x03, 0x00, 0x18, 0x01, 0x81, 0x80,
  0x08, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x00, 0x10, 0x30, 0x01, 0x80, 0x18, 0x10, 0x00, 0x80, 0x0C, 0x18,
  0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x03, 0x06, 0x00, 0x30, 0x01, 0x03,
  0x00, 0x10, 0x01, 0x81, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x00, 0x20, 0x60, 0x03, 0x00, 0x10, 0x30, 0x01, 0x00, 0x18,
  0x10, 0x01, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x02,
  0x06, 0x00, 0x20, 0x03, 0x02, 0x00, 0x10, 0x01, 0x81, 0x00, 0x18, 0x00,
  0xC1, 0x80, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x20, 0x60, 0x02, 0x00,
  0x30, 0x20, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x03,
  0xC0, 0x0C, 0x7F, 0x80, 0x6E, 0x0E, 0x03, 0x40, 0x30, 0x14, 0x01, 0x80,
  0xE0, 0x04, 0x0E, 0x00, 0x20, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18, 0x10,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18,
  0x10, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x02,
  0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x02, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x01,
  0xC1, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x02, 0x18, 0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x02,
  0x30, 0x00, 0x23, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x18, 0x03, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x04, 0x7F, 0x80, 0x03, 0x30, 0x70, 0x00, 0xD8,
  0x0C, 0x00, 0x2C, 0x01, 0x80, 0x0A, 0x00, 0x60, 0x07, 0x80, 0x08, 0x01,
  0xC0, 0x02, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00,
  0x18, 0x02, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x04, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x07, 0x00, 0x18, 0x01, 0xC0,
  0x06, 0x00, 0xF0, 0x03, 0x00, 0x34, 0x01, 0x80, 0x0D, 0x80, 0xC0, 0x03,
  0x30, 0xE0, 0x00, 0x8F, 0xF0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFE,
  0x30, 0x0C, 0x0C, 0xC0, 0x60, 0x1A, 0x03, 0x00, 0x68, 0x18, 0x00, 0xA0,
  0x60, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x82, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x04, 0x00, 0x04, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0,
  0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0xF0, 0x18, 0x06, 0xC0, 0x60,
  0x32, 0x00, 0xC1, 0x98, 0x01, 0xFC, 0x60, 0x01, 0x81, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x63, 0xF0, 0x19, 0x80, 0x04, 0xC0, 0x01, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x07, 0x01, 0x81, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x80, 0x18, 0x1C, 0x0E, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x01,
  0xFF, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x7C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x08, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x10, 0x30, 0x01,
  0x81, 0x00, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x00, 0x1C, 0x08, 0x00, 0xE0, 0x40, 0x0E, 0x03, 0x00,
  0xD0, 0x18, 0x0D, 0x80, 0xE0, 0xCC, 0x03, 0xFC, 0x40, 0x07, 0x80, 0x00,
  0x80, 0x01, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0xC8, 0x00, 0x64, 0x00,
  0x22, 0x00, 0x31, 0x00, 0x10, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x0C, 0x10,
  0x06, 0x08, 0x06, 0x04, 0x03, 0x02, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80,
  0x40, 0xC0, 0x20, 0x60, 0x10, 0x60, 0x08, 0x30, 0x04, 0x30, 0x02, 0x18,
  0x01, 0x08, 0x00, 0x8C, 0x00, 0x46, 0x00, 0x26, 0x00, 0x13, 0x00, 0x0B,
  0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xB0, 0x01, 0xC0, 0x0D,
  0x80, 0x0E, 0x00, 0x4C, 0x00, 0xF0, 0x06, 0x60, 0x05, 0x80, 0x33, 0x00,
  0x6C, 0x01, 0x18, 0x03, 0x60, 0x18, 0xC0, 0x33, 0x00, 0x86, 0x01, 0x98,
  0x0C, 0x30, 0x08, 0xC0, 0x61, 0x80, 0xC6, 0x02, 0x0C, 0x04, 0x30, 0x30,
  0x60, 0x61, 0x81, 0x03, 0x03, 0x0C, 0x18, 0x18, 0x10, 0x60, 0xC0, 0xC1,
  0x83, 0x04, 0x06, 0x08, 0x10, 0x60, 0x30, 0xC0, 0x83, 0x01, 0x86, 0x04,
  0x10, 0x0C, 0x20, 0x21, 0x80, 0x43, 0x01, 0x08, 0x02, 0x10, 0x08, 0xC0,
  0x11, 0x80, 0x46, 0x00, 0x8C, 0x02, 0x20, 0x04, 0xC0, 0x13, 0x00, 0x26,
  0x00, 0x90, 0x01, 0x20, 0x05, 0x80, 0x0B, 0x00, 0x2C, 0x00, 0x58, 0x01,
  0x40, 0x02, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x40, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x20, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x31, 0x00, 0x00, 0x13, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x84, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x02, 0x00, 0x0C, 0x02, 0x00, 0x08, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x4F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0x00, 0x16, 0x07, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x0F,
  0xF0, 0x00, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 46, 13, 1, -46 },
  { 70, 13, 16, 17, 6, -46 },
  { 96, 25, 46, 24, 0, -46 },
  { 240, 25, 53, 22, -1, -49 },
  { 406, 28, 48, 34, 3, -47 },
  { 574, 21, 48, 21, -1, -47 },
  { 700, 5, 16, 9, 6, -46 },
  { 710, 17, 56, 16, 2, -46 },
  { 829, 17, 56, 16, -4, -46 },
  { 948, 16, 17, 21, 8, -49 },
  { 982, 22, 30, 26, 2, -38 },
  { 1065, 8, 14, 10, -3, -6 },
  { 1079, 13, 1, 17, 2, -18 },
  { 1081, 3, 4, 10, 1, -4 },
  { 1083, 26, 46, 19, -3, -46 },
  { 1233, 21, 48, 22, 1, -47 },
  { 1359, 11, 46, 22, 7, -46 },
  { 1423, 24, 47, 22, -2, -47 },
  { 1564, 25, 48, 22, -2, -47 },
  { 1714, 24, 47, 22, -1, -47 },
  { 1855, 25, 47, 22, -2, -46 },
  { 2002, 23, 48, 22, 1, -47 },
  { 2140, 23, 46, 22, 2, -46 },
  { 2273, 24, 48, 22, -1, -47 },
  { 2417, 22, 48, 22, 0, -47 },
  { 2549, 10, 34, 10, 0, -34 },
  { 2592, 13, 42, 10, -3, -34 },
  { 2661, 22, 26, 26, 2, -36 },
  { 2733, 22, 16, 26, 2, -31 },
  { 2777, 22, 26, 26, 2, -36 },
  { 2849, 17, 47, 16, 1, -47 },
  { 2949, 30, 53, 33, 2, -47 },
  { 3148, 21, 47, 21, -4, -47 },
  { 3272, 25, 46, 24, 0, -46 },
  { 3416, 25, 48, 22, 2, -47 },
  { 3566, 25, 46, 27, 0, -46 },
  { 3710, 25, 46, 22, 0, -46 },
  { 3854, 25, 46, 20, 0, -46 },
  { 3998, 29, 48, 29, 2, -47 },
  { 4172, 30, 46, 29, 0, -46 },
  { 4345, 19, 46, 11, -4, -46 },
  { 4455, 21, 57, 10, -9, -46 },
  { 4605, 27, 46, 22, 0, -46 },
  { 4761, 14, 46, 20, 0, -46 },
  { 4842, 39, 46, 38, 0, -46 },
  { 5067, 31, 46, 30, 0, -46 },
  { 5246, 26, 48, 29, 2, -47 },
  { 5402, 24, 46, 23, 0, -46 },
  { 5540, 26, 58, 29, 2, -47 },
  { 5729, 24, 46, 23, 0, -46 },
  { 5867, 26, 48, 22, -2, -47 },
  { 6023, 20, 46, 19, 4, -46 },
  { 6138, 27, 47, 28, 2, -46 },
  { 6297, 23, 46, 22, 5, -46 },
  { 6430, 39, 46, 39, 5, -46 },
  { 6655, 28, 46, 20, -4, -46 },
  { 6816, 20, 46, 19, 4, -46 },
  { 6931, 27, 46, 20, -3, -46 },
  { 7087, 23, 56, 18, -1, -46 },
  { 7248, 8, 46, 21, 7, -46 },
  { 7294, 23, 56, 18, -4, -46 },
  { 7455, 23, 22, 25, 2, -46 },
  { 7519, 17, 2, 17, -5, 6 },
  { 7524, 6, 11, 13, 9, -50 },
  { 7533, 22, 36, 25, 2, -35 },
  { 7632, 22, 50, 24, 0, -49 },
  { 7770, 17, 36, 17, 2, -35 },
  { 7847, 25, 50, 25, 2, -49 },
  { 8004, 18, 36, 21, 2, -35 },
  { 8085, 29, 66, 12, -9, -50 },
  { 8325, 25, 51, 25, -1, -35 },
  { 8485, 21, 49, 23, 0, -49 },
  { 8614, 12, 46, 10, 0, -46 },
  { 8683, 22, 62, 10, -9, -46 },
  { 8854, 22, 49, 19, 0, -49 },
  { 8989, 13, 49, 10, 0, -49 },
  { 9069, 33, 35, 35, 0, -35 },
  { 9214, 21, 35, 23, 0, -35 },
  { 9306, 20, 36, 23, 2, -35 },
  { 9396, 26, 50, 24, -3, -35 },
  { 9559, 22, 50, 25, 2, -35 },
  { 9697, 18, 35, 15, 0, -35 },
  { 9776, 19, 36, 18, -1, -35 },
  { 9862, 12, 44, 12, 1, -43 },
  { 9928, 21, 35, 23, 2, -34 },
  { 10020, 17, 34, 18, 4, -34 },
  { 10093, 29, 34, 30, 4, -34 },
  { 10217, 24, 34, 18, -3, -34 },
  { 10319, 29, 50, 19, -7, -34 },
  { 10501, 19, 34, 15, -2, -34 },
  { 10582, 22, 56, 20, 2, -46 },
  { 10736, 2, 65, 22, 10, -49 },
  { 10753, 22, 56, 20, -4, -46 },
  { 10907, 22, 6, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC65PT7B_H_
