#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x42, 0x00, 0x6E, 0xD0, 0x14, 0x52, 0x9F, 0x29,
  0x45, 0x3E, 0xA2, 0x8A, 0x00, 0x11, 0xD4, 0xA6, 0x10, 0xC6, 0x32, 0xB8,
  0x80, 0x66, 0x9A, 0xAA, 0xB7, 0x7B, 0x4D, 0x55, 0x59, 0x80, 0x31, 0x54,
  0xA2, 0x11, 0x95, 0x94, 0xBC, 0x5A, 0x11, 0x24, 0x44, 0x88, 0x88, 0x88,
  0x40, 0x21, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x5F, 0x10, 0x20, 0x82,
  0x3F, 0x20, 0x82, 0x00, 0x58, 0xF0, 0x80, 0x04, 0x10, 0x42, 0x10, 0x42,
  0x08, 0x41, 0x08, 0x00, 0x19, 0x52, 0x94, 0xC6, 0x31, 0x94, 0xB8, 0x75,
  0x6A, 0xA8, 0x18, 0x10, 0x41, 0x04, 0x20, 0x84, 0x21, 0x0F, 0x80, 0x38,
  0x42, 0x10, 0x98, 0x42, 0x10, 0xB8, 0x08, 0xC6, 0x52, 0xAA, 0x52, 0x78,
  0x88, 0x3A, 0x10, 0x86, 0x08, 0x21, 0x10, 0xB8, 0x19, 0x10, 0x87, 0x26,
  0x31, 0x8C, 0xBC, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x84, 0x20, 0x3A, 0x52,
  0x93, 0x93, 0x52, 0x8C, 0xBC, 0x32, 0x52, 0x98, 0xA5, 0xE1, 0x10, 0xB8,
  0x40, 0x02, 0x20, 0x00, 0x02, 0x50, 0x1D, 0x88, 0x18, 0x18, 0x10, 0xFC,
  0x00, 0x3F, 0xE0, 0x40, 0xC6, 0x62, 0x00, 0x71, 0x11, 0x22, 0x44, 0x80,
  0x80, 0x1C, 0x44, 0x8A, 0x75, 0x75, 0x6A, 0xD5, 0xBD, 0x02, 0x03, 0x80,
  0x08, 0x46, 0x32, 0x94, 0xE9, 0x4C, 0x62, 0x38, 0x92, 0x51, 0x49, 0xC4,
  0xA2, 0x8A, 0x2F, 0x00, 0x3A, 0x11, 0x08, 0x42, 0x10, 0x84, 0x38, 0x38,
  0x92, 0x51, 0x45, 0x14, 0x62, 0x8A, 0x4E, 0x00, 0x3C, 0x82, 0x10, 0x41,
  0xC4, 0x20, 0x82, 0x0E, 0x00, 0x3C, 0x82, 0x10, 0x41, 0xC4, 0x20, 0x82,
  0x08, 0x00, 0x3D, 0x08, 0x20, 0x82, 0x48, 0xA2, 0x8A, 0x2F, 0x00, 0x22,
  0x44, 0x8A, 0x24, 0x4F, 0x91, 0x42, 0x89, 0x12, 0x20, 0x38, 0x84, 0x42,
  0x10, 0x88, 0x42, 0x30, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x40, 0x24, 0x92, 0x94, 0x61, 0x86, 0x24, 0x92, 0x49, 0x00, 0x24, 0xA4,
  0x94, 0x93, 0x80, 0x20, 0x90, 0x48, 0x6C, 0x26, 0x33, 0x19, 0x55, 0x2A,
  0x99, 0x49, 0x24, 0x80, 0x22, 0x44, 0x8A, 0x95, 0x2A, 0x95, 0x4A, 0x89,
  0x12, 0x20, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xB8, 0x31, 0x4A, 0x94,
  0xAD, 0x90, 0x84, 0x20, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xB8, 0x42,
  0x10, 0x31, 0x4A, 0x94, 0xAD, 0x92, 0x94, 0xA4, 0x3D, 0x04, 0x10, 0x40,
  0x81, 0x04, 0x10, 0x4E, 0x00, 0xF9, 0x10, 0x84, 0x21, 0x10, 0x84, 0x20,
  0x22, 0x45, 0x12, 0x24, 0x48, 0x91, 0x44, 0x89, 0x11, 0xC0, 0x8C, 0x63,
  0x29, 0x52, 0x94, 0xC4, 0x20, 0x88, 0xC4, 0x62, 0x53, 0x29, 0x95, 0x52,
  0xA9, 0x98, 0xCC, 0x44, 0x22, 0x00, 0x22, 0x28, 0x50, 0xC1, 0x02, 0x0C,
  0x18, 0x50, 0xA2, 0x20, 0x8C, 0xA5, 0x4A, 0x21, 0x10, 0x84, 0x20, 0x1C,
  0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x0F, 0x00, 0x39, 0x08, 0x44, 0x21,
  0x08, 0x84, 0x21, 0x0C, 0x00, 0xAA, 0xAA, 0x94, 0x18, 0x42, 0x10, 0x84,
  0x42, 0x10, 0x88, 0x4E, 0x00, 0x10, 0xC2, 0x92, 0xC4, 0xF0, 0x90, 0x3D,
  0x24, 0xA2, 0x8A, 0x29, 0x1C, 0x21, 0x08, 0xF4, 0xA5, 0x29, 0x8C, 0xBC,
  0x34, 0x48, 0x88, 0x86, 0x04, 0x10, 0x4E, 0x49, 0x28, 0xA2, 0x8A, 0x47,
  0x00, 0x3A, 0x53, 0x6C, 0x42, 0x0E, 0x0E, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x20, 0x00, 0x3D, 0x24, 0xA2, 0x8A,
  0x29, 0x1C, 0x10, 0x42, 0x30, 0x21, 0x08, 0x74, 0xA5, 0x29, 0x94, 0xA4,
  0x20, 0x24, 0x92, 0x92, 0x00, 0x08, 0x00, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x22, 0x00, 0x21, 0x08, 0x95, 0x31, 0x8C, 0xA4, 0xA4, 0x24, 0xA4,
  0x92, 0x92, 0x00, 0x3F, 0x49, 0x49, 0x49, 0x52, 0x92, 0x92, 0x92, 0x3A,
  0x52, 0x94, 0xCA, 0x52, 0x3A, 0x53, 0x18, 0xC6, 0x5E, 0x3C, 0x92, 0x49,
  0x25, 0x14, 0x9E, 0x42, 0x08, 0x00, 0x3D, 0x24, 0xA2, 0x8A, 0x29, 0x3C,
  0x10, 0x41, 0x08, 0x34, 0x44, 0x48, 0x88, 0x74, 0x44, 0x22, 0x2E, 0x29,
  0xA4, 0xA4, 0x98, 0x4A, 0x52, 0x98, 0xCA, 0x5E, 0x9A, 0xAA, 0xC8, 0x88,
  0x93, 0x2A, 0xD6, 0xAD, 0x92, 0x24, 0x48, 0x24, 0xA2, 0x84, 0x20, 0xC5,
  0x24, 0x12, 0x24, 0x50, 0xA1, 0x43, 0x04, 0x08, 0x10, 0x40, 0x86, 0x00,
  0x38, 0x44, 0x22, 0x21, 0x1C, 0x0C, 0x41, 0x08, 0x20, 0x84, 0x30, 0x41,
  0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x42, 0x11, 0x08, 0x62, 0x21, 0x08,
  0x4C, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 4, 1, -11 },
  { 8, 6, 11, 5, 0, -11 },
  { 17, 5, 12, 5, 0, -11 },
  { 25, 6, 11, 8, 1, -11 },
  { 34, 5, 11, 5, 0, -11 },
  { 41, 2, 4, 2, 1, -11 },
  { 42, 4, 13, 4, 0, -11 },
  { 49, 4, 13, 4, -1, -11 },
  { 56, 3, 4, 5, 2, -11 },
  { 58, 6, 7, 6, 0, -9 },
  { 64, 2, 3, 2, -1, -1 },
  { 65, 4, 1, 4, 0, -5 },
  { 66, 1, 1, 2, 0, -1 },
  { 67, 6, 11, 4, -1, -11 },
  { 76, 5, 11, 5, 0, -11 },
  { 83, 2, 11, 5, 2, -11 },
  { 86, 6, 11, 5, -1, -11 },
  { 95, 5, 11, 5, 0, -11 },
  { 102, 5, 11, 5, 0, -11 },
  { 109, 5, 11, 5, 0, -11 },
  { 116, 5, 11, 5, 0, -11 },
  { 123, 5, 11, 5, 1, -11 },
  { 130, 5, 11, 5, 0, -11 },
  { 137, 5, 11, 5, 0, -11 },
  { 144, 2, 8, 2, 0, -8 },
  { 146, 3, 10, 2, -1, -8 },
  { 150, 6, 6, 6, 0, -8 },
  { 155, 6, 4, 6, 0, -7 },
  { 158, 6, 6, 6, 0, -8 },
  { 163, 4, 11, 4, 0, -11 },
  { 169, 7, 12, 8, 0, -11 },
  { 180, 5, 11, 5, -1, -11 },
  { 187, 6, 11, 6, 0, -11 },
  { 196, 5, 11, 5, 1, -11 },
  { 203, 6, 11, 6, 0, -11 },
  { 212, 6, 11, 5, 0, -11 },
  { 221, 6, 11, 5, 0, -11 },
  { 230, 6, 11, 7, 1, -11 },
  { 239, 7, 11, 7, 0, -11 },
  { 249, 5, 11, 2, -1, -11 },
  { 256, 5, 14, 2, -2, -11 },
  { 265, 6, 11, 5, 0, -11 },
  { 274, 3, 11, 5, 0, -11 },
  { 279, 9, 11, 9, 0, -11 },
  { 292, 7, 11, 7, 0, -11 },
  { 302, 5, 11, 7, 1, -11 },
  { 309, 5, 11, 5, 0, -11 },
  { 316, 5, 14, 7, 1, -11 },
  { 325, 5, 11, 5, 0, -11 },
  { 332, 6, 11, 5, 0, -11 },
  { 341, 5, 11, 4, 1, -11 },
  { 348, 7, 11, 6, 0, -11 },
  { 358, 5, 11, 5, 1, -11 },
  { 365, 9, 11, 9, 1, -11 },
  { 378, 7, 11, 5, -1, -11 },
  { 388, 5, 11, 4, 1, -11 },
  { 395, 6, 11, 5, -1, -11 },
  { 404, 5, 13, 4, 0, -11 },
  { 413, 2, 11, 5, 2, -11 },
  { 416, 5, 13, 4, -1, -11 },
  { 425, 6, 5, 6, 0, -11 },
  { 429, 4, 1, 4, -1, 1 },
  { 430, 2, 2, 3, 2, -11 },
  { 431, 6, 8, 6, 0, -8 },
  { 437, 5, 11, 6, 0, -11 },
  { 444, 4, 8, 4, 0, -8 },
  { 448, 6, 11, 6, 0, -11 },
  { 457, 5, 8, 5, 0, -8 },
  { 462, 7, 15, 3, -2, -11 },
  { 476, 6, 12, 6, 0, -8 },
  { 485, 5, 11, 5, 0, -11 },
  { 492, 3, 11, 2, 0, -11 },
  { 497, 5, 15, 2, -2, -11 },
  { 507, 5, 11, 4, 0, -11 },
  { 514, 3, 11, 2, 0, -11 },
  { 519, 8, 8, 8, 0, -8 },
  { 527, 5, 8, 5, 0, -8 },
  { 532, 5, 8, 5, 0, -8 },
  { 537, 6, 11, 6, -1, -8 },
  { 546, 6, 12, 6, 0, -8 },
  { 555, 4, 8, 4, 0, -8 },
  { 559, 4, 8, 4, 0, -8 },
  { 563, 3, 10, 3, 0, -10 },
  { 567, 5, 8, 5, 0, -8 },
  { 572, 4, 8, 4, 1, -8 },
  { 576, 7, 8, 7, 1, -8 },
  { 583, 6, 8, 4, -1, -8 },
  { 589, 7, 12, 4, -2, -8 },
  { 600, 5, 8, 3, -1, -8 },
  { 605, 6, 13, 5, 0, -11 },
  { 615, 1, 15, 5, 2, -11 },
  { 617, 5, 13, 5, -1, -11 },
  { 626, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC15PT7B_H_
