#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x04, 0x00, 0x00, 0x00, 0x20, 0x80, 0x22, 0x44, 0x8A, 0x24,
  0x48, 0x91, 0x44, 0x88, 0x00, 0x88, 0x08, 0x40, 0x42, 0x02, 0x20, 0x21,
  0x01, 0x08, 0x08, 0x83, 0xFF, 0x04, 0x20, 0x22, 0x02, 0x10, 0x10, 0x80,
  0x88, 0x04, 0x40, 0x42, 0x02, 0x10, 0xFF, 0xE1, 0x08, 0x08, 0x40, 0x44,
  0x04, 0x20, 0x21, 0x01, 0x10, 0x10, 0x80, 0x84, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x03, 0xC0, 0x69, 0x84, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x05,
  0x80, 0x24, 0x01, 0x10, 0x08, 0x80, 0x44, 0x04, 0x20, 0x22, 0x01, 0x10,
  0x8B, 0x03, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x1E, 0x04, 0x44,
  0x10, 0x88, 0x22, 0x10, 0x84, 0x21, 0x10, 0x44, 0x20, 0x88, 0x41, 0x20,
  0x84, 0x41, 0x09, 0x02, 0x12, 0x74, 0x29, 0x18, 0x94, 0x33, 0x48, 0x7C,
  0xA0, 0x82, 0x41, 0x04, 0x82, 0x11, 0x08, 0x22, 0x10, 0x88, 0x21, 0x10,
  0x44, 0x21, 0x08, 0x42, 0x20, 0x88, 0x40, 0xE0, 0x03, 0x80, 0x88, 0x11,
  0x04, 0x20, 0x84, 0x10, 0x82, 0x20, 0x44, 0x09, 0x01, 0x20, 0x28, 0x02,
  0x00, 0xC0, 0x28, 0x08, 0x8A, 0x12, 0x42, 0x50, 0x4A, 0x06, 0x40, 0xC8,
  0x19, 0x02, 0x20, 0xA4, 0x24, 0x7C, 0x80, 0x24, 0xA4, 0x94, 0x80, 0x00,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x02, 0x00, 0x08, 0x02, 0x02,
  0x19, 0x03, 0xB8, 0x60, 0x60, 0xC8, 0x82, 0x01, 0x00, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x12, 0x24, 0x44,
  0x80, 0xFE, 0xC0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x88, 0x20, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09,
  0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x04,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x20, 0x78,
  0x00, 0x0C, 0x52, 0x92, 0x88, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80, 0x03, 0xE0, 0x20, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x20, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x03, 0x00, 0x78, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x10, 0x20, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00,
  0xA0, 0x05, 0x00, 0x48, 0x02, 0x40, 0x22, 0x02, 0x20, 0x11, 0x01, 0x08,
  0x08, 0x40, 0x84, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x42, 0x04, 0x3F,
  0xFC, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x03,
  0xF8, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x07, 0xC0, 0x21, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x10, 0x20, 0xFE, 0x00, 0x03, 0xF0, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x5F, 0x06, 0x08, 0xA0, 0x8C,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88,
  0x10, 0x81, 0x04, 0x20, 0x7C, 0x00, 0x3F, 0xF0, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0xC3, 0x08,
  0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x08, 0x20, 0x84, 0x04,
  0x80, 0x70, 0x0E, 0x01, 0x10, 0x20, 0x84, 0x08, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x07, 0xC0,
  0xC2, 0x08, 0x21, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12,
  0x03, 0x20, 0x22, 0x02, 0x20, 0x61, 0x0A, 0x1F, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0xF8, 0x00,
  0x08, 0x46, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x20,
  0x02, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x20, 0x41, 0x02, 0x08, 0x30, 0x00, 0x00, 0x10, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0x06, 0x06, 0x02, 0x04,
  0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0xF1, 0x21, 0x11, 0x21,
  0x11, 0x42, 0x21, 0x44, 0x21, 0x44, 0x21, 0x44, 0x22, 0x84, 0x42, 0x88,
  0x42, 0x88, 0x42, 0x88, 0xC4, 0x88, 0xC4, 0x89, 0x48, 0x87, 0x30, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x1F,
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x09,
  0x02, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x43, 0xF8, 0xC1, 0x10,
  0x22, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x20,
  0x07, 0xE0, 0x20, 0x81, 0x02, 0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21,
  0x01, 0x08, 0x10, 0x80, 0x84, 0x08, 0x3F, 0x01, 0x18, 0x08, 0x20, 0x80,
  0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x21,
  0x02, 0x10, 0x20, 0xFE, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x10, 0xC0, 0x40, 0x81, 0x02, 0x08, 0x08, 0x20, 0x10,
  0x80, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x08,
  0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10, 0x08,
  0x40, 0x41, 0x03, 0x04, 0x18, 0x20, 0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0x81, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x17,
  0xE0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x03, 0x03, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x78, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x40,
  0x10, 0x40, 0x20, 0x40, 0x20, 0x20, 0x20, 0x1F, 0xE0, 0x04, 0x01, 0x04,
  0x01, 0x04, 0x02, 0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08,
  0x04, 0x08, 0x04, 0x10, 0x04, 0x10, 0x04, 0x1F, 0xF8, 0x10, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x10, 0x40, 0x20, 0x40, 0x20, 0x80, 0x20, 0x80, 0x20, 0x07,
  0xC0, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0xF8, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x30,
  0x3C, 0x00, 0x04, 0x06, 0x08, 0x18, 0x10, 0x20, 0x20, 0x80, 0x82, 0x01,
  0x0C, 0x02, 0x10, 0x04, 0x40, 0x09, 0x00, 0x22, 0x00, 0x48, 0x00, 0xB0,
  0x01, 0xA0, 0x05, 0x40, 0x0C, 0x80, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x40, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0xFF, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0A, 0x0C, 0x00,
  0x60, 0xA0, 0x05, 0x05, 0x00, 0x28, 0x28, 0x02, 0x41, 0x40, 0x14, 0x0A,
  0x01, 0x20, 0x90, 0x09, 0x04, 0x80, 0x48, 0x24, 0x04, 0x41, 0x20, 0x24,
  0x10, 0x82, 0x20, 0x84, 0x11, 0x04, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08,
  0x84, 0x10, 0x44, 0x20, 0x82, 0x41, 0x04, 0x12, 0x08, 0x20, 0xA0, 0x41,
  0x05, 0x04, 0x10, 0x30, 0x20, 0x81, 0x81, 0x00, 0x06, 0x00, 0x83, 0x00,
  0x81, 0x80, 0x40, 0xC0, 0x20, 0xA0, 0x10, 0x48, 0x10, 0x24, 0x08, 0x12,
  0x04, 0x09, 0x02, 0x08, 0x81, 0x04, 0x21, 0x02, 0x10, 0x81, 0x08, 0x41,
  0x04, 0x20, 0x82, 0x10, 0x41, 0x10, 0x20, 0x48, 0x10, 0x24, 0x10, 0x12,
  0x08, 0x09, 0x04, 0x05, 0x02, 0x01, 0x81, 0x00, 0xC1, 0x00, 0x60, 0x80,
  0x20, 0x00, 0x01, 0xF0, 0x18, 0x20, 0x40, 0x82, 0x01, 0x10, 0x04, 0x40,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40,
  0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x80, 0x22, 0x01, 0x04, 0x08, 0x10, 0x60, 0x3E, 0x00, 0x07, 0xC0,
  0x21, 0x81, 0x04, 0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08,
  0x10, 0x80, 0x84, 0x04, 0x20, 0x41, 0x04, 0x0F, 0xC0, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x00, 0x01, 0xF0, 0x18, 0x20, 0x40, 0x82, 0x01, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02,
  0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x08, 0x80, 0x22, 0x01, 0x04, 0x08, 0x10, 0x60, 0x3E, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x07, 0xC0,
  0x21, 0x81, 0x04, 0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08,
  0x10, 0x80, 0x84, 0x08, 0x20, 0x41, 0x0C, 0x0F, 0x80, 0x88, 0x04, 0x20,
  0x21, 0x01, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20, 0x41, 0x02, 0x10,
  0x10, 0x80, 0x80, 0x03, 0xF8, 0x18, 0x10, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x20, 0x20, 0xFF, 0x00, 0x7F,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x00, 0x08, 0x06,
  0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x04, 0x02, 0x08,
  0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x08, 0x02,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x01, 0x04, 0x02, 0x08,
  0x04, 0x10, 0x08, 0x20, 0x20, 0x20, 0x80, 0x3E, 0x00, 0x80, 0x18, 0x02,
  0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10,
  0x82, 0x08, 0x20, 0x86, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88, 0x09, 0x00,
  0x90, 0x09, 0x00, 0xA0, 0x0A, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x88, 0x24, 0x08,
  0x82, 0x41, 0x08, 0x44, 0x10, 0x84, 0x42, 0x08, 0x84, 0x20, 0x88, 0x42,
  0x08, 0x84, 0x40, 0x90, 0x44, 0x09, 0x04, 0x80, 0xA0, 0x48, 0x0A, 0x04,
  0x80, 0xA0, 0x50, 0x0C, 0x05, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x80,
  0x60, 0x00, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x40, 0x10, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x84, 0x03, 0x08, 0x04, 0x10, 0x10, 0x10, 0x20, 0x20, 0x80,
  0x40, 0x40, 0x28, 0x09, 0x01, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x10,
  0x22, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xF0, 0x00, 0x88,
  0x88, 0x88, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x22, 0x11, 0x11, 0x10,
  0x03, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFC, 0x00, 0x02,
  0x00, 0x50, 0x05, 0x00, 0x90, 0x08, 0x81, 0x08, 0x10, 0x42, 0x04, 0x20,
  0x24, 0x02, 0x40, 0x18, 0x01, 0xFF, 0x80, 0x91, 0x22, 0x40, 0x03, 0x00,
  0xC5, 0x18, 0x51, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x04, 0x40, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x18, 0x81, 0x84,
  0x30, 0x7D, 0x00, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0xC0, 0xA2, 0x0C, 0x11, 0x81, 0x18, 0x11, 0x01,
  0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02,
  0x40, 0x44, 0x04, 0x60, 0x8A, 0x10, 0x9E, 0x00, 0x03, 0x86, 0x44, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x1F, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x03, 0x10, 0x31, 0x41,
  0x85, 0x04, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x10, 0x40, 0x42,
  0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x60,
  0x82, 0x81, 0x0C, 0x07, 0xD0, 0x00, 0x03, 0x03, 0x21, 0x04, 0x41, 0x20,
  0x48, 0x24, 0x09, 0x04, 0x42, 0x3F, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x48,
  0x01, 0xF0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x0C, 0x50, 0x61, 0x41, 0x02, 0x08,
  0x08, 0x20, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x18, 0x20, 0xA0, 0x43, 0x01,
  0xF4, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x0F, 0xE0, 0x00, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x09, 0xC1, 0x44, 0x30, 0x84, 0x11, 0x82, 0x20, 0x44,
  0x08, 0x81, 0x20, 0x24, 0x08, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90, 0x22,
  0x04, 0x40, 0x88, 0x12, 0x04, 0x00, 0x06, 0x08, 0x10, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x40, 0x80, 0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0xF0, 0x00, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x10, 0x81, 0x10, 0x12, 0x01, 0x40, 0x24, 0x02, 0xA0, 0x32, 0x02, 0x20,
  0x22, 0x04, 0x20, 0x42, 0x04, 0x10, 0x41, 0x08, 0x10, 0x81, 0x00, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00, 0x01,
  0xC7, 0x02, 0x8A, 0x30, 0xC3, 0x04, 0x60, 0xC1, 0x10, 0x20, 0x44, 0x08,
  0x11, 0x02, 0x04, 0x40, 0x82, 0x20, 0x40, 0x88, 0x10, 0x22, 0x04, 0x08,
  0x81, 0x04, 0x20, 0x81, 0x10, 0x20, 0x44, 0x08, 0x11, 0x02, 0x04, 0x40,
  0x82, 0x20, 0x40, 0x88, 0x10, 0x20, 0x01, 0xC1, 0x44, 0x30, 0x8C, 0x11,
  0x82, 0x20, 0x44, 0x08, 0x81, 0x20, 0x24, 0x08, 0x81, 0x10, 0x22, 0x04,
  0x80, 0x90, 0x22, 0x04, 0x40, 0x90, 0x12, 0x04, 0x00, 0x03, 0x01, 0x98,
  0x41, 0x18, 0x22, 0x02, 0x40, 0x50, 0x0A, 0x02, 0x40, 0x50, 0x0A, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x20, 0x24, 0x08, 0x81, 0x08, 0x41, 0xF0, 0x00,
  0x00, 0x60, 0x28, 0x81, 0x82, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20, 0x21,
  0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80,
  0x84, 0x04, 0x30, 0x41, 0x84, 0x13, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x03, 0x00, 0xCD, 0x10,
  0x51, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x18, 0x82, 0x84, 0x30, 0x7D,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x01, 0xC2, 0x80, 0xC0, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x00, 0x03, 0x81, 0x8C, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x10, 0x63, 0xF8, 0x00, 0x08, 0x41, 0x04, 0x11, 0xF2, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0E, 0x00, 0x10, 0x22,
  0x04, 0x80, 0x90, 0x22, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x88, 0x11,
  0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x44, 0x18, 0x85, 0x0F, 0x40, 0x80,
  0xC0, 0xA0, 0x50, 0x48, 0x24, 0x12, 0x11, 0x08, 0x88, 0x44, 0x24, 0x12,
  0x09, 0x05, 0x02, 0x81, 0x80, 0xC0, 0x40, 0x00, 0x81, 0x83, 0x81, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x82, 0x84, 0x84, 0x88, 0x84, 0x88, 0x88, 0x88,
  0x88, 0x90, 0x88, 0x90, 0x90, 0xA0, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0,
  0xA1, 0x40, 0xC1, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x04, 0x08, 0x20, 0x81,
  0x08, 0x08, 0x40, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x40, 0x0A, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x10, 0x40, 0x86,
  0x04, 0x00, 0x01, 0x01, 0x01, 0x02, 0x01, 0x02, 0x01, 0x04, 0x01, 0x04,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0xB0, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x70, 0x18, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x0E, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xD0, 0x0E, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x07, 0x00, 0x80, 0x00, 0x38, 0x1C,
  0x61, 0x81, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 25, 7, 1, -25 },
  { 20, 7, 9, 9, 3, -25 },
  { 28, 13, 25, 13, 0, -25 },
  { 69, 13, 29, 12, 0, -27 },
  { 117, 15, 25, 18, 2, -25 },
  { 164, 11, 25, 11, 0, -25 },
  { 199, 3, 9, 5, 3, -25 },
  { 203, 9, 31, 8, 1, -25 },
  { 238, 9, 31, 8, -2, -25 },
  { 273, 9, 10, 11, 4, -27 },
  { 285, 12, 16, 14, 1, -20 },
  { 309, 4, 7, 5, -1, -3 },
  { 313, 7, 1, 9, 1, -10 },
  { 314, 1, 2, 5, 1, -2 },
  { 315, 15, 25, 10, -2, -25 },
  { 362, 11, 25, 12, 1, -25 },
  { 397, 6, 25, 12, 4, -25 },
  { 416, 13, 25, 12, -1, -25 },
  { 457, 13, 25, 12, -1, -25 },
  { 498, 13, 25, 12, -1, -25 },
  { 539, 13, 25, 12, -1, -25 },
  { 580, 12, 25, 12, 1, -25 },
  { 618, 12, 25, 12, 1, -25 },
  { 656, 12, 25, 12, 0, -25 },
  { 694, 12, 25, 12, 0, -25 },
  { 732, 5, 19, 5, 0, -19 },
  { 744, 7, 23, 5, -2, -19 },
  { 765, 12, 15, 14, 1, -20 },
  { 788, 12, 9, 14, 1, -17 },
  { 802, 12, 15, 14, 1, -20 },
  { 825, 10, 25, 8, 0, -25 },
  { 857, 16, 28, 18, 1, -25 },
  { 913, 11, 25, 11, -2, -25 },
  { 948, 13, 25, 13, 0, -25 },
  { 989, 14, 25, 12, 1, -25 },
  { 1033, 14, 25, 14, 0, -25 },
  { 1077, 13, 25, 12, 0, -25 },
  { 1118, 13, 25, 11, 0, -25 },
  { 1159, 16, 25, 16, 1, -25 },
  { 1209, 16, 25, 15, 0, -25 },
  { 1259, 10, 25, 6, -2, -25 },
  { 1291, 11, 31, 5, -5, -25 },
  { 1334, 15, 25, 12, 0, -25 },
  { 1381, 8, 25, 11, 0, -25 },
  { 1406, 21, 25, 21, 0, -25 },
  { 1472, 17, 25, 16, 0, -25 },
  { 1526, 14, 25, 16, 1, -25 },
  { 1570, 13, 25, 12, 0, -25 },
  { 1611, 14, 31, 16, 1, -25 },
  { 1666, 13, 25, 13, 0, -25 },
  { 1707, 14, 25, 12, -1, -25 },
  { 1751, 11, 25, 10, 2, -25 },
  { 1786, 15, 25, 15, 1, -25 },
  { 1833, 12, 25, 12, 3, -25 },
  { 1871, 20, 25, 21, 3, -25 },
  { 1934, 15, 25, 11, -2, -25 },
  { 1981, 11, 25, 10, 2, -25 },
  { 2016, 14, 25, 11, -1, -25 },
  { 2060, 13, 31, 10, -1, -25 },
  { 2111, 4, 25, 11, 4, -25 },
  { 2124, 12, 31, 10, -2, -25 },
  { 2171, 12, 12, 14, 1, -25 },
  { 2189, 9, 1, 9, -3, 3 },
  { 2191, 3, 6, 7, 5, -27 },
  { 2194, 12, 19, 13, 1, -19 },
  { 2223, 12, 27, 13, 0, -27 },
  { 2264, 9, 19, 9, 1, -19 },
  { 2286, 14, 27, 13, 1, -27 },
  { 2334, 10, 19, 11, 1, -19 },
  { 2358, 16, 35, 6, -5, -27 },
  { 2428, 14, 27, 13, -1, -19 },
  { 2476, 11, 27, 13, 0, -27 },
  { 2514, 7, 25, 5, 0, -25 },
  { 2536, 12, 33, 6, -5, -25 },
  { 2586, 12, 27, 10, 0, -27 },
  { 2627, 7, 27, 5, 0, -27 },
  { 2651, 18, 19, 19, 0, -19 },
  { 2694, 11, 19, 13, 0, -19 },
  { 2721, 11, 19, 13, 1, -19 },
  { 2748, 13, 27, 13, -1, -19 },
  { 2792, 12, 27, 13, 1, -19 },
  { 2833, 10, 19, 8, 0, -19 },
  { 2857, 11, 19, 10, -1, -19 },
  { 2884, 6, 23, 6, 1, -23 },
  { 2902, 11, 18, 13, 1, -18 },
  { 2927, 9, 18, 9, 2, -18 },
  { 2948, 16, 18, 16, 2, -18 },
  { 2984, 13, 18, 10, -2, -18 },
  { 3014, 16, 27, 10, -4, -18 },
  { 3068, 10, 18, 8, -1, -18 },
  { 3091, 12, 31, 11, 1, -25 },
  { 3138, 1, 36, 12, 5, -27 },
  { 3143, 12, 31, 11, -2, -25 },
  { 3190, 12, 3, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC35PT7B_H_
