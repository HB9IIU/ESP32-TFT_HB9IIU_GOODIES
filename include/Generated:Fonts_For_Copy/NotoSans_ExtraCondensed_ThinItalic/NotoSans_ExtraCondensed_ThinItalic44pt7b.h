#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x80, 0x31, 0x90, 0x88, 0x44,
  0x26, 0x32, 0x11, 0x08, 0x84, 0x42, 0x42, 0x21, 0x00, 0x00, 0x61, 0x80,
  0x20, 0x80, 0x10, 0x40, 0x08, 0x60, 0x08, 0x20, 0x04, 0x10, 0x02, 0x18,
  0x02, 0x08, 0x01, 0x04, 0x0F, 0xFF, 0xC0, 0xC2, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x30, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x30, 0x04, 0x10, 0x02,
  0x08, 0x01, 0x0C, 0x0F, 0xFF, 0xC0, 0x82, 0x00, 0x43, 0x00, 0x61, 0x00,
  0x20, 0x80, 0x10, 0x40, 0x18, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x18,
  0x02, 0x08, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0xF8, 0x03,
  0xA7, 0x06, 0x21, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x60, 0x01, 0x20, 0x01, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x30, 0x04,
  0x20, 0x84, 0xC0, 0xFF, 0x80, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x01, 0xB0, 0x18, 0x62, 0x02, 0x08, 0x40,
  0xC2, 0x08, 0x10, 0x41, 0x06, 0x18, 0x20, 0x82, 0x04, 0x30, 0x40, 0x84,
  0x08, 0x11, 0x83, 0x02, 0x20, 0x60, 0xCC, 0x08, 0x11, 0x01, 0x02, 0x67,
  0xA0, 0xC9, 0x9C, 0x13, 0x21, 0x82, 0x48, 0x30, 0x99, 0x05, 0x22, 0x60,
  0x98, 0xC8, 0x10, 0x11, 0x02, 0x06, 0x60, 0xC0, 0x88, 0x18, 0x31, 0x02,
  0x04, 0x20, 0x41, 0x84, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x02, 0x08,
  0x60, 0x42, 0x08, 0x08, 0xC3, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x70,
  0x03, 0x60, 0x18, 0x80, 0x43, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0x80, 0x82,
  0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x88, 0x03, 0x60, 0x05, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x80, 0x32, 0x00, 0x88, 0x04, 0x21, 0x30, 0xC4, 0x81,
  0x36, 0x04, 0x90, 0x12, 0x40, 0x79, 0x00, 0xCC, 0x03, 0x30, 0x08, 0x40,
  0x71, 0x03, 0x46, 0x19, 0x0F, 0xC4, 0x32, 0x22, 0x64, 0x44, 0x48, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x08, 0x62, 0x03,
  0x46, 0x1F, 0x03, 0x00, 0x90, 0x22, 0x18, 0x20, 0x02, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x0C, 0x21, 0x84, 0x10, 0x82, 0x10, 0x42, 0x00, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xF0, 0x06, 0x60, 0x20, 0x81, 0x83, 0x04, 0x04, 0x20, 0x10, 0x80,
  0x46, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x03, 0x20, 0x0D, 0x80,
  0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x6C, 0x01, 0x30, 0x04, 0x80,
  0x12, 0x00, 0xC8, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20,
  0x20, 0x80, 0x83, 0x04, 0x04, 0x30, 0x0F, 0x00, 0x06, 0x14, 0x4B, 0x3C,
  0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x00,
  0x00, 0x7C, 0x00, 0xE3, 0x00, 0x40, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0x8E,
  0x02, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x30, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x80, 0xC0, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x05, 0x00, 0x0F, 0x00, 0x0A, 0x00, 0x1A,
  0x00, 0x12, 0x00, 0x22, 0x00, 0x66, 0x00, 0x44, 0x00, 0xC4, 0x00, 0x84,
  0x01, 0x04, 0x03, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10, 0x40, 0x30, 0xC0, 0x20,
  0xFF, 0xFC, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0xFF, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x0B, 0x80, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x80, 0xC0, 0xFF, 0x00, 0x00, 0x3E, 0x01, 0xC4, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0xF8, 0x12, 0x18, 0x28, 0x18,
  0x60, 0x10, 0xC0, 0x23, 0x00, 0x46, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x03, 0x0C, 0x04,
  0x08, 0x18, 0x18, 0x60, 0x1F, 0x80, 0x3F, 0xFE, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x00, 0x00, 0x78, 0x00, 0xE3, 0x00, 0xC0, 0xC0,
  0x40, 0x20, 0x60, 0x10, 0x20, 0x0C, 0x10, 0x06, 0x08, 0x02, 0x04, 0x01,
  0x02, 0x00, 0x81, 0x00, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x08, 0xC0, 0x06,
  0xC0, 0x01, 0x80, 0x03, 0x40, 0x02, 0x10, 0x06, 0x04, 0x06, 0x02, 0x02,
  0x00, 0x83, 0x00, 0x41, 0x00, 0x20, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x30, 0x02, 0x08, 0x01, 0x04, 0x01, 0x83, 0x00, 0x80, 0xC0, 0x80, 0x3F,
  0x80, 0x00, 0xF0, 0x03, 0x30, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x61, 0x00,
  0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x19, 0x80, 0x33,
  0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x10, 0x14, 0x30, 0x78, 0x3B,
  0xA0, 0x18, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x7E,
  0x00, 0x04, 0x30, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x83, 0x18,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x30, 0x01, 0x01, 0x00, 0x08, 0x10, 0x00, 0x41,
  0x80, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x20, 0xC4, 0x0F, 0xC6, 0x20, 0xC4,
  0x33, 0x0C, 0x21, 0x10, 0x41, 0x08, 0x86, 0x10, 0x4C, 0x20, 0x82, 0x41,
  0x04, 0x12, 0x18, 0x21, 0x90, 0x82, 0x08, 0x84, 0x10, 0x4C, 0x20, 0x82,
  0x61, 0x0C, 0x32, 0x08, 0x61, 0x10, 0x45, 0x18, 0x82, 0x28, 0x84, 0x12,
  0x48, 0x20, 0x73, 0x81, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x14, 0x00, 0x50, 0x03, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40,
  0x31, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x41, 0x03, 0x04, 0x08, 0x10,
  0x3F, 0xC1, 0xFF, 0x04, 0x04, 0x30, 0x10, 0x80, 0x46, 0x01, 0x10, 0x04,
  0x40, 0x13, 0x00, 0x48, 0x01, 0x60, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01,
  0x01, 0xFC, 0x01, 0x81, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x18, 0x10,
  0x0C, 0x10, 0x06, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x83, 0x00, 0x81,
  0x00, 0xC0, 0x80, 0xC0, 0x40, 0xC0, 0x3F, 0x80, 0x30, 0x60, 0x10, 0x08,
  0x08, 0x06, 0x04, 0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00, 0x20, 0x80,
  0x10, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x04, 0x10, 0x06, 0x08, 0x02, 0x04,
  0x02, 0x06, 0x06, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xE3, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x01, 0x83, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x08, 0x10, 0x04, 0x18,
  0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x08, 0x40, 0x04, 0x20, 0x06, 0x30, 0x03, 0x10, 0x01, 0x08, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x63, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x40,
  0x08, 0x60, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x04, 0x04, 0x0C, 0x06,
  0x1C, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xE0,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x81, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x38, 0x06, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x07, 0xE2, 0x00,
  0x0C, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00,
  0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x60, 0x06, 0x04, 0x00,
  0x80, 0xC0, 0x10, 0x0C, 0x02, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x10, 0x30,
  0x03, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04,
  0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x00, 0x40,
  0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x0F, 0xFF, 0x81, 0x80, 0x18,
  0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x20, 0x03,
  0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00,
  0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0x80,
  0x08, 0x00, 0x01, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x03, 0xE0, 0x04,
  0x00, 0x00, 0x01, 0x00, 0xC0, 0xC0, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x02,
  0x06, 0x00, 0x81, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x30, 0x01, 0x08,
  0x00, 0xC4, 0x00, 0x23, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0xB0, 0x00,
  0x72, 0x00, 0x14, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0x43, 0x00, 0x20,
  0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x80, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x30, 0x04, 0x08, 0x01, 0x00,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0F, 0xFC, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x28, 0x00,
  0x14, 0x0A, 0x00, 0x07, 0x02, 0x80, 0x02, 0x80, 0xA0, 0x00, 0xA0, 0x48,
  0x00, 0x68, 0x12, 0x00, 0x12, 0x04, 0x80, 0x0D, 0x81, 0x20, 0x02, 0x40,
  0xC8, 0x01, 0x90, 0x22, 0x00, 0x44, 0x08, 0x80, 0x31, 0x02, 0x20, 0x08,
  0x80, 0x88, 0x06, 0x20, 0x62, 0x01, 0x08, 0x10, 0x80, 0xC2, 0x04, 0x20,
  0x21, 0x81, 0x08, 0x08, 0x40, 0x43, 0x04, 0x10, 0x20, 0xC1, 0x04, 0x08,
  0x30, 0x81, 0x02, 0x04, 0x20, 0xC0, 0x81, 0x10, 0x20, 0x60, 0x44, 0x08,
  0x10, 0x12, 0x02, 0x04, 0x04, 0x80, 0x81, 0x01, 0x40, 0x60, 0x40, 0x50,
  0x10, 0x30, 0x1C, 0x04, 0x08, 0x06, 0x01, 0x00, 0x01, 0x00, 0x08, 0x1C,
  0x00, 0xC0, 0xA0, 0x04, 0x05, 0x00, 0x20, 0x28, 0x01, 0x01, 0x40, 0x18,
  0x13, 0x00, 0x80, 0x88, 0x04, 0x04, 0x40, 0x20, 0x22, 0x01, 0x03, 0x10,
  0x18, 0x10, 0x80, 0x80, 0x86, 0x04, 0x04, 0x10, 0x20, 0x20, 0x81, 0x03,
  0x04, 0x18, 0x10, 0x20, 0x80, 0x81, 0x84, 0x04, 0x04, 0x20, 0x20, 0x23,
  0x03, 0x01, 0x10, 0x10, 0x08, 0x80, 0x80, 0x44, 0x04, 0x03, 0x20, 0x60,
  0x0B, 0x02, 0x00, 0x50, 0x10, 0x02, 0x80, 0x80, 0x14, 0x04, 0x00, 0xE0,
  0x60, 0x03, 0x02, 0x00, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x39, 0xC0, 0x18,
  0x18, 0x0C, 0x02, 0x02, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x0C, 0x20, 0x03,
  0x18, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x02, 0x20, 0x00, 0x88,
  0x00, 0x22, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x64, 0x00,
  0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x23, 0x00, 0x08,
  0xC0, 0x06, 0x10, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x10, 0x18,
  0x0C, 0x03, 0x06, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0x06, 0x02, 0x02,
  0x02, 0x03, 0x02, 0x01, 0x02, 0x01, 0x06, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x03, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x08,
  0x18, 0x30, 0x1F, 0xE0, 0x1E, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x39,
  0xC0, 0x18, 0x18, 0x0C, 0x02, 0x02, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x0C,
  0x20, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x64, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x23,
  0x00, 0x08, 0xC0, 0x06, 0x10, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40,
  0x10, 0x18, 0x0C, 0x03, 0x06, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x01, 0xFC, 0x03, 0x06, 0x02, 0x02, 0x02, 0x03, 0x02, 0x01,
  0x02, 0x01, 0x06, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x03, 0x0C, 0x02,
  0x08, 0x02, 0x08, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x1F, 0xC0,
  0x10, 0x80, 0x10, 0x80, 0x10, 0xC0, 0x30, 0x40, 0x20, 0x40, 0x20, 0x40,
  0x20, 0x40, 0x60, 0x60, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20,
  0xC0, 0x20, 0x80, 0x30, 0x00, 0x3C, 0x00, 0xE1, 0xC0, 0xC0, 0x20, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x02, 0x01, 0x81, 0xFF, 0x00,
  0x7F, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x03,
  0x04, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x86,
  0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x83, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x30,
  0x06, 0x0C, 0x01, 0x01, 0x00, 0x40, 0x40, 0x20, 0x18, 0x10, 0x03, 0xF8,
  0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x02,
  0x20, 0x0C, 0x40, 0x10, 0x80, 0x21, 0x00, 0x82, 0x01, 0x04, 0x06, 0x08,
  0x08, 0x10, 0x30, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x04, 0x02, 0x18,
  0x04, 0x20, 0x08, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x60, 0x02, 0x80, 0x05, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x50, 0x03, 0x00, 0x34, 0x00, 0xC0, 0x09, 0x00, 0x30,
  0x02, 0x40, 0x14, 0x01, 0x90, 0x05, 0x00, 0x44, 0x02, 0x40, 0x31, 0x00,
  0x90, 0x08, 0x40, 0x24, 0x02, 0x10, 0x11, 0x01, 0x04, 0x04, 0x40, 0x41,
  0x03, 0x10, 0x30, 0xC0, 0x84, 0x08, 0x30, 0x21, 0x02, 0x0C, 0x10, 0x41,
  0x03, 0x04, 0x10, 0x40, 0xC3, 0x04, 0x30, 0x30, 0x81, 0x08, 0x0C, 0x20,
  0x42, 0x03, 0x10, 0x11, 0x00, 0xC4, 0x0C, 0x40, 0x33, 0x03, 0x30, 0x08,
  0x80, 0xC8, 0x02, 0x20, 0x22, 0x00, 0x90, 0x09, 0x00, 0x24, 0x02, 0x40,
  0x0B, 0x00, 0xB0, 0x02, 0x80, 0x28, 0x00, 0xA0, 0x0A, 0x00, 0x38, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x20, 0x18, 0x08, 0x01, 0x01,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x02, 0x10,
  0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x14, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x14, 0x00,
  0x06, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00,
  0x20, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x40, 0x40, 0x18, 0x08, 0x02,
  0x01, 0x80, 0xC0, 0x30, 0x30, 0x02, 0x00, 0x40, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10, 0x60, 0x81, 0x08, 0x08,
  0x40, 0x44, 0x02, 0x20, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0x00,
  0x84, 0x21, 0x08, 0x61, 0x08, 0x42, 0x10, 0x86, 0x10, 0x84, 0x21, 0x08,
  0x61, 0x08, 0x42, 0x10, 0x86, 0x10, 0x84, 0x20, 0x00, 0xFF, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30,
  0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x04,
  0x60, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xFF, 0xE0, 0xC4, 0x42, 0x21, 0x10,
  0x00, 0x40, 0x07, 0xE4, 0x18, 0x28, 0x60, 0x50, 0x80, 0xC2, 0x00, 0x84,
  0x01, 0x10, 0x06, 0x20, 0x0C, 0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x03, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x11, 0x00, 0x62, 0x00, 0xC6,
  0x03, 0x04, 0x06, 0x08, 0x14, 0x18, 0x48, 0x1F, 0x20, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x60, 0x13, 0xF0, 0x28, 0x20, 0x60, 0x21, 0x40, 0x43,
  0x00, 0x86, 0x01, 0x08, 0x02, 0x10, 0x04, 0x60, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x00, 0xCC, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x23,
  0x00, 0x46, 0x01, 0x0C, 0x06, 0x18, 0x08, 0x28, 0x20, 0x8F, 0x80, 0x00,
  0x60, 0x3F, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x21, 0x00, 0xFC, 0x80, 0xC1,
  0x40, 0xC0, 0xA0, 0x40, 0x60, 0x40, 0x10, 0x20, 0x18, 0x20, 0x0C, 0x10,
  0x06, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x61,
  0x80, 0x20, 0xC0, 0x10, 0x60, 0x08, 0x20, 0x0C, 0x10, 0x06, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x02, 0x80, 0xC2, 0x40, 0x3E, 0x40, 0x00, 0x00, 0x40,
  0x1F, 0x81, 0x84, 0x18, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0x44, 0x02, 0x20,
  0x23, 0x03, 0x10, 0x30, 0x8E, 0x07, 0xC0, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x82, 0x07,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x74, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x7E, 0x40, 0x60, 0xA0, 0x60, 0x50, 0x20, 0x30, 0x20,
  0x08, 0x10, 0x0C, 0x10, 0x06, 0x08, 0x03, 0x04, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x08, 0x30, 0x0C,
  0x10, 0x06, 0x08, 0x03, 0x06, 0x03, 0x01, 0x01, 0x80, 0x81, 0x40, 0x61,
  0x20, 0x1F, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x80, 0x80, 0x7F, 0x80,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x80, 0x4F, 0xC1, 0x41,
  0x06, 0x04, 0x30, 0x10, 0xC0, 0x43, 0x01, 0x08, 0x04, 0x20, 0x11, 0x80,
  0xC4, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x88, 0x06, 0x20, 0x10, 0x80,
  0x42, 0x01, 0x18, 0x0C, 0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0xC0,
  0x60, 0x03, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x04, 0x10, 0x10, 0x20, 0x40, 0x41, 0x81, 0x82,
  0x02, 0x08, 0x04, 0x20, 0x08, 0xC0, 0x11, 0x00, 0x44, 0x00, 0x98, 0x01,
  0x50, 0x03, 0xA0, 0x0E, 0x40, 0x18, 0xC0, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x03, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x80, 0x40,
  0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x00, 0x20, 0x20,
  0x0B, 0xF1, 0xF8, 0x1C, 0x14, 0x10, 0x30, 0x30, 0x30, 0xC0, 0x60, 0x61,
  0x80, 0x80, 0xC2, 0x01, 0x01, 0x04, 0x06, 0x02, 0x08, 0x08, 0x04, 0x30,
  0x10, 0x08, 0x40, 0x20, 0x30, 0x80, 0x40, 0x41, 0x01, 0x80, 0x86, 0x02,
  0x01, 0x08, 0x04, 0x02, 0x10, 0x08, 0x08, 0x20, 0x10, 0x10, 0x40, 0x40,
  0x21, 0x80, 0x80, 0x42, 0x01, 0x01, 0x84, 0x02, 0x02, 0x08, 0x0C, 0x04,
  0x10, 0x10, 0x08, 0x60, 0x20, 0x10, 0x00, 0x20, 0x13, 0xF0, 0x50, 0x41,
  0x81, 0x0C, 0x04, 0x30, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x60, 0x31,
  0x00, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x22, 0x01, 0x08, 0x04, 0x20, 0x10,
  0x80, 0x46, 0x03, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x30, 0x18,
  0x00, 0x40, 0x0F, 0xC0, 0x61, 0x83, 0x02, 0x18, 0x08, 0x40, 0x23, 0x00,
  0xC8, 0x03, 0x20, 0x0D, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x2C, 0x01, 0xB0, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x30, 0x08, 0xC0,
  0x41, 0x03, 0x06, 0x18, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x9F, 0x80, 0x50,
  0x40, 0x30, 0x10, 0x38, 0x08, 0x18, 0x04, 0x0C, 0x02, 0x04, 0x01, 0x02,
  0x00, 0x83, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x18, 0x20, 0x08,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x03, 0x04, 0x01, 0x06, 0x00, 0x83, 0x00,
  0x81, 0x80, 0xC0, 0xC0, 0x40, 0x50, 0x40, 0x67, 0xC0, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xE4, 0x18,
  0x68, 0x60, 0x50, 0x80, 0xC2, 0x01, 0x84, 0x01, 0x10, 0x06, 0x20, 0x0C,
  0x40, 0x11, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x04, 0x60,
  0x08, 0xC0, 0x11, 0x00, 0x62, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x08, 0x14,
  0x18, 0x48, 0x1F, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x00,
  0x30, 0x4F, 0x05, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0x40, 0x1F, 0xC1, 0x02, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x62, 0x06,
  0x1F, 0xE0, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x3F, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x44, 0x03, 0x10, 0x08, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x20, 0x10, 0x80,
  0x42, 0x01, 0x08, 0x04, 0x60, 0x31, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40,
  0x63, 0x01, 0x88, 0x04, 0x20, 0x30, 0x81, 0xC3, 0x0D, 0x07, 0xEC, 0x00,
  0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x03, 0x20, 0x44, 0x08, 0x82,
  0x10, 0x42, 0x10, 0x42, 0x08, 0xC1, 0x10, 0x26, 0x04, 0x80, 0x90, 0x14,
  0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x0E, 0x03, 0x01, 0x40, 0x60, 0x28, 0x14, 0x09, 0x02, 0x81, 0x20, 0xD0,
  0x64, 0x12, 0x08, 0x82, 0x41, 0x10, 0x88, 0x42, 0x11, 0x08, 0x46, 0x21,
  0x08, 0x84, 0x41, 0x10, 0x88, 0x24, 0x12, 0x04, 0x82, 0x40, 0xB0, 0x48,
  0x14, 0x0A, 0x02, 0x81, 0x40, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x00, 0x02, 0x03, 0x02, 0x02, 0x02, 0x04, 0x02, 0x0C, 0x03,
  0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x06, 0x40, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0x60, 0x20, 0x20, 0x40, 0x20, 0xC0,
  0x20, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00,
  0x40, 0x40, 0x04, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x41, 0x00,
  0x04, 0x10, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40,
  0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x05, 0x00, 0x00, 0x50,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0xB8, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x01, 0xC0, 0x05, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x3E, 0x03,
  0x83, 0x06, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 9, 11, 11, 4, -31 },
  { 45, 17, 31, 16, 0, -31 },
  { 111, 16, 36, 15, 0, -33 },
  { 183, 19, 33, 23, 2, -32 },
  { 262, 14, 32, 14, -1, -32 },
  { 318, 4, 11, 6, 4, -31 },
  { 324, 12, 38, 11, 1, -31 },
  { 381, 12, 38, 11, -3, -31 },
  { 438, 11, 11, 14, 5, -33 },
  { 454, 15, 21, 18, 1, -26 },
  { 494, 6, 10, 7, -2, -4 },
  { 502, 9, 2, 12, 1, -13 },
  { 505, 2, 3, 7, 1, -3 },
  { 506, 18, 31, 13, -2, -31 },
  { 576, 14, 32, 15, 1, -32 },
  { 632, 7, 31, 15, 5, -31 },
  { 660, 17, 32, 15, -2, -32 },
  { 728, 16, 32, 15, -1, -32 },
  { 792, 16, 32, 15, -1, -32 },
  { 856, 16, 31, 15, -1, -31 },
  { 918, 15, 32, 15, 1, -32 },
  { 978, 15, 31, 15, 2, -31 },
  { 1037, 17, 32, 15, -1, -32 },
  { 1105, 15, 32, 15, 0, -32 },
  { 1165, 6, 23, 7, 0, -23 },
  { 1183, 9, 29, 7, -2, -23 },
  { 1216, 15, 18, 18, 1, -25 },
  { 1250, 15, 11, 18, 1, -21 },
  { 1271, 15, 18, 18, 1, -25 },
  { 1305, 11, 32, 11, 1, -32 },
  { 1349, 21, 36, 22, 1, -32 },
  { 1444, 14, 32, 14, -3, -32 },
  { 1500, 17, 31, 16, 0, -31 },
  { 1566, 16, 32, 15, 2, -32 },
  { 1630, 17, 31, 18, 0, -31 },
  { 1696, 17, 31, 15, 0, -31 },
  { 1762, 17, 31, 14, 0, -31 },
  { 1828, 19, 32, 20, 2, -32 },
  { 1904, 20, 31, 19, 0, -31 },
  { 1982, 13, 31, 7, -3, -31 },
  { 2033, 14, 39, 7, -6, -31 },
  { 2102, 18, 31, 15, 0, -31 },
  { 2172, 10, 31, 13, 0, -31 },
  { 2211, 26, 31, 26, 0, -31 },
  { 2312, 21, 31, 20, 0, -31 },
  { 2394, 18, 32, 20, 1, -32 },
  { 2466, 16, 31, 15, 0, -31 },
  { 2528, 18, 40, 20, 1, -32 },
  { 2618, 16, 31, 16, 0, -31 },
  { 2680, 17, 32, 15, -1, -32 },
  { 2748, 13, 31, 13, 3, -31 },
  { 2799, 18, 31, 19, 1, -31 },
  { 2869, 15, 31, 15, 4, -31 },
  { 2928, 26, 31, 26, 3, -31 },
  { 3029, 19, 31, 13, -3, -31 },
  { 3103, 13, 31, 13, 3, -31 },
  { 3154, 18, 31, 13, -2, -31 },
  { 3224, 16, 38, 12, -1, -31 },
  { 3300, 5, 31, 14, 5, -31 },
  { 3320, 16, 38, 12, -3, -31 },
  { 3396, 16, 15, 17, 1, -31 },
  { 3426, 11, 1, 11, -3, 4 },
  { 3428, 4, 7, 9, 6, -34 },
  { 3432, 15, 24, 17, 1, -24 },
  { 3477, 15, 33, 16, 0, -33 },
  { 3539, 12, 24, 12, 1, -24 },
  { 3575, 17, 33, 17, 1, -33 },
  { 3646, 13, 24, 14, 1, -24 },
  { 3685, 19, 45, 8, -6, -34 },
  { 3792, 17, 35, 17, -1, -24 },
  { 3867, 14, 33, 16, 0, -33 },
  { 3925, 8, 31, 7, 0, -31 },
  { 3956, 14, 42, 7, -6, -31 },
  { 4030, 15, 33, 13, 0, -33 },
  { 4092, 8, 33, 7, 0, -33 },
  { 4125, 23, 24, 24, 0, -24 },
  { 4194, 14, 24, 16, 0, -24 },
  { 4236, 14, 24, 16, 1, -24 },
  { 4278, 17, 34, 16, -2, -24 },
  { 4351, 15, 34, 17, 1, -24 },
  { 4415, 12, 24, 10, 0, -24 },
  { 4451, 13, 24, 12, -1, -24 },
  { 4490, 8, 29, 8, 1, -29 },
  { 4519, 14, 23, 16, 1, -23 },
  { 4560, 11, 23, 12, 3, -23 },
  { 4592, 19, 23, 20, 3, -23 },
  { 4647, 16, 23, 13, -2, -23 },
  { 4693, 20, 34, 13, -5, -23 },
  { 4778, 13, 23, 10, -1, -23 },
  { 4816, 15, 38, 14, 1, -31 },
  { 4888, 1, 44, 15, 7, -33 },
  { 4894, 15, 38, 14, -3, -31 },
  { 4966, 15, 3, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC44PT7B_H_
