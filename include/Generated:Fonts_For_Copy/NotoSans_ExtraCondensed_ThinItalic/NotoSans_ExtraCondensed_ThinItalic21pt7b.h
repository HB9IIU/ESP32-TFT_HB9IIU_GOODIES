#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x24, 0x44, 0x00, 0x80, 0x55, 0x9A, 0xA0,
  0x09, 0x09, 0x0A, 0x12, 0x3F, 0x12, 0x24, 0x24, 0x24, 0xFE, 0x48, 0x48,
  0x50, 0x90, 0x90, 0x04, 0x04, 0x1F, 0x28, 0x28, 0x28, 0x28, 0x30, 0x10,
  0x18, 0x14, 0x14, 0x24, 0x24, 0xF8, 0x20, 0x20, 0x31, 0xA4, 0x92, 0x51,
  0x49, 0x24, 0xA2, 0x5F, 0x55, 0xEC, 0x8A, 0x45, 0x25, 0x12, 0x92, 0x49,
  0x18, 0x1C, 0x52, 0x49, 0x24, 0xA1, 0x0C, 0x52, 0x58, 0xE2, 0x8A, 0x2F,
  0x40, 0x5A, 0x80, 0x08, 0x84, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x00, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0x08,
  0x84, 0x44, 0x00, 0x25, 0x1E, 0x8A, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE2,
  0x04, 0x08, 0x10, 0x29, 0x28, 0xF8, 0x80, 0x01, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00,
  0x0E, 0x24, 0x89, 0x14, 0x28, 0x50, 0xA1, 0x83, 0x0A, 0x14, 0x28, 0x91,
  0x1C, 0x00, 0x17, 0x92, 0x22, 0x22, 0x44, 0x44, 0x88, 0x80, 0x1E, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0xFC, 0x3E, 0x04, 0x08, 0x10, 0x20, 0x41, 0x1C, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x3C, 0x00, 0x02, 0x0C, 0x18, 0x51, 0x22, 0x89, 0x12, 0x45, 0x12,
  0x23, 0xE0, 0x81, 0x04, 0x00, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x20, 0x3C,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x0F, 0x10, 0x20, 0x20,
  0x20, 0x40, 0x7C, 0x44, 0x42, 0x82, 0x84, 0x84, 0x84, 0x88, 0x78, 0x7E,
  0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x00, 0x1E, 0x44, 0x89, 0x12, 0x24, 0x47, 0x18, 0x49, 0x0A, 0x14, 0x28,
  0x50, 0x9E, 0x00, 0x1C, 0x44, 0x8A, 0x14, 0x28, 0x50, 0xA3, 0x3A, 0x08,
  0x10, 0x20, 0x82, 0x38, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x02, 0x44, 0x88, 0x02, 0x18, 0xC2, 0x08, 0x08, 0x0C, 0x06,
  0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x80, 0xC0, 0x60, 0x21, 0x8C,
  0x20, 0x80, 0x38, 0x10, 0x41, 0x08, 0x21, 0x08, 0x21, 0x04, 0x10, 0x00,
  0x08, 0x00, 0x0F, 0x08, 0x48, 0x28, 0x14, 0xEC, 0x96, 0x4B, 0x49, 0xA4,
  0xD2, 0x69, 0x55, 0xA9, 0x24, 0x02, 0x01, 0x00, 0x70, 0x00, 0x04, 0x10,
  0xC3, 0x0C, 0x51, 0x49, 0x3C, 0x94, 0x51, 0x86, 0x18, 0x40, 0x1E, 0x11,
  0x21, 0x21, 0x21, 0x22, 0x24, 0x5C, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84,
  0xF8, 0x0F, 0x30, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x78, 0x1E, 0x11, 0x21, 0x21, 0x21, 0x21, 0x21, 0x41,
  0x41, 0x41, 0x42, 0x42, 0x84, 0x88, 0xF0, 0x1F, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x5C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xF8, 0x1F, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x7C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x0F, 0x98, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x0C, 0x81, 0x41,
  0x20, 0x90, 0x48, 0x24, 0x11, 0xF0, 0x10, 0x44, 0x22, 0x08, 0x82, 0x20,
  0x88, 0x22, 0x11, 0x7C, 0x41, 0x10, 0x44, 0x11, 0x08, 0x82, 0x20, 0x88,
  0x20, 0x1C, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x0E,
  0x00, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x43, 0x00, 0x10, 0x88, 0x88, 0x84, 0x82, 0x41,
  0x40, 0xC0, 0xE0, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84, 0x22, 0x10, 0x10,
  0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x43, 0xE0, 0x10, 0x18, 0x80,
  0x8C, 0x0C, 0x60, 0x62, 0x85, 0x14, 0x28, 0xA2, 0x89, 0x14, 0x49, 0x22,
  0x49, 0x12, 0x88, 0x94, 0x88, 0xA4, 0x46, 0x22, 0x21, 0x00, 0x10, 0x44,
  0x12, 0x84, 0xA2, 0x28, 0x8A, 0x22, 0x89, 0x12, 0x45, 0x11, 0x44, 0x51,
  0x14, 0x85, 0x20, 0x88, 0x20, 0x1E, 0x21, 0x21, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x88, 0x70, 0x1E, 0x11, 0x21, 0x21,
  0x21, 0x22, 0x22, 0x44, 0x78, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x1E,
  0x21, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84,
  0x88, 0x70, 0x10, 0x10, 0x10, 0x08, 0x1E, 0x11, 0x21, 0x21, 0x21, 0x22,
  0x22, 0x44, 0x78, 0x48, 0x48, 0x48, 0x88, 0x84, 0x84, 0x0F, 0x88, 0x04,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x23, 0xE0, 0x7E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x00, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82,
  0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0xF0, 0x83, 0x0A, 0x14, 0x28, 0x91,
  0x24, 0x48, 0xA1, 0x42, 0x86, 0x0C, 0x10, 0x20, 0x00, 0x84, 0x18, 0x41,
  0x8C, 0x28, 0xC2, 0x8C, 0x49, 0x44, 0x94, 0x4A, 0x48, 0xA4, 0x8A, 0x50,
  0xC5, 0x0C, 0x50, 0x86, 0x08, 0x60, 0x84, 0x00, 0x10, 0x88, 0x82, 0x41,
  0x40, 0xA0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x0A, 0x04, 0x84, 0x44, 0x22,
  0x10, 0x42, 0x89, 0x12, 0x44, 0x8A, 0x14, 0x30, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x00, 0x1F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x03, 0xF0, 0x1E, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0xC0,
  0x92, 0x44, 0x92, 0x49, 0x12, 0x48, 0x0E, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x11, 0xE0, 0x10, 0x50,
  0xA2, 0x24, 0x50, 0xA0, 0x80, 0xFC, 0xA4, 0x3E, 0x89, 0x14, 0x28, 0x50,
  0xA1, 0x44, 0x89, 0x33, 0xA0, 0x10, 0x20, 0x40, 0x82, 0x07, 0xC8, 0x91,
  0x22, 0x85, 0x0A, 0x14, 0x28, 0xB1, 0x7C, 0x3A, 0x11, 0x08, 0x42, 0x10,
  0x84, 0x3C, 0x01, 0x01, 0x02, 0x02, 0x02, 0x3E, 0x44, 0x44, 0x84, 0x84,
  0x84, 0x84, 0x88, 0x88, 0x98, 0xE8, 0x3A, 0x53, 0x19, 0x72, 0x10, 0x84,
  0x3C, 0x01, 0x81, 0x00, 0x80, 0x40, 0x40, 0x78, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x0C,
  0x00, 0x1F, 0x22, 0x22, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x4C, 0x74,
  0x04, 0x08, 0x08, 0x08, 0xF0, 0x10, 0x20, 0x40, 0x82, 0x07, 0xC8, 0x91,
  0x22, 0x85, 0x12, 0x24, 0x50, 0xA1, 0x44, 0x11, 0x00, 0x22, 0x24, 0x44,
  0x44, 0x88, 0x80, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x86, 0x00, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x49, 0x14, 0x50, 0xA1, 0xC2, 0x84, 0x91, 0x22, 0x44, 0x11,
  0x11, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x3F, 0xE4, 0x44, 0x88, 0x91,
  0x14, 0x42, 0x88, 0x91, 0x12, 0x22, 0x84, 0x51, 0x12, 0x22, 0x00, 0x3E,
  0x44, 0x89, 0x14, 0x28, 0x91, 0x22, 0x85, 0x0A, 0x20, 0x3D, 0x14, 0x61,
  0x86, 0x18, 0x62, 0x8A, 0x4F, 0x00, 0x1F, 0x11, 0x11, 0x11, 0x21, 0x21,
  0x21, 0x21, 0x22, 0x62, 0x7C, 0x40, 0x40, 0x80, 0x80, 0x80, 0x3E, 0x89,
  0x14, 0x28, 0x50, 0xA1, 0x44, 0x89, 0x33, 0xA0, 0x41, 0x02, 0x04, 0x08,
  0x3C, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x00, 0x3D, 0x04, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x4F, 0x00, 0x12, 0x27, 0x22, 0x44, 0x44, 0x88,
  0x8C, 0x45, 0x14, 0x61, 0x86, 0x28, 0xA2, 0x8A, 0x4F, 0x00, 0x86, 0x28,
  0xA4, 0x92, 0x8A, 0x28, 0xC3, 0x08, 0x00, 0x88, 0x62, 0x28, 0x8A, 0x54,
  0x95, 0x29, 0x4A, 0x63, 0x18, 0xCC, 0x21, 0x08, 0x40, 0x11, 0x12, 0x14,
  0x14, 0x08, 0x10, 0x18, 0x28, 0x48, 0x48, 0x84, 0x10, 0x88, 0x44, 0x41,
  0x20, 0xA0, 0x50, 0x28, 0x18, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x81, 0x80, 0x1E, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x83, 0xC0,
  0x0E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x41, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x80, 0xC0, 0xFF, 0xFF, 0xF8, 0x18, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x0C, 0x20, 0x81, 0x02, 0x04, 0x10, 0x21, 0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 15, 4, 0, -15 },
  { 9, 4, 5, 5, 2, -15 },
  { 12, 8, 15, 8, 0, -15 },
  { 27, 8, 17, 7, 0, -16 },
  { 44, 9, 15, 11, 1, -15 },
  { 61, 6, 15, 7, 0, -15 },
  { 73, 2, 5, 3, 2, -15 },
  { 75, 5, 18, 5, 1, -15 },
  { 87, 5, 18, 5, -1, -15 },
  { 99, 5, 6, 7, 3, -16 },
  { 103, 7, 9, 8, 1, -12 },
  { 111, 3, 5, 3, -1, -2 },
  { 113, 5, 1, 6, 0, -6 },
  { 114, 1, 1, 3, 0, -1 },
  { 115, 9, 15, 6, -1, -15 },
  { 132, 7, 15, 7, 0, -15 },
  { 146, 4, 15, 7, 2, -15 },
  { 154, 8, 15, 7, -1, -15 },
  { 169, 7, 15, 7, 0, -15 },
  { 183, 7, 15, 7, 0, -15 },
  { 197, 8, 15, 7, -1, -15 },
  { 212, 8, 15, 7, 0, -15 },
  { 227, 7, 15, 7, 1, -15 },
  { 241, 7, 15, 7, 0, -15 },
  { 255, 7, 15, 7, 0, -15 },
  { 269, 3, 11, 3, 0, -11 },
  { 274, 4, 14, 3, -1, -11 },
  { 281, 7, 9, 8, 1, -12 },
  { 289, 7, 5, 8, 1, -10 },
  { 294, 7, 9, 8, 1, -12 },
  { 302, 6, 15, 5, 0, -15 },
  { 314, 9, 17, 11, 1, -15 },
  { 334, 6, 15, 7, -1, -15 },
  { 346, 8, 15, 8, 0, -15 },
  { 361, 8, 15, 7, 1, -15 },
  { 376, 8, 15, 9, 0, -15 },
  { 391, 8, 15, 7, 0, -15 },
  { 406, 8, 15, 7, 0, -15 },
  { 421, 9, 15, 9, 1, -15 },
  { 438, 10, 15, 9, 0, -15 },
  { 457, 6, 15, 3, -1, -15 },
  { 469, 7, 19, 3, -3, -15 },
  { 486, 9, 15, 7, 0, -15 },
  { 503, 5, 15, 6, 0, -15 },
  { 513, 13, 15, 12, 0, -15 },
  { 538, 10, 15, 10, 0, -15 },
  { 557, 8, 15, 9, 1, -15 },
  { 572, 8, 15, 7, 0, -15 },
  { 587, 8, 19, 9, 1, -15 },
  { 606, 8, 15, 8, 0, -15 },
  { 621, 9, 15, 7, -1, -15 },
  { 638, 7, 15, 6, 1, -15 },
  { 652, 8, 15, 9, 1, -15 },
  { 667, 7, 15, 7, 2, -15 },
  { 681, 12, 15, 13, 2, -15 },
  { 704, 9, 15, 6, -1, -15 },
  { 721, 7, 15, 6, 1, -15 },
  { 735, 9, 15, 6, -1, -15 },
  { 752, 7, 18, 6, 0, -15 },
  { 768, 3, 15, 7, 2, -15 },
  { 774, 7, 18, 6, -1, -15 },
  { 790, 7, 7, 8, 1, -15 },
  { 797, 6, 1, 5, -2, 2 },
  { 798, 2, 3, 4, 3, -16 },
  { 799, 7, 11, 8, 1, -11 },
  { 809, 7, 16, 8, 0, -16 },
  { 823, 5, 11, 6, 1, -11 },
  { 830, 8, 16, 8, 1, -16 },
  { 846, 5, 11, 7, 1, -11 },
  { 853, 9, 21, 4, -3, -16 },
  { 877, 8, 16, 8, 0, -11 },
  { 893, 7, 16, 8, 0, -16 },
  { 907, 4, 15, 3, 0, -15 },
  { 915, 7, 20, 3, -3, -15 },
  { 933, 7, 16, 6, 0, -16 },
  { 947, 4, 16, 3, 0, -16 },
  { 955, 11, 11, 11, 0, -11 },
  { 971, 7, 11, 8, 0, -11 },
  { 981, 6, 11, 8, 1, -11 },
  { 990, 8, 16, 8, -1, -11 },
  { 1006, 7, 16, 8, 1, -11 },
  { 1020, 6, 11, 5, 0, -11 },
  { 1029, 6, 11, 6, 0, -11 },
  { 1038, 4, 14, 4, 0, -14 },
  { 1045, 6, 11, 8, 1, -11 },
  { 1054, 6, 11, 6, 1, -11 },
  { 1063, 10, 11, 10, 1, -11 },
  { 1077, 8, 11, 6, -1, -11 },
  { 1088, 9, 16, 6, -2, -11 },
  { 1106, 7, 11, 5, -1, -11 },
  { 1116, 7, 18, 7, 1, -15 },
  { 1132, 1, 21, 7, 3, -16 },
  { 1135, 7, 18, 6, -1, -15 },
  { 1151, 7, 1, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC21PT7B_H_
