#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x80, 0x02, 0x10, 0x55,
  0x59, 0x9A, 0x05, 0x09, 0x09, 0x09, 0x12, 0x3F, 0x12, 0x24, 0x24, 0x24,
  0xFE, 0x48, 0x48, 0x50, 0x90, 0x90, 0x04, 0x04, 0x1F, 0x24, 0x28, 0x28,
  0x28, 0x28, 0x10, 0x08, 0x14, 0x14, 0x14, 0x14, 0x24, 0xF8, 0x20, 0x20,
  0x30, 0x92, 0x24, 0x92, 0x24, 0x8A, 0x22, 0x89, 0x5A, 0x59, 0xAA, 0x73,
  0x11, 0x44, 0x52, 0x24, 0x89, 0x24, 0x51, 0x1C, 0x0C, 0x28, 0x91, 0x22,
  0x44, 0x86, 0x08, 0x30, 0xA6, 0x2C, 0x68, 0xD1, 0x22, 0x7A, 0x56, 0xA0,
  0x04, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x00, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x84, 0x10, 0x8C, 0x00, 0x21, 0x3A, 0x66, 0x48, 0x10, 0x20,
  0x40, 0x81, 0x1F, 0xC4, 0x08, 0x10, 0x20, 0x29, 0x28, 0xF0, 0xC0, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x01, 0x01, 0x00, 0x0E, 0x24, 0x49, 0x12, 0x28, 0x50, 0xA1,
  0x43, 0x06, 0x0C, 0x28, 0x50, 0xA2, 0x38, 0x13, 0x51, 0x12, 0x22, 0x24,
  0x44, 0x44, 0x88, 0x1E, 0x00, 0x80, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0xF8, 0x0F, 0x08, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x3C, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x11, 0xF0, 0x03, 0x02, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x24, 0x44,
  0x44, 0x84, 0x88, 0x7E, 0x08, 0x08, 0x08, 0x0F, 0x84, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x78, 0x02, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x11,
  0xF0, 0x07, 0x08, 0x10, 0x20, 0x20, 0x40, 0x58, 0x64, 0x42, 0x42, 0x82,
  0x82, 0x82, 0x84, 0x44, 0x78, 0x7E, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x1E, 0x21, 0x21, 0x21, 0x21,
  0x22, 0x24, 0x18, 0x28, 0x44, 0x84, 0x84, 0x84, 0x84, 0x84, 0x78, 0x1C,
  0x44, 0x8A, 0x14, 0x28, 0x50, 0xA1, 0x46, 0x74, 0x08, 0x20, 0x41, 0x02,
  0x78, 0x24, 0x00, 0x00, 0x02, 0x40, 0x11, 0x00, 0x00, 0x00, 0x00, 0x24,
  0x48, 0x80, 0x06, 0x30, 0x86, 0x08, 0x0C, 0x06, 0x02, 0x02, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x30, 0x61, 0x0C, 0x20, 0x80, 0x38,
  0x10, 0x41, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x00, 0x08, 0x20, 0x07,
  0x06, 0x22, 0x04, 0x81, 0x40, 0x53, 0x99, 0x26, 0x49, 0x92, 0x69, 0x2A,
  0x4A, 0x92, 0xAD, 0x24, 0x88, 0x02, 0x00, 0x80, 0x1E, 0x00, 0x01, 0x03,
  0x03, 0x05, 0x05, 0x05, 0x09, 0x09, 0x11, 0x1F, 0x11, 0x21, 0x21, 0x41,
  0x41, 0xC1, 0x1E, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x44, 0x42,
  0x42, 0x42, 0x42, 0x82, 0x84, 0xF8, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78, 0x1E, 0x08,
  0x84, 0x22, 0x12, 0x09, 0x04, 0x82, 0x41, 0x41, 0x20, 0x90, 0x48, 0x24,
  0x24, 0x22, 0x31, 0xE0, 0x1F, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x3E,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xF8, 0x1F, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x3C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x0F, 0x88, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x87, 0x40, 0xA0,
  0x50, 0x48, 0x24, 0x12, 0x08, 0xF8, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20,
  0x88, 0x22, 0x08, 0xFC, 0x41, 0x10, 0x44, 0x11, 0x04, 0x41, 0x20, 0x88,
  0x22, 0x08, 0x1C, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21,
  0x04, 0x38, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x86, 0x00, 0x10, 0x88, 0x84, 0x44,
  0x42, 0x41, 0x40, 0xA0, 0x60, 0x28, 0x24, 0x12, 0x09, 0x04, 0x84, 0x22,
  0x11, 0x08, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x1F,
  0x10, 0x08, 0x80, 0x44, 0x06, 0x50, 0x32, 0x82, 0x94, 0x18, 0xA1, 0x45,
  0x0A, 0x48, 0x92, 0x45, 0x12, 0x48, 0x92, 0x44, 0xA2, 0x45, 0x12, 0x31,
  0x11, 0x88, 0x10, 0x44, 0x11, 0x84, 0xA1, 0x28, 0x4A, 0x12, 0x88, 0x92,
  0x44, 0x91, 0x24, 0x51, 0x14, 0x43, 0x20, 0xC8, 0x22, 0x08, 0x0E, 0x11,
  0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84,
  0x84, 0x78, 0x1E, 0x11, 0x11, 0x21, 0x21, 0x21, 0x21, 0x22, 0x7C, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x0E, 0x11, 0x21, 0x41, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x84, 0x68, 0x10, 0x10,
  0x10, 0x08, 0x1E, 0x11, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x48,
  0x48, 0x48, 0x48, 0x84, 0x84, 0x84, 0x0F, 0x88, 0x04, 0x02, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09, 0xF8,
  0x7E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x20, 0x90, 0x48, 0x48, 0x24, 0x12, 0x09, 0x04, 0x84, 0x82,
  0x41, 0x20, 0x90, 0x88, 0x44, 0x22, 0x21, 0xE0, 0x83, 0x06, 0x0C, 0x28,
  0x51, 0x22, 0x48, 0x91, 0x22, 0x85, 0x0C, 0x18, 0x20, 0x40, 0x82, 0x0C,
  0x10, 0xA1, 0x85, 0x0C, 0x28, 0xA2, 0x45, 0x12, 0x49, 0x12, 0x48, 0x92,
  0x45, 0x14, 0x28, 0xA1, 0x8A, 0x0C, 0x50, 0x42, 0x82, 0x08, 0x10, 0x40,
  0x10, 0x84, 0x42, 0x41, 0x20, 0xA0, 0x50, 0x30, 0x10, 0x08, 0x0C, 0x05,
  0x04, 0x84, 0x42, 0x22, 0x11, 0x08, 0x42, 0x85, 0x12, 0x24, 0x89, 0x14,
  0x28, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x0F, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x01, 0xF8, 0x0E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x03, 0x80, 0x92, 0x24, 0x92, 0x48, 0x92,
  0x49, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x23, 0xC0, 0x10, 0x20, 0xA1, 0x24, 0x48, 0x60,
  0xC1, 0xFC, 0xA5, 0x1A, 0x4D, 0x0A, 0x18, 0x50, 0xA1, 0x42, 0x85, 0x12,
  0x27, 0xC0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x2E, 0x32, 0x21, 0x21, 0x21,
  0x41, 0x42, 0x42, 0x42, 0x44, 0xC4, 0xF8, 0x1C, 0x84, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01, 0x1A, 0x26, 0x42,
  0x42, 0x84, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0xF8, 0x18, 0x94, 0x61,
  0x8A, 0xCC, 0x20, 0x82, 0x08, 0x3C, 0x01, 0xC0, 0x40, 0x20, 0x08, 0x02,
  0x03, 0xC0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x38, 0x00, 0x0D, 0x13,
  0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x82, 0x84, 0x44, 0x7C, 0x04, 0x04,
  0x08, 0x08, 0xF0, 0x10, 0x20, 0x40, 0x81, 0x05, 0xCC, 0x91, 0x22, 0x45,
  0x0A, 0x14, 0x48, 0xA1, 0x42, 0x84, 0x11, 0x00, 0x22, 0x22, 0x24, 0x44,
  0x48, 0x88, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x0E, 0x00, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x48, 0x92, 0x28, 0xA1, 0x43, 0x84, 0x89, 0x22, 0x44, 0x88,
  0x11, 0x11, 0x12, 0x22, 0x24, 0x44, 0x44, 0x88, 0x80, 0x2C, 0xE6, 0x64,
  0x88, 0x91, 0x12, 0x22, 0x84, 0x51, 0x0A, 0x22, 0x44, 0x50, 0x8A, 0x11,
  0x44, 0x20, 0x2C, 0x64, 0x89, 0x12, 0x28, 0x50, 0xA2, 0x45, 0x0A, 0x14,
  0x20, 0x18, 0x94, 0x61, 0x86, 0x18, 0x61, 0x86, 0x28, 0xBC, 0x17, 0x0C,
  0x84, 0x22, 0x11, 0x09, 0x04, 0x84, 0x42, 0x21, 0x11, 0x18, 0x8F, 0x84,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1A, 0x4D, 0x0A, 0x18, 0x50, 0xA1,
  0x42, 0x85, 0x12, 0x27, 0xC0, 0x81, 0x04, 0x08, 0x10, 0x2C, 0xC2, 0x08,
  0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x3D, 0x04, 0x10, 0x40, 0x81, 0x04,
  0x08, 0x20, 0xBC, 0x12, 0x72, 0x22, 0x44, 0x44, 0x88, 0x8C, 0x42, 0x85,
  0x12, 0x28, 0x50, 0xA1, 0x44, 0x89, 0x12, 0x67, 0x40, 0x86, 0x18, 0xA2,
  0x92, 0x49, 0x28, 0xA3, 0x0C, 0x20, 0x84, 0x61, 0x18, 0xC6, 0x32, 0x94,
  0xA5, 0x4A, 0x52, 0x94, 0xA6, 0x31, 0x8C, 0x42, 0x10, 0x11, 0x12, 0x12,
  0x14, 0x14, 0x08, 0x18, 0x18, 0x28, 0x48, 0x44, 0x84, 0x04, 0x20, 0x88,
  0x11, 0x02, 0x40, 0x48, 0x09, 0x01, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0xE0, 0x00, 0x1E, 0x04, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x07, 0x80, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x21, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x01,
  0x80, 0xFF, 0xFF, 0xFC, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x0C, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x43, 0x80, 0x63, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 4, 0, -16 },
  { 11, 4, 6, 6, 2, -16 },
  { 14, 8, 16, 8, 0, -16 },
  { 30, 8, 18, 8, 0, -17 },
  { 48, 10, 16, 11, 1, -16 },
  { 68, 7, 16, 7, 0, -16 },
  { 82, 2, 6, 3, 2, -16 },
  { 84, 6, 19, 5, 1, -16 },
  { 99, 6, 19, 5, -2, -16 },
  { 114, 5, 6, 7, 3, -17 },
  { 118, 7, 10, 9, 1, -13 },
  { 127, 3, 5, 3, -1, -2 },
  { 129, 4, 1, 6, 1, -6 },
  { 130, 1, 2, 3, 0, -2 },
  { 131, 9, 16, 6, -1, -16 },
  { 149, 7, 16, 8, 0, -16 },
  { 163, 4, 16, 8, 2, -16 },
  { 171, 9, 16, 8, -1, -16 },
  { 189, 9, 16, 8, -1, -16 },
  { 207, 8, 16, 8, 0, -16 },
  { 223, 9, 16, 8, -1, -16 },
  { 241, 8, 16, 8, 0, -16 },
  { 257, 7, 16, 8, 1, -16 },
  { 271, 8, 16, 8, 0, -16 },
  { 287, 7, 16, 8, 0, -16 },
  { 301, 3, 12, 3, 0, -12 },
  { 306, 4, 15, 3, -1, -12 },
  { 314, 7, 9, 9, 1, -12 },
  { 322, 7, 5, 9, 1, -10 },
  { 327, 7, 9, 9, 1, -12 },
  { 335, 6, 16, 5, 0, -16 },
  { 347, 10, 18, 11, 1, -16 },
  { 370, 8, 16, 7, -2, -16 },
  { 386, 8, 16, 8, 0, -16 },
  { 402, 8, 16, 7, 1, -16 },
  { 418, 9, 16, 9, 0, -16 },
  { 436, 8, 16, 7, 0, -16 },
  { 452, 8, 16, 7, 0, -16 },
  { 468, 9, 16, 10, 1, -16 },
  { 486, 10, 16, 10, 0, -16 },
  { 506, 6, 16, 4, -1, -16 },
  { 518, 7, 20, 3, -3, -16 },
  { 536, 9, 16, 8, 0, -16 },
  { 554, 5, 16, 7, 0, -16 },
  { 564, 13, 16, 13, 0, -16 },
  { 590, 10, 16, 10, 0, -16 },
  { 610, 8, 16, 10, 1, -16 },
  { 626, 8, 16, 8, 0, -16 },
  { 642, 8, 20, 10, 1, -16 },
  { 662, 8, 16, 8, 0, -16 },
  { 678, 9, 16, 8, -1, -16 },
  { 696, 7, 16, 6, 1, -16 },
  { 710, 9, 16, 9, 1, -16 },
  { 728, 7, 16, 8, 2, -16 },
  { 742, 13, 16, 13, 2, -16 },
  { 768, 9, 16, 7, -1, -16 },
  { 786, 7, 16, 6, 1, -16 },
  { 800, 9, 16, 7, -1, -16 },
  { 818, 7, 19, 6, 0, -16 },
  { 835, 3, 16, 7, 2, -16 },
  { 841, 7, 19, 6, -1, -16 },
  { 858, 7, 8, 9, 1, -16 },
  { 865, 6, 1, 6, -2, 2 },
  { 866, 2, 4, 5, 3, -17 },
  { 867, 7, 12, 8, 1, -12 },
  { 878, 8, 17, 8, 0, -17 },
  { 895, 6, 12, 6, 1, -12 },
  { 904, 8, 17, 8, 1, -17 },
  { 921, 6, 12, 7, 1, -12 },
  { 930, 10, 22, 4, -3, -17 },
  { 958, 8, 17, 8, 0, -12 },
  { 975, 7, 17, 8, 0, -17 },
  { 990, 4, 16, 3, 0, -16 },
  { 998, 7, 21, 4, -3, -16 },
  { 1017, 7, 17, 7, 0, -17 },
  { 1032, 4, 17, 3, 0, -17 },
  { 1041, 11, 12, 12, 0, -12 },
  { 1058, 7, 12, 8, 0, -12 },
  { 1069, 6, 12, 8, 1, -12 },
  { 1078, 9, 17, 8, -1, -12 },
  { 1098, 7, 17, 8, 1, -12 },
  { 1113, 6, 12, 5, 0, -12 },
  { 1122, 6, 12, 6, 0, -12 },
  { 1131, 4, 14, 4, 0, -14 },
  { 1138, 7, 12, 8, 1, -12 },
  { 1149, 6, 12, 6, 1, -12 },
  { 1158, 10, 12, 10, 1, -12 },
  { 1173, 8, 12, 6, -1, -12 },
  { 1185, 11, 17, 6, -3, -12 },
  { 1209, 7, 12, 5, -1, -12 },
  { 1220, 7, 19, 7, 1, -16 },
  { 1237, 1, 22, 8, 3, -17 },
  { 1240, 7, 19, 7, -1, -16 },
  { 1257, 7, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC22PT7B_H_
