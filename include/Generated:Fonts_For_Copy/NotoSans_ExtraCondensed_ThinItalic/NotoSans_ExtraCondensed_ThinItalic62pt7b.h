#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x31, 0x03, 0x30, 0x23,
  0x06, 0x30, 0x62, 0x06, 0x20, 0x46, 0x04, 0x60, 0xC4, 0x0C, 0x40, 0x84,
  0x08, 0x40, 0x8C, 0x18, 0x81, 0x08, 0x10, 0x00, 0x02, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x10,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x07, 0xFF,
  0xFF, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x40, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x81,
  0x80, 0x01, 0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03,
  0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0xFF, 0xFF, 0xE0, 0x04, 0x04,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x40, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x61, 0x86, 0x00, 0xC1, 0x00, 0x01, 0x81,
  0x00, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x84, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x13, 0x00, 0x00, 0x13, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x60, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40,
  0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0xC1, 0x80, 0x80, 0x83,
  0x00, 0xE0, 0x8E, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x18,
  0x60, 0x04, 0x06, 0x0C, 0x01, 0x80, 0xC1, 0x80, 0x20, 0x30, 0x10, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x03,
  0x03, 0x01, 0x80, 0x60, 0x40, 0x30, 0x0C, 0x18, 0x06, 0x01, 0x82, 0x00,
  0x80, 0x20, 0xC0, 0x10, 0x0C, 0x10, 0x06, 0x01, 0x86, 0x00, 0xC0, 0x30,
  0x80, 0x18, 0x06, 0x30, 0x03, 0x01, 0x84, 0x1E, 0x60, 0x31, 0x8F, 0xEC,
  0x06, 0x21, 0x85, 0x81, 0x8C, 0x60, 0xF0, 0x31, 0x18, 0x1E, 0x0C, 0x63,
  0x03, 0xC1, 0x88, 0xC0, 0x78, 0x63, 0x18, 0x0D, 0xF8, 0x42, 0x01, 0x9E,
  0x18, 0xC0, 0x30, 0x02, 0x18, 0x04, 0x00, 0xC2, 0x00, 0x80, 0x10, 0xC0,
  0x30, 0x06, 0x18, 0x06, 0x00, 0x83, 0x00, 0xC0, 0x30, 0x60, 0x18, 0x06,
  0x08, 0x02, 0x01, 0x81, 0x00, 0xC0, 0x30, 0x20, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x06, 0x03, 0x00,
  0x40, 0xC0, 0x60, 0x08, 0x30, 0x18, 0x01, 0x8C, 0x03, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x38, 0xC0,
  0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x04,
  0x60, 0x00, 0x4C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xF0, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x61, 0x00, 0x0C, 0x18, 0x30,
  0xC1, 0x83, 0x18, 0x18, 0x23, 0x00, 0x86, 0x30, 0x0C, 0x66, 0x00, 0xC4,
  0x60, 0x0C, 0xC6, 0x00, 0x4C, 0x40, 0x06, 0x8C, 0x00, 0x78, 0xC0, 0x07,
  0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x0F, 0x06, 0x01,
  0x90, 0x60, 0x31, 0x03, 0x06, 0x18, 0x1F, 0xC1, 0x80, 0x20, 0x00, 0x18,
  0x8C, 0x63, 0x10, 0x8C, 0x62, 0x10, 0x84, 0x62, 0x10, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x40, 0x80, 0xE0, 0x80, 0x18, 0x81, 0x07,
  0x1F, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x80, 0x08, 0x40, 0x10, 0x40, 0x60,
  0x20, 0x40, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xFC, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18,
  0x03, 0x01, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x0C,
  0x00, 0x80, 0x40, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00,
  0x1F, 0x80, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x33, 0x18, 0x8C,
  0x2E, 0x19, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xC0, 0x60, 0x02, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x70, 0x06, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x32, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x30, 0x80, 0x00, 0x43,
  0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x04, 0x00,
  0x30, 0x18, 0x00, 0x40, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x0C,
  0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x20, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x80, 0x0E, 0x00, 0xE0, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x07, 0xC0, 0x0C, 0x7F, 0x80, 0x37, 0x03, 0x00, 0xD0, 0x06,
  0x02, 0x80, 0x08, 0x0E, 0x00, 0x30, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x0E, 0x0C,
  0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xE0, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x20, 0x01,
  0x80, 0x60, 0x02, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x30, 0x01, 0x80, 0xC0,
  0x01, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x86, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x10, 0x30, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30,
  0x20, 0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFE, 0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80,
  0x08, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00,
  0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x20, 0x03, 0xC1, 0x80, 0x14,
  0x0C, 0x01, 0xA0, 0x38, 0x3B, 0x00, 0xFF, 0x18, 0x01, 0xE0, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x03, 0x80, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x01, 0x06, 0x00, 0x78, 0x0C, 0x20, 0x0F, 0xE0,
  0x43, 0x00, 0xC3, 0x02, 0x18, 0x0C, 0x18, 0x10, 0x80, 0xC0, 0xC0, 0x8C,
  0x06, 0x04, 0x04, 0x60, 0x60, 0x60, 0x62, 0x02, 0x03, 0x03, 0x30, 0x30,
  0x18, 0x19, 0x81, 0x80, 0x80, 0xCC, 0x08, 0x0C, 0x04, 0x40, 0xC0, 0x60,
  0x62, 0x06, 0x03, 0x03, 0x30, 0x30, 0x30, 0x19, 0x81, 0x01, 0x80, 0x8C,
  0x18, 0x0C, 0x0C, 0x60, 0xC0, 0x60, 0x63, 0x06, 0x06, 0x02, 0x10, 0x30,
  0x30, 0x30, 0x81, 0x83, 0x81, 0x84, 0x0C, 0x14, 0x18, 0x20, 0x61, 0xA0,
  0x81, 0x01, 0x09, 0x0C, 0x08, 0x0F, 0xCF, 0xC0, 0x40, 0x38, 0x38, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x50, 0x00, 0x0D, 0x00, 0x00, 0xD0,
  0x00, 0x09, 0x00, 0x01, 0xB0, 0x00, 0x13, 0x00, 0x03, 0x30, 0x00, 0x33,
  0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x30, 0x30, 0x02,
  0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x30, 0x1F, 0xFF, 0x01, 0x80, 0x30, 0x10, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00,
  0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x7F, 0xE0, 0x00, 0xC1, 0xF0, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x30, 0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x60, 0x01,
  0x00, 0x80, 0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x20, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x18, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0x00, 0x70, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30,
  0x60, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x06, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x80,
  0x1C, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x1C, 0x02, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0xF0, 0x00, 0x60, 0x18, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x00, 0x01, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x08,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x10,
  0x00, 0x18, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x60, 0x03, 0x80, 0x60,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0x40, 0x38, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0x10, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xF0, 0x40,
  0x01, 0xFE, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00,
  0x70, 0x00, 0x80, 0x07, 0x80, 0x70, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x10, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x04, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x10, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x20, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x83, 0x00, 0x0F, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01,
  0xBC, 0x00, 0x00, 0x59, 0x00, 0x00, 0x34, 0x60, 0x00, 0x0E, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x10,
  0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0xA0, 0x00,
  0x00, 0xE0, 0x05, 0x00, 0x00, 0x0D, 0x00, 0x68, 0x00, 0x00, 0x78, 0x03,
  0x40, 0x00, 0x06, 0xC0, 0x12, 0x00, 0x00, 0x36, 0x00, 0x90, 0x00, 0x03,
  0x20, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x64, 0x00, 0x01, 0x98, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x11, 0x80, 0x00, 0x46, 0x00, 0x8C, 0x00, 0x06, 0x20,
  0x0C, 0x60, 0x00, 0x23, 0x00, 0x63, 0x00, 0x03, 0x18, 0x03, 0x18, 0x00,
  0x10, 0xC0, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x86, 0x00, 0x08, 0x20, 0x0C,
  0x30, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x04, 0x18, 0x03, 0x0C, 0x00, 0x60,
  0xC0, 0x10, 0x20, 0x03, 0x04, 0x01, 0x81, 0x00, 0x30, 0x20, 0x0C, 0x08,
  0x01, 0x83, 0x00, 0x60, 0x40, 0x18, 0x18, 0x02, 0x02, 0x00, 0xC0, 0xC0,
  0x10, 0x10, 0x0C, 0x04, 0x01, 0x80, 0x80, 0x60, 0x20, 0x0C, 0x06, 0x06,
  0x03, 0x00, 0x60, 0x30, 0x30, 0x18, 0x02, 0x01, 0x83, 0x00, 0xC0, 0x10,
  0x0C, 0x18, 0x04, 0x01, 0x80, 0x61, 0x80, 0x60, 0x0C, 0x03, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x40, 0x18, 0x02, 0x00, 0xC6, 0x00, 0x80, 0x30, 0x06,
  0x20, 0x04, 0x01, 0x80, 0x33, 0x00, 0x60, 0x0C, 0x01, 0x90, 0x03, 0x00,
  0x40, 0x0D, 0x80, 0x18, 0x02, 0x00, 0x28, 0x00, 0x80, 0x30, 0x01, 0xC0,
  0x04, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x08, 0x03,
  0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xA0, 0x00, 0x30, 0x05, 0x00,
  0x01, 0x00, 0x6C, 0x00, 0x08, 0x03, 0x60, 0x00, 0xC0, 0x1B, 0x00, 0x06,
  0x00, 0x88, 0x00, 0x30, 0x0C, 0x40, 0x01, 0x00, 0x63, 0x00, 0x18, 0x03,
  0x18, 0x00, 0xC0, 0x10, 0xC0, 0x06, 0x00, 0x82, 0x00, 0x30, 0x0C, 0x10,
  0x01, 0x00, 0x60, 0xC0, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x10, 0x30, 0x06,
  0x00, 0x81, 0x80, 0x20, 0x0C, 0x04, 0x01, 0x00, 0x60, 0x20, 0x18, 0x03,
  0x01, 0x80, 0xC0, 0x10, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x01,
  0x03, 0x00, 0x60, 0x08, 0x18, 0x03, 0x00, 0x60, 0xC0, 0x10, 0x03, 0x06,
  0x01, 0x80, 0x18, 0x20, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0x02, 0x18, 0x02,
  0x00, 0x10, 0xC0, 0x10, 0x00, 0xC6, 0x01, 0x80, 0x06, 0x20, 0x0C, 0x00,
  0x33, 0x00, 0x60, 0x00, 0x98, 0x02, 0x00, 0x04, 0xC0, 0x30, 0x00, 0x34,
  0x01, 0x80, 0x01, 0xA0, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x78, 0x02,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x06, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20,
  0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x60,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xC1, 0xE0, 0x01,
  0x80, 0xE0, 0x02, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x40, 0x20, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x08, 0x04, 0x00, 0x30, 0x08, 0x00, 0x40,
  0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x06, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x20, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x1C, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xC3, 0xE0, 0x01, 0x80, 0xE0, 0x02, 0x00, 0xC0,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x01, 0x00, 0x60, 0x03, 0x00,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x18,
  0x00, 0x40, 0x20, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x04, 0x03, 0x00,
  0x18, 0x04, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0E,
  0x00, 0xC0, 0x38, 0x01, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x40, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x08, 0x02, 0x00, 0x10, 0x04, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x18, 0x00, 0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18, 0x00, 0x08, 0x08,
  0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01,
  0x80, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00, 0x20,
  0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x10, 0x00,
  0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x02, 0x03, 0x00,
  0x03, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x04, 0x01, 0x80, 0x06, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x02, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x03, 0x00, 0x01, 0xB0, 0x00, 0x18, 0x00, 0x09, 0x80,
  0x01, 0xC0, 0x00, 0xCC, 0x00, 0x0A, 0x00, 0x06, 0x60, 0x00, 0xD0, 0x00,
  0x63, 0x00, 0x06, 0x80, 0x03, 0x18, 0x00, 0x24, 0x00, 0x10, 0xC0, 0x03,
  0x20, 0x01, 0x86, 0x00, 0x13, 0x00, 0x0C, 0x30, 0x01, 0x98, 0x00, 0xC1,
  0x80, 0x0C, 0xC0, 0x06, 0x0C, 0x00, 0x46, 0x00, 0x20, 0x60, 0x06, 0x30,
  0x03, 0x03, 0x00, 0x21, 0x80, 0x18, 0x18, 0x03, 0x0C, 0x01, 0x80, 0xC0,
  0x18, 0x60, 0x0C, 0x06, 0x00, 0x83, 0x00, 0x40, 0x30, 0x0C, 0x18, 0x06,
  0x01, 0x80, 0x60, 0xC0, 0x30, 0x0C, 0x06, 0x06, 0x03, 0x00, 0x40, 0x30,
  0x30, 0x18, 0x02, 0x01, 0x01, 0x80, 0x80, 0x10, 0x18, 0x0C, 0x0C, 0x00,
  0x80, 0xC0, 0x40, 0x60, 0x04, 0x0C, 0x02, 0x06, 0x00, 0x20, 0x60, 0x10,
  0x30, 0x01, 0x02, 0x00, 0x81, 0x00, 0x08, 0x30, 0x04, 0x18, 0x00, 0x41,
  0x80, 0x20, 0xC0, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x08, 0x60,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x04, 0x60, 0x02, 0x30, 0x00, 0x23, 0x00,
  0x11, 0x80, 0x01, 0x10, 0x00, 0x98, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x03, 0x60, 0x00, 0x16, 0x00, 0x1B,
  0x00, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x80, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40,
  0x18, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC2,
  0x00, 0x18, 0x40, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x30, 0x20, 0x06, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C,
  0x0C, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0x42, 0x00, 0x08,
  0xC0, 0x01, 0x10, 0x00, 0x36, 0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18,
  0x04, 0x00, 0x60, 0x18, 0x03, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xC1, 0x06,
  0x08, 0x30, 0x41, 0x02, 0x0C, 0x00, 0x3F, 0x08, 0x07, 0x9C, 0xC0, 0x60,
  0x24, 0x06, 0x01, 0xA0, 0x60, 0x05, 0x02, 0x00, 0x38, 0x30, 0x01, 0xC1,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC2, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40,
  0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00,
  0x38, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x20, 0x0B, 0x01,
  0x80, 0xD8, 0x06, 0x0C, 0x80, 0x3F, 0xC4, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x3F, 0x00, 0x33, 0x9C, 0x01, 0x30, 0x30, 0x0B, 0x00, 0xC0, 0xF0,
  0x06, 0x07, 0x00, 0x30, 0x38, 0x00, 0x81, 0x80, 0x04, 0x0C, 0x00, 0x20,
  0xC0, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x02, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80,
  0x0C, 0x1E, 0x00, 0xC0, 0xF0, 0x06, 0x04, 0xC0, 0x60, 0x27, 0x0E, 0x03,
  0x1F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x00, 0xE3, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x20, 0x1F, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x18, 0x00, 0xF3,
  0x98, 0x01, 0x80, 0x90, 0x03, 0x00, 0xD0, 0x06, 0x00, 0x70, 0x04, 0x00,
  0x70, 0x0C, 0x00, 0x70, 0x08, 0x00, 0x60, 0x18, 0x00, 0x60, 0x10, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x40, 0x00, 0x80, 0xC0, 0x00,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x07, 0x00, 0x80, 0x07,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0A, 0x00, 0xC0, 0x1E, 0x00, 0x40, 0x16,
  0x00, 0x60, 0x36, 0x00, 0x30, 0xE4, 0x00, 0x3F, 0xC4, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x60, 0x60, 0x60, 0x30, 0x60, 0x18,
  0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x98, 0x00, 0x8C, 0x00,
  0xC4, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0xE1, 0x00, 0xE0, 0x83, 0xC0, 0xFF,
  0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x20, 0x60, 0x60, 0x1F, 0xF0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0x00,
  0x1E, 0x73, 0x00, 0x30, 0x12, 0x00, 0x60, 0x1A, 0x00, 0xC0, 0x0A, 0x00,
  0x80, 0x0E, 0x01, 0x80, 0x0E, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x02,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x10, 0x18,
  0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0xE0, 0x10,
  0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x03, 0xC0, 0x08,
  0x02, 0xC0, 0x0C, 0x06, 0xC0, 0x06, 0x1C, 0x80, 0x07, 0xF8, 0x80, 0x01,
  0xC1, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x8F, 0xC0, 0x1B, 0xCE,
  0x01, 0x30, 0x30, 0x14, 0x01, 0x03, 0xC0, 0x10, 0x38, 0x01, 0x03, 0x00,
  0x10, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x02, 0x04, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C,
  0x00, 0x40, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x81,
  0x80, 0x08, 0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x10,
  0x20, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02,
  0x04, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0x00,
  0x60, 0x08, 0x06, 0x00, 0xC0, 0x20, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01,
  0x03, 0x00, 0x08, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80,
  0x01, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0xD0, 0x00, 0x24,
  0xC0, 0x01, 0x46, 0x00, 0x1E, 0x30, 0x00, 0xE0, 0x80, 0x06, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x04,
  0x00, 0xC0, 0x20, 0x06, 0x03, 0x00, 0x10, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x8F, 0xC1, 0xFC, 0x01,
  0x38, 0xE3, 0x8E, 0x01, 0x60, 0x66, 0x06, 0x01, 0x40, 0x3C, 0x03, 0x03,
  0x80, 0x38, 0x03, 0x03, 0x80, 0x38, 0x03, 0x03, 0x00, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x03, 0x03, 0x00, 0x30, 0x03, 0x06, 0x00, 0x20, 0x02, 0x06,
  0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x06, 0x04, 0x00, 0x60, 0x06, 0x0C,
  0x00, 0x40, 0x04, 0x0C, 0x00, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0x0C, 0x08, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x80, 0x08, 0x18,
  0x01, 0x80, 0x08, 0x18, 0x01, 0x80, 0x18, 0x10, 0x01, 0x80, 0x18, 0x10,
  0x01, 0x00, 0x18, 0x30, 0x01, 0x00, 0x10, 0x30, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x00, 0x30, 0x20, 0x03, 0x00, 0x30, 0x20, 0x02, 0x00, 0x20, 0x60,
  0x06, 0x00, 0x20, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00, 0x60, 0x40,
  0x04, 0x00, 0x60, 0xC0, 0x04, 0x00, 0x40, 0x01, 0x8F, 0xC0, 0x13, 0xCE,
  0x01, 0x60, 0x30, 0x14, 0x03, 0x03, 0xC0, 0x10, 0x38, 0x01, 0x03, 0x00,
  0x10, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x60,
  0x02, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C,
  0x00, 0x40, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x81,
  0x00, 0x08, 0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x10,
  0x20, 0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x60, 0x02,
  0x04, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0xF0, 0x0E,
  0x06, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x10, 0xC0,
  0x02, 0x18, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x26, 0x00,
  0x04, 0xC0, 0x00, 0x98, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00,
  0x44, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0xC2, 0x00, 0x18, 0x60, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x30, 0x18, 0x0C, 0x03, 0x83, 0x00, 0x3F, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x31, 0xF8, 0x00, 0x11, 0xCE, 0x00, 0x09, 0x81,
  0x80, 0x05, 0x80, 0x60, 0x06, 0x80, 0x30, 0x03, 0x80, 0x08, 0x01, 0xC0,
  0x04, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x30,
  0x00, 0x40, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x08, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x06, 0x00, 0x78, 0x03,
  0x00, 0x34, 0x03, 0x00, 0x13, 0x07, 0x00, 0x08, 0xFF, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x08, 0x07, 0x3C, 0xC0,
  0x60, 0x64, 0x06, 0x01, 0xA0, 0x60, 0x05, 0x02, 0x00, 0x38, 0x30, 0x01,
  0xC1, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC2, 0x00, 0x04, 0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x40, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x03, 0x04,
  0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x01, 0xE0, 0x60, 0x0B,
  0x01, 0x80, 0xD8, 0x0E, 0x1C, 0x80, 0x3F, 0xCC, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x01, 0x8F, 0x80, 0x8E, 0x40, 0x4C, 0x00, 0x2C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x3C, 0x7C, 0x0E, 0x01, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x20, 0x0C,
  0x06, 0x03, 0x80, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x1F, 0xE3, 0xFC, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x7C, 0x03, 0x00, 0x06, 0x00, 0x30, 0x60, 0x02, 0x04,
  0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0x40,
  0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x08,
  0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x10, 0x20, 0x03,
  0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x80,
  0x0C, 0x08, 0x01, 0xC0, 0x80, 0x1C, 0x08, 0x02, 0x80, 0xC0, 0x68, 0x0E,
  0x1C, 0x80, 0x7F, 0x98, 0x01, 0xC0, 0x00, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x18, 0x80,
  0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x60, 0x80, 0x60, 0x80, 0xC0, 0x80,
  0xC0, 0x81, 0x80, 0x81, 0x80, 0x81, 0x00, 0x83, 0x00, 0x82, 0x00, 0x86,
  0x00, 0x86, 0x00, 0x8C, 0x00, 0x8C, 0x00, 0x88, 0x00, 0x98, 0x00, 0x90,
  0x00, 0xB0, 0x00, 0xB0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0x40,
  0x07, 0x00, 0x68, 0x00, 0xE0, 0x0D, 0x00, 0x3C, 0x01, 0x20, 0x05, 0x80,
  0x64, 0x01, 0xB0, 0x0C, 0x80, 0x26, 0x01, 0x10, 0x0C, 0xC0, 0x62, 0x01,
  0x98, 0x08, 0x40, 0x23, 0x03, 0x08, 0x0C, 0x60, 0x61, 0x01, 0x0C, 0x08,
  0x20, 0x61, 0x83, 0x04, 0x0C, 0x30, 0x40, 0x81, 0x06, 0x18, 0x10, 0x60,
  0xC3, 0x02, 0x08, 0x18, 0x40, 0x43, 0x03, 0x18, 0x08, 0x60, 0x62, 0x01,
  0x08, 0x0C, 0x40, 0x23, 0x01, 0x18, 0x04, 0x40, 0x22, 0x00, 0x98, 0x04,
  0xC0, 0x12, 0x00, 0x90, 0x02, 0x40, 0x12, 0x00, 0x58, 0x02, 0xC0, 0x0A,
  0x00, 0x50, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x20, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x08, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x43, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00,
  0x02, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x82, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x01, 0x80, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xDE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x80, 0x0B, 0x07, 0x00, 0xF0, 0x0E, 0x0D, 0x00, 0x1F, 0xC0, 0x00, 0x30,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 44, 13, 1, -44 },
  { 67, 12, 16, 16, 6, -44 },
  { 91, 24, 44, 23, 0, -44 },
  { 223, 24, 51, 21, -1, -47 },
  { 376, 27, 46, 32, 3, -45 },
  { 532, 20, 46, 20, -1, -45 },
  { 647, 5, 16, 9, 6, -44 },
  { 657, 16, 54, 15, 2, -44 },
  { 765, 16, 54, 15, -4, -44 },
  { 873, 16, 17, 20, 7, -47 },
  { 907, 21, 28, 25, 2, -36 },
  { 981, 7, 14, 10, -2, -6 },
  { 994, 14, 2, 16, 1, -18 },
  { 998, 3, 4, 10, 1, -4 },
  { 1000, 25, 44, 18, -3, -44 },
  { 1138, 20, 46, 21, 1, -45 },
  { 1253, 10, 44, 21, 7, -44 },
  { 1308, 23, 45, 21, -2, -45 },
  { 1438, 23, 46, 21, -1, -45 },
  { 1571, 23, 45, 21, -1, -45 },
  { 1701, 24, 45, 21, -2, -44 },
  { 1836, 22, 46, 21, 1, -45 },
  { 1963, 22, 44, 21, 2, -44 },
  { 2084, 23, 46, 21, -1, -45 },
  { 2217, 21, 46, 21, 0, -45 },
  { 2338, 9, 33, 9, 0, -33 },
  { 2376, 12, 41, 10, -3, -33 },
  { 2438, 21, 26, 25, 2, -35 },
  { 2507, 21, 15, 25, 2, -29 },
  { 2547, 21, 26, 25, 2, -35 },
  { 2616, 16, 45, 15, 1, -45 },
  { 2706, 29, 51, 32, 2, -45 },
  { 2891, 20, 44, 20, -4, -44 },
  { 3001, 23, 44, 23, 0, -44 },
  { 3128, 24, 46, 21, 2, -45 },
  { 3266, 24, 44, 25, 0, -44 },
  { 3398, 24, 44, 21, 0, -44 },
  { 3530, 24, 44, 19, 0, -44 },
  { 3662, 27, 46, 28, 2, -45 },
  { 3818, 28, 44, 27, 0, -44 },
  { 3972, 19, 44, 10, -4, -44 },
  { 4077, 20, 55, 10, -9, -44 },
  { 4215, 26, 44, 21, 0, -44 },
  { 4358, 14, 44, 19, 0, -44 },
  { 4435, 37, 44, 36, 0, -44 },
  { 4639, 29, 44, 29, 0, -44 },
  { 4799, 24, 46, 28, 2, -45 },
  { 4937, 23, 44, 22, 0, -44 },
  { 5064, 24, 56, 28, 2, -45 },
  { 5232, 23, 44, 22, 0, -44 },
  { 5359, 25, 46, 21, -2, -45 },
  { 5503, 19, 44, 18, 4, -44 },
  { 5608, 25, 45, 26, 2, -44 },
  { 5749, 21, 44, 21, 5, -44 },
  { 5865, 37, 44, 37, 5, -44 },
  { 6069, 27, 44, 19, -4, -44 },
  { 6218, 19, 44, 18, 4, -44 },
  { 6323, 26, 44, 19, -3, -44 },
  { 6466, 22, 54, 17, -1, -44 },
  { 6615, 9, 44, 20, 6, -44 },
  { 6665, 22, 54, 17, -4, -44 },
  { 6814, 22, 21, 24, 2, -44 },
  { 6872, 16, 1, 16, -5, 6 },
  { 6874, 6, 9, 13, 9, -47 },
  { 6881, 21, 34, 24, 2, -33 },
  { 6971, 21, 48, 23, 0, -47 },
  { 7097, 16, 34, 17, 2, -33 },
  { 7165, 24, 48, 24, 2, -47 },
  { 7309, 17, 34, 20, 2, -33 },
  { 7382, 27, 62, 11, -8, -47 },
  { 7592, 24, 48, 23, -1, -33 },
  { 7736, 20, 47, 22, 0, -47 },
  { 7854, 12, 44, 10, 0, -44 },
  { 7920, 20, 59, 10, -8, -44 },
  { 8068, 21, 47, 18, 0, -47 },
  { 8192, 12, 47, 9, 0, -47 },
  { 8263, 32, 33, 34, 0, -33 },
  { 8395, 20, 33, 22, 0, -33 },
  { 8478, 19, 34, 22, 2, -33 },
  { 8559, 25, 47, 23, -3, -33 },
  { 8706, 21, 48, 24, 2, -33 },
  { 8832, 17, 33, 14, 0, -33 },
  { 8903, 19, 34, 17, -1, -33 },
  { 8984, 11, 42, 11, 1, -41 },
  { 9042, 20, 34, 22, 2, -33 },
  { 9127, 16, 33, 17, 4, -33 },
  { 9193, 27, 33, 29, 4, -33 },
  { 9305, 23, 33, 18, -3, -33 },
  { 9400, 28, 48, 18, -7, -33 },
  { 9568, 18, 33, 14, -2, -33 },
  { 9643, 21, 54, 19, 2, -44 },
  { 9785, 1, 62, 21, 10, -47 },
  { 9793, 21, 54, 19, -4, -44 },
  { 9935, 21, 5, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC62PT7B_H_
