#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x24, 0x44, 0x40, 0x08, 0xB6, 0xE0, 0x12, 0x28, 0x53,
  0xF2, 0x85, 0x12, 0x7C, 0x50, 0xA2, 0x85, 0x00, 0x08, 0x33, 0x14, 0x51,
  0x42, 0x04, 0x28, 0xA2, 0xAC, 0x41, 0x00, 0x73, 0x2A, 0x55, 0x4A, 0x96,
  0xF6, 0x95, 0x32, 0xA5, 0x4C, 0xE0, 0x39, 0x4A, 0x53, 0x11, 0x93, 0x9C,
  0xA5, 0xD0, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x21,
  0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x44, 0x80, 0x2A, 0x7E, 0x10,
  0x10, 0x41, 0x04, 0xFC, 0x41, 0x04, 0x56, 0xF0, 0x80, 0x02, 0x04, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x1C, 0x94, 0x51, 0x45,
  0x18, 0x62, 0x8A, 0x29, 0x18, 0x74, 0xA4, 0x94, 0x92, 0x40, 0x1E, 0x04,
  0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x07, 0xC0, 0x3C, 0x10, 0x41,
  0x08, 0xC0, 0x82, 0x08, 0x21, 0x38, 0x04, 0x31, 0x46, 0x29, 0x24, 0xA2,
  0xF8, 0x41, 0x04, 0x3C, 0x84, 0x10, 0x40, 0xC0, 0x82, 0x08, 0x21, 0x38,
  0x1C, 0x82, 0x10, 0x51, 0xA8, 0xA2, 0x8A, 0x28, 0x9C, 0x78, 0x42, 0x21,
  0x10, 0x88, 0x42, 0x21, 0x00, 0x3D, 0x14, 0x51, 0x28, 0xC5, 0x22, 0x8A,
  0x28, 0xBC, 0x3D, 0x14, 0x51, 0x45, 0x15, 0x8A, 0x08, 0x21, 0x38, 0x20,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x04, 0x44, 0x80, 0x0C, 0xCC, 0x18,
  0x10, 0x30, 0xFC, 0x00, 0x3F, 0xE0, 0x60, 0x43, 0x13, 0x80, 0x78, 0x42,
  0x11, 0x11, 0x08, 0x40, 0x01, 0x00, 0x0F, 0x11, 0x21, 0x4D, 0x55, 0x55,
  0x95, 0xA5, 0xA9, 0xBE, 0x80, 0x80, 0x40, 0x30, 0x08, 0x46, 0x31, 0x94,
  0xE9, 0x4A, 0x63, 0x10, 0x3C, 0x92, 0x49, 0x45, 0xE4, 0x91, 0x46, 0x28,
  0xBC, 0x3D, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x3C, 0x44,
  0x89, 0x14, 0x28, 0x50, 0xA2, 0x45, 0x12, 0x27, 0x80, 0x3C, 0x82, 0x08,
  0x41, 0xE4, 0x10, 0x82, 0x08, 0x3C, 0x3C, 0x82, 0x08, 0x41, 0x07, 0x90,
  0x82, 0x08, 0x20, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x23, 0x42, 0x85, 0x12,
  0x23, 0xC0, 0x21, 0x21, 0x22, 0x22, 0x42, 0x7E, 0x42, 0x44, 0x84, 0x84,
  0x84, 0x84, 0x18, 0x84, 0x22, 0x10, 0x84, 0x42, 0x11, 0xC0, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x23, 0x00, 0x22, 0x48, 0xA1, 0x45,
  0x0C, 0x14, 0x28, 0x91, 0x22, 0x24, 0x40, 0x22, 0x22, 0x44, 0x44, 0x88,
  0x8F, 0x20, 0x48, 0x12, 0x0C, 0x85, 0x51, 0x54, 0x65, 0x29, 0x4A, 0x94,
  0xA5, 0x49, 0x92, 0x44, 0x21, 0x21, 0x31, 0x31, 0x52, 0x52, 0x4A, 0x4A,
  0x4C, 0x8C, 0x84, 0x84, 0x3D, 0x14, 0x61, 0x86, 0x18, 0x61, 0x8A, 0x28,
  0xBC, 0x3C, 0x92, 0x49, 0x45, 0x27, 0x10, 0x42, 0x08, 0x20, 0x3D, 0x14,
  0x61, 0x86, 0x18, 0x61, 0x8A, 0x28, 0xB4, 0x20, 0x81, 0x00, 0x3C, 0x92,
  0x49, 0x45, 0x27, 0x14, 0x52, 0x48, 0xA2, 0x1E, 0x40, 0x81, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x08, 0x17, 0xC0, 0xF9, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x21, 0x00, 0x42, 0x89, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x89, 0x12, 0x47,
  0x80, 0x86, 0x18, 0xA2, 0x92, 0x49, 0x28, 0xA3, 0x0C, 0x20, 0x84, 0x61,
  0x18, 0xC6, 0x52, 0x94, 0xA5, 0x4A, 0x52, 0x94, 0xA6, 0x31, 0x88, 0x42,
  0x10, 0x12, 0x24, 0x50, 0xA0, 0x82, 0x04, 0x14, 0x28, 0x91, 0x24, 0x40,
  0x8C, 0x65, 0x26, 0x21, 0x08, 0x44, 0x21, 0x00, 0x1E, 0x04, 0x10, 0x20,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x07, 0xC0, 0x3C, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x0E, 0x00, 0xAA, 0xA9, 0x55, 0x1C, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x10, 0x50,
  0xA2, 0x24, 0x50, 0x40, 0xF0, 0x94, 0x3C, 0x94, 0x51, 0x86, 0x28, 0xA2,
  0x70, 0x20, 0x82, 0x08, 0x3C, 0x94, 0x51, 0x45, 0x18, 0xA2, 0xF0, 0x78,
  0x88, 0x88, 0x88, 0xE0, 0x02, 0x04, 0x08, 0x13, 0xC4, 0x91, 0x22, 0x85,
  0x12, 0x24, 0x47, 0x00, 0x3A, 0x52, 0x97, 0x42, 0x10, 0x70, 0x06, 0x10,
  0x20, 0x41, 0xC1, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20,
  0xC0, 0x3C, 0x94, 0x51, 0x86, 0x28, 0xA2, 0x70, 0x21, 0x04, 0xE0, 0x20,
  0x82, 0x08, 0x3C, 0x94, 0x52, 0x49, 0x28, 0xA2, 0x90, 0x20, 0x14, 0x92,
  0x52, 0x40, 0x08, 0x00, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x11, 0x18,
  0x20, 0x82, 0x08, 0x25, 0x25, 0x18, 0x61, 0x49, 0x24, 0x90, 0x24, 0x92,
  0x92, 0x4A, 0x48, 0x3B, 0x92, 0x51, 0x29, 0x14, 0x92, 0x4A, 0x25, 0x22,
  0x91, 0x00, 0x3C, 0x94, 0x52, 0x49, 0x28, 0xA2, 0x90, 0x39, 0x14, 0x51,
  0x86, 0x28, 0xA2, 0x70, 0x1E, 0x24, 0x89, 0x12, 0x24, 0x51, 0x22, 0x78,
  0x81, 0x04, 0x08, 0x00, 0x3C, 0x94, 0x51, 0x86, 0x28, 0xA2, 0x70, 0x21,
  0x04, 0x10, 0x3A, 0x10, 0x84, 0x22, 0x10, 0x80, 0x7A, 0x10, 0x82, 0x08,
  0x42, 0xE0, 0x25, 0x24, 0x94, 0x93, 0x00, 0x25, 0x14, 0x52, 0x49, 0x28,
  0xA4, 0xF0, 0x99, 0x9A, 0xAC, 0xC8, 0x80, 0x91, 0x92, 0xB2, 0xB2, 0xB4,
  0xD4, 0xD8, 0x88, 0x90, 0x24, 0x91, 0x84, 0x10, 0xC3, 0x12, 0x88, 0x11,
  0x12, 0x12, 0x12, 0x14, 0x14, 0x18, 0x18, 0x10, 0x10, 0x20, 0x20, 0xC0,
  0x38, 0x42, 0x22, 0x11, 0x08, 0xF0, 0x19, 0x08, 0x42, 0x21, 0x10, 0x42,
  0x21, 0x08, 0x41, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x10, 0x42, 0x08, 0x20, 0x8C, 0x00, 0xCD, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 3, 0, -12 },
  { 7, 3, 4, 4, 2, -12 },
  { 9, 7, 12, 6, 0, -12 },
  { 20, 6, 14, 6, 0, -13 },
  { 31, 7, 12, 9, 1, -12 },
  { 42, 5, 12, 5, 0, -12 },
  { 50, 1, 4, 2, 2, -12 },
  { 51, 5, 15, 4, 0, -12 },
  { 61, 4, 15, 4, -1, -12 },
  { 69, 4, 5, 5, 2, -13 },
  { 72, 6, 8, 7, 0, -10 },
  { 78, 2, 4, 3, -1, -2 },
  { 79, 4, 1, 4, 0, -5 },
  { 80, 1, 1, 3, 0, -1 },
  { 81, 7, 12, 5, -1, -12 },
  { 92, 6, 12, 6, 0, -12 },
  { 101, 3, 12, 6, 2, -12 },
  { 106, 7, 12, 6, -1, -12 },
  { 117, 6, 12, 6, 0, -12 },
  { 126, 6, 12, 6, 0, -12 },
  { 135, 6, 12, 6, 0, -12 },
  { 144, 6, 12, 6, 0, -12 },
  { 153, 5, 12, 6, 1, -12 },
  { 161, 6, 12, 6, 0, -12 },
  { 170, 6, 12, 6, 0, -12 },
  { 179, 3, 9, 3, 0, -9 },
  { 183, 4, 11, 3, -1, -9 },
  { 189, 6, 6, 7, 0, -9 },
  { 194, 6, 4, 7, 0, -8 },
  { 197, 6, 6, 7, 0, -9 },
  { 202, 5, 12, 4, 0, -12 },
  { 210, 8, 14, 9, 0, -12 },
  { 224, 5, 12, 6, -1, -12 },
  { 232, 6, 12, 6, 0, -12 },
  { 241, 6, 12, 6, 1, -12 },
  { 250, 7, 12, 7, 0, -12 },
  { 261, 6, 12, 6, 0, -12 },
  { 270, 6, 12, 5, 0, -12 },
  { 279, 7, 12, 8, 1, -12 },
  { 290, 8, 12, 7, 0, -12 },
  { 302, 5, 12, 3, -1, -12 },
  { 310, 5, 15, 3, -2, -12 },
  { 320, 7, 12, 6, 0, -12 },
  { 331, 4, 12, 5, 0, -12 },
  { 337, 10, 12, 10, 0, -12 },
  { 352, 8, 12, 8, 0, -12 },
  { 364, 6, 12, 8, 1, -12 },
  { 373, 6, 12, 6, 0, -12 },
  { 382, 6, 15, 8, 1, -12 },
  { 394, 6, 12, 6, 0, -12 },
  { 403, 7, 12, 6, -1, -12 },
  { 414, 5, 12, 5, 1, -12 },
  { 422, 7, 12, 7, 1, -12 },
  { 433, 6, 12, 6, 1, -12 },
  { 442, 10, 12, 10, 1, -12 },
  { 457, 7, 12, 5, -1, -12 },
  { 468, 5, 12, 5, 1, -12 },
  { 476, 7, 12, 5, -1, -12 },
  { 487, 6, 15, 5, 0, -12 },
  { 499, 2, 12, 5, 2, -12 },
  { 502, 6, 15, 5, -1, -12 },
  { 514, 7, 6, 7, 0, -12 },
  { 520, 4, 1, 4, -1, 1 },
  { 521, 2, 3, 3, 2, -13 },
  { 522, 6, 9, 6, 0, -9 },
  { 529, 6, 13, 6, 0, -13 },
  { 539, 4, 9, 5, 1, -9 },
  { 544, 7, 13, 6, 0, -13 },
  { 556, 5, 9, 6, 0, -9 },
  { 562, 7, 17, 3, -2, -13 },
  { 577, 6, 13, 6, 0, -9 },
  { 587, 6, 13, 6, 0, -13 },
  { 597, 3, 12, 3, 0, -12 },
  { 602, 5, 16, 3, -2, -12 },
  { 612, 6, 13, 5, 0, -13 },
  { 622, 3, 13, 3, 0, -13 },
  { 627, 9, 9, 9, 0, -9 },
  { 638, 6, 9, 6, 0, -9 },
  { 645, 6, 9, 6, 0, -9 },
  { 652, 7, 13, 6, -1, -9 },
  { 664, 6, 13, 6, 0, -9 },
  { 674, 5, 9, 4, 0, -9 },
  { 680, 5, 9, 5, 0, -9 },
  { 686, 3, 11, 3, 0, -11 },
  { 691, 6, 9, 6, 0, -9 },
  { 698, 4, 9, 5, 1, -9 },
  { 703, 8, 9, 8, 1, -9 },
  { 712, 6, 9, 5, -1, -9 },
  { 719, 8, 13, 5, -2, -9 },
  { 732, 5, 9, 4, -1, -9 },
  { 738, 5, 15, 5, 1, -12 },
  { 748, 1, 17, 6, 2, -13 },
  { 751, 6, 15, 5, -1, -12 },
  { 763, 5, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC17PT7B_H_
