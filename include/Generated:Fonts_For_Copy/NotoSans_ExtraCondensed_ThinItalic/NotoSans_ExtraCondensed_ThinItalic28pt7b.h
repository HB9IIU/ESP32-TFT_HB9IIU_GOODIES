#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x00, 0x00, 0x04, 0x30, 0x4A, 0x63, 0x29, 0x4A, 0x40, 0x02, 0x20, 0x48,
  0x11, 0x02, 0x20, 0x48, 0x11, 0x0F, 0xF8, 0x48, 0x11, 0x02, 0x20, 0x44,
  0x09, 0x02, 0x21, 0xFF, 0x09, 0x02, 0x20, 0x44, 0x09, 0x02, 0x20, 0x44,
  0x00, 0x01, 0x00, 0x40, 0xF8, 0x49, 0x12, 0x08, 0x82, 0x20, 0x90, 0x14,
  0x05, 0x00, 0x80, 0x10, 0x0A, 0x02, 0x40, 0x90, 0x24, 0x11, 0x04, 0x41,
  0x23, 0xF0, 0x10, 0x08, 0x02, 0x00, 0x1C, 0x12, 0x42, 0x24, 0x24, 0x44,
  0x44, 0x44, 0x48, 0x84, 0x88, 0x50, 0x89, 0x78, 0xA9, 0x92, 0x97, 0x51,
  0x05, 0x10, 0x91, 0x09, 0x11, 0x21, 0x12, 0x12, 0x22, 0x22, 0x24, 0x1C,
  0x0F, 0x09, 0x11, 0x11, 0x11, 0x12, 0x12, 0x14, 0x18, 0x18, 0x28, 0x28,
  0x45, 0x85, 0x85, 0x86, 0x82, 0x86, 0x86, 0xFA, 0x5A, 0xA8, 0x02, 0x08,
  0x20, 0x41, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x09, 0x11, 0x41, 0xF2, 0x89,
  0x21, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x24, 0xA5, 0x20, 0xFC, 0x70, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x00, 0x0F, 0x08, 0x84, 0x24, 0x12, 0x0A, 0x05, 0x04, 0x82, 0x81,
  0x40, 0xA0, 0x50, 0x28, 0x24, 0x12, 0x09, 0x08, 0x84, 0x42, 0x22, 0x1E,
  0x00, 0x19, 0x55, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x21, 0x00, 0x0F, 0x80, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x7F, 0x80, 0x07, 0xC1, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x01, 0x81, 0xC0, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x7E, 0x00, 0x00, 0x60,
  0x14, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x81, 0x20, 0x24, 0x08, 0x81, 0x10,
  0x42, 0x10, 0x82, 0x10, 0x82, 0x1F, 0xF4, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x07, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x1E, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x7E, 0x00, 0x07, 0x84, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0xBC, 0x61, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x04,
  0x82, 0x42, 0x21, 0x0F, 0x00, 0x3F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x0F, 0x84, 0x11, 0x04, 0x81, 0x20,
  0x48, 0x11, 0x08, 0x44, 0x0A, 0x03, 0x01, 0x41, 0x88, 0x41, 0x20, 0x48,
  0x12, 0x04, 0x81, 0x20, 0x48, 0x21, 0xF0, 0x0F, 0x08, 0x44, 0x24, 0x12,
  0x09, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x48, 0x63, 0xD0, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x1E, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x80, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x10, 0x88,
  0x44, 0x20, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x04, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x10, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x10, 0x00, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x03, 0xE0,
  0x20, 0x82, 0x04, 0x20, 0x12, 0x00, 0x90, 0x05, 0x0F, 0x28, 0x91, 0x48,
  0x8C, 0x44, 0x62, 0x25, 0x22, 0x29, 0x11, 0x48, 0x92, 0x4C, 0x92, 0x68,
  0x8C, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x32, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x28, 0x14, 0x12, 0x09, 0x04, 0x84, 0x42,
  0x21, 0xF1, 0x08, 0x84, 0x82, 0x41, 0x40, 0xA0, 0x50, 0x30, 0x10, 0x0F,
  0x81, 0x08, 0x20, 0x88, 0x11, 0x02, 0x20, 0x84, 0x10, 0x82, 0x21, 0x87,
  0xC0, 0x84, 0x10, 0x42, 0x08, 0x81, 0x10, 0x22, 0x04, 0x41, 0x10, 0x22,
  0x08, 0x7E, 0x00, 0x07, 0xE1, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x1E, 0x00, 0x0F, 0x81, 0x08, 0x20, 0x88,
  0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x22,
  0x04, 0x80, 0x90, 0x22, 0x04, 0x41, 0x10, 0x42, 0x18, 0x7C, 0x00, 0x0F,
  0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x07,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x7F, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0xFC, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x00, 0x03, 0xF0, 0xC0, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x81, 0xC8,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x40, 0x83,
  0xF0, 0x08, 0x08, 0x40, 0x42, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40,
  0x82, 0x04, 0x20, 0x21, 0xFF, 0x08, 0x08, 0x40, 0x82, 0x04, 0x20, 0x21,
  0x01, 0x08, 0x08, 0x40, 0x84, 0x04, 0x20, 0x21, 0x01, 0x00, 0x07, 0x81,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x1E, 0x00, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0xE0, 0x00, 0x08, 0x30, 0x82, 0x08, 0x41, 0x08, 0x11, 0x01, 0x10, 0x12,
  0x01, 0x40, 0x28, 0x02, 0x80, 0x34, 0x02, 0x40, 0x24, 0x04, 0x40, 0x42,
  0x04, 0x20, 0x42, 0x08, 0x20, 0x81, 0x08, 0x10, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x3F, 0x08,
  0x01, 0x84, 0x00, 0xC3, 0x00, 0xC2, 0x80, 0x61, 0x40, 0x50, 0xA0, 0x28,
  0x50, 0x24, 0x28, 0x14, 0x24, 0x12, 0x12, 0x09, 0x09, 0x04, 0x84, 0x84,
  0x42, 0x42, 0x42, 0x22, 0x21, 0x11, 0x10, 0x89, 0x08, 0x44, 0x88, 0x42,
  0x84, 0x20, 0xC2, 0x10, 0x41, 0x00, 0x08, 0x08, 0x60, 0x43, 0x02, 0x28,
  0x11, 0x41, 0x0A, 0x08, 0x48, 0x42, 0x42, 0x22, 0x11, 0x11, 0x08, 0x88,
  0x44, 0x42, 0x12, 0x20, 0x91, 0x05, 0x08, 0x28, 0x41, 0x44, 0x06, 0x20,
  0x21, 0x01, 0x00, 0x07, 0xC1, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x50,
  0x0A, 0x01, 0x40, 0x30, 0x06, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x24,
  0x04, 0x81, 0x10, 0x21, 0x08, 0x3E, 0x00, 0x0F, 0x82, 0x10, 0x84, 0x41,
  0x10, 0x44, 0x11, 0x04, 0x41, 0x20, 0x88, 0x42, 0x60, 0xE0, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x07, 0xC1, 0x08, 0x40,
  0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x30, 0x06, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x10, 0x21, 0x08, 0x3E, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0x82, 0x10, 0x84, 0x41,
  0x10, 0x44, 0x11, 0x04, 0x41, 0x20, 0x88, 0x43, 0xE0, 0x90, 0x24, 0x11,
  0x04, 0x21, 0x08, 0x42, 0x20, 0x88, 0x22, 0x08, 0x07, 0xE1, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x7F, 0x00,
  0xFF, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x10, 0x22, 0x04, 0x40,
  0x90, 0x12, 0x02, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20,
  0x48, 0x09, 0x01, 0x20, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0x3E, 0x00,
  0x80, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x84, 0x21,
  0x08, 0x82, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0C, 0x03,
  0x00, 0x80, 0x80, 0xC0, 0x40, 0xA0, 0x60, 0x50, 0x30, 0x48, 0x28, 0x24,
  0x14, 0x12, 0x0A, 0x11, 0x09, 0x08, 0x84, 0x88, 0x44, 0x44, 0x22, 0x22,
  0x11, 0x12, 0x09, 0x09, 0x04, 0x85, 0x02, 0x82, 0x81, 0x41, 0x40, 0xA0,
  0xC0, 0x60, 0x60, 0x30, 0x20, 0x10, 0x10, 0x00, 0x04, 0x10, 0x41, 0x04,
  0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x50, 0x05, 0x00, 0x90, 0x11, 0x01, 0x10, 0x21, 0x02, 0x10, 0x41,
  0x0C, 0x10, 0x81, 0x81, 0x82, 0x82, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xE0,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x7F, 0x00, 0x07, 0x84, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xE0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22,
  0x22, 0x22, 0x21, 0x07, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x83, 0xE0, 0x08, 0x03, 0x01,
  0x20, 0x48, 0x22, 0x08, 0x44, 0x11, 0x02, 0x80, 0xA0, 0x10, 0xFE, 0x89,
  0x10, 0x0E, 0x88, 0xC8, 0x28, 0x14, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x41,
  0x20, 0x90, 0x48, 0x64, 0x31, 0xE8, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x78, 0x62, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x48, 0x24,
  0x09, 0x02, 0x40, 0x90, 0x44, 0x13, 0x08, 0xBC, 0x00, 0x0E, 0x20, 0x82,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x1E, 0x00, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xA0, 0x8C, 0x20, 0x88,
  0x11, 0x04, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x42,
  0x18, 0x43, 0x07, 0xA0, 0x0E, 0x11, 0x21, 0x41, 0x42, 0x82, 0x8C, 0xF0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78, 0x00, 0x70, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x03, 0xC0, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x0E,
  0x00, 0x03, 0xA0, 0x8C, 0x20, 0x88, 0x11, 0x04, 0x20, 0x88, 0x11, 0x02,
  0x20, 0x44, 0x10, 0x82, 0x10, 0x42, 0x18, 0x43, 0x07, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x08, 0x40, 0xF0, 0x00, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x5C, 0x31, 0x10, 0x88, 0x48, 0x24, 0x12, 0x09, 0x09,
  0x04, 0x82, 0x41, 0x20, 0x90, 0x90, 0x48, 0x20, 0x08, 0x40, 0x00, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x38, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x42,
  0x22, 0x11, 0x11, 0x09, 0x05, 0x02, 0x81, 0xC0, 0x90, 0x88, 0x44, 0x22,
  0x11, 0x10, 0x88, 0x20, 0x08, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x11, 0x08, 0x00, 0x17, 0x3C, 0x63, 0x11, 0x08, 0x44,
  0x21, 0x20, 0x84, 0x82, 0x12, 0x10, 0x48, 0x41, 0x41, 0x09, 0x04, 0x24,
  0x20, 0x90, 0x82, 0x42, 0x0A, 0x08, 0x48, 0x21, 0x00, 0x17, 0x0C, 0x44,
  0x22, 0x12, 0x09, 0x04, 0x82, 0x42, 0x41, 0x20, 0x90, 0x48, 0x24, 0x24,
  0x12, 0x08, 0x0E, 0x11, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x84, 0x84, 0x78, 0x0B, 0xC1, 0x88, 0x20, 0x84, 0x11, 0x02,
  0x20, 0x44, 0x08, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0xC2,
  0x17, 0x82, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0E, 0x88,
  0xC8, 0x68, 0x14, 0x0A, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x48,
  0x64, 0x31, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x17,
  0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x1F, 0x20, 0x20, 0x40, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x04, 0x04, 0x08, 0xF8, 0x08, 0x41, 0x0F, 0x10, 0x82, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x81, 0x80, 0x20, 0x90, 0x48, 0x48, 0x24,
  0x12, 0x09, 0x04, 0x84, 0x82, 0x41, 0x20, 0x90, 0x88, 0x44, 0x63, 0xD0,
  0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA1, 0x42, 0x86, 0x0C, 0x10,
  0x20, 0x00, 0x82, 0x18, 0x61, 0x84, 0x28, 0xA2, 0x8A, 0x29, 0x24, 0x92,
  0x49, 0x28, 0xA2, 0x8A, 0x28, 0xC3, 0x0C, 0x50, 0x85, 0x08, 0x20, 0x82,
  0x00, 0x10, 0x44, 0x20, 0x88, 0x24, 0x0A, 0x02, 0x80, 0xC0, 0x20, 0x0C,
  0x05, 0x02, 0x40, 0x90, 0x42, 0x10, 0x88, 0x20, 0x04, 0x08, 0x20, 0x81,
  0x04, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24,
  0x01, 0x40, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x1F, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0xF8, 0x01,
  0x83, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04,
  0x0C, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x04, 0x01, 0xC0, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x03, 0xC0,
  0x78, 0xC3, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 20, 6, 0, -20 },
  { 16, 5, 7, 7, 3, -20 },
  { 21, 11, 20, 10, 0, -20 },
  { 49, 10, 23, 10, 0, -21 },
  { 78, 12, 20, 15, 1, -20 },
  { 108, 8, 20, 9, 0, -20 },
  { 128, 2, 7, 4, 3, -20 },
  { 130, 7, 24, 7, 1, -20 },
  { 151, 8, 24, 7, -2, -20 },
  { 175, 7, 7, 9, 3, -21 },
  { 182, 9, 13, 11, 1, -16 },
  { 197, 3, 7, 4, -1, -3 },
  { 200, 6, 1, 7, 1, -8 },
  { 201, 2, 2, 4, 0, -2 },
  { 202, 11, 20, 8, -1, -20 },
  { 230, 9, 20, 10, 1, -20 },
  { 253, 5, 20, 10, 3, -20 },
  { 266, 11, 20, 10, -1, -20 },
  { 294, 11, 20, 10, -1, -20 },
  { 322, 11, 20, 10, -1, -20 },
  { 350, 11, 20, 10, -1, -20 },
  { 378, 9, 20, 10, 1, -20 },
  { 401, 10, 20, 10, 1, -20 },
  { 426, 10, 20, 10, 0, -20 },
  { 451, 9, 20, 10, 0, -20 },
  { 474, 4, 15, 4, 0, -15 },
  { 482, 5, 19, 4, -1, -15 },
  { 494, 9, 12, 11, 1, -16 },
  { 508, 9, 7, 11, 1, -13 },
  { 516, 9, 12, 11, 1, -16 },
  { 530, 8, 20, 7, 0, -20 },
  { 550, 13, 23, 14, 1, -20 },
  { 588, 9, 20, 9, -2, -20 },
  { 611, 11, 20, 10, 0, -20 },
  { 639, 11, 20, 9, 1, -20 },
  { 667, 11, 20, 12, 0, -20 },
  { 695, 11, 20, 9, 0, -20 },
  { 723, 11, 20, 9, 0, -20 },
  { 751, 12, 20, 13, 1, -20 },
  { 781, 13, 20, 12, 0, -20 },
  { 814, 9, 20, 5, -2, -20 },
  { 837, 9, 25, 4, -4, -20 },
  { 866, 12, 20, 10, 0, -20 },
  { 896, 6, 20, 8, 0, -20 },
  { 911, 17, 20, 16, 0, -20 },
  { 954, 13, 20, 13, 0, -20 },
  { 987, 11, 20, 12, 1, -20 },
  { 1015, 10, 20, 10, 0, -20 },
  { 1040, 11, 25, 12, 1, -20 },
  { 1075, 10, 20, 10, 0, -20 },
  { 1100, 11, 20, 10, -1, -20 },
  { 1128, 8, 20, 8, 2, -20 },
  { 1148, 11, 20, 12, 1, -20 },
  { 1176, 10, 20, 10, 2, -20 },
  { 1201, 17, 20, 17, 2, -20 },
  { 1244, 12, 20, 8, -2, -20 },
  { 1274, 8, 20, 8, 2, -20 },
  { 1294, 11, 20, 9, -1, -20 },
  { 1322, 9, 24, 8, 0, -20 },
  { 1349, 4, 20, 9, 3, -20 },
  { 1359, 10, 24, 8, -2, -20 },
  { 1389, 10, 10, 11, 1, -20 },
  { 1402, 7, 1, 7, -2, 2 },
  { 1403, 3, 4, 6, 4, -21 },
  { 1405, 9, 15, 11, 1, -15 },
  { 1422, 10, 21, 10, 0, -21 },
  { 1449, 7, 15, 8, 1, -15 },
  { 1463, 11, 21, 11, 1, -21 },
  { 1492, 8, 15, 9, 1, -15 },
  { 1507, 12, 28, 5, -4, -21 },
  { 1549, 11, 22, 11, -1, -15 },
  { 1580, 9, 21, 10, 0, -21 },
  { 1604, 5, 20, 4, 0, -20 },
  { 1617, 9, 27, 5, -4, -20 },
  { 1648, 9, 21, 8, 0, -21 },
  { 1672, 5, 21, 4, 0, -21 },
  { 1686, 14, 15, 15, 0, -15 },
  { 1713, 9, 15, 10, 0, -15 },
  { 1730, 8, 15, 10, 1, -15 },
  { 1745, 11, 21, 10, -1, -15 },
  { 1774, 9, 22, 11, 1, -15 },
  { 1799, 8, 15, 7, 0, -15 },
  { 1814, 8, 15, 8, 0, -15 },
  { 1829, 6, 18, 5, 0, -18 },
  { 1843, 9, 15, 10, 1, -15 },
  { 1860, 7, 15, 8, 2, -15 },
  { 1874, 12, 15, 13, 2, -15 },
  { 1897, 10, 15, 8, -1, -15 },
  { 1916, 13, 22, 8, -3, -15 },
  { 1952, 8, 15, 6, -1, -15 },
  { 1967, 9, 24, 9, 1, -20 },
  { 1994, 1, 28, 10, 4, -21 },
  { 1998, 10, 24, 9, -2, -20 },
  { 2028, 9, 2, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC28PT7B_H_
