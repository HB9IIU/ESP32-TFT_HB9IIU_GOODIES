#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x00, 0x00, 0x00, 0x81, 0x02,
  0x00, 0x62, 0x85, 0x12, 0x24, 0x50, 0xA2, 0x44, 0x89, 0x10, 0x00, 0x84,
  0x01, 0x08, 0x02, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x84, 0x01,
  0x08, 0x1F, 0xFE, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x20, 0x10, 0x81, 0xFF, 0xE0, 0x42, 0x01, 0x08, 0x02,
  0x10, 0x04, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x02, 0x10,
  0x00, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x78, 0x06, 0x5C, 0x22, 0x00,
  0x88, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x06, 0x40, 0x09, 0x00,
  0x14, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x90,
  0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x08, 0x40, 0x22, 0x0E, 0xB0,
  0x07, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x00, 0x04, 0x00, 0x1A, 0x02,
  0x11, 0x04, 0x21, 0x04, 0x61, 0x08, 0x41, 0x08, 0x41, 0x10, 0x41, 0x10,
  0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x44, 0x84, 0xCB, 0x84, 0x91,
  0x85, 0x21, 0x89, 0x21, 0xF3, 0x61, 0x22, 0x41, 0x06, 0x41, 0x04, 0x41,
  0x04, 0x81, 0x08, 0x82, 0x08, 0x82, 0x10, 0x82, 0x10, 0x84, 0x20, 0x84,
  0x20, 0x88, 0x40, 0x78, 0x00, 0x80, 0x34, 0x06, 0x20, 0x42, 0x04, 0x20,
  0xC2, 0x08, 0x60, 0x84, 0x08, 0x40, 0x88, 0x04, 0x80, 0x50, 0x06, 0x00,
  0x40, 0x0E, 0x01, 0x20, 0x22, 0x16, 0x22, 0x41, 0x28, 0x12, 0x81, 0x48,
  0x14, 0x80, 0xC8, 0x08, 0x81, 0x88, 0x18, 0x82, 0x87, 0xC4, 0x69, 0x25,
  0x24, 0x90, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x00, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x04, 0x02, 0x11, 0x06, 0x98,
  0xF0, 0xA0, 0x88, 0x84, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13, 0x22,
  0x44, 0x88, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x36, 0x04, 0x20, 0x81, 0x08, 0x11, 0x01, 0x10, 0x13, 0x01, 0x20, 0x12,
  0x01, 0x60, 0x14, 0x03, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08,
  0x20, 0xC4, 0x07, 0x80, 0x06, 0x18, 0xD3, 0x28, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x00, 0x00, 0x40, 0x0E, 0xC0, 0x40, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x40, 0x0E, 0xE0, 0x40, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x1F, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x08, 0x18, 0x3F, 0xC0, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x40,
  0x0A, 0x00, 0x28, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x10, 0x04, 0x40,
  0x21, 0x01, 0x84, 0x04, 0x20, 0x20, 0x80, 0x82, 0x04, 0x08, 0x30, 0x20,
  0x81, 0x04, 0x04, 0x10, 0x12, 0xFF, 0xF0, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x42, 0x06, 0x0F, 0xE0, 0x00, 0x00, 0x20, 0x0E, 0xC0, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x84, 0x04, 0xD8, 0x28, 0x21, 0x81, 0x18, 0x0C, 0xC0, 0x24, 0x01, 0x20,
  0x19, 0x00, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x08,
  0x10, 0xC0, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x06, 0xE0, 0x20, 0xC1, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80,
  0x42, 0x01, 0x08, 0x04, 0x10, 0x20, 0x40, 0x81, 0x84, 0x02, 0x60, 0x06,
  0x00, 0x68, 0x03, 0x10, 0x10, 0x60, 0x80, 0x86, 0x02, 0x10, 0x04, 0x40,
  0x11, 0x00, 0x4C, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x82, 0x04, 0x07,
  0xE0, 0x00, 0x80, 0x1B, 0x01, 0x04, 0x10, 0x20, 0x80, 0x88, 0x04, 0x40,
  0x22, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x18,
  0x80, 0xC2, 0x0A, 0x0F, 0xB0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x81, 0xF0, 0x00, 0x0C,
  0x20, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x0C, 0x30, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x00, 0x02, 0x03, 0xB8, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0x00, 0x60, 0x00, 0x00,
  0x7E, 0x00, 0x60, 0x40, 0x20, 0x08, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00,
  0x11, 0x00, 0x04, 0x40, 0x41, 0x30, 0x78, 0x48, 0x22, 0x12, 0x10, 0x85,
  0x0C, 0x42, 0x42, 0x10, 0x90, 0x84, 0x24, 0x41, 0x0B, 0x10, 0x82, 0x84,
  0x21, 0x21, 0x08, 0x48, 0x46, 0x12, 0x11, 0x88, 0x84, 0xA2, 0x21, 0x6B,
  0x08, 0x31, 0x82, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x42, 0x02, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0xFF, 0x04, 0x08, 0x40,
  0x42, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x60, 0x0A,
  0x00, 0x70, 0x02, 0x03, 0xF0, 0x08, 0x20, 0x40, 0x41, 0x01, 0x04, 0x04,
  0x10, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x81, 0x84, 0x0C,
  0x1F, 0xC0, 0x43, 0x01, 0x02, 0x04, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01,
  0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x40, 0x42, 0x06,
  0x0F, 0xE0, 0x00, 0x00, 0x10, 0x01, 0xDC, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x04, 0x30,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x01,
  0x08, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0xC6, 0x01, 0x08,
  0x06, 0x10, 0x08, 0x20, 0x20, 0x40, 0x81, 0x06, 0x03, 0xF0, 0x00, 0x03,
  0xFC, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x1F, 0xE0, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0xFE, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x7B, 0x80, 0x40, 0x20, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0xF8, 0x40, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x10, 0x40, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x03, 0xFE, 0x00, 0x02,
  0x00, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x82, 0x00,
  0x41, 0xFF, 0xE0, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20, 0x04, 0x10,
  0x06, 0x08, 0x02, 0x04, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40,
  0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x00, 0x07, 0xE0, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x03, 0xE0, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0xB0,
  0x04, 0x00, 0x02, 0x03, 0x02, 0x06, 0x04, 0x04, 0x04, 0x08, 0x04, 0x10,
  0x04, 0x10, 0x08, 0x20, 0x08, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x16, 0x00, 0x16, 0x00, 0x19, 0x00, 0x11, 0x00, 0x21, 0x00,
  0x21, 0x00, 0x20, 0x80, 0x20, 0x80, 0x40, 0x80, 0x40, 0x80, 0x40, 0xC0,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x80, 0x60, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xFF, 0x02,
  0x00, 0x06, 0x04, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x28, 0x00, 0xE0, 0x50,
  0x01, 0x40, 0xA0, 0x02, 0x82, 0x40, 0x0A, 0x04, 0x80, 0x14, 0x09, 0x00,
  0x48, 0x12, 0x00, 0x90, 0x24, 0x02, 0x20, 0x88, 0x04, 0x81, 0x10, 0x11,
  0x02, 0x20, 0x22, 0x04, 0x40, 0x84, 0x08, 0x81, 0x08, 0x21, 0x04, 0x20,
  0x42, 0x08, 0x40, 0x84, 0x20, 0x81, 0x08, 0x41, 0x04, 0x11, 0x04, 0x08,
  0x22, 0x08, 0x10, 0x28, 0x10, 0x20, 0x50, 0x20, 0x40, 0xE0, 0x41, 0x01,
  0x81, 0x02, 0x03, 0x02, 0x00, 0x02, 0x00, 0x40, 0x80, 0x10, 0x50, 0x08,
  0x14, 0x02, 0x05, 0x00, 0x81, 0x40, 0x20, 0x90, 0x08, 0x22, 0x04, 0x08,
  0x81, 0x02, 0x20, 0x40, 0x88, 0x10, 0x42, 0x04, 0x10, 0x82, 0x04, 0x10,
  0x81, 0x04, 0x20, 0x41, 0x08, 0x20, 0x44, 0x08, 0x11, 0x02, 0x02, 0x40,
  0x80, 0x90, 0x60, 0x24, 0x10, 0x0A, 0x04, 0x02, 0x81, 0x00, 0xA0, 0x40,
  0x18, 0x20, 0x06, 0x08, 0x01, 0x00, 0x00, 0x20, 0x03, 0xB0, 0x08, 0x10,
  0x20, 0x30, 0xC0, 0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x02,
  0x40, 0x05, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20,
  0x04, 0x40, 0x10, 0x40, 0x20, 0x80, 0x81, 0x82, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x08, 0x60, 0x40, 0x81, 0x01, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42,
  0x01, 0x08, 0x0C, 0x20, 0x20, 0x80, 0x84, 0x04, 0x10, 0x30, 0x41, 0x81,
  0xF8, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x03, 0xB0, 0x08, 0x10, 0x20, 0x30, 0xC0, 0x21, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x50, 0x01, 0x20, 0x02, 0x40, 0x05, 0x80, 0x0A, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x10, 0x40, 0x20, 0x80, 0x81,
  0x82, 0x01, 0xF8, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x08, 0x60, 0x40, 0x81, 0x01,
  0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x80,
  0x84, 0x04, 0x10, 0x30, 0x41, 0x81, 0xF0, 0x04, 0x40, 0x21, 0x00, 0x84,
  0x02, 0x08, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x42, 0x01, 0x08, 0x04, 0x00, 0x00, 0x20, 0x03, 0xBC, 0x08, 0x08, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x82, 0x02, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x00, 0x04, 0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08,
  0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x20,
  0x04, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x20, 0x80, 0x20, 0x80,
  0x20, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x80, 0x3F, 0x00, 0x80, 0x0C, 0x00,
  0xA0, 0x05, 0x00, 0x68, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x84,
  0x04, 0x20, 0x61, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x80, 0x84,
  0x04, 0x60, 0x22, 0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00,
  0xA0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x24, 0x08, 0x81, 0x10, 0x22, 0x04, 0x40, 0x88, 0x11, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x10, 0x82, 0x08, 0x82, 0x08, 0x42, 0x08, 0x21, 0x08,
  0x40, 0x88, 0x21, 0x02, 0x20, 0x88, 0x08, 0x82, 0x20, 0x24, 0x08, 0x80,
  0x90, 0x24, 0x02, 0x80, 0x90, 0x0A, 0x02, 0x80, 0x28, 0x0A, 0x00, 0xC0,
  0x28, 0x03, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x00, 0x03, 0x01, 0x01, 0x02,
  0x01, 0x02, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10,
  0x01, 0x30, 0x00, 0xA0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40,
  0x18, 0x40, 0x10, 0x40, 0x20, 0x40, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x40, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x21, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x84,
  0x21, 0x04, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x21, 0x04, 0x21,
  0x08, 0x42, 0x18, 0x42, 0x01, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0xFC, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x48, 0x01, 0x20, 0x08, 0x40, 0x21, 0x01, 0x06, 0x04, 0x08,
  0x20, 0x30, 0x80, 0x44, 0x01, 0x90, 0x02, 0x80, 0x0C, 0xFF, 0xC0, 0x91,
  0x22, 0x40, 0x07, 0xC8, 0x61, 0x46, 0x0A, 0x20, 0x22, 0x01, 0x10, 0x09,
  0x80, 0x48, 0x04, 0x40, 0x22, 0x01, 0x30, 0x09, 0x00, 0x48, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x18, 0x80, 0xC6, 0x0C, 0x10, 0xA0, 0x79, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x4F, 0x82, 0x84, 0x18, 0x10, 0xC0, 0x8C, 0x04, 0x60, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x32, 0x01, 0x10, 0x08, 0x80,
  0x4C, 0x04, 0x60, 0x23, 0x02, 0x18, 0x11, 0x41, 0x09, 0xF0, 0x00, 0x07,
  0xC3, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00, 0xF8,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x0F, 0x90, 0x30, 0xA0, 0xC1, 0x41, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x30, 0x18, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86,
  0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0xC1, 0x01,
  0x83, 0x06, 0x02, 0x14, 0x03, 0xC8, 0x00, 0x07, 0xC1, 0x0C, 0x60, 0x88,
  0x12, 0x02, 0x40, 0x90, 0x12, 0x04, 0x43, 0x1F, 0x82, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x04, 0x1F, 0x80, 0x00,
  0x07, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0xF0, 0x00, 0x01, 0xF2, 0x06, 0x14, 0x18, 0x28, 0x20, 0x20, 0x80,
  0x41, 0x00, 0x86, 0x03, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21,
  0x00, 0x42, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x18, 0x20, 0x30, 0x40,
  0xC0, 0x42, 0x80, 0x79, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x04, 0x08, 0x07, 0xE0, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x9F, 0x0A, 0x10, 0xC1, 0x08, 0x10, 0x81, 0x18, 0x11, 0x01, 0x10, 0x11,
  0x03, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40, 0x44,
  0x04, 0x40, 0x44, 0x08, 0x80, 0x80, 0x02, 0x0C, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x00, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x0E, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0xC2, 0x0C, 0x10, 0x40, 0x84, 0x0C, 0x40, 0x44,
  0x02, 0x20, 0x12, 0x00, 0xB0, 0x0A, 0x80, 0x54, 0x03, 0x20, 0x10, 0x80,
  0x84, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x81, 0x08, 0x08, 0x00,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x06,
  0x08, 0x00, 0x09, 0xE3, 0xE0, 0xA1, 0x42, 0x0C, 0x18, 0x10, 0x81, 0x01,
  0x18, 0x10, 0x21, 0x01, 0x02, 0x10, 0x10, 0x21, 0x02, 0x02, 0x10, 0x20,
  0x22, 0x02, 0x04, 0x20, 0x20, 0x42, 0x02, 0x04, 0x20, 0x40, 0x42, 0x04,
  0x0C, 0x40, 0x40, 0x84, 0x04, 0x08, 0x40, 0x80, 0x84, 0x08, 0x08, 0x40,
  0x81, 0x08, 0x08, 0x10, 0x09, 0xF0, 0xA1, 0x0C, 0x10, 0x81, 0x18, 0x11,
  0x01, 0x10, 0x11, 0x01, 0x10, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x22,
  0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x88, 0x08, 0x07, 0xC0,
  0x82, 0x18, 0x21, 0x02, 0x20, 0x12, 0x01, 0x60, 0x34, 0x02, 0x40, 0x24,
  0x02, 0xC0, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x88,
  0x10, 0x43, 0x07, 0xE0, 0x02, 0x7C, 0x05, 0x08, 0x0C, 0x08, 0x18, 0x10,
  0x20, 0x20, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20,
  0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86, 0x02, 0x0C, 0x04, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x81, 0x3E, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xC8, 0x61, 0x46, 0x0A, 0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x04,
  0x40, 0x22, 0x01, 0x10, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10,
  0x18, 0x80, 0xC4, 0x0C, 0x10, 0xA0, 0xF9, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x09,
  0xE1, 0x40, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x00, 0x07, 0xE0, 0x81, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x81, 0x0F, 0xE0, 0x08, 0x10, 0x20,
  0x41, 0x0F, 0xC4, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0xE0, 0x10, 0x11, 0x01, 0x10, 0x11,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40, 0x44,
  0x04, 0x40, 0x44, 0x08, 0x80, 0x88, 0x08, 0x81, 0x88, 0x28, 0x83, 0x07,
  0xD0, 0x80, 0x60, 0x38, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x22, 0x08, 0x84,
  0x21, 0x08, 0xC2, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x50, 0x50, 0x28, 0x28, 0x14,
  0x24, 0x12, 0x12, 0x09, 0x09, 0x08, 0x88, 0x84, 0x84, 0x42, 0x44, 0x22,
  0x22, 0x11, 0x11, 0x09, 0x09, 0x04, 0x84, 0x82, 0x42, 0x41, 0x41, 0x40,
  0xA0, 0xA0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x00, 0x04, 0x04, 0x10,
  0x20, 0x41, 0x80, 0x84, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0xA0, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x80, 0x22, 0x00, 0x88, 0x04,
  0x20, 0x10, 0x80, 0x81, 0x04, 0x04, 0x30, 0x10, 0x01, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x60, 0x10, 0x20, 0x08, 0x10, 0x04, 0x10, 0x02,
  0x08, 0x01, 0x08, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x7F, 0x00, 0x00, 0x78, 0x06, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x03, 0x00, 0xE0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x38, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0xF0, 0x00, 0x3C, 0x0E, 0x18, 0x60, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 27, 8, 1, -27 },
  { 25, 7, 10, 10, 4, -27 },
  { 34, 15, 27, 14, 0, -27 },
  { 85, 14, 31, 13, 0, -29 },
  { 140, 16, 28, 20, 2, -28 },
  { 196, 12, 28, 12, 0, -28 },
  { 238, 3, 10, 5, 4, -27 },
  { 242, 10, 33, 9, 1, -27 },
  { 284, 11, 33, 9, -3, -27 },
  { 330, 9, 10, 12, 5, -29 },
  { 342, 13, 17, 15, 1, -22 },
  { 370, 4, 8, 6, -1, -3 },
  { 374, 8, 1, 10, 1, -11 },
  { 375, 1, 3, 6, 1, -3 },
  { 376, 16, 27, 11, -2, -27 },
  { 430, 12, 28, 13, 1, -28 },
  { 472, 7, 27, 13, 4, -27 },
  { 496, 14, 28, 13, -1, -28 },
  { 545, 14, 28, 13, -1, -28 },
  { 594, 14, 27, 13, -1, -27 },
  { 642, 14, 27, 13, -1, -27 },
  { 690, 13, 28, 13, 1, -28 },
  { 736, 13, 27, 13, 1, -27 },
  { 780, 14, 28, 13, -1, -28 },
  { 829, 13, 28, 13, 0, -28 },
  { 875, 6, 20, 6, 0, -20 },
  { 890, 8, 25, 6, -2, -20 },
  { 915, 13, 15, 15, 1, -21 },
  { 940, 13, 9, 15, 1, -18 },
  { 955, 13, 15, 15, 1, -21 },
  { 980, 11, 28, 9, 0, -28 },
  { 1019, 18, 30, 19, 1, -27 },
  { 1087, 13, 27, 12, -3, -27 },
  { 1131, 14, 27, 14, 0, -27 },
  { 1179, 15, 28, 13, 1, -28 },
  { 1232, 15, 27, 16, 0, -27 },
  { 1283, 14, 27, 13, 0, -27 },
  { 1331, 14, 27, 12, 0, -27 },
  { 1379, 17, 28, 17, 1, -28 },
  { 1439, 17, 27, 17, 0, -27 },
  { 1497, 11, 27, 6, -2, -27 },
  { 1535, 12, 34, 6, -5, -27 },
  { 1586, 16, 27, 13, 0, -27 },
  { 1640, 8, 27, 11, 0, -27 },
  { 1667, 23, 27, 22, 0, -27 },
  { 1745, 18, 27, 18, 0, -27 },
  { 1806, 15, 28, 17, 1, -28 },
  { 1859, 14, 27, 13, 0, -27 },
  { 1907, 15, 35, 17, 1, -28 },
  { 1973, 14, 27, 14, 0, -27 },
  { 2021, 15, 28, 13, -1, -28 },
  { 2074, 12, 27, 11, 2, -27 },
  { 2115, 16, 27, 16, 1, -27 },
  { 2169, 13, 27, 13, 3, -27 },
  { 2213, 22, 27, 23, 3, -27 },
  { 2288, 16, 27, 12, -2, -27 },
  { 2342, 12, 27, 11, 2, -27 },
  { 2383, 16, 27, 12, -2, -27 },
  { 2437, 14, 33, 10, -1, -27 },
  { 2495, 5, 27, 12, 4, -27 },
  { 2512, 13, 33, 10, -2, -27 },
  { 2566, 14, 13, 15, 1, -27 },
  { 2589, 10, 1, 10, -3, 3 },
  { 2591, 3, 6, 8, 6, -29 },
  { 2594, 13, 20, 14, 1, -20 },
  { 2627, 13, 29, 14, 0, -29 },
  { 2675, 10, 20, 10, 1, -20 },
  { 2700, 15, 29, 14, 1, -29 },
  { 2755, 11, 20, 12, 1, -20 },
  { 2783, 16, 38, 7, -5, -29 },
  { 2859, 15, 29, 14, -1, -20 },
  { 2914, 12, 29, 14, 0, -29 },
  { 2958, 7, 27, 6, 0, -27 },
  { 2982, 12, 36, 6, -5, -27 },
  { 3036, 13, 29, 11, 0, -29 },
  { 3084, 7, 29, 6, 0, -29 },
  { 3110, 20, 20, 21, 0, -20 },
  { 3160, 12, 20, 14, 0, -20 },
  { 3190, 12, 20, 14, 1, -20 },
  { 3220, 15, 29, 14, -2, -20 },
  { 3275, 13, 29, 14, 1, -20 },
  { 3323, 11, 20, 9, 0, -20 },
  { 3351, 12, 20, 10, -1, -20 },
  { 3381, 7, 25, 7, 1, -25 },
  { 3403, 12, 20, 14, 1, -20 },
  { 3433, 10, 20, 10, 2, -20 },
  { 3458, 17, 20, 17, 2, -20 },
  { 3501, 14, 20, 11, -2, -20 },
  { 3536, 17, 29, 11, -4, -20 },
  { 3598, 11, 20, 9, -1, -20 },
  { 3626, 13, 33, 12, 1, -27 },
  { 3680, 1, 38, 13, 6, -29 },
  { 3685, 13, 33, 12, -3, -27 },
  { 3739, 13, 3, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC38PT7B_H_
