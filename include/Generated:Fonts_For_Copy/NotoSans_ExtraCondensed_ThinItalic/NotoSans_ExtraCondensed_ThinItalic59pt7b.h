#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x66, 0x0C, 0xC1, 0x10, 0x22, 0x0C, 0xC1, 0x98, 0x32, 0x04, 0x40, 0x88,
  0x33, 0x06, 0x60, 0x88, 0x11, 0x02, 0x20, 0xC0, 0x00, 0x06, 0x04, 0x00,
  0x08, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x04, 0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x40, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC0, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x80, 0x01, 0x01, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x10,
  0x10, 0x07, 0xFF, 0xFE, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x02, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xDF, 0xC0, 0x38, 0xC3, 0x00, 0x83, 0x00, 0x06, 0x08,
  0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00,
  0x20, 0x40, 0x00, 0x81, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x86, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x30, 0x20,
  0x00, 0xC1, 0x80, 0x02, 0x06, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0xC1,
  0x8E, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xF0, 0x01, 0x81, 0x8C, 0x01, 0x81, 0x82, 0x00, 0x81, 0x81, 0x00,
  0xC0, 0xC0, 0x80, 0x40, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20, 0x10,
  0x30, 0x30, 0x08, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x04, 0x03,
  0x0C, 0x06, 0x01, 0x86, 0x03, 0x00, 0x86, 0x01, 0x80, 0xC3, 0x00, 0xC0,
  0x63, 0x00, 0x40, 0x31, 0x83, 0x20, 0x11, 0x87, 0xD0, 0x18, 0xC6, 0x38,
  0x0C, 0xC6, 0x0C, 0x0C, 0x66, 0x06, 0x06, 0x63, 0x03, 0x86, 0x33, 0x01,
  0xC6, 0x31, 0x80, 0xBE, 0x18, 0x80, 0x4C, 0x08, 0xC0, 0x60, 0x0C, 0x60,
  0x30, 0x04, 0x20, 0x18, 0x06, 0x10, 0x0C, 0x02, 0x18, 0x04, 0x03, 0x0C,
  0x02, 0x01, 0x06, 0x03, 0x01, 0x83, 0x01, 0x80, 0x81, 0x00, 0xC0, 0xC0,
  0x80, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20, 0x10, 0x30, 0x30,
  0x08, 0x18, 0x10, 0x06, 0x18, 0x18, 0x03, 0x18, 0x18, 0x00, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0xC6, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x10, 0x10, 0x02, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x01, 0x06,
  0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x01, 0x60,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x00,
  0x06, 0x30, 0x01, 0x86, 0x0C, 0x60, 0x41, 0x88, 0x08, 0x23, 0x01, 0x84,
  0x40, 0x31, 0x98, 0x02, 0x23, 0x00, 0x4C, 0x40, 0x0D, 0x88, 0x01, 0xA3,
  0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x02, 0x82,
  0x00, 0xD0, 0x60, 0x33, 0x06, 0x0C, 0x60, 0x7F, 0x04, 0x01, 0x00, 0x00,
  0x33, 0x32, 0x26, 0x64, 0x44, 0xCC, 0x88, 0x80, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x08, 0x10, 0x0C,
  0x20, 0x04, 0x40, 0x86, 0x9E, 0x03, 0xC0, 0x0E, 0x00, 0x32, 0x00, 0xC4,
  0x02, 0x04, 0x18, 0x08, 0x10, 0x08, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x08, 0x30, 0x61, 0x83, 0x04, 0x18, 0x20,
  0xC1, 0x04, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x5F, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xF0, 0x01, 0xC3, 0x00,
  0x60, 0x20, 0x08, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x10,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x66, 0x00, 0x08, 0xC0,
  0x01, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x04, 0x60, 0x01, 0x88, 0x00, 0x31, 0x00, 0x06, 0x20, 0x00, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x60, 0x06, 0x18, 0x00, 0x7E, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x0D, 0x07, 0x61, 0xCC, 0x61, 0x18, 0x22, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x80, 0x06, 0x03, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x80, 0x18, 0x06, 0x03, 0x80,
  0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x58, 0x00, 0x03, 0x40, 0x00,
  0x19, 0x00, 0x00, 0x44, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x62,
  0x00, 0x03, 0x08, 0x00, 0x08, 0x60, 0x00, 0x61, 0x80, 0x01, 0x06, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60,
  0x20, 0x01, 0x80, 0x80, 0x0C, 0x06, 0x00, 0x20, 0x18, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x00, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x30,
  0x03, 0x01, 0x80, 0x08, 0x06, 0x00, 0x20, 0x30, 0x01, 0x80, 0xFF, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0D, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x40, 0x06, 0x00,
  0xE0, 0x38, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x07, 0x00, 0x31, 0xFC, 0x03, 0x70, 0x60, 0x2C,
  0x03, 0x02, 0x80, 0x10, 0x70, 0x01, 0x87, 0x00, 0x18, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x20, 0xC0, 0x06, 0x04, 0x00, 0x60, 0x40, 0x0C, 0x06, 0x01,
  0x80, 0x20, 0x18, 0x03, 0x07, 0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x80, 0x07, 0x03, 0x00, 0x30, 0x06, 0x00, 0x80, 0x18, 0x06, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x10,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x60, 0x03, 0x03, 0x00, 0x04, 0x38,
  0x00, 0x19, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0xC0, 0x00,
  0xC1, 0x80, 0x06, 0x02, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x60, 0x20, 0x00, 0x81, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x81, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x70, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xF8, 0x00, 0xE0, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x02,
  0x02, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0xE1, 0x80, 0x0E, 0x0C, 0x01, 0x60, 0xC0, 0x34, 0x06, 0x0E, 0xC0,
  0x3F, 0x8C, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x08, 0x1C, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x07, 0x03, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC,
  0x0C, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20, 0x18,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x04, 0x01, 0xF8, 0x30, 0xC0, 0x31, 0x83, 0x0C,
  0x06, 0x18, 0x30, 0x80, 0xC1, 0x83, 0x18, 0x18, 0x10, 0x31, 0x81, 0x03,
  0x03, 0x10, 0x30, 0x30, 0x33, 0x02, 0x03, 0x02, 0x30, 0x60, 0x20, 0x22,
  0x06, 0x06, 0x06, 0x20, 0x40, 0x60, 0x66, 0x04, 0x04, 0x06, 0x60, 0xC0,
  0x40, 0x46, 0x0C, 0x0C, 0x0C, 0x60, 0xC0, 0xC0, 0xC4, 0x08, 0x0C, 0x08,
  0x40, 0x81, 0x81, 0x84, 0x08, 0x18, 0x18, 0x40, 0x83, 0x83, 0x04, 0x08,
  0x28, 0x30, 0xC0, 0xC6, 0x86, 0x0C, 0x0C, 0xCC, 0xC0, 0xC0, 0x78, 0x78,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x48,
  0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x06, 0x10,
  0x00, 0xC2, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20,
  0x06, 0x04, 0x00, 0x80, 0x80, 0x30, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x01, 0x01, 0xFF, 0xE0, 0x20, 0x04, 0x0C, 0x00, 0x81,
  0x80, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x0C,
  0x00, 0x23, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x13, 0x00, 0x02, 0x60,
  0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x04, 0x00,
  0x7F, 0xC0, 0x01, 0x07, 0xC0, 0x04, 0x01, 0x80, 0x30, 0x02, 0x00, 0xC0,
  0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0x40, 0x60, 0x01, 0x01, 0x80, 0x04,
  0x06, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x20, 0x30, 0x01, 0x80, 0x80, 0x0C, 0x02, 0x00, 0x20, 0x18, 0x03,
  0x80, 0x60, 0x18, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x10, 0x0E, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x08, 0x00, 0x40, 0x20, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x01, 0x81, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x40, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x08,
  0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x10, 0x03,
  0x00, 0x41, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x70, 0x10, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x83, 0xC0, 0x01, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x03,
  0x02, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x40, 0x00, 0x40, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x01, 0x02, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x01, 0x80, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x20, 0x1C, 0x00, 0xC7, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x04, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xC1, 0x00, 0x0F,
  0xF0, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x02, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x40, 0x03, 0x80, 0x70, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x60, 0x08, 0x00,
  0x08, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x30,
  0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x10,
  0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x18, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x18, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x20, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x20, 0x04,
  0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x04, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40,
  0x18, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x02, 0x38, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x02, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x60,
  0x00, 0x20, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x30, 0x00, 0x02, 0x10, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x9C, 0x00, 0x00, 0x4A, 0x00, 0x00, 0x69, 0x80, 0x00, 0x3C,
  0xC0, 0x00, 0x1C, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x40, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x04, 0x00, 0x10, 0x02, 0x00,
  0x08, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x14, 0x01, 0x60, 0x00,
  0x06, 0x80, 0x2C, 0x00, 0x00, 0xB0, 0x0D, 0x80, 0x00, 0x36, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x36, 0x00, 0x01, 0x90, 0x04, 0xC0, 0x00, 0x32, 0x00,
  0x98, 0x00, 0x0C, 0xC0, 0x31, 0x00, 0x01, 0x98, 0x06, 0x20, 0x00, 0x63,
  0x00, 0xC4, 0x00, 0x0C, 0x40, 0x10, 0x80, 0x03, 0x08, 0x02, 0x10, 0x00,
  0x63, 0x00, 0xC2, 0x00, 0x08, 0x60, 0x18, 0x40, 0x03, 0x08, 0x02, 0x08,
  0x00, 0x41, 0x00, 0x41, 0x00, 0x18, 0x20, 0x18, 0x30, 0x02, 0x0C, 0x03,
  0x06, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x10, 0x20, 0x08, 0x18, 0x06, 0x04,
  0x01, 0x03, 0x00, 0x81, 0x80, 0x60, 0x60, 0x30, 0x30, 0x0C, 0x0C, 0x04,
  0x06, 0x01, 0x81, 0x81, 0x80, 0x80, 0x20, 0x30, 0x20, 0x10, 0x04, 0x06,
  0x0C, 0x06, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0x30, 0x08, 0x60, 0x18, 0x04,
  0x01, 0x0C, 0x02, 0x00, 0x80, 0x23, 0x00, 0x40, 0x30, 0x04, 0x60, 0x18,
  0x06, 0x00, 0x98, 0x03, 0x00, 0xC0, 0x13, 0x00, 0x40, 0x10, 0x02, 0xC0,
  0x08, 0x02, 0x00, 0x58, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x20, 0x0F, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x60, 0x09, 0x00, 0x06,
  0x00, 0x90, 0x00, 0x60, 0x19, 0x00, 0x04, 0x01, 0x98, 0x00, 0x40, 0x19,
  0x80, 0x0C, 0x01, 0x18, 0x00, 0xC0, 0x10, 0x80, 0x0C, 0x03, 0x08, 0x00,
  0x80, 0x30, 0xC0, 0x08, 0x03, 0x0C, 0x01, 0x80, 0x20, 0xC0, 0x18, 0x02,
  0x04, 0x01, 0x00, 0x60, 0x40, 0x10, 0x06, 0x04, 0x03, 0x00, 0x60, 0x60,
  0x30, 0x04, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x20, 0x0C, 0x02, 0x02, 0x00,
  0xC0, 0x20, 0x60, 0x08, 0x03, 0x06, 0x00, 0x80, 0x30, 0x60, 0x18, 0x03,
  0x04, 0x01, 0x80, 0x10, 0x40, 0x18, 0x01, 0x0C, 0x01, 0x00, 0x10, 0xC0,
  0x10, 0x01, 0x8C, 0x03, 0x00, 0x18, 0x80, 0x30, 0x01, 0x98, 0x03, 0x00,
  0x09, 0x80, 0x20, 0x00, 0x98, 0x06, 0x00, 0x0D, 0x00, 0x60, 0x00, 0xD0,
  0x06, 0x00, 0x0F, 0x00, 0x40, 0x00, 0x70, 0x04, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0xE0, 0xE0, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x80,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x88, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x20, 0x00, 0x06, 0x40, 0x00, 0x09, 0x80, 0x00, 0x13, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0x70, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0x07, 0x80, 0x04, 0x07, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x03, 0x00,
  0x08, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x04, 0x02, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x10,
  0x1C, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x30, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x09, 0x80, 0x00, 0x13,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x20, 0x18, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x1F, 0x00,
  0x10, 0x1C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x60, 0x04, 0x02, 0x00,
  0x20, 0x30, 0x01, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02,
  0x02, 0x00, 0x30, 0x30, 0x01, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x40,
  0x18, 0x02, 0x0F, 0x80, 0x3F, 0xE0, 0x01, 0x82, 0x00, 0x08, 0x18, 0x00,
  0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0x80, 0x08, 0x04,
  0x00, 0x40, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x00, 0x18,
  0x08, 0x00, 0x40, 0xC0, 0x02, 0x06, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x38, 0x07, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x06, 0x00,
  0xE0, 0x1C, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x04, 0x06, 0x00, 0x04, 0x04,
  0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x08,
  0x00, 0x08, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40,
  0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x80,
  0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00,
  0x68, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00,
  0x18, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80,
  0x06, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0x80, 0x80, 0x18, 0x08,
  0x01, 0x00, 0x80, 0x30, 0x08, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00,
  0x80, 0x40, 0x08, 0x0C, 0x00, 0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x80,
  0x08, 0x10, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00, 0x86, 0x00, 0x08, 0x60,
  0x00, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x88, 0x00, 0x09, 0x80, 0x00, 0x90,
  0x00, 0x0B, 0x00, 0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x34, 0x00, 0x06, 0x00, 0x06, 0x40,
  0x00, 0x60, 0x00, 0x44, 0x00, 0x0E, 0x00, 0x0C, 0x40, 0x00, 0xA0, 0x00,
  0xC4, 0x00, 0x1A, 0x00, 0x08, 0x40, 0x01, 0x20, 0x01, 0x84, 0x00, 0x16,
  0x00, 0x10, 0x40, 0x03, 0x60, 0x03, 0x04, 0x00, 0x26, 0x00, 0x30, 0x40,
  0x06, 0x60, 0x02, 0x04, 0x00, 0x66, 0x00, 0x60, 0x40, 0x04, 0x60, 0x04,
  0x04, 0x00, 0xC6, 0x00, 0xC0, 0x40, 0x08, 0x60, 0x0C, 0x04, 0x01, 0x86,
  0x00, 0x80, 0x40, 0x18, 0x60, 0x18, 0x04, 0x01, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x60, 0x30, 0x04, 0x02, 0x04, 0x03, 0x00, 0x40, 0x60, 0x40, 0x20,
  0x04, 0x06, 0x04, 0x06, 0x00, 0x40, 0x40, 0x40, 0x40, 0x04, 0x0C, 0x04,
  0x0C, 0x00, 0x40, 0x80, 0x40, 0xC0, 0x04, 0x18, 0x04, 0x08, 0x00, 0x41,
  0x80, 0x41, 0x80, 0x04, 0x10, 0x04, 0x10, 0x00, 0x43, 0x00, 0x43, 0x00,
  0x04, 0x30, 0x04, 0x30, 0x00, 0xC6, 0x00, 0x42, 0x00, 0x0C, 0x60, 0x04,
  0x60, 0x00, 0xC4, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x04, 0xC0, 0x00, 0xCC,
  0x00, 0x4C, 0x00, 0x0C, 0x80, 0x04, 0x80, 0x00, 0xD8, 0x00, 0xD8, 0x00,
  0x0D, 0x00, 0x0D, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x10, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x26, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x64, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x08, 0x00,
  0x0C, 0x04, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00, 0x80,
  0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x80, 0x00, 0x40,
  0x00, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01,
  0x86, 0x00, 0x60, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x06, 0x02, 0x01, 0x80,
  0x80, 0xC0, 0x20, 0x20, 0x0C, 0x18, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x30,
  0x80, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x05, 0x80,
  0x01, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20,
  0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10, 0x18, 0x18, 0x18,
  0x08, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06,
  0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x80, 0x00, 0x1B, 0x00, 0x00, 0xC4, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x20, 0x00, 0x60, 0xC0, 0x03, 0x01, 0x00, 0x0C, 0x06,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00,
  0x01, 0xB8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x86, 0x10, 0x82, 0x10,
  0x42, 0x08, 0x00, 0x18, 0x00, 0x0F, 0xE3, 0x01, 0xC3, 0x20, 0x30, 0x1A,
  0x06, 0x00, 0xA0, 0xC0, 0x0E, 0x0C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00,
  0x08, 0x60, 0x01, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08,
  0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0xE0, 0x80, 0x0C, 0x0C, 0x01, 0x40,
  0xC0, 0x34, 0x06, 0x06, 0xC0, 0x70, 0xCC, 0x03, 0xF8, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x70,
  0x01, 0x1F, 0xC0, 0x13, 0x06, 0x03, 0x60, 0x20, 0x3C, 0x03, 0x02, 0x80,
  0x30, 0x38, 0x01, 0x03, 0x00, 0x10, 0x70, 0x01, 0x06, 0x00, 0x10, 0x60,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08,
  0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x61,
  0x00, 0x06, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08,
  0x30, 0x01, 0x83, 0x00, 0x10, 0x70, 0x03, 0x05, 0x80, 0x60, 0x58, 0x0C,
  0x04, 0xC1, 0x80, 0xC7, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0x01, 0x81, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x40, 0x3F, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x03, 0x06, 0x00, 0x3F, 0x8C, 0x00, 0xE1, 0x90,
  0x03, 0x01, 0xA0, 0x0C, 0x01, 0x40, 0x30, 0x03, 0x80, 0x60, 0x07, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20,
  0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x00, 0x06, 0x02, 0x00, 0x08, 0x04, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x10, 0x01, 0xC0, 0x20, 0x03, 0x80, 0x40, 0x0E, 0x00, 0xC0, 0x14, 0x01,
  0x80, 0x68, 0x01, 0x81, 0xB0, 0x03, 0x86, 0x60, 0x03, 0xF8, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFE, 0x01, 0x83, 0x03, 0x03, 0x06,
  0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x20,
  0x06, 0x60, 0x06, 0x60, 0x0C, 0x40, 0x18, 0x40, 0x70, 0xC7, 0xC0, 0xFE,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x30, 0x3F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x46,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x27, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0x8C, 0x00, 0xE1, 0x90, 0x03, 0x01, 0xA0, 0x0C, 0x01, 0x40,
  0x30, 0x03, 0x80, 0x60, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00,
  0x40, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08,
  0x04, 0x00, 0x30, 0x08, 0x00, 0x60, 0x10, 0x01, 0xC0, 0x20, 0x03, 0x80,
  0x40, 0x0E, 0x00, 0xC0, 0x14, 0x01, 0x80, 0x68, 0x01, 0x81, 0xB0, 0x03,
  0x86, 0x60, 0x03, 0xF8, 0x80, 0x00, 0x81, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x0F, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x47, 0xF0, 0x0B, 0x83,
  0x03, 0x40, 0x60, 0x70, 0x04, 0x0A, 0x00, 0x81, 0x80, 0x10, 0x30, 0x02,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08,
  0x30, 0x03, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x06, 0x00, 0x20,
  0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x30, 0x40, 0x04, 0x18, 0x00, 0x83,
  0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x60, 0x06, 0x0C,
  0x00, 0xC1, 0x00, 0x18, 0x20, 0x02, 0x0C, 0x00, 0x40, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x27, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x70, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x02, 0x03, 0x00, 0x20, 0x20, 0x02, 0x06,
  0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0xC6,
  0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x09, 0x60, 0x00, 0xB2, 0x00, 0x1E,
  0x20, 0x01, 0xC2, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x10, 0x30, 0x03,
  0x01, 0x00, 0x30, 0x10, 0x02, 0x01, 0x00, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x40, 0x08, 0x04, 0x00, 0x80, 0xC0, 0x0C,
  0x00, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x04, 0xFE, 0x1F, 0xE0, 0x16,
  0x0C, 0xC1, 0xC0, 0xF0, 0x1E, 0x03, 0x03, 0x80, 0x70, 0x04, 0x0E, 0x01,
  0xC0, 0x10, 0x30, 0x06, 0x00, 0x40, 0xC0, 0x18, 0x01, 0x06, 0x00, 0x60,
  0x0C, 0x18, 0x01, 0x00, 0x30, 0x60, 0x04, 0x00, 0xC1, 0x00, 0x30, 0x02,
  0x0C, 0x00, 0xC0, 0x08, 0x30, 0x03, 0x00, 0x60, 0xC0, 0x08, 0x01, 0x82,
  0x00, 0x60, 0x06, 0x08, 0x01, 0x80, 0x10, 0x60, 0x06, 0x00, 0x41, 0x80,
  0x10, 0x03, 0x06, 0x00, 0x40, 0x0C, 0x10, 0x03, 0x00, 0x20, 0x40, 0x0C,
  0x00, 0x83, 0x00, 0x30, 0x06, 0x0C, 0x00, 0x80, 0x18, 0x30, 0x02, 0x00,
  0x60, 0x80, 0x18, 0x01, 0x02, 0x00, 0x60, 0x04, 0x18, 0x01, 0x00, 0x30,
  0x60, 0x04, 0x00, 0xC1, 0x00, 0x30, 0x03, 0x04, 0x00, 0xC0, 0x08, 0x30,
  0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x23, 0xF8, 0x05, 0xC1, 0x81, 0xA0,
  0x30, 0x38, 0x02, 0x07, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x01, 0x06, 0x00,
  0x60, 0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x04, 0x18, 0x01,
  0x83, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0x83, 0x00, 0x10, 0x60, 0x06,
  0x0C, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x20, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x60,
  0x80, 0x0C, 0x10, 0x01, 0x06, 0x00, 0x60, 0x00, 0x18, 0x00, 0x3F, 0x80,
  0x18, 0x30, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x20, 0x80, 0x08, 0x60,
  0x02, 0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x02, 0x60, 0x00,
  0x98, 0x00, 0x26, 0x00, 0x09, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x13, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00,
  0x18, 0x80, 0x06, 0x20, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x10,
  0x18, 0x0C, 0x07, 0x0E, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0x1F, 0xC0, 0x04, 0xC1, 0x80, 0x36, 0x02, 0x00, 0xF0, 0x0C,
  0x02, 0x80, 0x30, 0x0E, 0x00, 0x40, 0x30, 0x01, 0x01, 0xC0, 0x04, 0x06,
  0x00, 0x10, 0x18, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00, 0x04, 0x0C, 0x00,
  0x10, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x81, 0x80, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00, 0x40, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x04,
  0x07, 0x00, 0x30, 0x1E, 0x01, 0x80, 0x48, 0x0C, 0x01, 0x30, 0x60, 0x04,
  0x7F, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xE3, 0x01, 0x83, 0x20, 0x30, 0x1A,
  0x06, 0x00, 0xA0, 0xC0, 0x0E, 0x0C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00,
  0x08, 0x60, 0x01, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08,
  0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0xE0, 0x80, 0x0C, 0x0C, 0x01, 0x40,
  0xC0, 0x3C, 0x06, 0x06, 0xC0, 0x70, 0xCC, 0x03, 0xF8, 0x80, 0x04, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x07, 0x01,
  0x1F, 0x01, 0x30, 0x03, 0x40, 0x02, 0x80, 0x02, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x38, 0x1C, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x20, 0x0C, 0x0C, 0x06, 0x03, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x1F, 0xE4, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x1F, 0x00, 0xC0, 0x04,
  0x00, 0x41, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC2, 0x00,
  0x21, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x41, 0x00, 0x10,
  0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x60,
  0x06, 0x18, 0x01, 0x84, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03,
  0x0C, 0x00, 0xC2, 0x00, 0x70, 0x80, 0x18, 0x20, 0x06, 0x08, 0x03, 0x82,
  0x01, 0xE0, 0x80, 0x50, 0x30, 0x64, 0x07, 0xF1, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x00, 0xC3,
  0x00, 0xC2, 0x00, 0xC6, 0x00, 0xC4, 0x00, 0xCC, 0x00, 0x4C, 0x00, 0x58,
  0x00, 0x58, 0x00, 0x50, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x06, 0x00, 0x68, 0x00, 0xC0, 0x09, 0x00, 0x38, 0x03, 0x20,
  0x05, 0x00, 0x44, 0x00, 0xE0, 0x08, 0x80, 0x3C, 0x03, 0x10, 0x05, 0x80,
  0x42, 0x01, 0xB0, 0x18, 0x40, 0x26, 0x02, 0x08, 0x0C, 0xC0, 0x41, 0x01,
  0x98, 0x18, 0x20, 0x23, 0x02, 0x04, 0x0C, 0x60, 0xC0, 0x81, 0x0C, 0x18,
  0x10, 0x61, 0x82, 0x02, 0x0C, 0x30, 0xC0, 0x41, 0x06, 0x10, 0x08, 0x60,
  0xC6, 0x01, 0x08, 0x18, 0xC0, 0x23, 0x03, 0x10, 0x04, 0x40, 0x66, 0x00,
  0x88, 0x0C, 0x80, 0x13, 0x01, 0x90, 0x02, 0x40, 0x36, 0x00, 0x58, 0x06,
  0x80, 0x0A, 0x00, 0xB0, 0x03, 0x40, 0x14, 0x00, 0x78, 0x02, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x60,
  0x01, 0x01, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x00,
  0x8C, 0x00, 0x02, 0x20, 0x00, 0x09, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0x60, 0x00,
  0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x30, 0x00, 0x20,
  0xC0, 0x01, 0x83, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x01, 0x80, 0x60,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x80, 0x08, 0x00, 0x10, 0x03, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x40, 0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20,
  0x18, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x10, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x16,
  0x1C, 0x01, 0xC0, 0x70, 0x68, 0x01, 0xFC, 0x00, 0x02, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 42, 12, 1, -42 },
  { 59, 11, 15, 15, 6, -42 },
  { 80, 23, 42, 22, 0, -42 },
  { 201, 22, 48, 20, -1, -45 },
  { 333, 25, 44, 31, 3, -43 },
  { 471, 19, 44, 19, -1, -43 },
  { 576, 4, 15, 8, 6, -42 },
  { 584, 15, 51, 14, 2, -42 },
  { 680, 16, 51, 14, -4, -42 },
  { 782, 15, 16, 19, 7, -45 },
  { 812, 20, 27, 24, 2, -34 },
  { 880, 7, 13, 9, -2, -5 },
  { 892, 13, 2, 15, 1, -17 },
  { 896, 3, 4, 9, 1, -4 },
  { 898, 24, 42, 17, -3, -42 },
  { 1024, 19, 44, 20, 1, -43 },
  { 1129, 11, 42, 20, 6, -42 },
  { 1187, 22, 43, 20, -2, -43 },
  { 1306, 21, 44, 20, -1, -43 },
  { 1422, 22, 43, 20, -1, -43 },
  { 1541, 23, 43, 20, -2, -42 },
  { 1665, 20, 44, 20, 1, -43 },
  { 1775, 20, 42, 20, 2, -42 },
  { 1880, 22, 44, 20, -1, -43 },
  { 2001, 20, 44, 20, 0, -43 },
  { 2111, 9, 31, 9, 0, -31 },
  { 2146, 12, 39, 9, -3, -31 },
  { 2205, 20, 24, 24, 2, -33 },
  { 2265, 20, 14, 24, 2, -28 },
  { 2300, 20, 24, 24, 2, -33 },
  { 2360, 16, 43, 14, 1, -43 },
  { 2446, 28, 47, 30, 1, -42 },
  { 2611, 19, 42, 19, -4, -42 },
  { 2711, 22, 42, 22, 0, -42 },
  { 2827, 23, 44, 20, 2, -43 },
  { 2954, 23, 42, 24, 0, -42 },
  { 3075, 22, 42, 20, 0, -42 },
  { 3191, 22, 42, 18, 0, -42 },
  { 3307, 26, 44, 27, 2, -43 },
  { 3450, 27, 42, 26, 0, -42 },
  { 3592, 17, 42, 10, -3, -42 },
  { 3682, 19, 52, 9, -8, -42 },
  { 3806, 25, 42, 20, 0, -42 },
  { 3938, 13, 42, 18, 0, -42 },
  { 4007, 35, 42, 35, 0, -42 },
  { 4191, 28, 42, 27, 0, -42 },
  { 4338, 23, 44, 26, 2, -43 },
  { 4465, 22, 42, 21, 0, -42 },
  { 4581, 23, 53, 26, 2, -43 },
  { 4734, 21, 42, 21, 0, -42 },
  { 4845, 24, 44, 20, -2, -43 },
  { 4977, 18, 42, 17, 4, -42 },
  { 5072, 24, 43, 25, 2, -42 },
  { 5201, 20, 42, 20, 5, -42 },
  { 5306, 36, 42, 35, 4, -42 },
  { 5495, 25, 42, 18, -3, -42 },
  { 5627, 18, 42, 17, 4, -42 },
  { 5722, 23, 42, 18, -2, -42 },
  { 5843, 21, 51, 16, -1, -42 },
  { 5977, 8, 42, 19, 6, -42 },
  { 6019, 21, 51, 16, -4, -42 },
  { 6153, 22, 20, 23, 1, -42 },
  { 6208, 15, 2, 15, -4, 5 },
  { 6212, 5, 9, 12, 9, -45 },
  { 6218, 20, 33, 22, 2, -32 },
  { 6301, 20, 46, 22, 0, -45 },
  { 6416, 16, 33, 16, 2, -32 },
  { 6482, 23, 46, 22, 2, -45 },
  { 6615, 16, 33, 19, 2, -32 },
  { 6681, 26, 59, 11, -8, -45 },
  { 6873, 23, 46, 22, -1, -32 },
  { 7006, 19, 45, 21, 0, -45 },
  { 7113, 11, 42, 9, 0, -42 },
  { 7171, 19, 56, 10, -8, -42 },
  { 7304, 20, 45, 17, 0, -45 },
  { 7417, 11, 45, 9, 0, -45 },
  { 7479, 30, 32, 32, 0, -32 },
  { 7599, 19, 32, 21, 0, -32 },
  { 7675, 18, 33, 21, 2, -32 },
  { 7750, 22, 45, 22, -2, -32 },
  { 7874, 20, 46, 22, 2, -32 },
  { 7989, 16, 32, 14, 0, -32 },
  { 8053, 18, 33, 16, -1, -32 },
  { 8128, 11, 40, 11, 1, -39 },
  { 8183, 18, 32, 21, 2, -31 },
  { 8255, 16, 31, 16, 3, -31 },
  { 8317, 27, 31, 27, 3, -31 },
  { 8422, 22, 31, 17, -3, -31 },
  { 8508, 27, 45, 17, -7, -31 },
  { 8660, 17, 31, 14, -2, -31 },
  { 8726, 20, 51, 18, 2, -42 },
  { 8854, 2, 59, 20, 9, -45 },
  { 8869, 20, 51, 18, -4, -42 },
  { 8997, 20, 5, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC59PT7B_H_
