#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x31, 0x83,
  0x10, 0x33, 0x02, 0x30, 0x63, 0x06, 0x20, 0x62, 0x04, 0x60, 0x46, 0x04,
  0x60, 0xC4, 0x0C, 0x40, 0x84, 0x08, 0xC0, 0x88, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x02, 0x02, 0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x04, 0x06,
  0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x40, 0x60, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0,
  0x01, 0x80, 0x80, 0x01, 0x81, 0x80, 0x01, 0x01, 0x80, 0x03, 0x01, 0x00,
  0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x06, 0x02, 0x00, 0x06, 0x02, 0x00,
  0xFF, 0xFF, 0xF0, 0x04, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00,
  0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x71, 0x87,
  0x00, 0xE1, 0x81, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x00, 0x01, 0x01, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00,
  0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x84, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x11, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x80, 0xC3, 0x00, 0xE0, 0x8E, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x1C, 0x60, 0x06, 0x03, 0x0C,
  0x00, 0x80, 0xC0, 0x80, 0x30, 0x10, 0x10, 0x04, 0x06, 0x02, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x08, 0x0C, 0x06, 0x01, 0x01, 0x00, 0x80, 0x60,
  0x60, 0x30, 0x0C, 0x08, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x30, 0x40, 0x10,
  0x06, 0x18, 0x02, 0x00, 0x82, 0x00, 0xC0, 0x30, 0xC0, 0x18, 0x06, 0x10,
  0x03, 0x00, 0xC6, 0x00, 0x60, 0x10, 0x87, 0xEC, 0x06, 0x31, 0xCF, 0x80,
  0xC4, 0x30, 0xF0, 0x31, 0x8C, 0x1E, 0x06, 0x23, 0x01, 0xC1, 0x8C, 0x60,
  0x38, 0x31, 0x98, 0x05, 0x8C, 0x63, 0x00, 0xBF, 0x0C, 0x60, 0x31, 0x03,
  0x18, 0x06, 0x00, 0x63, 0x00, 0xC0, 0x18, 0x60, 0x18, 0x03, 0x08, 0x03,
  0x00, 0xC3, 0x00, 0x40, 0x18, 0x60, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC1,
  0x80, 0x60, 0x30, 0x30, 0x08, 0x06, 0x06, 0x03, 0x01, 0x80, 0x80, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x02, 0x03, 0x01, 0x80, 0x40, 0x60, 0x60, 0x0C,
  0x18, 0x0C, 0x01, 0x82, 0x03, 0x00, 0x30, 0xC0, 0x60, 0x03, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x18, 0xC0, 0x03,
  0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x04, 0x06, 0x00,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x60,
  0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xB0, 0x00, 0x31, 0x00, 0x06, 0x18, 0x00, 0xC1,
  0x83, 0x18, 0x18, 0x31, 0x80, 0x83, 0x30, 0x0C, 0x23, 0x00, 0xC6, 0x60,
  0x0C, 0x66, 0x00, 0x44, 0x40, 0x06, 0xC4, 0x00, 0x68, 0xC0, 0x07, 0x8C,
  0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0xD0,
  0x60, 0x09, 0x06, 0x01, 0x98, 0x30, 0x71, 0x81, 0xFC, 0x08, 0x02, 0x00,
  0x00, 0x18, 0xC4, 0x63, 0x18, 0x84, 0x63, 0x18, 0x84, 0x23, 0x10, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x08, 0x10, 0x18, 0x20, 0x0C, 0x40, 0x0C, 0x87, 0x07, 0xF0, 0x06, 0x00,
  0x14, 0x00, 0xC4, 0x03, 0x08, 0x0C, 0x08, 0x30, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x06,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x60,
  0x06, 0x02, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x10, 0x10, 0x01,
  0x03, 0x00, 0x10, 0x30, 0x01, 0x06, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00,
  0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x02, 0x30,
  0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x46,
  0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x00, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02,
  0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0x40, 0x08, 0x04, 0x01,
  0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0x30, 0xE0, 0x01, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x0D, 0x03, 0x61, 0xCC, 0x71, 0x98, 0x26,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x78,
  0x18, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xC0, 0x08, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xA0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x13, 0x00, 0x00,
  0x64, 0x00, 0x01, 0x88, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0x61, 0x00, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x60, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x10, 0x08, 0x00, 0x60, 0x10, 0x01, 0x80, 0x60, 0x03,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x80, 0x60, 0x03,
  0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x0E, 0x00,
  0xE0, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x40, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x3F, 0x80, 0x33, 0x87, 0x00, 0xD8, 0x06, 0x03, 0xC0, 0x18,
  0x0A, 0x00, 0x30, 0x78, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x04, 0x18,
  0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x10, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x40,
  0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x40, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00,
  0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10, 0x00,
  0x60, 0x20, 0x00, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x03, 0x38, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xC6, 0x00, 0x06,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x18, 0x08, 0x00, 0x10, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0xC0, 0x06, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x18, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x02, 0x18, 0x00, 0x10, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x20, 0x01, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xB0, 0x30, 0x1D, 0x01,
  0xE3, 0x88, 0x03, 0xF8, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x08, 0x1C,
  0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x03, 0x81, 0x80, 0x80, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0xFE, 0x0C, 0x20, 0x0E, 0x30, 0x63, 0x00,
  0xC1, 0x03, 0x18, 0x0C, 0x18, 0x18, 0x80, 0xC0, 0xC0, 0xCC, 0x06, 0x06,
  0x06, 0x60, 0x60, 0x20, 0x32, 0x03, 0x03, 0x01, 0x30, 0x30, 0x18, 0x19,
  0x81, 0x80, 0xC0, 0xCC, 0x08, 0x04, 0x06, 0x40, 0xC0, 0x60, 0x32, 0x06,
  0x03, 0x01, 0x30, 0x30, 0x10, 0x19, 0x81, 0x01, 0x80, 0xCC, 0x08, 0x0C,
  0x04, 0x60, 0xC0, 0x60, 0x63, 0x06, 0x07, 0x03, 0x18, 0x30, 0x38, 0x10,
  0x81, 0x81, 0x81, 0x84, 0x0C, 0x1C, 0x08, 0x20, 0x21, 0xB0, 0xC1, 0x01,
  0x8D, 0x8C, 0x08, 0x0F, 0xC7, 0xC0, 0x40, 0x3C, 0x1C, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x04,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x05, 0x00, 0x00, 0xD0, 0x00, 0x0D,
  0x00, 0x01, 0x90, 0x00, 0x19, 0x00, 0x01, 0x10, 0x00, 0x31, 0x00, 0x02,
  0x10, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x10, 0x00,
  0x81, 0x00, 0x18, 0x10, 0x01, 0x81, 0x00, 0x10, 0x10, 0x03, 0x01, 0x00,
  0x20, 0x10, 0x06, 0x01, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x10,
  0x08, 0x01, 0x01, 0xFF, 0xF0, 0x18, 0x01, 0x03, 0x00, 0x10, 0x30, 0x01,
  0x02, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00,
  0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x80, 0x01, 0x30, 0x00, 0x13, 0x00,
  0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x60, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x60, 0x1C, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x02, 0x01, 0x80, 0x02, 0x01, 0x80, 0x06, 0x01, 0x00, 0x06, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x02,
  0x00, 0xE0, 0x06, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x06, 0x07, 0x80, 0x04,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x08, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x40, 0x0E, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x18, 0x07, 0x00,
  0x0C, 0x01, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0x80, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x08,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x06,
  0x00, 0x80, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x07, 0x00, 0x30, 0x07,
  0x00, 0x10, 0x0E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x04, 0x00, 0x10, 0x20,
  0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01,
  0xC0, 0x02, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x04,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10,
  0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x04,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x10,
  0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x10, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x20,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x69, 0x00, 0x00, 0x16, 0x60, 0x00, 0x0F,
  0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x20, 0x00,
  0x08, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x10,
  0x00, 0x10, 0x06, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x08, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x18,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0A, 0x00, 0x50,
  0x00, 0x00, 0x78, 0x01, 0x40, 0x00, 0x01, 0x60, 0x0D, 0x00, 0x00, 0x0D,
  0x00, 0x36, 0x00, 0x00, 0x24, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x02, 0x60,
  0x00, 0x04, 0xC0, 0x19, 0x80, 0x00, 0x33, 0x00, 0x66, 0x00, 0x00, 0x88,
  0x01, 0x98, 0x00, 0x06, 0x20, 0x04, 0x60, 0x00, 0x19, 0x80, 0x11, 0x80,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x03, 0x18, 0x00, 0x18, 0x40,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x82, 0x00,
  0x0C, 0x30, 0x06, 0x08, 0x00, 0x60, 0xC0, 0x18, 0x20, 0x01, 0x82, 0x00,
  0x60, 0x80, 0x0C, 0x18, 0x01, 0x02, 0x00, 0x30, 0x60, 0x0C, 0x08, 0x01,
  0x81, 0x80, 0x30, 0x20, 0x06, 0x04, 0x00, 0xC0, 0xC0, 0x10, 0x10, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x08, 0x0C, 0x02, 0x03, 0x00, 0x60, 0x30, 0x18,
  0x0C, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x06, 0x03, 0x03, 0x00, 0x80, 0x10,
  0x0C, 0x08, 0x06, 0x00, 0x40, 0x30, 0x60, 0x18, 0x03, 0x00, 0xC1, 0x00,
  0x60, 0x0C, 0x03, 0x0C, 0x01, 0x00, 0x30, 0x0C, 0x30, 0x0C, 0x00, 0x80,
  0x31, 0x80, 0x30, 0x06, 0x00, 0x46, 0x00, 0xC0, 0x18, 0x01, 0x30, 0x02,
  0x00, 0x60, 0x04, 0xC0, 0x08, 0x01, 0x80, 0x16, 0x00, 0x60, 0x04, 0x00,
  0x58, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x80, 0x1C, 0x00, 0x06, 0x00, 0x58, 0x00, 0x18, 0x01, 0x60, 0x00, 0x60,
  0x0D, 0x80, 0x01, 0x80, 0x32, 0x00, 0x04, 0x00, 0xC8, 0x00, 0x30, 0x02,
  0x30, 0x00, 0xC0, 0x18, 0xC0, 0x03, 0x00, 0x63, 0x00, 0x08, 0x01, 0x8C,
  0x00, 0x20, 0x06, 0x10, 0x01, 0x80, 0x10, 0x40, 0x06, 0x00, 0xC1, 0x80,
  0x18, 0x03, 0x06, 0x00, 0x40, 0x0C, 0x18, 0x03, 0x00, 0x20, 0x20, 0x0C,
  0x00, 0x80, 0x80, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x02, 0x00,
  0x60, 0x30, 0x18, 0x01, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x01, 0x80, 0x30,
  0x04, 0x06, 0x00, 0xC0, 0x18, 0x10, 0x03, 0x00, 0x60, 0xC0, 0x08, 0x01,
  0x83, 0x00, 0x60, 0x02, 0x0C, 0x01, 0x80, 0x08, 0x20, 0x06, 0x00, 0x30,
  0x80, 0x10, 0x00, 0xC6, 0x00, 0x40, 0x03, 0x18, 0x03, 0x00, 0x0C, 0x60,
  0x0C, 0x00, 0x11, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x80, 0x01, 0xB0, 0x06,
  0x00, 0x06, 0xC0, 0x18, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x28, 0x01, 0x80,
  0x00, 0xE0, 0x04, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x07, 0x00,
  0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x08, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0x80, 0xE0, 0x03, 0x00, 0xE0, 0x04, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x60,
  0x10, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x70, 0x02,
  0x03, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x07,
  0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x08, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x00, 0x80, 0x30,
  0x00, 0xC0, 0x08, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0x80, 0xE0, 0x03,
  0x00, 0xE0, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x30, 0x01, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x10, 0x01, 0x80,
  0x60, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x03, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x60, 0x60, 0x00, 0x80,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x10, 0x06,
  0x00, 0x20, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00,
  0xC0, 0x06, 0x01, 0x00, 0x04, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x01, 0xE0, 0x06, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x08, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00,
  0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x70,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x30, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x0D, 0x80, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x02, 0x60,
  0x00, 0x58, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00, 0x34, 0x00,
  0x18, 0xC0, 0x01, 0x20, 0x00, 0xC6, 0x00, 0x19, 0x00, 0x04, 0x30, 0x00,
  0xC8, 0x00, 0x61, 0x80, 0x04, 0x40, 0x03, 0x0C, 0x00, 0x62, 0x00, 0x30,
  0x60, 0x02, 0x10, 0x01, 0x83, 0x00, 0x30, 0x80, 0x08, 0x18, 0x01, 0x84,
  0x00, 0xC0, 0xC0, 0x08, 0x20, 0x06, 0x06, 0x00, 0xC1, 0x00, 0x60, 0x30,
  0x04, 0x08, 0x03, 0x01, 0x80, 0x60, 0x40, 0x10, 0x0C, 0x03, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x30, 0x0C, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x18, 0x08,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x06, 0x06, 0x03, 0x03, 0x00,
  0x30, 0x20, 0x18, 0x18, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x06,
  0x0C, 0x00, 0x41, 0x80, 0x30, 0x40, 0x02, 0x0C, 0x01, 0x86, 0x00, 0x10,
  0x40, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x63, 0x00, 0x04, 0x30, 0x03, 0x18,
  0x00, 0x23, 0x00, 0x18, 0x80, 0x01, 0x18, 0x00, 0xCC, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x02, 0x60, 0x01, 0x30, 0x00,
  0x16, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x00, 0x38, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x80, 0x08,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x76, 0x00, 0x06,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x20, 0x01, 0x82, 0x00, 0x18, 0x20, 0x03,
  0x02, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30, 0x01, 0x03, 0x00, 0x10,
  0x60, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x19, 0x80, 0x01,
  0x90, 0x00, 0x1B, 0x00, 0x01, 0xA0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xC0,
  0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40,
  0x30, 0x18, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6,
  0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x40, 0x30, 0x62, 0x03, 0x01, 0xB0, 0x30, 0x05, 0x03, 0x00,
  0x28, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x04,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00,
  0xE0, 0x60, 0x05, 0x01, 0x00, 0x68, 0x0C, 0x06, 0xC0, 0x30, 0x66, 0x00,
  0xFE, 0x20, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x63,
  0xF8, 0x01, 0x98, 0x30, 0x04, 0xC0, 0x60, 0x16, 0x01, 0x80, 0xF0, 0x02,
  0x03, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00,
  0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18,
  0x60, 0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40,
  0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x18, 0x1E, 0x00, 0x60, 0x78, 0x03, 0x01, 0x30, 0x18, 0x04,
  0xE1, 0xC0, 0x31, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x70, 0x20, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x20, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x1E, 0x08, 0x00, 0x7F, 0x98, 0x00,
  0xC1, 0x98, 0x01, 0x80, 0xD8, 0x03, 0x00, 0x50, 0x06, 0x00, 0x50, 0x0C,
  0x00, 0x70, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x10,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60,
  0x00, 0x40, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0A, 0x00, 0x40,
  0x1A, 0x00, 0x60, 0x36, 0x00, 0x30, 0xE6, 0x00, 0x1F, 0xC4, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x70, 0x60, 0x70, 0x30, 0x70,
  0x08, 0x30, 0x04, 0x30, 0x02, 0x10, 0x01, 0x18, 0x01, 0x88, 0x00, 0xCC,
  0x00, 0x46, 0x00, 0x62, 0x00, 0x63, 0x00, 0x71, 0x80, 0x70, 0x80, 0xE0,
  0x4F, 0xE0, 0x7F, 0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x30, 0x30,
  0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF1, 0x00, 0x18, 0x31, 0x00,
  0x30, 0x1B, 0x00, 0x60, 0x0A, 0x00, 0xC0, 0x0A, 0x01, 0x80, 0x0E, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0xE0, 0x18, 0x01, 0xC0, 0x18, 0x01, 0x40, 0x08, 0x03, 0xC0, 0x0C,
  0x06, 0xC0, 0x06, 0x1C, 0xC0, 0x03, 0xF8, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x80, 0x38, 0x00, 0xFB,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x0E, 0x00, 0x33, 0xFC, 0x01,
  0xB8, 0x30, 0x0B, 0x00, 0x80, 0x50, 0x06, 0x07, 0x00, 0x30, 0x38, 0x01,
  0x81, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x60, 0x02, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x00,
  0x20, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0xBC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x03, 0x01, 0x80, 0x30, 0x08, 0x03,
  0x00, 0x40, 0x30, 0x06, 0x01, 0x00, 0x30, 0x18, 0x01, 0x81, 0x80, 0x08,
  0x18, 0x00, 0x40, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x78, 0x00, 0x36, 0xC0, 0x01, 0x66,
  0x00, 0x0A, 0x30, 0x00, 0xF0, 0x80, 0x07, 0x04, 0x00, 0x30, 0x30, 0x01,
  0x01, 0x80, 0x08, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x00, 0x30, 0x08,
  0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x02, 0x01, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x01,
  0x9F, 0xE1, 0xFE, 0x01, 0x30, 0x63, 0x07, 0x01, 0x60, 0x36, 0x03, 0x01,
  0xC0, 0x3C, 0x01, 0x03, 0x80, 0x18, 0x01, 0x03, 0x80, 0x18, 0x01, 0x03,
  0x00, 0x30, 0x01, 0x03, 0x00, 0x30, 0x03, 0x02, 0x00, 0x30, 0x03, 0x06,
  0x00, 0x30, 0x03, 0x06, 0x00, 0x20, 0x03, 0x06, 0x00, 0x60, 0x02, 0x04,
  0x00, 0x60, 0x06, 0x0C, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x40, 0x06, 0x0C,
  0x00, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0x04, 0x08, 0x00, 0xC0, 0x0C, 0x18,
  0x00, 0xC0, 0x0C, 0x18, 0x00, 0x80, 0x0C, 0x18, 0x01, 0x80, 0x08, 0x10,
  0x01, 0x80, 0x08, 0x10, 0x01, 0x80, 0x18, 0x30, 0x01, 0x00, 0x18, 0x30,
  0x01, 0x00, 0x18, 0x30, 0x03, 0x00, 0x10, 0x20, 0x03, 0x00, 0x30, 0x20,
  0x03, 0x00, 0x30, 0x60, 0x02, 0x00, 0x30, 0x60, 0x06, 0x00, 0x20, 0x60,
  0x06, 0x00, 0x20, 0x40, 0x06, 0x00, 0x60, 0xC0, 0x04, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x0C, 0xFF, 0x00, 0x4C, 0x0C, 0x02, 0xC0, 0x20, 0x14, 0x01,
  0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x02, 0x03, 0x00, 0x10, 0x18,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x10,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x02, 0x00,
  0x10, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02, 0x02,
  0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02,
  0x02, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x40, 0x40,
  0x02, 0x06, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x07, 0x06,
  0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x83, 0x00, 0x18, 0x60, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x0C, 0x80, 0x03, 0x10, 0x00, 0x62, 0x00, 0x08, 0x60, 0x03, 0x0C,
  0x00, 0x41, 0x80, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x30, 0x60, 0x03,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x18, 0xFE, 0x00,
  0x08, 0xC1, 0x80, 0x04, 0xC0, 0x60, 0x02, 0xC0, 0x30, 0x03, 0x40, 0x08,
  0x01, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x78, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x1B, 0x01, 0x80, 0x09, 0xC3, 0x80,
  0x04, 0x7F, 0x80, 0x06, 0x04, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xF8, 0x40, 0x70, 0x62, 0x07, 0x01, 0xB0, 0x30, 0x05,
  0x03, 0x00, 0x28, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x18, 0x00, 0x70, 0xC0,
  0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x31,
  0x80, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0E,
  0x0C, 0x00, 0xE0, 0x60, 0x05, 0x01, 0x00, 0x78, 0x0C, 0x06, 0xC0, 0x30,
  0xE6, 0x01, 0xFE, 0x20, 0x01, 0x81, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0xCF,
  0xC0, 0x4C, 0x00, 0x2C, 0x00, 0x14, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x06, 0x03, 0x81, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x04, 0x01,
  0xC0, 0xC0, 0x70, 0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x1F, 0xF0, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7C, 0x03, 0x80,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x00, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x01, 0xC0, 0x80, 0x1C,
  0x08, 0x03, 0xC0, 0xC0, 0x68, 0x0E, 0x0C, 0x80, 0x7F, 0x88, 0x00, 0xC0,
  0x00, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80,
  0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x80,
  0x60, 0x80, 0x60, 0x80, 0xC0, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x80, 0x81,
  0x00, 0x83, 0x00, 0x83, 0x00, 0x86, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x8C,
  0x00, 0x88, 0x00, 0x98, 0x00, 0x90, 0x00, 0xB0, 0x00, 0xB0, 0x00, 0xA0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x60, 0x02, 0x80, 0x0E, 0x00, 0x68, 0x00, 0xA0, 0x04, 0x80, 0x0A, 0x00,
  0xC8, 0x01, 0xA0, 0x0C, 0x80, 0x12, 0x00, 0x88, 0x03, 0x20, 0x18, 0x80,
  0x32, 0x01, 0x08, 0x02, 0x20, 0x30, 0x80, 0x62, 0x03, 0x08, 0x04, 0x20,
  0x20, 0x80, 0xC6, 0x06, 0x08, 0x08, 0x60, 0x40, 0x81, 0x86, 0x0C, 0x08,
  0x18, 0x60, 0xC0, 0x81, 0x06, 0x08, 0x08, 0x30, 0x61, 0x80, 0x82, 0x06,
  0x18, 0x08, 0x60, 0x61, 0x00, 0x86, 0x06, 0x30, 0x08, 0x40, 0x62, 0x00,
  0x8C, 0x06, 0x60, 0x08, 0x80, 0x66, 0x00, 0x98, 0x06, 0x40, 0x09, 0x80,
  0x6C, 0x00, 0x90, 0x06, 0x80, 0x0B, 0x00, 0x68, 0x00, 0xA0, 0x07, 0x80,
  0x0E, 0x00, 0x50, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20,
  0x02, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x43, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x61, 0x00, 0x01, 0x82, 0x00,
  0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x10, 0x01,
  0x80, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x78, 0x1C, 0x07, 0x00, 0x3C, 0xE8,
  0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 45, 13, 1, -45 },
  { 69, 12, 16, 16, 6, -45 },
  { 93, 24, 45, 23, 0, -45 },
  { 228, 24, 52, 21, -1, -48 },
  { 384, 27, 47, 33, 3, -46 },
  { 543, 20, 47, 20, -1, -46 },
  { 661, 5, 16, 9, 6, -45 },
  { 671, 17, 55, 15, 2, -45 },
  { 788, 17, 55, 15, -4, -45 },
  { 905, 15, 17, 20, 8, -48 },
  { 937, 21, 29, 25, 2, -37 },
  { 1014, 7, 14, 10, -2, -6 },
  { 1027, 13, 2, 17, 2, -18 },
  { 1031, 3, 4, 10, 1, -4 },
  { 1033, 26, 45, 18, -3, -45 },
  { 1180, 20, 47, 22, 1, -46 },
  { 1298, 11, 45, 22, 7, -45 },
  { 1360, 24, 46, 22, -2, -46 },
  { 1498, 23, 47, 22, -1, -46 },
  { 1634, 23, 46, 22, -1, -46 },
  { 1767, 24, 46, 22, -2, -45 },
  { 1905, 22, 47, 22, 1, -46 },
  { 2035, 22, 45, 22, 2, -45 },
  { 2159, 23, 47, 22, -1, -46 },
  { 2295, 21, 47, 22, 0, -46 },
  { 2419, 9, 33, 10, 0, -33 },
  { 2457, 13, 41, 10, -3, -33 },
  { 2524, 21, 26, 25, 2, -35 },
  { 2593, 21, 15, 25, 2, -30 },
  { 2633, 21, 26, 25, 2, -35 },
  { 2702, 17, 46, 15, 1, -46 },
  { 2800, 29, 51, 32, 2, -45 },
  { 2985, 20, 45, 21, -4, -45 },
  { 3098, 24, 45, 24, 0, -45 },
  { 3233, 24, 47, 21, 2, -46 },
  { 3374, 25, 45, 26, 0, -45 },
  { 3515, 24, 45, 21, 0, -45 },
  { 3650, 24, 45, 20, 0, -45 },
  { 3785, 28, 47, 28, 2, -46 },
  { 3950, 29, 45, 28, 0, -45 },
  { 4114, 19, 45, 10, -4, -45 },
  { 4221, 20, 56, 10, -9, -45 },
  { 4361, 26, 45, 22, 0, -45 },
  { 4508, 14, 45, 19, 0, -45 },
  { 4587, 38, 45, 37, 0, -45 },
  { 4801, 30, 45, 29, 0, -45 },
  { 4970, 25, 47, 28, 2, -46 },
  { 5117, 23, 45, 22, 0, -45 },
  { 5247, 25, 57, 28, 2, -46 },
  { 5426, 23, 45, 22, 0, -45 },
  { 5556, 25, 47, 21, -2, -46 },
  { 5703, 19, 45, 19, 4, -45 },
  { 5810, 26, 46, 27, 2, -45 },
  { 5960, 22, 45, 22, 5, -45 },
  { 6084, 37, 45, 38, 5, -45 },
  { 6293, 28, 45, 19, -4, -45 },
  { 6451, 20, 45, 18, 4, -45 },
  { 6564, 26, 45, 19, -3, -45 },
  { 6711, 22, 55, 17, -1, -45 },
  { 6863, 9, 45, 20, 6, -45 },
  { 6914, 22, 55, 17, -4, -45 },
  { 7066, 22, 22, 25, 2, -45 },
  { 7127, 16, 1, 16, -5, 6 },
  { 7129, 6, 10, 13, 9, -48 },
  { 7137, 21, 35, 24, 2, -34 },
  { 7229, 22, 49, 23, 0, -48 },
  { 7364, 17, 35, 17, 2, -34 },
  { 7439, 24, 49, 24, 2, -48 },
  { 7586, 17, 35, 21, 2, -34 },
  { 7661, 27, 63, 12, -8, -48 },
  { 7874, 24, 49, 24, -1, -34 },
  { 8021, 21, 48, 23, 0, -48 },
  { 8147, 12, 45, 10, 0, -45 },
  { 8215, 20, 60, 10, -8, -45 },
  { 8365, 21, 48, 19, 0, -48 },
  { 8491, 12, 48, 9, 0, -48 },
  { 8563, 32, 34, 34, 0, -34 },
  { 8699, 21, 34, 22, 0, -34 },
  { 8789, 19, 35, 23, 2, -34 },
  { 8873, 25, 48, 24, -3, -34 },
  { 9023, 21, 49, 24, 2, -34 },
  { 9152, 17, 34, 15, 0, -34 },
  { 9225, 19, 35, 17, -1, -34 },
  { 9309, 12, 42, 11, 1, -41 },
  { 9372, 20, 34, 23, 2, -33 },
  { 9457, 16, 33, 17, 4, -33 },
  { 9523, 28, 33, 29, 4, -33 },
  { 9639, 23, 33, 18, -3, -33 },
  { 9734, 29, 48, 19, -7, -33 },
  { 9908, 19, 33, 14, -2, -33 },
  { 9987, 21, 55, 20, 2, -45 },
  { 10132, 1, 63, 22, 10, -48 },
  { 10140, 21, 55, 19, -4, -45 },
  { 10285, 21, 5, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC63PT7B_H_
