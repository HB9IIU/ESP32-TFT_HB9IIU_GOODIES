#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x38, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x66,
  0x08, 0x81, 0x10, 0x66, 0x0C, 0xC1, 0x10, 0x22, 0x04, 0x41, 0x98, 0x23,
  0x04, 0x40, 0x88, 0x11, 0x04, 0x20, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x20, 0x00, 0xC0, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40,
  0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x10, 0x0F, 0xFF, 0xFC, 0x01, 0x03, 0x00, 0x0C, 0x08,
  0x00, 0x20, 0x20, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00,
  0x40, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x10, 0x10, 0x0F, 0xFF, 0xFC, 0x03, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x10,
  0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x33, 0xC0, 0x30, 0xC1, 0x01, 0x82,
  0x00, 0x04, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x04, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x20, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x21, 0x00, 0x01, 0x86, 0x00, 0x06,
  0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x08,
  0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x08, 0x60, 0x30,
  0x63, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xB0, 0x03, 0x03, 0x0C, 0x01, 0x01, 0x06, 0x01, 0x81, 0x81,
  0x00, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x20, 0x60, 0x20,
  0x30, 0x20, 0x30, 0x18, 0x30, 0x18, 0x0C, 0x10, 0x08, 0x06, 0x18, 0x0C,
  0x02, 0x08, 0x06, 0x01, 0x0C, 0x03, 0x01, 0x84, 0x01, 0x80, 0xC6, 0x00,
  0x80, 0x62, 0x00, 0x40, 0x23, 0x0F, 0x20, 0x31, 0x0C, 0xD0, 0x19, 0x8C,
  0x38, 0x18, 0xCC, 0x1C, 0x0C, 0xC4, 0x0E, 0x0C, 0x66, 0x07, 0x84, 0x62,
  0x03, 0x6E, 0x33, 0x01, 0x9C, 0x31, 0x80, 0xC0, 0x18, 0x80, 0x60, 0x18,
  0x40, 0x20, 0x0C, 0x60, 0x10, 0x0C, 0x30, 0x18, 0x06, 0x18, 0x0C, 0x06,
  0x08, 0x06, 0x03, 0x04, 0x02, 0x03, 0x02, 0x01, 0x01, 0x83, 0x01, 0x81,
  0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x30, 0x20,
  0x20, 0x08, 0x30, 0x30, 0x06, 0x30, 0x30, 0x03, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x04,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10,
  0x30, 0x02, 0x06, 0x00, 0x40, 0x80, 0x08, 0x30, 0x01, 0x06, 0x00, 0x21,
  0x80, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xC8, 0x00, 0x31, 0x00, 0x0C, 0x30,
  0x23, 0x06, 0x08, 0x60, 0x41, 0x18, 0x08, 0x62, 0x01, 0x8C, 0xC0, 0x31,
  0x18, 0x02, 0x62, 0x00, 0x48, 0x40, 0x0F, 0x18, 0x01, 0xE3, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x14, 0x10, 0x06, 0x83, 0x01, 0x90,
  0x30, 0x63, 0x07, 0xF8, 0x60, 0x10, 0x00, 0x00, 0x33, 0x22, 0x66, 0x44,
  0x4C, 0xC8, 0x88, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0xC1, 0x01, 0x84, 0x01, 0x90, 0xC1, 0xBC, 0x03, 0x00, 0x14, 0x01,
  0x88, 0x0C, 0x20, 0x60, 0x43, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x01, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x18, 0x30, 0x41, 0x83, 0x04, 0x18, 0x20, 0xC1,
  0x04, 0x00, 0xFF, 0xF8, 0x5F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0x70, 0x01, 0x83, 0x00, 0x60, 0x60, 0x18, 0x04, 0x02, 0x00, 0x80,
  0xC0, 0x18, 0x10, 0x03, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80, 0x02, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x62, 0x00, 0x0C, 0xC0,
  0x01, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00,
  0x04, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x04, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01,
  0x80, 0x80, 0x60, 0x10, 0x08, 0x03, 0x03, 0x00, 0x30, 0xC0, 0x03, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x6C, 0x33, 0x18, 0x9C, 0x24,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xF7, 0x80, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x70, 0x0C,
  0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x10, 0x03,
  0x00, 0xC0, 0x70, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00,
  0xC8, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00,
  0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x08, 0x20, 0x00, 0xC1,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x04, 0x00, 0x20, 0x20, 0x03,
  0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x04, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x04, 0x02, 0x00,
  0x20, 0x30, 0x03, 0x03, 0x00, 0x18, 0x1F, 0xFF, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x20, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x38,
  0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01,
  0xF7, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x1F, 0x80, 0x33, 0x8E, 0x02, 0x60, 0x20, 0x28, 0x03,
  0x07, 0x80, 0x10, 0x70, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x40, 0x01, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x03, 0x00,
  0x30, 0x70, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xEF, 0x00, 0x18, 0x0C, 0x01,
  0x80, 0x30, 0x18, 0x01, 0x80, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x60, 0x01,
  0x03, 0x00, 0x08, 0x18, 0x00, 0x40, 0xC0, 0x02, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x18, 0x04, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x80, 0xC0,
  0x06, 0x0C, 0x00, 0x19, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x6C,
  0x00, 0x0E, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80,
  0x01, 0x04, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x06, 0x00, 0xC0,
  0x18, 0x1C, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xB8, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x02, 0x06,
  0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0x80, 0x02, 0x08, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x02,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00,
  0xC0, 0x80, 0x14, 0x0C, 0x03, 0x40, 0x60, 0x6C, 0x07, 0xFC, 0xC0, 0x1E,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x81, 0x80, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x0E, 0x07, 0x03, 0x00, 0x00, 0x20, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x78, 0x20, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60,
  0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0xE0, 0x30, 0xC0, 0x3F, 0x83,
  0x0C, 0x06, 0x18, 0x20, 0x80, 0xC1, 0x02, 0x18, 0x18, 0x30, 0x21, 0x81,
  0x03, 0x02, 0x10, 0x30, 0x30, 0x23, 0x02, 0x02, 0x06, 0x30, 0x60, 0x60,
  0x62, 0x06, 0x06, 0x06, 0x20, 0x40, 0x60, 0x46, 0x0C, 0x04, 0x04, 0x60,
  0xC0, 0xC0, 0xC6, 0x0C, 0x0C, 0x0C, 0x60, 0x80, 0xC0, 0x84, 0x08, 0x18,
  0x18, 0x40, 0x81, 0x81, 0x84, 0x08, 0x18, 0x10, 0x40, 0x82, 0x83, 0x04,
  0x08, 0x28, 0x20, 0xC0, 0x86, 0x86, 0x0C, 0x0C, 0xC8, 0xC0, 0xC0, 0x78,
  0xF8, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x30, 0x04, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x7F, 0xE0, 0x01, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x0C, 0x02, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x20, 0x03, 0x00, 0x80, 0x08, 0x06, 0x00, 0x60, 0x18,
  0x07, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x04, 0x07, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0x40, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x01, 0x00, 0x18, 0x04, 0x01, 0xC0, 0x10,
  0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0xF0, 0x03,
  0x80, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x3F, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x81, 0xC0, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x60, 0x01,
  0x00, 0xC0, 0x02, 0x01, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x81,
  0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x02, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0, 0x01,
  0x81, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x20, 0x00, 0xC0, 0x40, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x60, 0x08, 0x03, 0x80, 0x10, 0x0E, 0x00, 0x63, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x0E, 0x00, 0x60, 0x0E, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x21, 0x00, 0x0F, 0xE1,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10, 0x10, 0x00,
  0x18, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x10, 0x00,
  0x10, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20,
  0x00, 0x20, 0x08, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x18, 0x00, 0x80, 0x30, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x01, 0x03,
  0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x18,
  0x00, 0x02, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x04, 0xE0,
  0x00, 0x04, 0xA0, 0x00, 0x0D, 0x20, 0x00, 0x0F, 0x30, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x0A, 0x00, 0x00, 0x3C,
  0x01, 0x40, 0x00, 0x05, 0x80, 0x6C, 0x00, 0x01, 0xA0, 0x0D, 0x80, 0x00,
  0x24, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x26, 0x00, 0x01, 0x30, 0x04, 0xC0,
  0x00, 0x66, 0x01, 0x98, 0x00, 0x08, 0x80, 0x33, 0x00, 0x03, 0x10, 0x06,
  0x60, 0x00, 0x46, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x10, 0x80, 0x02, 0x10,
  0x06, 0x10, 0x00, 0xC2, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x10, 0x40, 0x06,
  0x18, 0x02, 0x08, 0x00, 0xC3, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x18, 0x20,
  0x06, 0x08, 0x03, 0x04, 0x01, 0x83, 0x00, 0x40, 0x80, 0x30, 0x60, 0x08,
  0x10, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x00, 0x60, 0x60, 0x20, 0x20,
  0x0C, 0x0C, 0x0C, 0x0C, 0x01, 0x01, 0x81, 0x01, 0x80, 0x20, 0x30, 0x60,
  0x30, 0x0C, 0x06, 0x08, 0x04, 0x01, 0x80, 0xC3, 0x00, 0x80, 0x20, 0x18,
  0x40, 0x30, 0x04, 0x03, 0x18, 0x06, 0x01, 0x80, 0x62, 0x00, 0x80, 0x30,
  0x04, 0xC0, 0x10, 0x06, 0x00, 0x90, 0x06, 0x00, 0x80, 0x16, 0x00, 0xC0,
  0x10, 0x02, 0x80, 0x18, 0x06, 0x00, 0x70, 0x02, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0xE0, 0x00,
  0x60, 0x0F, 0x00, 0x06, 0x00, 0xB0, 0x00, 0x60, 0x0B, 0x00, 0x04, 0x01,
  0x90, 0x00, 0x40, 0x19, 0x00, 0x0C, 0x01, 0x90, 0x00, 0xC0, 0x11, 0x80,
  0x08, 0x01, 0x18, 0x00, 0x80, 0x30, 0x80, 0x18, 0x03, 0x08, 0x01, 0x80,
  0x30, 0x80, 0x18, 0x02, 0x0C, 0x01, 0x00, 0x20, 0xC0, 0x10, 0x06, 0x0C,
  0x03, 0x00, 0x60, 0x40, 0x30, 0x04, 0x04, 0x03, 0x00, 0x40, 0x60, 0x20,
  0x0C, 0x06, 0x02, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x02, 0x06, 0x00, 0x80,
  0x20, 0x40, 0x08, 0x02, 0x04, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x0C,
  0x01, 0x80, 0x30, 0xC0, 0x10, 0x01, 0x08, 0x01, 0x00, 0x10, 0x80, 0x30,
  0x01, 0x98, 0x03, 0x00, 0x19, 0x80, 0x30, 0x01, 0x98, 0x02, 0x00, 0x09,
  0x00, 0x60, 0x00, 0x90, 0x06, 0x00, 0x0B, 0x00, 0x60, 0x00, 0xF0, 0x04,
  0x00, 0x0F, 0x00, 0x40, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3D, 0xE0, 0x01, 0xC0, 0x60, 0x06,
  0x00, 0x40, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x00,
  0x02, 0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x18, 0x00, 0x02,
  0x30, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x46, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x41, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x08, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x38, 0x38, 0x00,
  0x3F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x07, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x06,
  0x06, 0x00, 0x20, 0x30, 0x03, 0x01, 0x00, 0x30, 0x08, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x1F, 0x00, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3D, 0xE0,
  0x01, 0xC0, 0x60, 0x06, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0xC0, 0x01, 0x01, 0x00, 0x02, 0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x18, 0x00, 0x02, 0x30, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x46,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x38, 0x38, 0x00, 0x3F, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x02, 0x07, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x08,
  0x01, 0x80, 0x40, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x01, 0x01, 0x80, 0x08,
  0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x08, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01,
  0x80, 0x30, 0x08, 0x03, 0x00, 0xC0, 0x70, 0x07, 0xFE, 0x00, 0x30, 0x40,
  0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x00,
  0x60, 0x20, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0x40, 0xC0, 0x02, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x40, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x04, 0x06, 0x00, 0x04, 0x06, 0x00,
  0x0C, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00,
  0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00,
  0x20, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x20, 0x00,
  0x40, 0x60, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x40, 0x00,
  0xC0, 0x40, 0x00, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x38,
  0x00, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x06,
  0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01,
  0x88, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00,
  0x40, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x01, 0x80, 0x80,
  0x10, 0x08, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x80, 0x60, 0x08,
  0x04, 0x00, 0x80, 0xC0, 0x08, 0x08, 0x00, 0x81, 0x80, 0x08, 0x18, 0x00,
  0x83, 0x00, 0x08, 0x30, 0x00, 0x82, 0x00, 0x08, 0x60, 0x00, 0x84, 0x00,
  0x08, 0xC0, 0x00, 0x8C, 0x00, 0x09, 0x80, 0x00, 0x98, 0x00, 0x09, 0x00,
  0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x19, 0x00,
  0x03, 0x80, 0x03, 0x20, 0x00, 0x70, 0x00, 0x44, 0x00, 0x1E, 0x00, 0x18,
  0x80, 0x02, 0xC0, 0x02, 0x10, 0x00, 0xD8, 0x00, 0xC2, 0x00, 0x1A, 0x00,
  0x18, 0x40, 0x02, 0x40, 0x02, 0x08, 0x00, 0xC8, 0x00, 0xC1, 0x00, 0x11,
  0x00, 0x10, 0x20, 0x02, 0x20, 0x06, 0x04, 0x00, 0xC4, 0x00, 0xC0, 0x80,
  0x10, 0x80, 0x10, 0x10, 0x06, 0x10, 0x06, 0x02, 0x00, 0x82, 0x00, 0x80,
  0x40, 0x10, 0x40, 0x30, 0x08, 0x06, 0x08, 0x06, 0x01, 0x00, 0x81, 0x00,
  0x80, 0x20, 0x30, 0x20, 0x30, 0x04, 0x06, 0x04, 0x04, 0x00, 0x80, 0x80,
  0x81, 0x80, 0x10, 0x30, 0x10, 0x30, 0x02, 0x04, 0x02, 0x04, 0x00, 0x41,
  0x80, 0xC1, 0x80, 0x18, 0x30, 0x18, 0x20, 0x03, 0x04, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x61, 0x80, 0x0C, 0x20, 0x0C, 0x20, 0x01, 0x8C, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x31, 0x00, 0x06, 0x20, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0xCC, 0x00, 0x19, 0x00, 0x19, 0x00, 0x03, 0x60, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x68, 0x00, 0x0D, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x01, 0x60, 0x00,
  0x38, 0x00, 0x28, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x40, 0x60,
  0x00, 0x20, 0x20, 0x00, 0x10, 0x30, 0x00, 0x08, 0x10, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x64, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00,
  0x06, 0x00, 0x80, 0x02, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40,
  0x01, 0xD0, 0x00, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0xC1, 0x80, 0x30, 0x20, 0x18, 0x08, 0x06, 0x02, 0x03, 0x00,
  0x80, 0xC0, 0x20, 0x60, 0x08, 0x10, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x31,
  0x80, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xC0,
  0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x20,
  0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06,
  0x06, 0x02, 0x02, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1A, 0x00,
  0x00, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06, 0x08, 0x00, 0x20,
  0x60, 0x03, 0x03, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x01, 0x80,
  0xC0, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00,
  0x33, 0x00, 0x00, 0xB8, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x86,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x00, 0x7C, 0x20, 0x3D, 0xC4, 0x0C, 0x0C,
  0x83, 0x00, 0xF0, 0x40, 0x0E, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06,
  0x10, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x10, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x84,
  0x00, 0x70, 0x80, 0x0C, 0x10, 0x03, 0x83, 0x00, 0x50, 0x60, 0x1E, 0x04,
  0x06, 0xC0, 0xC1, 0x90, 0x0F, 0xE2, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0xF8, 0x01, 0x3D, 0xC0, 0x36,
  0x06, 0x03, 0xC0, 0x20, 0x28, 0x03, 0x03, 0x80, 0x30, 0x70, 0x03, 0x07,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x21, 0x80, 0x02,
  0x18, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x08, 0x30, 0x01, 0x83, 0x00, 0x10, 0x70, 0x03, 0x07, 0x00,
  0x20, 0x58, 0x06, 0x05, 0x80, 0xC0, 0x4C, 0x18, 0x0C, 0x7F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7E, 0x03, 0xCC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x08, 0x0F, 0xF0,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x01, 0xF0, 0x80, 0x1E, 0xF2, 0x00, 0xC0, 0xD8, 0x06, 0x01,
  0xE0, 0x10, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x40, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08,
  0x00, 0x60, 0x20, 0x01, 0x80, 0x80, 0x0E, 0x02, 0x00, 0x30, 0x08, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0xC0, 0x3C, 0x01, 0x01, 0xB0, 0x06, 0x0C, 0x80,
  0x0F, 0xE2, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xEE, 0x03, 0x03,
  0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x02,
  0x20, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x18, 0x40, 0x70, 0xC1, 0xC0,
  0xFF, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x60, 0x3F, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x84, 0x00, 0xF7,
  0x10, 0x06, 0x06, 0x40, 0x30, 0x0F, 0x00, 0x80, 0x1C, 0x06, 0x00, 0x60,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40,
  0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x02,
  0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04,
  0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00,
  0x70, 0x10, 0x01, 0x80, 0x40, 0x0E, 0x01, 0x80, 0x38, 0x06, 0x01, 0xE0,
  0x08, 0x0D, 0x00, 0x30, 0x64, 0x00, 0x7F, 0x10, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x08, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x3F, 0x00, 0x4E, 0x70, 0x1B,
  0x03, 0x03, 0xC0, 0x60, 0x50, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00,
  0x60, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06,
  0x08, 0x00, 0x81, 0x00, 0x10, 0x60, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x40, 0x40, 0x10, 0x18, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x08,
  0x08, 0x01, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x04, 0x00, 0x21,
  0x80, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x80, 0x04, 0xF0, 0x00, 0xB6,
  0x00, 0x3C, 0x40, 0x07, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x30, 0x02, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x08, 0x03, 0x01, 0x00, 0x20, 0x60, 0x04,
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x00, 0x01, 0x1F, 0x03, 0xE0, 0x04, 0xE7, 0x38, 0xE0, 0x34, 0x0D,
  0x80, 0x80, 0xE0, 0x14, 0x03, 0x03, 0x80, 0x70, 0x0C, 0x0C, 0x01, 0x80,
  0x30, 0x30, 0x06, 0x00, 0xC1, 0x80, 0x10, 0x03, 0x06, 0x00, 0x40, 0x08,
  0x18, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x01, 0x83, 0x00, 0x20, 0x06, 0x0C,
  0x00, 0x80, 0x18, 0x30, 0x06, 0x00, 0x40, 0x80, 0x18, 0x01, 0x02, 0x00,
  0x60, 0x0C, 0x18, 0x01, 0x00, 0x30, 0x60, 0x04, 0x00, 0x81, 0x80, 0x30,
  0x02, 0x04, 0x00, 0xC0, 0x08, 0x10, 0x03, 0x00, 0x60, 0xC0, 0x08, 0x01,
  0x83, 0x00, 0x20, 0x04, 0x08, 0x01, 0x80, 0x10, 0x20, 0x06, 0x00, 0xC1,
  0x80, 0x10, 0x03, 0x06, 0x00, 0x40, 0x0C, 0x18, 0x03, 0x00, 0x20, 0x40,
  0x0C, 0x00, 0x81, 0x00, 0x30, 0x06, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x01,
  0x1F, 0x80, 0x27, 0x38, 0x0D, 0x81, 0x81, 0x60, 0x30, 0x28, 0x06, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x10,
  0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x02, 0x00, 0x20, 0x40,
  0x04, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03,
  0x00, 0x00, 0x7C, 0x00, 0xF7, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0xC0, 0x18,
  0x60, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x30, 0x00, 0x98, 0x00, 0x48, 0x00,
  0x2C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0x60, 0x00, 0xB0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x24, 0x00, 0x32,
  0x00, 0x19, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x04, 0x30, 0x06, 0x18, 0x06,
  0x04, 0x06, 0x03, 0x07, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x43, 0xE0,
  0x01, 0x3D, 0xC0, 0x0D, 0x81, 0x80, 0x34, 0x02, 0x00, 0xA0, 0x0C, 0x03,
  0x80, 0x30, 0x0C, 0x00, 0xC0, 0x70, 0x01, 0x01, 0x80, 0x04, 0x06, 0x00,
  0x10, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x20, 0x00, 0xC0, 0x80, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x02,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x01, 0xC0, 0x08, 0x07,
  0x00, 0x60, 0x16, 0x03, 0x00, 0x4C, 0x38, 0x01, 0x1F, 0xC0, 0x0C, 0x10,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7C,
  0x20, 0x3D, 0xC4, 0x0C, 0x0C, 0x83, 0x00, 0xF0, 0x40, 0x1E, 0x18, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x02,
  0x10, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08,
  0xC0, 0x01, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x61,
  0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x70, 0x80, 0x0C, 0x10, 0x03, 0x83,
  0x00, 0x70, 0x60, 0x1E, 0x04, 0x06, 0xC0, 0xC1, 0x90, 0x0F, 0xE2, 0x00,
  0x20, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x1F, 0x01,
  0x39, 0x03, 0x60, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0xF3, 0xC0, 0xC0, 0x20, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x08, 0x03,
  0x06, 0x07, 0x03, 0xFF, 0x00, 0x08, 0x00, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x7F, 0x3F, 0xC0, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xF8, 0x04,
  0x00, 0x04, 0x00, 0x41, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00,
  0x82, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20, 0x0E, 0x08,
  0x03, 0x82, 0x01, 0xC0, 0x80, 0xD0, 0x30, 0x64, 0x07, 0xF3, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0,
  0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0,
  0x60, 0xC0, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC3,
  0x00, 0xC3, 0x00, 0xC2, 0x00, 0xC6, 0x00, 0xC4, 0x00, 0xCC, 0x00, 0xC8,
  0x00, 0xD8, 0x00, 0xD8, 0x00, 0xD0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x50, 0x01, 0x80, 0x34, 0x00, 0xE0,
  0x0D, 0x00, 0x38, 0x02, 0x40, 0x1E, 0x01, 0x90, 0x05, 0x80, 0x44, 0x01,
  0x60, 0x31, 0x00, 0xD8, 0x0C, 0x40, 0x26, 0x02, 0x10, 0x19, 0x01, 0x84,
  0x04, 0x40, 0x41, 0x01, 0x10, 0x10, 0x40, 0xC4, 0x0C, 0x10, 0x21, 0x02,
  0x04, 0x18, 0x41, 0x81, 0x04, 0x10, 0x40, 0x41, 0x04, 0x10, 0x10, 0xC1,
  0x0C, 0x0C, 0x20, 0x42, 0x03, 0x18, 0x11, 0x80, 0xC4, 0x04, 0x40, 0x33,
  0x01, 0x10, 0x0C, 0xC0, 0x4C, 0x03, 0x20, 0x12, 0x00, 0xD8, 0x04, 0x80,
  0x34, 0x01, 0x40, 0x0F, 0x00, 0x50, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x80, 0x08, 0x04,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x20, 0x20,
  0x01, 0x03, 0x00, 0x08, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x08,
  0x80, 0x00, 0x4C, 0x00, 0x02, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x02, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x10,
  0x00, 0x18, 0x80, 0x01, 0x84, 0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x04,
  0x0C, 0x00, 0x60, 0x20, 0x06, 0x01, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x80, 0x08, 0x00, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00, 0x80, 0x08, 0x00,
  0x10, 0x03, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00, 0x08, 0x02,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x27, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x0F,
  0xF8, 0x07, 0x03, 0x81, 0xC0, 0x1F, 0xE8, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 41, 12, 1, -41 },
  { 58, 11, 15, 15, 6, -41 },
  { 79, 22, 41, 21, 0, -41 },
  { 192, 22, 47, 20, -1, -44 },
  { 322, 25, 43, 30, 3, -42 },
  { 457, 19, 43, 19, -1, -42 },
  { 560, 4, 15, 8, 6, -41 },
  { 568, 15, 50, 14, 2, -41 },
  { 662, 16, 50, 14, -4, -41 },
  { 762, 14, 16, 18, 7, -44 },
  { 790, 19, 27, 23, 2, -34 },
  { 855, 7, 12, 9, -2, -5 },
  { 866, 13, 1, 15, 1, -16 },
  { 868, 3, 4, 9, 1, -4 },
  { 870, 24, 41, 17, -3, -41 },
  { 993, 19, 43, 20, 1, -42 },
  { 1096, 10, 41, 20, 6, -41 },
  { 1148, 22, 42, 20, -2, -42 },
  { 1264, 21, 43, 20, -1, -42 },
  { 1377, 21, 42, 20, -1, -42 },
  { 1488, 22, 42, 20, -2, -41 },
  { 1604, 20, 43, 20, 1, -42 },
  { 1712, 20, 41, 20, 2, -41 },
  { 1815, 21, 43, 20, -1, -42 },
  { 1928, 20, 43, 20, 0, -42 },
  { 2036, 9, 31, 9, 0, -31 },
  { 2071, 12, 38, 9, -3, -31 },
  { 2128, 19, 23, 23, 2, -32 },
  { 2183, 19, 14, 23, 2, -27 },
  { 2217, 19, 23, 23, 2, -32 },
  { 2272, 15, 42, 14, 1, -42 },
  { 2351, 28, 47, 30, 1, -42 },
  { 2516, 19, 42, 19, -4, -42 },
  { 2616, 22, 41, 22, 0, -41 },
  { 2729, 22, 43, 20, 2, -42 },
  { 2848, 23, 41, 24, 0, -41 },
  { 2966, 22, 41, 20, 0, -41 },
  { 3079, 22, 41, 18, 0, -41 },
  { 3192, 25, 43, 26, 2, -42 },
  { 3327, 26, 41, 26, 0, -41 },
  { 3461, 17, 41, 10, -3, -41 },
  { 3549, 18, 51, 9, -8, -41 },
  { 3664, 24, 41, 20, 0, -41 },
  { 3787, 13, 41, 18, 0, -41 },
  { 3854, 35, 41, 34, 0, -41 },
  { 4034, 28, 41, 27, 0, -41 },
  { 4178, 23, 43, 26, 2, -42 },
  { 4302, 21, 41, 20, 0, -41 },
  { 4410, 23, 52, 26, 2, -42 },
  { 4560, 21, 41, 21, 0, -41 },
  { 4668, 23, 43, 20, -2, -42 },
  { 4792, 18, 41, 17, 4, -41 },
  { 4885, 24, 42, 25, 2, -41 },
  { 5011, 20, 41, 20, 5, -41 },
  { 5114, 35, 41, 35, 4, -41 },
  { 5294, 25, 41, 18, -3, -41 },
  { 5423, 18, 41, 17, 4, -41 },
  { 5516, 23, 41, 18, -2, -41 },
  { 5634, 20, 50, 16, -1, -41 },
  { 5759, 8, 41, 19, 6, -41 },
  { 5800, 21, 50, 16, -4, -41 },
  { 5932, 21, 19, 23, 1, -41 },
  { 5982, 15, 2, 15, -4, 5 },
  { 5986, 6, 9, 12, 8, -44 },
  { 5993, 19, 32, 22, 2, -31 },
  { 6069, 20, 45, 22, 0, -44 },
  { 6182, 15, 32, 16, 2, -31 },
  { 6242, 22, 45, 22, 2, -44 },
  { 6366, 16, 32, 19, 2, -31 },
  { 6430, 26, 58, 11, -8, -44 },
  { 6619, 22, 45, 22, -1, -31 },
  { 6743, 19, 44, 21, 0, -44 },
  { 6848, 11, 41, 9, 0, -41 },
  { 6905, 19, 55, 9, -8, -41 },
  { 7036, 19, 44, 17, 0, -44 },
  { 7141, 11, 44, 9, 0, -44 },
  { 7202, 30, 31, 32, 0, -31 },
  { 7319, 19, 31, 21, 0, -31 },
  { 7393, 17, 32, 21, 2, -31 },
  { 7461, 22, 44, 22, -2, -31 },
  { 7582, 19, 45, 22, 2, -31 },
  { 7689, 16, 31, 14, 0, -31 },
  { 7751, 17, 32, 16, -1, -31 },
  { 7819, 11, 39, 11, 1, -38 },
  { 7873, 18, 32, 21, 2, -31 },
  { 7945, 16, 31, 16, 3, -31 },
  { 8007, 26, 31, 27, 3, -31 },
  { 8108, 21, 31, 16, -3, -31 },
  { 8190, 27, 45, 17, -7, -31 },
  { 8342, 17, 31, 13, -2, -31 },
  { 8408, 20, 50, 18, 2, -41 },
  { 8533, 2, 58, 20, 9, -44 },
  { 8548, 20, 50, 18, -4, -41 },
  { 8673, 19, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC58PT7B_H_
